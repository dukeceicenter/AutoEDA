* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "freepdk45_sram_1w1r_16x120.sp"

* Global Power Supplies
Vvdd vdd 0 0.9

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xfreepdk45_sram_1w1r_16x120 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 din0_40 din0_41 din0_42 din0_43 din0_44 din0_45 din0_46 din0_47 din0_48 din0_49 din0_50 din0_51 din0_52 din0_53 din0_54 din0_55 din0_56 din0_57 din0_58 din0_59 din0_60 din0_61 din0_62 din0_63 din0_64 din0_65 din0_66 din0_67 din0_68 din0_69 din0_70 din0_71 din0_72 din0_73 din0_74 din0_75 din0_76 din0_77 din0_78 din0_79 din0_80 din0_81 din0_82 din0_83 din0_84 din0_85 din0_86 din0_87 din0_88 din0_89 din0_90 din0_91 din0_92 din0_93 din0_94 din0_95 din0_96 din0_97 din0_98 din0_99 din0_100 din0_101 din0_102 din0_103 din0_104 din0_105 din0_106 din0_107 din0_108 din0_109 din0_110 din0_111 din0_112 din0_113 din0_114 din0_115 din0_116 din0_117 din0_118 din0_119 a0_0 a0_1 a0_2 a0_3 a1_0 a1_1 a1_2 a1_3 CSB0 CSB1 clk0 clk1 dout1_0 dout1_1 dout1_2 dout1_3 dout1_4 dout1_5 dout1_6 dout1_7 dout1_8 dout1_9 dout1_10 dout1_11 dout1_12 dout1_13 dout1_14 dout1_15 dout1_16 dout1_17 dout1_18 dout1_19 dout1_20 dout1_21 dout1_22 dout1_23 dout1_24 dout1_25 dout1_26 dout1_27 dout1_28 dout1_29 dout1_30 dout1_31 dout1_32 dout1_33 dout1_34 dout1_35 dout1_36 dout1_37 dout1_38 dout1_39 dout1_40 dout1_41 dout1_42 dout1_43 dout1_44 dout1_45 dout1_46 dout1_47 dout1_48 dout1_49 dout1_50 dout1_51 dout1_52 dout1_53 dout1_54 dout1_55 dout1_56 dout1_57 dout1_58 dout1_59 dout1_60 dout1_61 dout1_62 dout1_63 dout1_64 dout1_65 dout1_66 dout1_67 dout1_68 dout1_69 dout1_70 dout1_71 dout1_72 dout1_73 dout1_74 dout1_75 dout1_76 dout1_77 dout1_78 dout1_79 dout1_80 dout1_81 dout1_82 dout1_83 dout1_84 dout1_85 dout1_86 dout1_87 dout1_88 dout1_89 dout1_90 dout1_91 dout1_92 dout1_93 dout1_94 dout1_95 dout1_96 dout1_97 dout1_98 dout1_99 dout1_100 dout1_101 dout1_102 dout1_103 dout1_104 dout1_105 dout1_106 dout1_107 dout1_108 dout1_109 dout1_110 dout1_111 dout1_112 dout1_113 dout1_114 dout1_115 dout1_116 dout1_117 dout1_118 dout1_119 vdd gnd freepdk45_sram_1w1r_16x120

* SRAM output loads
CD10 dout1_0  0 0.8364f
CD11 dout1_1  0 0.8364f
CD12 dout1_2  0 0.8364f
CD13 dout1_3  0 0.8364f
CD14 dout1_4  0 0.8364f
CD15 dout1_5  0 0.8364f
CD16 dout1_6  0 0.8364f
CD17 dout1_7  0 0.8364f
CD18 dout1_8  0 0.8364f
CD19 dout1_9  0 0.8364f
CD110 dout1_10  0 0.8364f
CD111 dout1_11  0 0.8364f
CD112 dout1_12  0 0.8364f
CD113 dout1_13  0 0.8364f
CD114 dout1_14  0 0.8364f
CD115 dout1_15  0 0.8364f
CD116 dout1_16  0 0.8364f
CD117 dout1_17  0 0.8364f
CD118 dout1_18  0 0.8364f
CD119 dout1_19  0 0.8364f
CD120 dout1_20  0 0.8364f
CD121 dout1_21  0 0.8364f
CD122 dout1_22  0 0.8364f
CD123 dout1_23  0 0.8364f
CD124 dout1_24  0 0.8364f
CD125 dout1_25  0 0.8364f
CD126 dout1_26  0 0.8364f
CD127 dout1_27  0 0.8364f
CD128 dout1_28  0 0.8364f
CD129 dout1_29  0 0.8364f
CD130 dout1_30  0 0.8364f
CD131 dout1_31  0 0.8364f
CD132 dout1_32  0 0.8364f
CD133 dout1_33  0 0.8364f
CD134 dout1_34  0 0.8364f
CD135 dout1_35  0 0.8364f
CD136 dout1_36  0 0.8364f
CD137 dout1_37  0 0.8364f
CD138 dout1_38  0 0.8364f
CD139 dout1_39  0 0.8364f
CD140 dout1_40  0 0.8364f
CD141 dout1_41  0 0.8364f
CD142 dout1_42  0 0.8364f
CD143 dout1_43  0 0.8364f
CD144 dout1_44  0 0.8364f
CD145 dout1_45  0 0.8364f
CD146 dout1_46  0 0.8364f
CD147 dout1_47  0 0.8364f
CD148 dout1_48  0 0.8364f
CD149 dout1_49  0 0.8364f
CD150 dout1_50  0 0.8364f
CD151 dout1_51  0 0.8364f
CD152 dout1_52  0 0.8364f
CD153 dout1_53  0 0.8364f
CD154 dout1_54  0 0.8364f
CD155 dout1_55  0 0.8364f
CD156 dout1_56  0 0.8364f
CD157 dout1_57  0 0.8364f
CD158 dout1_58  0 0.8364f
CD159 dout1_59  0 0.8364f
CD160 dout1_60  0 0.8364f
CD161 dout1_61  0 0.8364f
CD162 dout1_62  0 0.8364f
CD163 dout1_63  0 0.8364f
CD164 dout1_64  0 0.8364f
CD165 dout1_65  0 0.8364f
CD166 dout1_66  0 0.8364f
CD167 dout1_67  0 0.8364f
CD168 dout1_68  0 0.8364f
CD169 dout1_69  0 0.8364f
CD170 dout1_70  0 0.8364f
CD171 dout1_71  0 0.8364f
CD172 dout1_72  0 0.8364f
CD173 dout1_73  0 0.8364f
CD174 dout1_74  0 0.8364f
CD175 dout1_75  0 0.8364f
CD176 dout1_76  0 0.8364f
CD177 dout1_77  0 0.8364f
CD178 dout1_78  0 0.8364f
CD179 dout1_79  0 0.8364f
CD180 dout1_80  0 0.8364f
CD181 dout1_81  0 0.8364f
CD182 dout1_82  0 0.8364f
CD183 dout1_83  0 0.8364f
CD184 dout1_84  0 0.8364f
CD185 dout1_85  0 0.8364f
CD186 dout1_86  0 0.8364f
CD187 dout1_87  0 0.8364f
CD188 dout1_88  0 0.8364f
CD189 dout1_89  0 0.8364f
CD190 dout1_90  0 0.8364f
CD191 dout1_91  0 0.8364f
CD192 dout1_92  0 0.8364f
CD193 dout1_93  0 0.8364f
CD194 dout1_94  0 0.8364f
CD195 dout1_95  0 0.8364f
CD196 dout1_96  0 0.8364f
CD197 dout1_97  0 0.8364f
CD198 dout1_98  0 0.8364f
CD199 dout1_99  0 0.8364f
CD1100 dout1_100  0 0.8364f
CD1101 dout1_101  0 0.8364f
CD1102 dout1_102  0 0.8364f
CD1103 dout1_103  0 0.8364f
CD1104 dout1_104  0 0.8364f
CD1105 dout1_105  0 0.8364f
CD1106 dout1_106  0 0.8364f
CD1107 dout1_107  0 0.8364f
CD1108 dout1_108  0 0.8364f
CD1109 dout1_109  0 0.8364f
CD1110 dout1_110  0 0.8364f
CD1111 dout1_111  0 0.8364f
CD1112 dout1_112  0 0.8364f
CD1113 dout1_113  0 0.8364f
CD1114 dout1_114  0 0.8364f
CD1115 dout1_115  0 0.8364f
CD1116 dout1_116  0 0.8364f
CD1117 dout1_117  0 0.8364f
CD1118 dout1_118  0 0.8364f
CD1119 dout1_119  0 0.8364f

* Important signals for debug
* bl:	xfreepdk45_sram_1w1r_16x120.xbank0.bl_1_0
* br:	xfreepdk45_sram_1w1r_16x120.xbank0.br_1_0
* s_en:	xfreepdk45_sram_1w1r_16x120.s_en
* q:	xfreepdk45_sram_1w1r_16x120.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xfreepdk45_sram_1w1r_16x120.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 000110011100011010111000100011101100011000101011101100101001011110110001100010111011100010100010111101100110000000110110  to  address 1110 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 100100110010101011011011110110000110011111101001100010111110010010000101100001000100110001000011010010001111100010100110  to  address 1110 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 110010011001110110011111001010001001110101110011000110000111110100001111000101111100001110011110000010111011100110011101  to  address 1110 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 110010011001110110011111001010001001110101110011000110000111110100001111000101111100001110011110000010111011100110011101 from address 1110 (from port 1) during cycle 4 (20ns - 25ns)
*	Reading 110010011001110110011111001010001001110101110011000110000111110100001111000101111100001110011110000010111011100110011101 from address 1110 (from port 1) during cycle 6 (30ns - 35ns)
*	Reading 110010011001110110011111001010001001110101110011000110000111110100001111000101111100001110011110000010111011100110011101 from address 1110 (from port 1) during cycle 7 (35ns - 40ns)
*	Writing 000101001010010101001000101110110001111101011001111010100100110100000111101101101111010101001001101101110100011010010011  to  address 0000 (from port 0) during cycle 8 (40ns - 45ns)
*	Writing 011010110110000001001110001010110000111010110001110100011110101001001101011101010100110111011001001111011100100011010100  to  address 1110 (from port 0) during cycle 9 (45ns - 50ns)
*	Writing 010100100010011000100110010100110001111111001010001111000110010000101010001111111100010110010110110110100100111100110011  to  address 1110 (from port 0) during cycle 10 (50ns - 55ns)
*	Writing 000110011010011110011000000010001100010111000011111010011110111011101111000010001010010111110100010010100100010101000010  to  address 0000 (from port 0) during cycle 11 (55ns - 60ns)
*	Writing 101110101111000011000100110000111100110011100000001000000010010010100101011110111111011000111001000000011100101100101000  to  address 1110 (from port 0) during cycle 12 (60ns - 65ns)
*	Reading 101110101111000011000100110000111100110011100000001000000010010010100101011110111111011000111001000000011100101100101000 from address 1110 (from port 1) during cycle 13 (65ns - 70ns)
*	Reading 000110011010011110011000000010001100010111000011111010011110111011101111000010001010010111110100010010100100010101000010 from address 0000 (from port 1) during cycle 14 (70ns - 75ns)
*	Reading 101110101111000011000100110000111100110011100000001000000010010010100101011110111111011000111001000000011100101100101000 from address 1110 (from port 1) during cycle 15 (75ns - 80ns)
*	Writing 000001011011010110000011000110101101010010100000010110010101101000000100110010000110000100010010100110000110000101010010  to  address 0000 (from port 0) during cycle 18 (90ns - 95ns)
*	Writing 101111010011101011000111010011011010000101100000001110100101010011100110111011110010110111101011101111011100011110100011  to  address 1110 (from port 0) during cycle 19 (95ns - 100ns)
*	Writing 111001010000110111001111010100011111111010101001010100001010001000110010101111101101100010011011101000100010001000011010  to  address 1110 (from port 0) during cycle 20 (100ns - 105ns)
*	Reading 000001011011010110000011000110101101010010100000010110010101101000000100110010000110000100010010100110000110000101010010 from address 0000 (from port 1) during cycle 20 (100ns - 105ns)
*	Writing 111100110101111001010001000011110010000110001000010111110110011100000011010101001111100001011001110010100010001111100110  to  address 1110 (from port 0) during cycle 21 (105ns - 110ns)
*	Writing 100010001001101111101010001100110000110001011110000111100000000110010101111001001001100111010110101101110001010001101111  to  address 1110 (from port 0) during cycle 22 (110ns - 115ns)
*	Writing 000111001111010001111011101111110100011110010001110000111011100011100000110101001111100001100001100001111001100010011011  to  address 1110 (from port 0) during cycle 23 (115ns - 120ns)
*	Writing 001001011000000111101000110110100101010011110100000001111101000111001101001010110000001010111011001101100011100111010001  to  address 1110 (from port 0) during cycle 24 (120ns - 125ns)
*	Writing 001011010000011000101101001011111100011100000001101101001001001010000111001100010111110000101101000101010011001111101111  to  address 1110 (from port 0) during cycle 25 (125ns - 130ns)
*	Writing 110100010000111110100001110010100000110100000000011001100101101000111111011011101010111000111011010100001101000111111111  to  address 1110 (from port 0) during cycle 29 (145ns - 150ns)
*	Reading 000001011011010110000011000110101101010010100000010110010101101000000100110010000110000100010010100110000110000101010010 from address 0000 (from port 1) during cycle 29 (145ns - 150ns)
*	Writing 110101111111110111111110100110101010001111000110111000101100100111001001010001101011101100100101000001100111111100011001  to  address 0000 (from port 0) during cycle 30 (150ns - 155ns)
*	Writing 111110110010000001100111000011001110011010110111111011010000101110111011110111011010001011110010011000111110101010100001  to  address 0000 (from port 0) during cycle 31 (155ns - 160ns)
*	Writing 000010011111011001000111101110111011001001010011000101110110010011010111110000000000101110111001011010111111110111010101  to  address 1110 (from port 0) during cycle 32 (160ns - 165ns)
*	Reading 111110110010000001100111000011001110011010110111111011010000101110111011110111011010001011110010011000111110101010100001 from address 0000 (from port 1) during cycle 32 (160ns - 165ns)
*	Reading 111110110010000001100111000011001110011010110111111011010000101110111011110111011010001011110010011000111110101010100001 from address 0000 (from port 1) during cycle 33 (165ns - 170ns)
*	Reading 000010011111011001000111101110111011001001010011000101110110010011010111110000000000101110111001011010111111110111010101 from address 1110 (from port 1) during cycle 34 (170ns - 175ns)
*	Reading 111110110010000001100111000011001110011010110111111011010000101110111011110111011010001011110010011000111110101010100001 from address 0000 (from port 1) during cycle 35 (175ns - 180ns)
*	Writing 010011000000001110100101011111101100100000011101110111010100010000010011100000100101011110010011000001010001111111111011  to  address 0000 (from port 0) during cycle 37 (185ns - 190ns)
*	Writing 111100110101000111011011110010100100000100011100010100001011001001110000100101000010001000110011010010010100111100110011  to  address 1110 (from port 0) during cycle 38 (190ns - 195ns)
*	Writing 000001101111110010111100101011101010000100000001110001011110011110111000101010010100111010111110010011111100001100111110  to  address 0000 (from port 0) during cycle 39 (195ns - 200ns)
*	Reading 000001101111110010111100101011101010000100000001110001011110011110111000101010010100111010111110010011111100001100111110 from address 0000 (from port 1) during cycle 40 (200ns - 205ns)
*	Reading 000001101111110010111100101011101010000100000001110001011110011110111000101010010100111010111110010011111100001100111110 from address 0000 (from port 1) during cycle 41 (205ns - 210ns)
*	Reading 000001101111110010111100101011101010000100000001110001011110011110111000101010010100111010111110010011111100001100111110 from address 0000 (from port 1) during cycle 44 (220ns - 225ns)
*	Writing 101100101101011001100101101011110111110001101110101011100101111001010010110001110010000011110101010010101110111100101101  to  address 0000 (from port 0) during cycle 45 (225ns - 230ns)
*	Writing 101111110101001001100111011011010001010111000001100110100111101110011111110111100100010111100010111001100111111100001110  to  address 0000 (from port 0) during cycle 48 (240ns - 245ns)
*	Reading 111100110101000111011011110010100100000100011100010100001011001001110000100101000010001000110011010010010100111100110011 from address 1110 (from port 1) during cycle 48 (240ns - 245ns)
*	Writing 010111000111110100000111011010010100110000010111010001111111011100101001100001000110001001110110001010001001111010010000  to  address 1110 (from port 0) during cycle 49 (245ns - 250ns)
*	Reading 101111110101001001100111011011010001010111000001100110100111101110011111110111100100010111100010111001100111111100001110 from address 0000 (from port 1) during cycle 50 (250ns - 255ns)
*	Writing 000010011011000101110101000100111000001111110010101000101000100010110110001100111100001100011100101001111000101000010111  to  address 1110 (from port 0) during cycle 51 (255ns - 260ns)
*	Reading 000010011011000101110101000100111000001111110010101000101000100010110110001100111100001100011100101001111000101000010111 from address 1110 (from port 1) during cycle 52 (260ns - 265ns)
*	Writing 011010001100101000111101011101011010110001000010010101101100000100100010101110110011111011110010111101110000011110001011  to  address 1110 (from port 0) during cycle 53 (265ns - 270ns)
*	Writing 101010100100001011111111110100100111011010000000011001100110011010000110111111101101011011110010001000001001010010001001  to  address 1110 (from port 0) during cycle 54 (270ns - 275ns)
*	Reading 101111110101001001100111011011010001010111000001100110100111101110011111110111100100010111100010111001100111111100001110 from address 0000 (from port 1) during cycle 54 (270ns - 275ns)
*	Writing 010100100000011011100011101010011101110101111000010011100110111011000101000000000110110010000011001000110100011000000011  to  address 1110 (from port 0) during cycle 57 (285ns - 290ns)
*	Writing 000111001110011111100100111100110111110011011000001011011011101101000110001011100110100110001100100110110101100101000111  to  address 1110 (from port 0) during cycle 58 (290ns - 295ns)
*	Writing 010010010100011001111100111000110000101000001011000110010100101111001101010111010010111011110001011111101010100011010110  to  address 1110 (from port 0) during cycle 59 (295ns - 300ns)
*	Writing 000010111111011111110110101001111100011001111010000011001101100111100001100000101011010100011001111101001011101001001001  to  address 0000 (from port 0) during cycle 60 (300ns - 305ns)
*	Writing 001101100010010010100101100110010110101011010000100011010101111011111100100001001110110110100100000010000000111111000010  to  address 0000 (from port 0) during cycle 61 (305ns - 310ns)
*	Reading 010010010100011001111100111000110000101000001011000110010100101111001101010111010010111011110001011111101010100011010110 from address 1110 (from port 1) during cycle 61 (305ns - 310ns)
*	Writing 100011010101101110101111100010000110110000111011111111110010110010101110101011101001000110110010000000001110110101010010  to  address 0000 (from port 0) during cycle 62 (310ns - 315ns)
*	Reading 010010010100011001111100111000110000101000001011000110010100101111001101010111010010111011110001011111101010100011010110 from address 1110 (from port 1) during cycle 62 (310ns - 315ns)
*	Writing 111100100010000011101101001000110100111011101100011001111000010010100110000111010111001011111001000010101110101010101011  to  address 1110 (from port 0) during cycle 63 (315ns - 320ns)
*	Writing 011011111111001011011101101000000001110011010110010001010110000001010010110110100001111101100001011110010001011010111010  to  address 0000 (from port 0) during cycle 65 (325ns - 330ns)
*	Reading 111100100010000011101101001000110100111011101100011001111000010010100110000111010111001011111001000010101110101010101011 from address 1110 (from port 1) during cycle 66 (330ns - 335ns)
*	Reading 111100100010000011101101001000110100111011101100011001111000010010100110000111010111001011111001000010101110101010101011 from address 1110 (from port 1) during cycle 67 (335ns - 340ns)
*	Writing 010010110100101001111010001011000000001000100010100011011010110001000110111100110100001100010010000101101000001111010101  to  address 1110 (from port 0) during cycle 68 (340ns - 345ns)
*	Writing 011001011100100111001110010011100101010011101011001100010000001011100110000010011100111010001011010111110101101101011110  to  address 0000 (from port 0) during cycle 70 (350ns - 355ns)
*	Writing 000000001000001111111000011010010011010111000000111110100110111010000010001110100011111000100011101100001011011100001011  to  address 0000 (from port 0) during cycle 71 (355ns - 360ns)
*	Reading 010010110100101001111010001011000000001000100010100011011010110001000110111100110100001100010010000101101000001111010101 from address 1110 (from port 1) during cycle 71 (355ns - 360ns)
*	Writing 000001100000011100000100110100010000110000000110101011110011011111011110111100000011000111100001011001000110101100000010  to  address 1110 (from port 0) during cycle 72 (360ns - 365ns)
*	Writing 000000100000101110011000111101100000010100110011101011111011110111100100111110011101101110100110101111001011111010011000  to  address 1110 (from port 0) during cycle 73 (365ns - 370ns)
*	Reading 000000100000101110011000111101100000010100110011101011111011110111100100111110011101101110100110101111001011111010011000 from address 1110 (from port 1) during cycle 75 (375ns - 380ns)
*	Writing 100000010101001100100111110001100111010101101010101101101001001000101100100110100001111001100100010010111111101011101111  to  address 0000 (from port 0) during cycle 76 (380ns - 385ns)
*	Writing 000000101100100010100000010110001010011100100100010001001000101111100011001000101010100011101111011001111111011110001011  to  address 1110 (from port 0) during cycle 78 (390ns - 395ns)
*	Reading 100000010101001100100111110001100111010101101010101101101001001000101100100110100001111001100100010010111111101011101111 from address 0000 (from port 1) during cycle 78 (390ns - 395ns)
*	Reading 100000010101001100100111110001100111010101101010101101101001001000101100100110100001111001100100010010111111101011101111 from address 0000 (from port 1) during cycle 79 (395ns - 400ns)
*	Writing 111100100100111110100100111010101001101001100100000010100111010000001001010111110011001011100110001000010101101100010111  to  address 0000 (from port 0) during cycle 80 (400ns - 405ns)
*	Reading 000000101100100010100000010110001010011100100100010001001000101111100011001000101010100011101111011001111111011110001011 from address 1110 (from port 1) during cycle 80 (400ns - 405ns)
*	Writing 101000110110110011001000101110110100101010000011000011111000110111101000000110100111010111101000010101011010011010011010  to  address 0000 (from port 0) during cycle 81 (405ns - 410ns)
*	Writing 000000001100011110100001011001000101101001001010100101100111000000010011100111000111000110111101100100111000000010111000  to  address 1110 (from port 0) during cycle 82 (410ns - 415ns)
*	Reading 000000001100011110100001011001000101101001001010100101100111000000010011100111000111000110111101100100111000000010111000 from address 1110 (from port 1) during cycle 84 (420ns - 425ns)
*	Writing 010101010011000111000111000000100011001001010001110101101011011110110000010110000010101011111001010111101001101011110110  to  address 1110 (from port 0) during cycle 86 (430ns - 435ns)
*	Writing 011010011101100110000000111000110111010011000011101111101111011111100100111010000111011010001011100010100010000010111101  to  address 0000 (from port 0) during cycle 87 (435ns - 440ns)
*	Writing 010110100100010011011001101001001000100011100101001000011011001000101101010001001011101010111010100001111010011100101000  to  address 1110 (from port 0) during cycle 89 (445ns - 450ns)
*	Writing 000010111111000101110000011101010010111101100111110000111000111000111010111111011111011101010100011111111000011011101101  to  address 1110 (from port 0) during cycle 90 (450ns - 455ns)
*	Reading 011010011101100110000000111000110111010011000011101111101111011111100100111010000111011010001011100010100010000010111101 from address 0000 (from port 1) during cycle 90 (450ns - 455ns)
*	Writing 010110111011010111110101101111000011110101001000011111001000001100001001111100101110011000100100110011011100011101110111  to  address 0000 (from port 0) during cycle 92 (460ns - 465ns)
*	Reading 000010111111000101110000011101010010111101100111110000111000111000111010111111011111011101010100011111111000011011101101 from address 1110 (from port 1) during cycle 92 (460ns - 465ns)
*	Writing 100100101010010001100001111101101011110111000011011111001010100101100011011111010000100000000000100000011011000010111100  to  address 1110 (from port 0) during cycle 93 (465ns - 470ns)
*	Writing 100100111110010010011001101100110111101011011010010110001011000110000011110001101011001000011010011010000111111101101001  to  address 0000 (from port 0) during cycle 94 (470ns - 475ns)
*	Reading 100100101010010001100001111101101011110111000011011111001010100101100011011111010000100000000000100000011011000010111100 from address 1110 (from port 1) during cycle 94 (470ns - 475ns)
*	Writing 001100101100001101111110000011011000001001011011100111110000101001001101010101100100011111001000110101111001100010111110  to  address 0000 (from port 0) during cycle 95 (475ns - 480ns)
*	Writing 001000110001110011111101110101000000000000111001100000110010110001110111010110100100110011010111110100011010001101010000  to  address 0000 (from port 0) during cycle 96 (480ns - 485ns)
*	Reading 001000110001110011111101110101000000000000111001100000110010110001110111010110100100110011010111110100011010001101010000 from address 0000 (from port 1) during cycle 97 (485ns - 490ns)
*	Reading 001000110001110011111101110101000000000000111001100000110010110001110111010110100100110011010111110100011010001101010000 from address 0000 (from port 1) during cycle 98 (490ns - 495ns)
*	Writing 100101001101111000011111101011110100000101110010010100100111100110111001111011010010010100000100011101011110000111000010  to  address 1110 (from port 0) during cycle 100 (500ns - 505ns)
*	Writing 011101110110110001001101010101010010101111111101001100010100111101111011111110000011011001100110101100001100010011010110  to  address 0000 (from port 0) during cycle 102 (510ns - 515ns)
*	Writing 110011011011001110001110100111110111111100011101011000110001101010010010000001101110111010011101000000010011011001101001  to  address 1110 (from port 0) during cycle 103 (515ns - 520ns)
*	Reading 011101110110110001001101010101010010101111111101001100010100111101111011111110000011011001100110101100001100010011010110 from address 0000 (from port 1) during cycle 103 (515ns - 520ns)
*	Writing 011010100001111010011011010111000011101110000010010000111000111001000000001100111110111010110110101011011000110001101001  to  address 1110 (from port 0) during cycle 105 (525ns - 530ns)
*	Writing 101110111001100100001100000001000101110111010011110100111101110100111101111101010111101101110010100101100011010011100000  to  address 0000 (from port 0) during cycle 106 (530ns - 535ns)
*	Writing 111111110000011000000110100000000100011001001010101011000100111000011110101011011110001010010010101010010111000001001011  to  address 1110 (from port 0) during cycle 107 (535ns - 540ns)
*	Reading 111111110000011000000110100000000100011001001010101011000100111000011110101011011110001010010010101010010111000001001011 from address 1110 (from port 1) during cycle 108 (540ns - 545ns)
*	Writing 001010001010001110010011011010111100101100011111001101010011000010100100001100110110011111001100101010100010111111111001  to  address 0000 (from port 0) during cycle 109 (545ns - 550ns)
*	Reading 111111110000011000000110100000000100011001001010101011000100111000011110101011011110001010010010101010010111000001001011 from address 1110 (from port 1) during cycle 109 (545ns - 550ns)
*	Writing 000000000011110111100011000101010101100000010111000001100100111010111011111000111000010011001110011110001111110101101001  to  address 0000 (from port 0) during cycle 110 (550ns - 555ns)
*	Writing 111101110110110111001100110111001100111001011001001111000011100001001010010010001101001100111111011111000111101111011000  to  address 1110 (from port 0) during cycle 111 (555ns - 560ns)
*	Writing 101001111011011010100001100110011011100010101000111100001110101100010101101001010011100011010011011000111101110111011001  to  address 1110 (from port 0) during cycle 112 (560ns - 565ns)
*	Reading 000000000011110111100011000101010101100000010111000001100100111010111011111000111000010011001110011110001111110101101001 from address 0000 (from port 1) during cycle 114 (570ns - 575ns)
*	Writing 111110001000110111011111101000100101100101011011010110010001101110101110011011101100010101011111011111010001111010100010  to  address 0000 (from port 0) during cycle 115 (575ns - 580ns)
*	Writing 100001010011000100111001001111011011101110010100100101010110001000111000000001101001100011101111110010100011111100100100  to  address 1110 (from port 0) during cycle 116 (580ns - 585ns)
*	Reading 111110001000110111011111101000100101100101011011010110010001101110101110011011101100010101011111011111010001111010100010 from address 0000 (from port 1) during cycle 116 (580ns - 585ns)
*	Writing 101010001111011110000011001101100100100101000010111011000111001101110111001010111100101111000110000100101110101110101101  to  address 0000 (from port 0) during cycle 117 (585ns - 590ns)
*	Reading 101010001111011110000011001101100100100101000010111011000111001101110111001010111100101111000110000100101110101110101101 from address 0000 (from port 1) during cycle 118 (590ns - 595ns)
*	Writing 110001001110001000101000101110010011001000111110111011110101101001010011010110101011110001001110011101011100111000100100  to  address 0000 (from port 0) during cycle 123 (615ns - 620ns)
*	Writing 001001101100101111011001111011001000011011101111010010010011111110110110110000000110001110011101011111011000111010000111  to  address 1110 (from port 0) during cycle 124 (620ns - 625ns)
*	Writing 011010101100011110010011101000100011011010000001110111001101000110010001011011010110110100011000101011110100010000000011  to  address 1110 (from port 0) during cycle 125 (625ns - 630ns)
*	Reading 011010101100011110010011101000100011011010000001110111001101000110010001011011010110110100011000101011110100010000000011 from address 1110 (from port 1) during cycle 127 (635ns - 640ns)
*	Reading 011010101100011110010011101000100011011010000001110111001101000110010001011011010110110100011000101011110100010000000011 from address 1110 (from port 1) during cycle 128 (640ns - 645ns)
*	Writing 110111111000010101110101010001110001010100100100001101001110100101100011100110001001000111011010010010111011111100101110  to  address 0000 (from port 0) during cycle 129 (645ns - 650ns)
*	Writing 011101011101110011100101010001110101001110011100001000000110100011011110110100010001110100111001011000101111110110110010  to  address 1110 (from port 0) during cycle 130 (650ns - 655ns)
*	Reading 011101011101110011100101010001110101001110011100001000000110100011011110110100010001110100111001011000101111110110110010 from address 1110 (from port 1) during cycle 131 (655ns - 660ns)
*	Writing 010001011010001001100111100000101111000111110001111111101011000111011100000100000000000011000101110001000110100100000101  to  address 1110 (from port 0) during cycle 134 (670ns - 675ns)
*	Reading 110111111000010101110101010001110001010100100100001101001110100101100011100110001001000111011010010010111011111100101110 from address 0000 (from port 1) during cycle 135 (675ns - 680ns)
*	Reading 010001011010001001100111100000101111000111110001111111101011000111011100000100000000000011000101110001000110100100000101 from address 1110 (from port 1) during cycle 136 (680ns - 685ns)
*	Writing 100101100111110010011001010011100000000100000110100011000000100100010011110001010111101110110010010101101100001110011000  to  address 0000 (from port 0) during cycle 137 (685ns - 690ns)
*	Reading 010001011010001001100111100000101111000111110001111111101011000111011100000100000000000011000101110001000110100100000101 from address 1110 (from port 1) during cycle 138 (690ns - 695ns)
*	Writing 010001000000100110100111100110111011010010000010100010001001001010100101001000001010011011001010100111010101111011100001  to  address 1110 (from port 0) during cycle 140 (700ns - 705ns)
*	Reading 100101100111110010011001010011100000000100000110100011000000100100010011110001010111101110110010010101101100001110011000 from address 0000 (from port 1) during cycle 140 (700ns - 705ns)
*	Writing 101101010001110101010111001101101011000100111010110000100011000001001010001110000101110010011100111100001110010101110010  to  address 0000 (from port 0) during cycle 141 (705ns - 710ns)
*	Reading 101101010001110101010111001101101011000100111010110000100011000001001010001110000101110010011100111100001110010101110010 from address 0000 (from port 1) during cycle 142 (710ns - 715ns)
*	Reading 010001000000100110100111100110111011010010000010100010001001001010100101001000001010011011001010100111010101111011100001 from address 1110 (from port 1) during cycle 143 (715ns - 720ns)
*	Writing 101111001000111001001101100101001000101110100100010110110010110000001011001110110011000101101110000010101111100100001000  to  address 0000 (from port 0) during cycle 145 (725ns - 730ns)
*	Writing 011011110100101001011100101111010111101001111111011111110000010011010111101111101000011011111011101111010000100100100101  to  address 0000 (from port 0) during cycle 146 (730ns - 735ns)
*	Reading 010001000000100110100111100110111011010010000010100010001001001010100101001000001010011011001010100111010101111011100001 from address 1110 (from port 1) during cycle 146 (730ns - 735ns)
*	Writing 011101001111011000100101110010111011111000010100111010010111100101001001110010001100010000111111111100101111001110010001  to  address 0000 (from port 0) during cycle 147 (735ns - 740ns)
*	Writing 000101000011100010100001000000110100010011100101111011001101001110110000001110100010011110110000010010000001100110100110  to  address 1110 (from port 0) during cycle 148 (740ns - 745ns)
*	Writing 111111110000010111101011111010100011010010001100000000101001110001000011101001110000101010111010110010001110101100011001  to  address 0000 (from port 0) during cycle 149 (745ns - 750ns)
*	Reading 111111110000010111101011111010100011010010001100000000101001110001000011101001110000101010111010110010001110101100011001 from address 0000 (from port 1) during cycle 150 (750ns - 755ns)
*	Writing 001100111001111000111000011001010001110010011110101000110010111010111110110000110100000001110101001001011100000100101011  to  address 1110 (from port 0) during cycle 151 (755ns - 760ns)
*	Reading 111111110000010111101011111010100011010010001100000000101001110001000011101001110000101010111010110010001110101100011001 from address 0000 (from port 1) during cycle 151 (755ns - 760ns)
*	Writing 001001101011100000101000110101101100111100111001101111011000101111011011000000000111100010010100011010011110000101101111  to  address 1110 (from port 0) during cycle 152 (760ns - 765ns)
*	Reading 001001101011100000101000110101101100111100111001101111011000101111011011000000000111100010010100011010011110000101101111 from address 1110 (from port 1) during cycle 154 (770ns - 775ns)
*	Writing 100100011100001100001111110110011010000101010001010011111110110000000110110101100100000001010000001010000010110010011101  to  address 1110 (from port 0) during cycle 156 (780ns - 785ns)
*	Writing 111100000010011110011010100001100100100010011011110001100011000100001110101001111110001100110011011011000010111001001101  to  address 1110 (from port 0) during cycle 157 (785ns - 790ns)
*	Reading 111111110000010111101011111010100011010010001100000000101001110001000011101001110000101010111010110010001110101100011001 from address 0000 (from port 1) during cycle 157 (785ns - 790ns)
*	Writing 100000101000011011100001000111111001001111101110001000000110000010000000001000101000101111010110101111111001010001001011  to  address 0000 (from port 0) during cycle 158 (790ns - 795ns)
*	Reading 100000101000011011100001000111111001001111101110001000000110000010000000001000101000101111010110101111111001010001001011 from address 0000 (from port 1) during cycle 159 (795ns - 800ns)
*	Writing 011000111110010000100110111101101110100000100110000011110110110010010110110000100111100010110110101000010000000100001100  to  address 0000 (from port 0) during cycle 160 (800ns - 805ns)
*	Writing 110001111010100010001110101010001111111110110101100001111111111010001000110001111101101000010100111010110010001011111000  to  address 1110 (from port 0) during cycle 161 (805ns - 810ns)
*	Writing 101011110110101110011010011000000100111001001001110110000011001111100101010001001111111010110101101100101101110110010001  to  address 1110 (from port 0) during cycle 162 (810ns - 815ns)
*	Reading 011000111110010000100110111101101110100000100110000011110110110010010110110000100111100010110110101000010000000100001100 from address 0000 (from port 1) during cycle 163 (815ns - 820ns)
*	Writing 001111111101011100000001110001010000001100010110110101101001000111101001011011101000011011001000010100011000001101100101  to  address 1110 (from port 0) during cycle 164 (820ns - 825ns)
*	Writing 010010010001111001000101101100111111000100000000110010110001010101001000001110001011000011000100111011100101001110100011  to  address 0000 (from port 0) during cycle 168 (840ns - 845ns)
*	Writing 101010101001111011101001110100001110100000001001110000001100111000010010111001001001001000111010100001110100110010001011  to  address 1110 (from port 0) during cycle 170 (850ns - 855ns)
*	Writing 101001110001111000000011111001111001011010001101111111011011100001100001100110101001100010000000000000101100010110010011  to  address 0000 (from port 0) during cycle 172 (860ns - 865ns)
*	Writing 010001001010001101111000111100011000000111000010011001001101101110100111110110011001010000110100110111000000110111011000  to  address 1110 (from port 0) during cycle 173 (865ns - 870ns)
*	Reading 101001110001111000000011111001111001011010001101111111011011100001100001100110101001100010000000000000101100010110010011 from address 0000 (from port 1) during cycle 173 (865ns - 870ns)
*	Writing 111001101100100100101100101100000100101000111111011001001011000010001011110001111001100011001100101111011011111000000001  to  address 1110 (from port 0) during cycle 174 (870ns - 875ns)
*	Reading 101001110001111000000011111001111001011010001101111111011011100001100001100110101001100010000000000000101100010110010011 from address 0000 (from port 1) during cycle 174 (870ns - 875ns)
*	Reading 111001101100100100101100101100000100101000111111011001001011000010001011110001111001100011001100101111011011111000000001 from address 1110 (from port 1) during cycle 175 (875ns - 880ns)
*	Reading 101001110001111000000011111001111001011010001101111111011011100001100001100110101001100010000000000000101100010110010011 from address 0000 (from port 1) during cycle 177 (885ns - 890ns)
*	Reading 101001110001111000000011111001111001011010001101111111011011100001100001100110101001100010000000000000101100010110010011 from address 0000 (from port 1) during cycle 178 (890ns - 895ns)
*	Reading 101001110001111000000011111001111001011010001101111111011011100001100001100110101001100010000000000000101100010110010011 from address 0000 (from port 1) during cycle 179 (895ns - 900ns)
*	Writing 001111100110000010010011111110000111010101100100110010100000110010110101100010010101101011101010011111000111011111011110  to  address 0000 (from port 0) during cycle 180 (900ns - 905ns)
*	Reading 111001101100100100101100101100000100101000111111011001001011000010001011110001111001100011001100101111011011111000000001 from address 1110 (from port 1) during cycle 180 (900ns - 905ns)
*	Reading 001111100110000010010011111110000111010101100100110010100000110010110101100010010101101011101010011111000111011111011110 from address 0000 (from port 1) during cycle 181 (905ns - 910ns)
*	Writing 110000110100011011000000011111000011010011111000110000110011011011010101110011000011011110001110100111011110000000011011  to  address 0000 (from port 0) during cycle 182 (910ns - 915ns)
*	Reading 111001101100100100101100101100000100101000111111011001001011000010001011110001111001100011001100101111011011111000000001 from address 1110 (from port 1) during cycle 182 (910ns - 915ns)
*	Writing 001101001011110010011000011010100110000111011100110011101100101000110000010110101000010011110101000101011111100011011100  to  address 0000 (from port 0) during cycle 183 (915ns - 920ns)
*	Writing 010100010000100101011011011110101110101100100001110010111100000100011000101000100111100000110100110101000101110011111011  to  address 1110 (from port 0) during cycle 185 (925ns - 930ns)
*	Reading 010100010000100101011011011110101110101100100001110010111100000100011000101000100111100000110100110101000101110011111011 from address 1110 (from port 1) during cycle 186 (930ns - 935ns)
*	Writing 110001110010011010101001011110111011000110011010011001001110000011011011101010100001000000011011010110100101011011000010  to  address 0000 (from port 0) during cycle 187 (935ns - 940ns)
*	Reading 010100010000100101011011011110101110101100100001110010111100000100011000101000100111100000110100110101000101110011111011 from address 1110 (from port 1) during cycle 190 (950ns - 955ns)
*	Reading 110001110010011010101001011110111011000110011010011001001110000011011011101010100001000000011011010110100101011011000010 from address 0000 (from port 1) during cycle 191 (955ns - 960ns)
*	Reading 010100010000100101011011011110101110101100100001110010111100000100011000101000100111100000110100110101000101110011111011 from address 1110 (from port 1) during cycle 193 (965ns - 970ns)
*	Reading 010100010000100101011011011110101110101100100001110010111100000100011000101000100111100000110100110101000101110011111011 from address 1110 (from port 1) during cycle 194 (970ns - 975ns)
*	Writing 000100010101001011101001110001001001001100000000101111011011011011110110101111110110100111000010110110111011100001001010  to  address 0000 (from port 0) during cycle 196 (980ns - 985ns)
*	Reading 010100010000100101011011011110101110101100100001110010111100000100011000101000100111100000110100110101000101110011111011 from address 1110 (from port 1) during cycle 196 (980ns - 985ns)
*	Writing 100010111000110111101101101101011011001110110001010001010001011111000011000010100100000010110011000100010110011000111100  to  address 1110 (from port 0) during cycle 197 (985ns - 990ns)
*	Reading 000100010101001011101001110001001001001100000000101111011011011011110110101111110110100111000010110110111011100001001010 from address 0000 (from port 1) during cycle 198 (990ns - 995ns)
*	Writing 000100010100011011001111001011010011111001111100110111111101100000010000100111011100010010001101010000101001000111101010  to  address 1110 (from port 0) during cycle 199 (995ns - 1000ns)
*	Reading 000100010101001011101001110001001001001100000000101111011011011011110110101111110110100111000010110110111011100001001010 from address 0000 (from port 1) during cycle 201 (1005ns - 1010ns)
*	Writing 110001111010101101001111100000010001100101001111000110010010010001000101111011111111001001001000110010001000011000100001  to  address 0000 (from port 0) during cycle 202 (1010ns - 1015ns)
*	Reading 000100010100011011001111001011010011111001111100110111111101100000010000100111011100010010001101010000101001000111101010 from address 1110 (from port 1) during cycle 202 (1010ns - 1015ns)
*	Writing 000100110101100101011010011001000000000011110010010001001001101111011110110101010100100100011111111011010011111000001001  to  address 0000 (from port 0) during cycle 203 (1015ns - 1020ns)
*	Reading 000100110101100101011010011001000000000011110010010001001001101111011110110101010100100100011111111011010011111000001001 from address 0000 (from port 1) during cycle 204 (1020ns - 1025ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 0), (110, 1), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 0), (465, 1), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 1), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 1), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 1), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 1), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 0), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 1), (105, 1), (110, 0), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_40  din0_40  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_41  din0_41  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_42  din0_42  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 0), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_43  din0_43  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 0), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 1), (530, 1), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_44  din0_44  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_45  din0_45  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_46  din0_46  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_47  din0_47  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_48  din0_48  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_49  din0_49  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_50  din0_50  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_51  din0_51  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_52  din0_52  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_53  din0_53  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_54  din0_54  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_55  din0_55  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_56  din0_56  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_57  din0_57  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_58  din0_58  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_59  din0_59  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 0), (530, 1), (535, 0), (540, 0), (545, 1), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_60  din0_60  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_61  din0_61  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 0), (105, 1), (110, 0), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_62  din0_62  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_63  din0_63  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_64  din0_64  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_65  din0_65  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_66  din0_66  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_67  din0_67  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_68  din0_68  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_69  din0_69  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 1), (105, 1), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_70  din0_70  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_71  din0_71  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 0), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 1), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_72  din0_72  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 0), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_73  din0_73  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_74  din0_74  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_75  din0_75  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 1), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_76  din0_76  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_77  din0_77  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_78  din0_78  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_79  din0_79  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 1), (110, 0), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_80  din0_80  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 0), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_81  din0_81  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_82  din0_82  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_83  din0_83  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 1), (105, 0), (110, 0), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_84  din0_84  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_85  din0_85  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_86  din0_86  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_87  din0_87  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_88  din0_88  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_89  din0_89  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 1), (110, 0), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_90  din0_90  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_91  din0_91  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_92  din0_92  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_93  din0_93  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 0), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_94  din0_94  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_95  din0_95  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_96  din0_96  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_97  din0_97  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_98  din0_98  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_99  din0_99  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_100  din0_100  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_101  din0_101  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_102  din0_102  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_103  din0_103  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 1), (105, 0), (110, 1), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 0), (530, 1), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_104  din0_104  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_105  din0_105  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 1), (105, 1), (110, 0), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 1), (530, 0), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_106  din0_106  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_107  din0_107  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_108  din0_108  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_109  din0_109  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_110  din0_110  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 0), (530, 1), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_111  din0_111  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_112  din0_112  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_113  din0_113  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_114  din0_114  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 1), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_115  din0_115  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 0), (105, 1), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_116  din0_116  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_117  din0_117  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_118  din0_118  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_119  din0_119  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va1_0  a1_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va1_1  a1_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va1_2  a1_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va1_3  a1_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 0), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 1), (335, 1), (340, 0), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 1), (390, 0), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 0), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 0), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 1), (5, 1), (10, 1), (15, 1), (20, 0), (25, 1), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 1), (260, 0), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 1), (460, 0), (465, 1), (470, 0), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 1), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 1), (690, 0), (695, 1), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 1), (980, 0), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 1)]
VCSB1 CSB1 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)
* PULSE: period=5
Vclk1 clk1 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout1_0 Vdout1_0ck4 = 0.9 time = 25
.meas tran vdout1_0ck4 FIND v(dout1_0) AT=25.025n

* CHECK dout1_1 Vdout1_1ck4 = 0 time = 25
.meas tran vdout1_1ck4 FIND v(dout1_1) AT=25.025n

* CHECK dout1_2 Vdout1_2ck4 = 0.9 time = 25
.meas tran vdout1_2ck4 FIND v(dout1_2) AT=25.025n

* CHECK dout1_3 Vdout1_3ck4 = 0.9 time = 25
.meas tran vdout1_3ck4 FIND v(dout1_3) AT=25.025n

* CHECK dout1_4 Vdout1_4ck4 = 0.9 time = 25
.meas tran vdout1_4ck4 FIND v(dout1_4) AT=25.025n

* CHECK dout1_5 Vdout1_5ck4 = 0 time = 25
.meas tran vdout1_5ck4 FIND v(dout1_5) AT=25.025n

* CHECK dout1_6 Vdout1_6ck4 = 0 time = 25
.meas tran vdout1_6ck4 FIND v(dout1_6) AT=25.025n

* CHECK dout1_7 Vdout1_7ck4 = 0.9 time = 25
.meas tran vdout1_7ck4 FIND v(dout1_7) AT=25.025n

* CHECK dout1_8 Vdout1_8ck4 = 0.9 time = 25
.meas tran vdout1_8ck4 FIND v(dout1_8) AT=25.025n

* CHECK dout1_9 Vdout1_9ck4 = 0 time = 25
.meas tran vdout1_9ck4 FIND v(dout1_9) AT=25.025n

* CHECK dout1_10 Vdout1_10ck4 = 0 time = 25
.meas tran vdout1_10ck4 FIND v(dout1_10) AT=25.025n

* CHECK dout1_11 Vdout1_11ck4 = 0.9 time = 25
.meas tran vdout1_11ck4 FIND v(dout1_11) AT=25.025n

* CHECK dout1_12 Vdout1_12ck4 = 0.9 time = 25
.meas tran vdout1_12ck4 FIND v(dout1_12) AT=25.025n

* CHECK dout1_13 Vdout1_13ck4 = 0.9 time = 25
.meas tran vdout1_13ck4 FIND v(dout1_13) AT=25.025n

* CHECK dout1_14 Vdout1_14ck4 = 0 time = 25
.meas tran vdout1_14ck4 FIND v(dout1_14) AT=25.025n

* CHECK dout1_15 Vdout1_15ck4 = 0.9 time = 25
.meas tran vdout1_15ck4 FIND v(dout1_15) AT=25.025n

* CHECK dout1_16 Vdout1_16ck4 = 0.9 time = 25
.meas tran vdout1_16ck4 FIND v(dout1_16) AT=25.025n

* CHECK dout1_17 Vdout1_17ck4 = 0.9 time = 25
.meas tran vdout1_17ck4 FIND v(dout1_17) AT=25.025n

* CHECK dout1_18 Vdout1_18ck4 = 0 time = 25
.meas tran vdout1_18ck4 FIND v(dout1_18) AT=25.025n

* CHECK dout1_19 Vdout1_19ck4 = 0.9 time = 25
.meas tran vdout1_19ck4 FIND v(dout1_19) AT=25.025n

* CHECK dout1_20 Vdout1_20ck4 = 0 time = 25
.meas tran vdout1_20ck4 FIND v(dout1_20) AT=25.025n

* CHECK dout1_21 Vdout1_21ck4 = 0 time = 25
.meas tran vdout1_21ck4 FIND v(dout1_21) AT=25.025n

* CHECK dout1_22 Vdout1_22ck4 = 0 time = 25
.meas tran vdout1_22ck4 FIND v(dout1_22) AT=25.025n

* CHECK dout1_23 Vdout1_23ck4 = 0 time = 25
.meas tran vdout1_23ck4 FIND v(dout1_23) AT=25.025n

* CHECK dout1_24 Vdout1_24ck4 = 0 time = 25
.meas tran vdout1_24ck4 FIND v(dout1_24) AT=25.025n

* CHECK dout1_25 Vdout1_25ck4 = 0.9 time = 25
.meas tran vdout1_25ck4 FIND v(dout1_25) AT=25.025n

* CHECK dout1_26 Vdout1_26ck4 = 0.9 time = 25
.meas tran vdout1_26ck4 FIND v(dout1_26) AT=25.025n

* CHECK dout1_27 Vdout1_27ck4 = 0.9 time = 25
.meas tran vdout1_27ck4 FIND v(dout1_27) AT=25.025n

* CHECK dout1_28 Vdout1_28ck4 = 0.9 time = 25
.meas tran vdout1_28ck4 FIND v(dout1_28) AT=25.025n

* CHECK dout1_29 Vdout1_29ck4 = 0 time = 25
.meas tran vdout1_29ck4 FIND v(dout1_29) AT=25.025n

* CHECK dout1_30 Vdout1_30ck4 = 0 time = 25
.meas tran vdout1_30ck4 FIND v(dout1_30) AT=25.025n

* CHECK dout1_31 Vdout1_31ck4 = 0.9 time = 25
.meas tran vdout1_31ck4 FIND v(dout1_31) AT=25.025n

* CHECK dout1_32 Vdout1_32ck4 = 0.9 time = 25
.meas tran vdout1_32ck4 FIND v(dout1_32) AT=25.025n

* CHECK dout1_33 Vdout1_33ck4 = 0.9 time = 25
.meas tran vdout1_33ck4 FIND v(dout1_33) AT=25.025n

* CHECK dout1_34 Vdout1_34ck4 = 0 time = 25
.meas tran vdout1_34ck4 FIND v(dout1_34) AT=25.025n

* CHECK dout1_35 Vdout1_35ck4 = 0 time = 25
.meas tran vdout1_35ck4 FIND v(dout1_35) AT=25.025n

* CHECK dout1_36 Vdout1_36ck4 = 0 time = 25
.meas tran vdout1_36ck4 FIND v(dout1_36) AT=25.025n

* CHECK dout1_37 Vdout1_37ck4 = 0 time = 25
.meas tran vdout1_37ck4 FIND v(dout1_37) AT=25.025n

* CHECK dout1_38 Vdout1_38ck4 = 0.9 time = 25
.meas tran vdout1_38ck4 FIND v(dout1_38) AT=25.025n

* CHECK dout1_39 Vdout1_39ck4 = 0.9 time = 25
.meas tran vdout1_39ck4 FIND v(dout1_39) AT=25.025n

* CHECK dout1_40 Vdout1_40ck4 = 0.9 time = 25
.meas tran vdout1_40ck4 FIND v(dout1_40) AT=25.025n

* CHECK dout1_41 Vdout1_41ck4 = 0.9 time = 25
.meas tran vdout1_41ck4 FIND v(dout1_41) AT=25.025n

* CHECK dout1_42 Vdout1_42ck4 = 0.9 time = 25
.meas tran vdout1_42ck4 FIND v(dout1_42) AT=25.025n

* CHECK dout1_43 Vdout1_43ck4 = 0 time = 25
.meas tran vdout1_43ck4 FIND v(dout1_43) AT=25.025n

* CHECK dout1_44 Vdout1_44ck4 = 0.9 time = 25
.meas tran vdout1_44ck4 FIND v(dout1_44) AT=25.025n

* CHECK dout1_45 Vdout1_45ck4 = 0 time = 25
.meas tran vdout1_45ck4 FIND v(dout1_45) AT=25.025n

* CHECK dout1_46 Vdout1_46ck4 = 0 time = 25
.meas tran vdout1_46ck4 FIND v(dout1_46) AT=25.025n

* CHECK dout1_47 Vdout1_47ck4 = 0 time = 25
.meas tran vdout1_47ck4 FIND v(dout1_47) AT=25.025n

* CHECK dout1_48 Vdout1_48ck4 = 0.9 time = 25
.meas tran vdout1_48ck4 FIND v(dout1_48) AT=25.025n

* CHECK dout1_49 Vdout1_49ck4 = 0.9 time = 25
.meas tran vdout1_49ck4 FIND v(dout1_49) AT=25.025n

* CHECK dout1_50 Vdout1_50ck4 = 0.9 time = 25
.meas tran vdout1_50ck4 FIND v(dout1_50) AT=25.025n

* CHECK dout1_51 Vdout1_51ck4 = 0.9 time = 25
.meas tran vdout1_51ck4 FIND v(dout1_51) AT=25.025n

* CHECK dout1_52 Vdout1_52ck4 = 0 time = 25
.meas tran vdout1_52ck4 FIND v(dout1_52) AT=25.025n

* CHECK dout1_53 Vdout1_53ck4 = 0 time = 25
.meas tran vdout1_53ck4 FIND v(dout1_53) AT=25.025n

* CHECK dout1_54 Vdout1_54ck4 = 0 time = 25
.meas tran vdout1_54ck4 FIND v(dout1_54) AT=25.025n

* CHECK dout1_55 Vdout1_55ck4 = 0 time = 25
.meas tran vdout1_55ck4 FIND v(dout1_55) AT=25.025n

* CHECK dout1_56 Vdout1_56ck4 = 0.9 time = 25
.meas tran vdout1_56ck4 FIND v(dout1_56) AT=25.025n

* CHECK dout1_57 Vdout1_57ck4 = 0 time = 25
.meas tran vdout1_57ck4 FIND v(dout1_57) AT=25.025n

* CHECK dout1_58 Vdout1_58ck4 = 0.9 time = 25
.meas tran vdout1_58ck4 FIND v(dout1_58) AT=25.025n

* CHECK dout1_59 Vdout1_59ck4 = 0.9 time = 25
.meas tran vdout1_59ck4 FIND v(dout1_59) AT=25.025n

* CHECK dout1_60 Vdout1_60ck4 = 0.9 time = 25
.meas tran vdout1_60ck4 FIND v(dout1_60) AT=25.025n

* CHECK dout1_61 Vdout1_61ck4 = 0.9 time = 25
.meas tran vdout1_61ck4 FIND v(dout1_61) AT=25.025n

* CHECK dout1_62 Vdout1_62ck4 = 0.9 time = 25
.meas tran vdout1_62ck4 FIND v(dout1_62) AT=25.025n

* CHECK dout1_63 Vdout1_63ck4 = 0 time = 25
.meas tran vdout1_63ck4 FIND v(dout1_63) AT=25.025n

* CHECK dout1_64 Vdout1_64ck4 = 0 time = 25
.meas tran vdout1_64ck4 FIND v(dout1_64) AT=25.025n

* CHECK dout1_65 Vdout1_65ck4 = 0 time = 25
.meas tran vdout1_65ck4 FIND v(dout1_65) AT=25.025n

* CHECK dout1_66 Vdout1_66ck4 = 0 time = 25
.meas tran vdout1_66ck4 FIND v(dout1_66) AT=25.025n

* CHECK dout1_67 Vdout1_67ck4 = 0.9 time = 25
.meas tran vdout1_67ck4 FIND v(dout1_67) AT=25.025n

* CHECK dout1_68 Vdout1_68ck4 = 0.9 time = 25
.meas tran vdout1_68ck4 FIND v(dout1_68) AT=25.025n

* CHECK dout1_69 Vdout1_69ck4 = 0 time = 25
.meas tran vdout1_69ck4 FIND v(dout1_69) AT=25.025n

* CHECK dout1_70 Vdout1_70ck4 = 0 time = 25
.meas tran vdout1_70ck4 FIND v(dout1_70) AT=25.025n

* CHECK dout1_71 Vdout1_71ck4 = 0 time = 25
.meas tran vdout1_71ck4 FIND v(dout1_71) AT=25.025n

* CHECK dout1_72 Vdout1_72ck4 = 0.9 time = 25
.meas tran vdout1_72ck4 FIND v(dout1_72) AT=25.025n

* CHECK dout1_73 Vdout1_73ck4 = 0.9 time = 25
.meas tran vdout1_73ck4 FIND v(dout1_73) AT=25.025n

* CHECK dout1_74 Vdout1_74ck4 = 0 time = 25
.meas tran vdout1_74ck4 FIND v(dout1_74) AT=25.025n

* CHECK dout1_75 Vdout1_75ck4 = 0 time = 25
.meas tran vdout1_75ck4 FIND v(dout1_75) AT=25.025n

* CHECK dout1_76 Vdout1_76ck4 = 0.9 time = 25
.meas tran vdout1_76ck4 FIND v(dout1_76) AT=25.025n

* CHECK dout1_77 Vdout1_77ck4 = 0.9 time = 25
.meas tran vdout1_77ck4 FIND v(dout1_77) AT=25.025n

* CHECK dout1_78 Vdout1_78ck4 = 0.9 time = 25
.meas tran vdout1_78ck4 FIND v(dout1_78) AT=25.025n

* CHECK dout1_79 Vdout1_79ck4 = 0 time = 25
.meas tran vdout1_79ck4 FIND v(dout1_79) AT=25.025n

* CHECK dout1_80 Vdout1_80ck4 = 0.9 time = 25
.meas tran vdout1_80ck4 FIND v(dout1_80) AT=25.025n

* CHECK dout1_81 Vdout1_81ck4 = 0 time = 25
.meas tran vdout1_81ck4 FIND v(dout1_81) AT=25.025n

* CHECK dout1_82 Vdout1_82ck4 = 0.9 time = 25
.meas tran vdout1_82ck4 FIND v(dout1_82) AT=25.025n

* CHECK dout1_83 Vdout1_83ck4 = 0.9 time = 25
.meas tran vdout1_83ck4 FIND v(dout1_83) AT=25.025n

* CHECK dout1_84 Vdout1_84ck4 = 0.9 time = 25
.meas tran vdout1_84ck4 FIND v(dout1_84) AT=25.025n

* CHECK dout1_85 Vdout1_85ck4 = 0 time = 25
.meas tran vdout1_85ck4 FIND v(dout1_85) AT=25.025n

* CHECK dout1_86 Vdout1_86ck4 = 0 time = 25
.meas tran vdout1_86ck4 FIND v(dout1_86) AT=25.025n

* CHECK dout1_87 Vdout1_87ck4 = 0.9 time = 25
.meas tran vdout1_87ck4 FIND v(dout1_87) AT=25.025n

* CHECK dout1_88 Vdout1_88ck4 = 0 time = 25
.meas tran vdout1_88ck4 FIND v(dout1_88) AT=25.025n

* CHECK dout1_89 Vdout1_89ck4 = 0 time = 25
.meas tran vdout1_89ck4 FIND v(dout1_89) AT=25.025n

* CHECK dout1_90 Vdout1_90ck4 = 0 time = 25
.meas tran vdout1_90ck4 FIND v(dout1_90) AT=25.025n

* CHECK dout1_91 Vdout1_91ck4 = 0.9 time = 25
.meas tran vdout1_91ck4 FIND v(dout1_91) AT=25.025n

* CHECK dout1_92 Vdout1_92ck4 = 0 time = 25
.meas tran vdout1_92ck4 FIND v(dout1_92) AT=25.025n

* CHECK dout1_93 Vdout1_93ck4 = 0.9 time = 25
.meas tran vdout1_93ck4 FIND v(dout1_93) AT=25.025n

* CHECK dout1_94 Vdout1_94ck4 = 0 time = 25
.meas tran vdout1_94ck4 FIND v(dout1_94) AT=25.025n

* CHECK dout1_95 Vdout1_95ck4 = 0 time = 25
.meas tran vdout1_95ck4 FIND v(dout1_95) AT=25.025n

* CHECK dout1_96 Vdout1_96ck4 = 0.9 time = 25
.meas tran vdout1_96ck4 FIND v(dout1_96) AT=25.025n

* CHECK dout1_97 Vdout1_97ck4 = 0.9 time = 25
.meas tran vdout1_97ck4 FIND v(dout1_97) AT=25.025n

* CHECK dout1_98 Vdout1_98ck4 = 0.9 time = 25
.meas tran vdout1_98ck4 FIND v(dout1_98) AT=25.025n

* CHECK dout1_99 Vdout1_99ck4 = 0.9 time = 25
.meas tran vdout1_99ck4 FIND v(dout1_99) AT=25.025n

* CHECK dout1_100 Vdout1_100ck4 = 0.9 time = 25
.meas tran vdout1_100ck4 FIND v(dout1_100) AT=25.025n

* CHECK dout1_101 Vdout1_101ck4 = 0 time = 25
.meas tran vdout1_101ck4 FIND v(dout1_101) AT=25.025n

* CHECK dout1_102 Vdout1_102ck4 = 0 time = 25
.meas tran vdout1_102ck4 FIND v(dout1_102) AT=25.025n

* CHECK dout1_103 Vdout1_103ck4 = 0.9 time = 25
.meas tran vdout1_103ck4 FIND v(dout1_103) AT=25.025n

* CHECK dout1_104 Vdout1_104ck4 = 0.9 time = 25
.meas tran vdout1_104ck4 FIND v(dout1_104) AT=25.025n

* CHECK dout1_105 Vdout1_105ck4 = 0 time = 25
.meas tran vdout1_105ck4 FIND v(dout1_105) AT=25.025n

* CHECK dout1_106 Vdout1_106ck4 = 0.9 time = 25
.meas tran vdout1_106ck4 FIND v(dout1_106) AT=25.025n

* CHECK dout1_107 Vdout1_107ck4 = 0.9 time = 25
.meas tran vdout1_107ck4 FIND v(dout1_107) AT=25.025n

* CHECK dout1_108 Vdout1_108ck4 = 0.9 time = 25
.meas tran vdout1_108ck4 FIND v(dout1_108) AT=25.025n

* CHECK dout1_109 Vdout1_109ck4 = 0 time = 25
.meas tran vdout1_109ck4 FIND v(dout1_109) AT=25.025n

* CHECK dout1_110 Vdout1_110ck4 = 0 time = 25
.meas tran vdout1_110ck4 FIND v(dout1_110) AT=25.025n

* CHECK dout1_111 Vdout1_111ck4 = 0.9 time = 25
.meas tran vdout1_111ck4 FIND v(dout1_111) AT=25.025n

* CHECK dout1_112 Vdout1_112ck4 = 0.9 time = 25
.meas tran vdout1_112ck4 FIND v(dout1_112) AT=25.025n

* CHECK dout1_113 Vdout1_113ck4 = 0 time = 25
.meas tran vdout1_113ck4 FIND v(dout1_113) AT=25.025n

* CHECK dout1_114 Vdout1_114ck4 = 0 time = 25
.meas tran vdout1_114ck4 FIND v(dout1_114) AT=25.025n

* CHECK dout1_115 Vdout1_115ck4 = 0.9 time = 25
.meas tran vdout1_115ck4 FIND v(dout1_115) AT=25.025n

* CHECK dout1_116 Vdout1_116ck4 = 0 time = 25
.meas tran vdout1_116ck4 FIND v(dout1_116) AT=25.025n

* CHECK dout1_117 Vdout1_117ck4 = 0 time = 25
.meas tran vdout1_117ck4 FIND v(dout1_117) AT=25.025n

* CHECK dout1_118 Vdout1_118ck4 = 0.9 time = 25
.meas tran vdout1_118ck4 FIND v(dout1_118) AT=25.025n

* CHECK dout1_119 Vdout1_119ck4 = 0.9 time = 25
.meas tran vdout1_119ck4 FIND v(dout1_119) AT=25.025n

* CHECK dout1_0 Vdout1_0ck6 = 0.9 time = 35
.meas tran vdout1_0ck6 FIND v(dout1_0) AT=35.025n

* CHECK dout1_1 Vdout1_1ck6 = 0 time = 35
.meas tran vdout1_1ck6 FIND v(dout1_1) AT=35.025n

* CHECK dout1_2 Vdout1_2ck6 = 0.9 time = 35
.meas tran vdout1_2ck6 FIND v(dout1_2) AT=35.025n

* CHECK dout1_3 Vdout1_3ck6 = 0.9 time = 35
.meas tran vdout1_3ck6 FIND v(dout1_3) AT=35.025n

* CHECK dout1_4 Vdout1_4ck6 = 0.9 time = 35
.meas tran vdout1_4ck6 FIND v(dout1_4) AT=35.025n

* CHECK dout1_5 Vdout1_5ck6 = 0 time = 35
.meas tran vdout1_5ck6 FIND v(dout1_5) AT=35.025n

* CHECK dout1_6 Vdout1_6ck6 = 0 time = 35
.meas tran vdout1_6ck6 FIND v(dout1_6) AT=35.025n

* CHECK dout1_7 Vdout1_7ck6 = 0.9 time = 35
.meas tran vdout1_7ck6 FIND v(dout1_7) AT=35.025n

* CHECK dout1_8 Vdout1_8ck6 = 0.9 time = 35
.meas tran vdout1_8ck6 FIND v(dout1_8) AT=35.025n

* CHECK dout1_9 Vdout1_9ck6 = 0 time = 35
.meas tran vdout1_9ck6 FIND v(dout1_9) AT=35.025n

* CHECK dout1_10 Vdout1_10ck6 = 0 time = 35
.meas tran vdout1_10ck6 FIND v(dout1_10) AT=35.025n

* CHECK dout1_11 Vdout1_11ck6 = 0.9 time = 35
.meas tran vdout1_11ck6 FIND v(dout1_11) AT=35.025n

* CHECK dout1_12 Vdout1_12ck6 = 0.9 time = 35
.meas tran vdout1_12ck6 FIND v(dout1_12) AT=35.025n

* CHECK dout1_13 Vdout1_13ck6 = 0.9 time = 35
.meas tran vdout1_13ck6 FIND v(dout1_13) AT=35.025n

* CHECK dout1_14 Vdout1_14ck6 = 0 time = 35
.meas tran vdout1_14ck6 FIND v(dout1_14) AT=35.025n

* CHECK dout1_15 Vdout1_15ck6 = 0.9 time = 35
.meas tran vdout1_15ck6 FIND v(dout1_15) AT=35.025n

* CHECK dout1_16 Vdout1_16ck6 = 0.9 time = 35
.meas tran vdout1_16ck6 FIND v(dout1_16) AT=35.025n

* CHECK dout1_17 Vdout1_17ck6 = 0.9 time = 35
.meas tran vdout1_17ck6 FIND v(dout1_17) AT=35.025n

* CHECK dout1_18 Vdout1_18ck6 = 0 time = 35
.meas tran vdout1_18ck6 FIND v(dout1_18) AT=35.025n

* CHECK dout1_19 Vdout1_19ck6 = 0.9 time = 35
.meas tran vdout1_19ck6 FIND v(dout1_19) AT=35.025n

* CHECK dout1_20 Vdout1_20ck6 = 0 time = 35
.meas tran vdout1_20ck6 FIND v(dout1_20) AT=35.025n

* CHECK dout1_21 Vdout1_21ck6 = 0 time = 35
.meas tran vdout1_21ck6 FIND v(dout1_21) AT=35.025n

* CHECK dout1_22 Vdout1_22ck6 = 0 time = 35
.meas tran vdout1_22ck6 FIND v(dout1_22) AT=35.025n

* CHECK dout1_23 Vdout1_23ck6 = 0 time = 35
.meas tran vdout1_23ck6 FIND v(dout1_23) AT=35.025n

* CHECK dout1_24 Vdout1_24ck6 = 0 time = 35
.meas tran vdout1_24ck6 FIND v(dout1_24) AT=35.025n

* CHECK dout1_25 Vdout1_25ck6 = 0.9 time = 35
.meas tran vdout1_25ck6 FIND v(dout1_25) AT=35.025n

* CHECK dout1_26 Vdout1_26ck6 = 0.9 time = 35
.meas tran vdout1_26ck6 FIND v(dout1_26) AT=35.025n

* CHECK dout1_27 Vdout1_27ck6 = 0.9 time = 35
.meas tran vdout1_27ck6 FIND v(dout1_27) AT=35.025n

* CHECK dout1_28 Vdout1_28ck6 = 0.9 time = 35
.meas tran vdout1_28ck6 FIND v(dout1_28) AT=35.025n

* CHECK dout1_29 Vdout1_29ck6 = 0 time = 35
.meas tran vdout1_29ck6 FIND v(dout1_29) AT=35.025n

* CHECK dout1_30 Vdout1_30ck6 = 0 time = 35
.meas tran vdout1_30ck6 FIND v(dout1_30) AT=35.025n

* CHECK dout1_31 Vdout1_31ck6 = 0.9 time = 35
.meas tran vdout1_31ck6 FIND v(dout1_31) AT=35.025n

* CHECK dout1_32 Vdout1_32ck6 = 0.9 time = 35
.meas tran vdout1_32ck6 FIND v(dout1_32) AT=35.025n

* CHECK dout1_33 Vdout1_33ck6 = 0.9 time = 35
.meas tran vdout1_33ck6 FIND v(dout1_33) AT=35.025n

* CHECK dout1_34 Vdout1_34ck6 = 0 time = 35
.meas tran vdout1_34ck6 FIND v(dout1_34) AT=35.025n

* CHECK dout1_35 Vdout1_35ck6 = 0 time = 35
.meas tran vdout1_35ck6 FIND v(dout1_35) AT=35.025n

* CHECK dout1_36 Vdout1_36ck6 = 0 time = 35
.meas tran vdout1_36ck6 FIND v(dout1_36) AT=35.025n

* CHECK dout1_37 Vdout1_37ck6 = 0 time = 35
.meas tran vdout1_37ck6 FIND v(dout1_37) AT=35.025n

* CHECK dout1_38 Vdout1_38ck6 = 0.9 time = 35
.meas tran vdout1_38ck6 FIND v(dout1_38) AT=35.025n

* CHECK dout1_39 Vdout1_39ck6 = 0.9 time = 35
.meas tran vdout1_39ck6 FIND v(dout1_39) AT=35.025n

* CHECK dout1_40 Vdout1_40ck6 = 0.9 time = 35
.meas tran vdout1_40ck6 FIND v(dout1_40) AT=35.025n

* CHECK dout1_41 Vdout1_41ck6 = 0.9 time = 35
.meas tran vdout1_41ck6 FIND v(dout1_41) AT=35.025n

* CHECK dout1_42 Vdout1_42ck6 = 0.9 time = 35
.meas tran vdout1_42ck6 FIND v(dout1_42) AT=35.025n

* CHECK dout1_43 Vdout1_43ck6 = 0 time = 35
.meas tran vdout1_43ck6 FIND v(dout1_43) AT=35.025n

* CHECK dout1_44 Vdout1_44ck6 = 0.9 time = 35
.meas tran vdout1_44ck6 FIND v(dout1_44) AT=35.025n

* CHECK dout1_45 Vdout1_45ck6 = 0 time = 35
.meas tran vdout1_45ck6 FIND v(dout1_45) AT=35.025n

* CHECK dout1_46 Vdout1_46ck6 = 0 time = 35
.meas tran vdout1_46ck6 FIND v(dout1_46) AT=35.025n

* CHECK dout1_47 Vdout1_47ck6 = 0 time = 35
.meas tran vdout1_47ck6 FIND v(dout1_47) AT=35.025n

* CHECK dout1_48 Vdout1_48ck6 = 0.9 time = 35
.meas tran vdout1_48ck6 FIND v(dout1_48) AT=35.025n

* CHECK dout1_49 Vdout1_49ck6 = 0.9 time = 35
.meas tran vdout1_49ck6 FIND v(dout1_49) AT=35.025n

* CHECK dout1_50 Vdout1_50ck6 = 0.9 time = 35
.meas tran vdout1_50ck6 FIND v(dout1_50) AT=35.025n

* CHECK dout1_51 Vdout1_51ck6 = 0.9 time = 35
.meas tran vdout1_51ck6 FIND v(dout1_51) AT=35.025n

* CHECK dout1_52 Vdout1_52ck6 = 0 time = 35
.meas tran vdout1_52ck6 FIND v(dout1_52) AT=35.025n

* CHECK dout1_53 Vdout1_53ck6 = 0 time = 35
.meas tran vdout1_53ck6 FIND v(dout1_53) AT=35.025n

* CHECK dout1_54 Vdout1_54ck6 = 0 time = 35
.meas tran vdout1_54ck6 FIND v(dout1_54) AT=35.025n

* CHECK dout1_55 Vdout1_55ck6 = 0 time = 35
.meas tran vdout1_55ck6 FIND v(dout1_55) AT=35.025n

* CHECK dout1_56 Vdout1_56ck6 = 0.9 time = 35
.meas tran vdout1_56ck6 FIND v(dout1_56) AT=35.025n

* CHECK dout1_57 Vdout1_57ck6 = 0 time = 35
.meas tran vdout1_57ck6 FIND v(dout1_57) AT=35.025n

* CHECK dout1_58 Vdout1_58ck6 = 0.9 time = 35
.meas tran vdout1_58ck6 FIND v(dout1_58) AT=35.025n

* CHECK dout1_59 Vdout1_59ck6 = 0.9 time = 35
.meas tran vdout1_59ck6 FIND v(dout1_59) AT=35.025n

* CHECK dout1_60 Vdout1_60ck6 = 0.9 time = 35
.meas tran vdout1_60ck6 FIND v(dout1_60) AT=35.025n

* CHECK dout1_61 Vdout1_61ck6 = 0.9 time = 35
.meas tran vdout1_61ck6 FIND v(dout1_61) AT=35.025n

* CHECK dout1_62 Vdout1_62ck6 = 0.9 time = 35
.meas tran vdout1_62ck6 FIND v(dout1_62) AT=35.025n

* CHECK dout1_63 Vdout1_63ck6 = 0 time = 35
.meas tran vdout1_63ck6 FIND v(dout1_63) AT=35.025n

* CHECK dout1_64 Vdout1_64ck6 = 0 time = 35
.meas tran vdout1_64ck6 FIND v(dout1_64) AT=35.025n

* CHECK dout1_65 Vdout1_65ck6 = 0 time = 35
.meas tran vdout1_65ck6 FIND v(dout1_65) AT=35.025n

* CHECK dout1_66 Vdout1_66ck6 = 0 time = 35
.meas tran vdout1_66ck6 FIND v(dout1_66) AT=35.025n

* CHECK dout1_67 Vdout1_67ck6 = 0.9 time = 35
.meas tran vdout1_67ck6 FIND v(dout1_67) AT=35.025n

* CHECK dout1_68 Vdout1_68ck6 = 0.9 time = 35
.meas tran vdout1_68ck6 FIND v(dout1_68) AT=35.025n

* CHECK dout1_69 Vdout1_69ck6 = 0 time = 35
.meas tran vdout1_69ck6 FIND v(dout1_69) AT=35.025n

* CHECK dout1_70 Vdout1_70ck6 = 0 time = 35
.meas tran vdout1_70ck6 FIND v(dout1_70) AT=35.025n

* CHECK dout1_71 Vdout1_71ck6 = 0 time = 35
.meas tran vdout1_71ck6 FIND v(dout1_71) AT=35.025n

* CHECK dout1_72 Vdout1_72ck6 = 0.9 time = 35
.meas tran vdout1_72ck6 FIND v(dout1_72) AT=35.025n

* CHECK dout1_73 Vdout1_73ck6 = 0.9 time = 35
.meas tran vdout1_73ck6 FIND v(dout1_73) AT=35.025n

* CHECK dout1_74 Vdout1_74ck6 = 0 time = 35
.meas tran vdout1_74ck6 FIND v(dout1_74) AT=35.025n

* CHECK dout1_75 Vdout1_75ck6 = 0 time = 35
.meas tran vdout1_75ck6 FIND v(dout1_75) AT=35.025n

* CHECK dout1_76 Vdout1_76ck6 = 0.9 time = 35
.meas tran vdout1_76ck6 FIND v(dout1_76) AT=35.025n

* CHECK dout1_77 Vdout1_77ck6 = 0.9 time = 35
.meas tran vdout1_77ck6 FIND v(dout1_77) AT=35.025n

* CHECK dout1_78 Vdout1_78ck6 = 0.9 time = 35
.meas tran vdout1_78ck6 FIND v(dout1_78) AT=35.025n

* CHECK dout1_79 Vdout1_79ck6 = 0 time = 35
.meas tran vdout1_79ck6 FIND v(dout1_79) AT=35.025n

* CHECK dout1_80 Vdout1_80ck6 = 0.9 time = 35
.meas tran vdout1_80ck6 FIND v(dout1_80) AT=35.025n

* CHECK dout1_81 Vdout1_81ck6 = 0 time = 35
.meas tran vdout1_81ck6 FIND v(dout1_81) AT=35.025n

* CHECK dout1_82 Vdout1_82ck6 = 0.9 time = 35
.meas tran vdout1_82ck6 FIND v(dout1_82) AT=35.025n

* CHECK dout1_83 Vdout1_83ck6 = 0.9 time = 35
.meas tran vdout1_83ck6 FIND v(dout1_83) AT=35.025n

* CHECK dout1_84 Vdout1_84ck6 = 0.9 time = 35
.meas tran vdout1_84ck6 FIND v(dout1_84) AT=35.025n

* CHECK dout1_85 Vdout1_85ck6 = 0 time = 35
.meas tran vdout1_85ck6 FIND v(dout1_85) AT=35.025n

* CHECK dout1_86 Vdout1_86ck6 = 0 time = 35
.meas tran vdout1_86ck6 FIND v(dout1_86) AT=35.025n

* CHECK dout1_87 Vdout1_87ck6 = 0.9 time = 35
.meas tran vdout1_87ck6 FIND v(dout1_87) AT=35.025n

* CHECK dout1_88 Vdout1_88ck6 = 0 time = 35
.meas tran vdout1_88ck6 FIND v(dout1_88) AT=35.025n

* CHECK dout1_89 Vdout1_89ck6 = 0 time = 35
.meas tran vdout1_89ck6 FIND v(dout1_89) AT=35.025n

* CHECK dout1_90 Vdout1_90ck6 = 0 time = 35
.meas tran vdout1_90ck6 FIND v(dout1_90) AT=35.025n

* CHECK dout1_91 Vdout1_91ck6 = 0.9 time = 35
.meas tran vdout1_91ck6 FIND v(dout1_91) AT=35.025n

* CHECK dout1_92 Vdout1_92ck6 = 0 time = 35
.meas tran vdout1_92ck6 FIND v(dout1_92) AT=35.025n

* CHECK dout1_93 Vdout1_93ck6 = 0.9 time = 35
.meas tran vdout1_93ck6 FIND v(dout1_93) AT=35.025n

* CHECK dout1_94 Vdout1_94ck6 = 0 time = 35
.meas tran vdout1_94ck6 FIND v(dout1_94) AT=35.025n

* CHECK dout1_95 Vdout1_95ck6 = 0 time = 35
.meas tran vdout1_95ck6 FIND v(dout1_95) AT=35.025n

* CHECK dout1_96 Vdout1_96ck6 = 0.9 time = 35
.meas tran vdout1_96ck6 FIND v(dout1_96) AT=35.025n

* CHECK dout1_97 Vdout1_97ck6 = 0.9 time = 35
.meas tran vdout1_97ck6 FIND v(dout1_97) AT=35.025n

* CHECK dout1_98 Vdout1_98ck6 = 0.9 time = 35
.meas tran vdout1_98ck6 FIND v(dout1_98) AT=35.025n

* CHECK dout1_99 Vdout1_99ck6 = 0.9 time = 35
.meas tran vdout1_99ck6 FIND v(dout1_99) AT=35.025n

* CHECK dout1_100 Vdout1_100ck6 = 0.9 time = 35
.meas tran vdout1_100ck6 FIND v(dout1_100) AT=35.025n

* CHECK dout1_101 Vdout1_101ck6 = 0 time = 35
.meas tran vdout1_101ck6 FIND v(dout1_101) AT=35.025n

* CHECK dout1_102 Vdout1_102ck6 = 0 time = 35
.meas tran vdout1_102ck6 FIND v(dout1_102) AT=35.025n

* CHECK dout1_103 Vdout1_103ck6 = 0.9 time = 35
.meas tran vdout1_103ck6 FIND v(dout1_103) AT=35.025n

* CHECK dout1_104 Vdout1_104ck6 = 0.9 time = 35
.meas tran vdout1_104ck6 FIND v(dout1_104) AT=35.025n

* CHECK dout1_105 Vdout1_105ck6 = 0 time = 35
.meas tran vdout1_105ck6 FIND v(dout1_105) AT=35.025n

* CHECK dout1_106 Vdout1_106ck6 = 0.9 time = 35
.meas tran vdout1_106ck6 FIND v(dout1_106) AT=35.025n

* CHECK dout1_107 Vdout1_107ck6 = 0.9 time = 35
.meas tran vdout1_107ck6 FIND v(dout1_107) AT=35.025n

* CHECK dout1_108 Vdout1_108ck6 = 0.9 time = 35
.meas tran vdout1_108ck6 FIND v(dout1_108) AT=35.025n

* CHECK dout1_109 Vdout1_109ck6 = 0 time = 35
.meas tran vdout1_109ck6 FIND v(dout1_109) AT=35.025n

* CHECK dout1_110 Vdout1_110ck6 = 0 time = 35
.meas tran vdout1_110ck6 FIND v(dout1_110) AT=35.025n

* CHECK dout1_111 Vdout1_111ck6 = 0.9 time = 35
.meas tran vdout1_111ck6 FIND v(dout1_111) AT=35.025n

* CHECK dout1_112 Vdout1_112ck6 = 0.9 time = 35
.meas tran vdout1_112ck6 FIND v(dout1_112) AT=35.025n

* CHECK dout1_113 Vdout1_113ck6 = 0 time = 35
.meas tran vdout1_113ck6 FIND v(dout1_113) AT=35.025n

* CHECK dout1_114 Vdout1_114ck6 = 0 time = 35
.meas tran vdout1_114ck6 FIND v(dout1_114) AT=35.025n

* CHECK dout1_115 Vdout1_115ck6 = 0.9 time = 35
.meas tran vdout1_115ck6 FIND v(dout1_115) AT=35.025n

* CHECK dout1_116 Vdout1_116ck6 = 0 time = 35
.meas tran vdout1_116ck6 FIND v(dout1_116) AT=35.025n

* CHECK dout1_117 Vdout1_117ck6 = 0 time = 35
.meas tran vdout1_117ck6 FIND v(dout1_117) AT=35.025n

* CHECK dout1_118 Vdout1_118ck6 = 0.9 time = 35
.meas tran vdout1_118ck6 FIND v(dout1_118) AT=35.025n

* CHECK dout1_119 Vdout1_119ck6 = 0.9 time = 35
.meas tran vdout1_119ck6 FIND v(dout1_119) AT=35.025n

* CHECK dout1_0 Vdout1_0ck7 = 0.9 time = 40
.meas tran vdout1_0ck7 FIND v(dout1_0) AT=40.025n

* CHECK dout1_1 Vdout1_1ck7 = 0 time = 40
.meas tran vdout1_1ck7 FIND v(dout1_1) AT=40.025n

* CHECK dout1_2 Vdout1_2ck7 = 0.9 time = 40
.meas tran vdout1_2ck7 FIND v(dout1_2) AT=40.025n

* CHECK dout1_3 Vdout1_3ck7 = 0.9 time = 40
.meas tran vdout1_3ck7 FIND v(dout1_3) AT=40.025n

* CHECK dout1_4 Vdout1_4ck7 = 0.9 time = 40
.meas tran vdout1_4ck7 FIND v(dout1_4) AT=40.025n

* CHECK dout1_5 Vdout1_5ck7 = 0 time = 40
.meas tran vdout1_5ck7 FIND v(dout1_5) AT=40.025n

* CHECK dout1_6 Vdout1_6ck7 = 0 time = 40
.meas tran vdout1_6ck7 FIND v(dout1_6) AT=40.025n

* CHECK dout1_7 Vdout1_7ck7 = 0.9 time = 40
.meas tran vdout1_7ck7 FIND v(dout1_7) AT=40.025n

* CHECK dout1_8 Vdout1_8ck7 = 0.9 time = 40
.meas tran vdout1_8ck7 FIND v(dout1_8) AT=40.025n

* CHECK dout1_9 Vdout1_9ck7 = 0 time = 40
.meas tran vdout1_9ck7 FIND v(dout1_9) AT=40.025n

* CHECK dout1_10 Vdout1_10ck7 = 0 time = 40
.meas tran vdout1_10ck7 FIND v(dout1_10) AT=40.025n

* CHECK dout1_11 Vdout1_11ck7 = 0.9 time = 40
.meas tran vdout1_11ck7 FIND v(dout1_11) AT=40.025n

* CHECK dout1_12 Vdout1_12ck7 = 0.9 time = 40
.meas tran vdout1_12ck7 FIND v(dout1_12) AT=40.025n

* CHECK dout1_13 Vdout1_13ck7 = 0.9 time = 40
.meas tran vdout1_13ck7 FIND v(dout1_13) AT=40.025n

* CHECK dout1_14 Vdout1_14ck7 = 0 time = 40
.meas tran vdout1_14ck7 FIND v(dout1_14) AT=40.025n

* CHECK dout1_15 Vdout1_15ck7 = 0.9 time = 40
.meas tran vdout1_15ck7 FIND v(dout1_15) AT=40.025n

* CHECK dout1_16 Vdout1_16ck7 = 0.9 time = 40
.meas tran vdout1_16ck7 FIND v(dout1_16) AT=40.025n

* CHECK dout1_17 Vdout1_17ck7 = 0.9 time = 40
.meas tran vdout1_17ck7 FIND v(dout1_17) AT=40.025n

* CHECK dout1_18 Vdout1_18ck7 = 0 time = 40
.meas tran vdout1_18ck7 FIND v(dout1_18) AT=40.025n

* CHECK dout1_19 Vdout1_19ck7 = 0.9 time = 40
.meas tran vdout1_19ck7 FIND v(dout1_19) AT=40.025n

* CHECK dout1_20 Vdout1_20ck7 = 0 time = 40
.meas tran vdout1_20ck7 FIND v(dout1_20) AT=40.025n

* CHECK dout1_21 Vdout1_21ck7 = 0 time = 40
.meas tran vdout1_21ck7 FIND v(dout1_21) AT=40.025n

* CHECK dout1_22 Vdout1_22ck7 = 0 time = 40
.meas tran vdout1_22ck7 FIND v(dout1_22) AT=40.025n

* CHECK dout1_23 Vdout1_23ck7 = 0 time = 40
.meas tran vdout1_23ck7 FIND v(dout1_23) AT=40.025n

* CHECK dout1_24 Vdout1_24ck7 = 0 time = 40
.meas tran vdout1_24ck7 FIND v(dout1_24) AT=40.025n

* CHECK dout1_25 Vdout1_25ck7 = 0.9 time = 40
.meas tran vdout1_25ck7 FIND v(dout1_25) AT=40.025n

* CHECK dout1_26 Vdout1_26ck7 = 0.9 time = 40
.meas tran vdout1_26ck7 FIND v(dout1_26) AT=40.025n

* CHECK dout1_27 Vdout1_27ck7 = 0.9 time = 40
.meas tran vdout1_27ck7 FIND v(dout1_27) AT=40.025n

* CHECK dout1_28 Vdout1_28ck7 = 0.9 time = 40
.meas tran vdout1_28ck7 FIND v(dout1_28) AT=40.025n

* CHECK dout1_29 Vdout1_29ck7 = 0 time = 40
.meas tran vdout1_29ck7 FIND v(dout1_29) AT=40.025n

* CHECK dout1_30 Vdout1_30ck7 = 0 time = 40
.meas tran vdout1_30ck7 FIND v(dout1_30) AT=40.025n

* CHECK dout1_31 Vdout1_31ck7 = 0.9 time = 40
.meas tran vdout1_31ck7 FIND v(dout1_31) AT=40.025n

* CHECK dout1_32 Vdout1_32ck7 = 0.9 time = 40
.meas tran vdout1_32ck7 FIND v(dout1_32) AT=40.025n

* CHECK dout1_33 Vdout1_33ck7 = 0.9 time = 40
.meas tran vdout1_33ck7 FIND v(dout1_33) AT=40.025n

* CHECK dout1_34 Vdout1_34ck7 = 0 time = 40
.meas tran vdout1_34ck7 FIND v(dout1_34) AT=40.025n

* CHECK dout1_35 Vdout1_35ck7 = 0 time = 40
.meas tran vdout1_35ck7 FIND v(dout1_35) AT=40.025n

* CHECK dout1_36 Vdout1_36ck7 = 0 time = 40
.meas tran vdout1_36ck7 FIND v(dout1_36) AT=40.025n

* CHECK dout1_37 Vdout1_37ck7 = 0 time = 40
.meas tran vdout1_37ck7 FIND v(dout1_37) AT=40.025n

* CHECK dout1_38 Vdout1_38ck7 = 0.9 time = 40
.meas tran vdout1_38ck7 FIND v(dout1_38) AT=40.025n

* CHECK dout1_39 Vdout1_39ck7 = 0.9 time = 40
.meas tran vdout1_39ck7 FIND v(dout1_39) AT=40.025n

* CHECK dout1_40 Vdout1_40ck7 = 0.9 time = 40
.meas tran vdout1_40ck7 FIND v(dout1_40) AT=40.025n

* CHECK dout1_41 Vdout1_41ck7 = 0.9 time = 40
.meas tran vdout1_41ck7 FIND v(dout1_41) AT=40.025n

* CHECK dout1_42 Vdout1_42ck7 = 0.9 time = 40
.meas tran vdout1_42ck7 FIND v(dout1_42) AT=40.025n

* CHECK dout1_43 Vdout1_43ck7 = 0 time = 40
.meas tran vdout1_43ck7 FIND v(dout1_43) AT=40.025n

* CHECK dout1_44 Vdout1_44ck7 = 0.9 time = 40
.meas tran vdout1_44ck7 FIND v(dout1_44) AT=40.025n

* CHECK dout1_45 Vdout1_45ck7 = 0 time = 40
.meas tran vdout1_45ck7 FIND v(dout1_45) AT=40.025n

* CHECK dout1_46 Vdout1_46ck7 = 0 time = 40
.meas tran vdout1_46ck7 FIND v(dout1_46) AT=40.025n

* CHECK dout1_47 Vdout1_47ck7 = 0 time = 40
.meas tran vdout1_47ck7 FIND v(dout1_47) AT=40.025n

* CHECK dout1_48 Vdout1_48ck7 = 0.9 time = 40
.meas tran vdout1_48ck7 FIND v(dout1_48) AT=40.025n

* CHECK dout1_49 Vdout1_49ck7 = 0.9 time = 40
.meas tran vdout1_49ck7 FIND v(dout1_49) AT=40.025n

* CHECK dout1_50 Vdout1_50ck7 = 0.9 time = 40
.meas tran vdout1_50ck7 FIND v(dout1_50) AT=40.025n

* CHECK dout1_51 Vdout1_51ck7 = 0.9 time = 40
.meas tran vdout1_51ck7 FIND v(dout1_51) AT=40.025n

* CHECK dout1_52 Vdout1_52ck7 = 0 time = 40
.meas tran vdout1_52ck7 FIND v(dout1_52) AT=40.025n

* CHECK dout1_53 Vdout1_53ck7 = 0 time = 40
.meas tran vdout1_53ck7 FIND v(dout1_53) AT=40.025n

* CHECK dout1_54 Vdout1_54ck7 = 0 time = 40
.meas tran vdout1_54ck7 FIND v(dout1_54) AT=40.025n

* CHECK dout1_55 Vdout1_55ck7 = 0 time = 40
.meas tran vdout1_55ck7 FIND v(dout1_55) AT=40.025n

* CHECK dout1_56 Vdout1_56ck7 = 0.9 time = 40
.meas tran vdout1_56ck7 FIND v(dout1_56) AT=40.025n

* CHECK dout1_57 Vdout1_57ck7 = 0 time = 40
.meas tran vdout1_57ck7 FIND v(dout1_57) AT=40.025n

* CHECK dout1_58 Vdout1_58ck7 = 0.9 time = 40
.meas tran vdout1_58ck7 FIND v(dout1_58) AT=40.025n

* CHECK dout1_59 Vdout1_59ck7 = 0.9 time = 40
.meas tran vdout1_59ck7 FIND v(dout1_59) AT=40.025n

* CHECK dout1_60 Vdout1_60ck7 = 0.9 time = 40
.meas tran vdout1_60ck7 FIND v(dout1_60) AT=40.025n

* CHECK dout1_61 Vdout1_61ck7 = 0.9 time = 40
.meas tran vdout1_61ck7 FIND v(dout1_61) AT=40.025n

* CHECK dout1_62 Vdout1_62ck7 = 0.9 time = 40
.meas tran vdout1_62ck7 FIND v(dout1_62) AT=40.025n

* CHECK dout1_63 Vdout1_63ck7 = 0 time = 40
.meas tran vdout1_63ck7 FIND v(dout1_63) AT=40.025n

* CHECK dout1_64 Vdout1_64ck7 = 0 time = 40
.meas tran vdout1_64ck7 FIND v(dout1_64) AT=40.025n

* CHECK dout1_65 Vdout1_65ck7 = 0 time = 40
.meas tran vdout1_65ck7 FIND v(dout1_65) AT=40.025n

* CHECK dout1_66 Vdout1_66ck7 = 0 time = 40
.meas tran vdout1_66ck7 FIND v(dout1_66) AT=40.025n

* CHECK dout1_67 Vdout1_67ck7 = 0.9 time = 40
.meas tran vdout1_67ck7 FIND v(dout1_67) AT=40.025n

* CHECK dout1_68 Vdout1_68ck7 = 0.9 time = 40
.meas tran vdout1_68ck7 FIND v(dout1_68) AT=40.025n

* CHECK dout1_69 Vdout1_69ck7 = 0 time = 40
.meas tran vdout1_69ck7 FIND v(dout1_69) AT=40.025n

* CHECK dout1_70 Vdout1_70ck7 = 0 time = 40
.meas tran vdout1_70ck7 FIND v(dout1_70) AT=40.025n

* CHECK dout1_71 Vdout1_71ck7 = 0 time = 40
.meas tran vdout1_71ck7 FIND v(dout1_71) AT=40.025n

* CHECK dout1_72 Vdout1_72ck7 = 0.9 time = 40
.meas tran vdout1_72ck7 FIND v(dout1_72) AT=40.025n

* CHECK dout1_73 Vdout1_73ck7 = 0.9 time = 40
.meas tran vdout1_73ck7 FIND v(dout1_73) AT=40.025n

* CHECK dout1_74 Vdout1_74ck7 = 0 time = 40
.meas tran vdout1_74ck7 FIND v(dout1_74) AT=40.025n

* CHECK dout1_75 Vdout1_75ck7 = 0 time = 40
.meas tran vdout1_75ck7 FIND v(dout1_75) AT=40.025n

* CHECK dout1_76 Vdout1_76ck7 = 0.9 time = 40
.meas tran vdout1_76ck7 FIND v(dout1_76) AT=40.025n

* CHECK dout1_77 Vdout1_77ck7 = 0.9 time = 40
.meas tran vdout1_77ck7 FIND v(dout1_77) AT=40.025n

* CHECK dout1_78 Vdout1_78ck7 = 0.9 time = 40
.meas tran vdout1_78ck7 FIND v(dout1_78) AT=40.025n

* CHECK dout1_79 Vdout1_79ck7 = 0 time = 40
.meas tran vdout1_79ck7 FIND v(dout1_79) AT=40.025n

* CHECK dout1_80 Vdout1_80ck7 = 0.9 time = 40
.meas tran vdout1_80ck7 FIND v(dout1_80) AT=40.025n

* CHECK dout1_81 Vdout1_81ck7 = 0 time = 40
.meas tran vdout1_81ck7 FIND v(dout1_81) AT=40.025n

* CHECK dout1_82 Vdout1_82ck7 = 0.9 time = 40
.meas tran vdout1_82ck7 FIND v(dout1_82) AT=40.025n

* CHECK dout1_83 Vdout1_83ck7 = 0.9 time = 40
.meas tran vdout1_83ck7 FIND v(dout1_83) AT=40.025n

* CHECK dout1_84 Vdout1_84ck7 = 0.9 time = 40
.meas tran vdout1_84ck7 FIND v(dout1_84) AT=40.025n

* CHECK dout1_85 Vdout1_85ck7 = 0 time = 40
.meas tran vdout1_85ck7 FIND v(dout1_85) AT=40.025n

* CHECK dout1_86 Vdout1_86ck7 = 0 time = 40
.meas tran vdout1_86ck7 FIND v(dout1_86) AT=40.025n

* CHECK dout1_87 Vdout1_87ck7 = 0.9 time = 40
.meas tran vdout1_87ck7 FIND v(dout1_87) AT=40.025n

* CHECK dout1_88 Vdout1_88ck7 = 0 time = 40
.meas tran vdout1_88ck7 FIND v(dout1_88) AT=40.025n

* CHECK dout1_89 Vdout1_89ck7 = 0 time = 40
.meas tran vdout1_89ck7 FIND v(dout1_89) AT=40.025n

* CHECK dout1_90 Vdout1_90ck7 = 0 time = 40
.meas tran vdout1_90ck7 FIND v(dout1_90) AT=40.025n

* CHECK dout1_91 Vdout1_91ck7 = 0.9 time = 40
.meas tran vdout1_91ck7 FIND v(dout1_91) AT=40.025n

* CHECK dout1_92 Vdout1_92ck7 = 0 time = 40
.meas tran vdout1_92ck7 FIND v(dout1_92) AT=40.025n

* CHECK dout1_93 Vdout1_93ck7 = 0.9 time = 40
.meas tran vdout1_93ck7 FIND v(dout1_93) AT=40.025n

* CHECK dout1_94 Vdout1_94ck7 = 0 time = 40
.meas tran vdout1_94ck7 FIND v(dout1_94) AT=40.025n

* CHECK dout1_95 Vdout1_95ck7 = 0 time = 40
.meas tran vdout1_95ck7 FIND v(dout1_95) AT=40.025n

* CHECK dout1_96 Vdout1_96ck7 = 0.9 time = 40
.meas tran vdout1_96ck7 FIND v(dout1_96) AT=40.025n

* CHECK dout1_97 Vdout1_97ck7 = 0.9 time = 40
.meas tran vdout1_97ck7 FIND v(dout1_97) AT=40.025n

* CHECK dout1_98 Vdout1_98ck7 = 0.9 time = 40
.meas tran vdout1_98ck7 FIND v(dout1_98) AT=40.025n

* CHECK dout1_99 Vdout1_99ck7 = 0.9 time = 40
.meas tran vdout1_99ck7 FIND v(dout1_99) AT=40.025n

* CHECK dout1_100 Vdout1_100ck7 = 0.9 time = 40
.meas tran vdout1_100ck7 FIND v(dout1_100) AT=40.025n

* CHECK dout1_101 Vdout1_101ck7 = 0 time = 40
.meas tran vdout1_101ck7 FIND v(dout1_101) AT=40.025n

* CHECK dout1_102 Vdout1_102ck7 = 0 time = 40
.meas tran vdout1_102ck7 FIND v(dout1_102) AT=40.025n

* CHECK dout1_103 Vdout1_103ck7 = 0.9 time = 40
.meas tran vdout1_103ck7 FIND v(dout1_103) AT=40.025n

* CHECK dout1_104 Vdout1_104ck7 = 0.9 time = 40
.meas tran vdout1_104ck7 FIND v(dout1_104) AT=40.025n

* CHECK dout1_105 Vdout1_105ck7 = 0 time = 40
.meas tran vdout1_105ck7 FIND v(dout1_105) AT=40.025n

* CHECK dout1_106 Vdout1_106ck7 = 0.9 time = 40
.meas tran vdout1_106ck7 FIND v(dout1_106) AT=40.025n

* CHECK dout1_107 Vdout1_107ck7 = 0.9 time = 40
.meas tran vdout1_107ck7 FIND v(dout1_107) AT=40.025n

* CHECK dout1_108 Vdout1_108ck7 = 0.9 time = 40
.meas tran vdout1_108ck7 FIND v(dout1_108) AT=40.025n

* CHECK dout1_109 Vdout1_109ck7 = 0 time = 40
.meas tran vdout1_109ck7 FIND v(dout1_109) AT=40.025n

* CHECK dout1_110 Vdout1_110ck7 = 0 time = 40
.meas tran vdout1_110ck7 FIND v(dout1_110) AT=40.025n

* CHECK dout1_111 Vdout1_111ck7 = 0.9 time = 40
.meas tran vdout1_111ck7 FIND v(dout1_111) AT=40.025n

* CHECK dout1_112 Vdout1_112ck7 = 0.9 time = 40
.meas tran vdout1_112ck7 FIND v(dout1_112) AT=40.025n

* CHECK dout1_113 Vdout1_113ck7 = 0 time = 40
.meas tran vdout1_113ck7 FIND v(dout1_113) AT=40.025n

* CHECK dout1_114 Vdout1_114ck7 = 0 time = 40
.meas tran vdout1_114ck7 FIND v(dout1_114) AT=40.025n

* CHECK dout1_115 Vdout1_115ck7 = 0.9 time = 40
.meas tran vdout1_115ck7 FIND v(dout1_115) AT=40.025n

* CHECK dout1_116 Vdout1_116ck7 = 0 time = 40
.meas tran vdout1_116ck7 FIND v(dout1_116) AT=40.025n

* CHECK dout1_117 Vdout1_117ck7 = 0 time = 40
.meas tran vdout1_117ck7 FIND v(dout1_117) AT=40.025n

* CHECK dout1_118 Vdout1_118ck7 = 0.9 time = 40
.meas tran vdout1_118ck7 FIND v(dout1_118) AT=40.025n

* CHECK dout1_119 Vdout1_119ck7 = 0.9 time = 40
.meas tran vdout1_119ck7 FIND v(dout1_119) AT=40.025n

* CHECK dout1_0 Vdout1_0ck13 = 0 time = 70
.meas tran vdout1_0ck13 FIND v(dout1_0) AT=70.025n

* CHECK dout1_1 Vdout1_1ck13 = 0 time = 70
.meas tran vdout1_1ck13 FIND v(dout1_1) AT=70.025n

* CHECK dout1_2 Vdout1_2ck13 = 0 time = 70
.meas tran vdout1_2ck13 FIND v(dout1_2) AT=70.025n

* CHECK dout1_3 Vdout1_3ck13 = 0.9 time = 70
.meas tran vdout1_3ck13 FIND v(dout1_3) AT=70.025n

* CHECK dout1_4 Vdout1_4ck13 = 0 time = 70
.meas tran vdout1_4ck13 FIND v(dout1_4) AT=70.025n

* CHECK dout1_5 Vdout1_5ck13 = 0.9 time = 70
.meas tran vdout1_5ck13 FIND v(dout1_5) AT=70.025n

* CHECK dout1_6 Vdout1_6ck13 = 0 time = 70
.meas tran vdout1_6ck13 FIND v(dout1_6) AT=70.025n

* CHECK dout1_7 Vdout1_7ck13 = 0 time = 70
.meas tran vdout1_7ck13 FIND v(dout1_7) AT=70.025n

* CHECK dout1_8 Vdout1_8ck13 = 0.9 time = 70
.meas tran vdout1_8ck13 FIND v(dout1_8) AT=70.025n

* CHECK dout1_9 Vdout1_9ck13 = 0.9 time = 70
.meas tran vdout1_9ck13 FIND v(dout1_9) AT=70.025n

* CHECK dout1_10 Vdout1_10ck13 = 0 time = 70
.meas tran vdout1_10ck13 FIND v(dout1_10) AT=70.025n

* CHECK dout1_11 Vdout1_11ck13 = 0.9 time = 70
.meas tran vdout1_11ck13 FIND v(dout1_11) AT=70.025n

* CHECK dout1_12 Vdout1_12ck13 = 0 time = 70
.meas tran vdout1_12ck13 FIND v(dout1_12) AT=70.025n

* CHECK dout1_13 Vdout1_13ck13 = 0 time = 70
.meas tran vdout1_13ck13 FIND v(dout1_13) AT=70.025n

* CHECK dout1_14 Vdout1_14ck13 = 0.9 time = 70
.meas tran vdout1_14ck13 FIND v(dout1_14) AT=70.025n

* CHECK dout1_15 Vdout1_15ck13 = 0.9 time = 70
.meas tran vdout1_15ck13 FIND v(dout1_15) AT=70.025n

* CHECK dout1_16 Vdout1_16ck13 = 0.9 time = 70
.meas tran vdout1_16ck13 FIND v(dout1_16) AT=70.025n

* CHECK dout1_17 Vdout1_17ck13 = 0 time = 70
.meas tran vdout1_17ck13 FIND v(dout1_17) AT=70.025n

* CHECK dout1_18 Vdout1_18ck13 = 0 time = 70
.meas tran vdout1_18ck13 FIND v(dout1_18) AT=70.025n

* CHECK dout1_19 Vdout1_19ck13 = 0 time = 70
.meas tran vdout1_19ck13 FIND v(dout1_19) AT=70.025n

* CHECK dout1_20 Vdout1_20ck13 = 0 time = 70
.meas tran vdout1_20ck13 FIND v(dout1_20) AT=70.025n

* CHECK dout1_21 Vdout1_21ck13 = 0 time = 70
.meas tran vdout1_21ck13 FIND v(dout1_21) AT=70.025n

* CHECK dout1_22 Vdout1_22ck13 = 0 time = 70
.meas tran vdout1_22ck13 FIND v(dout1_22) AT=70.025n

* CHECK dout1_23 Vdout1_23ck13 = 0 time = 70
.meas tran vdout1_23ck13 FIND v(dout1_23) AT=70.025n

* CHECK dout1_24 Vdout1_24ck13 = 0.9 time = 70
.meas tran vdout1_24ck13 FIND v(dout1_24) AT=70.025n

* CHECK dout1_25 Vdout1_25ck13 = 0 time = 70
.meas tran vdout1_25ck13 FIND v(dout1_25) AT=70.025n

* CHECK dout1_26 Vdout1_26ck13 = 0 time = 70
.meas tran vdout1_26ck13 FIND v(dout1_26) AT=70.025n

* CHECK dout1_27 Vdout1_27ck13 = 0.9 time = 70
.meas tran vdout1_27ck13 FIND v(dout1_27) AT=70.025n

* CHECK dout1_28 Vdout1_28ck13 = 0.9 time = 70
.meas tran vdout1_28ck13 FIND v(dout1_28) AT=70.025n

* CHECK dout1_29 Vdout1_29ck13 = 0.9 time = 70
.meas tran vdout1_29ck13 FIND v(dout1_29) AT=70.025n

* CHECK dout1_30 Vdout1_30ck13 = 0 time = 70
.meas tran vdout1_30ck13 FIND v(dout1_30) AT=70.025n

* CHECK dout1_31 Vdout1_31ck13 = 0 time = 70
.meas tran vdout1_31ck13 FIND v(dout1_31) AT=70.025n

* CHECK dout1_32 Vdout1_32ck13 = 0 time = 70
.meas tran vdout1_32ck13 FIND v(dout1_32) AT=70.025n

* CHECK dout1_33 Vdout1_33ck13 = 0.9 time = 70
.meas tran vdout1_33ck13 FIND v(dout1_33) AT=70.025n

* CHECK dout1_34 Vdout1_34ck13 = 0.9 time = 70
.meas tran vdout1_34ck13 FIND v(dout1_34) AT=70.025n

* CHECK dout1_35 Vdout1_35ck13 = 0 time = 70
.meas tran vdout1_35ck13 FIND v(dout1_35) AT=70.025n

* CHECK dout1_36 Vdout1_36ck13 = 0.9 time = 70
.meas tran vdout1_36ck13 FIND v(dout1_36) AT=70.025n

* CHECK dout1_37 Vdout1_37ck13 = 0.9 time = 70
.meas tran vdout1_37ck13 FIND v(dout1_37) AT=70.025n

* CHECK dout1_38 Vdout1_38ck13 = 0.9 time = 70
.meas tran vdout1_38ck13 FIND v(dout1_38) AT=70.025n

* CHECK dout1_39 Vdout1_39ck13 = 0.9 time = 70
.meas tran vdout1_39ck13 FIND v(dout1_39) AT=70.025n

* CHECK dout1_40 Vdout1_40ck13 = 0.9 time = 70
.meas tran vdout1_40ck13 FIND v(dout1_40) AT=70.025n

* CHECK dout1_41 Vdout1_41ck13 = 0.9 time = 70
.meas tran vdout1_41ck13 FIND v(dout1_41) AT=70.025n

* CHECK dout1_42 Vdout1_42ck13 = 0 time = 70
.meas tran vdout1_42ck13 FIND v(dout1_42) AT=70.025n

* CHECK dout1_43 Vdout1_43ck13 = 0.9 time = 70
.meas tran vdout1_43ck13 FIND v(dout1_43) AT=70.025n

* CHECK dout1_44 Vdout1_44ck13 = 0.9 time = 70
.meas tran vdout1_44ck13 FIND v(dout1_44) AT=70.025n

* CHECK dout1_45 Vdout1_45ck13 = 0.9 time = 70
.meas tran vdout1_45ck13 FIND v(dout1_45) AT=70.025n

* CHECK dout1_46 Vdout1_46ck13 = 0.9 time = 70
.meas tran vdout1_46ck13 FIND v(dout1_46) AT=70.025n

* CHECK dout1_47 Vdout1_47ck13 = 0 time = 70
.meas tran vdout1_47ck13 FIND v(dout1_47) AT=70.025n

* CHECK dout1_48 Vdout1_48ck13 = 0.9 time = 70
.meas tran vdout1_48ck13 FIND v(dout1_48) AT=70.025n

* CHECK dout1_49 Vdout1_49ck13 = 0 time = 70
.meas tran vdout1_49ck13 FIND v(dout1_49) AT=70.025n

* CHECK dout1_50 Vdout1_50ck13 = 0.9 time = 70
.meas tran vdout1_50ck13 FIND v(dout1_50) AT=70.025n

* CHECK dout1_51 Vdout1_51ck13 = 0 time = 70
.meas tran vdout1_51ck13 FIND v(dout1_51) AT=70.025n

* CHECK dout1_52 Vdout1_52ck13 = 0 time = 70
.meas tran vdout1_52ck13 FIND v(dout1_52) AT=70.025n

* CHECK dout1_53 Vdout1_53ck13 = 0.9 time = 70
.meas tran vdout1_53ck13 FIND v(dout1_53) AT=70.025n

* CHECK dout1_54 Vdout1_54ck13 = 0 time = 70
.meas tran vdout1_54ck13 FIND v(dout1_54) AT=70.025n

* CHECK dout1_55 Vdout1_55ck13 = 0.9 time = 70
.meas tran vdout1_55ck13 FIND v(dout1_55) AT=70.025n

* CHECK dout1_56 Vdout1_56ck13 = 0 time = 70
.meas tran vdout1_56ck13 FIND v(dout1_56) AT=70.025n

* CHECK dout1_57 Vdout1_57ck13 = 0 time = 70
.meas tran vdout1_57ck13 FIND v(dout1_57) AT=70.025n

* CHECK dout1_58 Vdout1_58ck13 = 0.9 time = 70
.meas tran vdout1_58ck13 FIND v(dout1_58) AT=70.025n

* CHECK dout1_59 Vdout1_59ck13 = 0 time = 70
.meas tran vdout1_59ck13 FIND v(dout1_59) AT=70.025n

* CHECK dout1_60 Vdout1_60ck13 = 0 time = 70
.meas tran vdout1_60ck13 FIND v(dout1_60) AT=70.025n

* CHECK dout1_61 Vdout1_61ck13 = 0.9 time = 70
.meas tran vdout1_61ck13 FIND v(dout1_61) AT=70.025n

* CHECK dout1_62 Vdout1_62ck13 = 0 time = 70
.meas tran vdout1_62ck13 FIND v(dout1_62) AT=70.025n

* CHECK dout1_63 Vdout1_63ck13 = 0 time = 70
.meas tran vdout1_63ck13 FIND v(dout1_63) AT=70.025n

* CHECK dout1_64 Vdout1_64ck13 = 0 time = 70
.meas tran vdout1_64ck13 FIND v(dout1_64) AT=70.025n

* CHECK dout1_65 Vdout1_65ck13 = 0 time = 70
.meas tran vdout1_65ck13 FIND v(dout1_65) AT=70.025n

* CHECK dout1_66 Vdout1_66ck13 = 0 time = 70
.meas tran vdout1_66ck13 FIND v(dout1_66) AT=70.025n

* CHECK dout1_67 Vdout1_67ck13 = 0 time = 70
.meas tran vdout1_67ck13 FIND v(dout1_67) AT=70.025n

* CHECK dout1_68 Vdout1_68ck13 = 0 time = 70
.meas tran vdout1_68ck13 FIND v(dout1_68) AT=70.025n

* CHECK dout1_69 Vdout1_69ck13 = 0.9 time = 70
.meas tran vdout1_69ck13 FIND v(dout1_69) AT=70.025n

* CHECK dout1_70 Vdout1_70ck13 = 0 time = 70
.meas tran vdout1_70ck13 FIND v(dout1_70) AT=70.025n

* CHECK dout1_71 Vdout1_71ck13 = 0 time = 70
.meas tran vdout1_71ck13 FIND v(dout1_71) AT=70.025n

* CHECK dout1_72 Vdout1_72ck13 = 0 time = 70
.meas tran vdout1_72ck13 FIND v(dout1_72) AT=70.025n

* CHECK dout1_73 Vdout1_73ck13 = 0 time = 70
.meas tran vdout1_73ck13 FIND v(dout1_73) AT=70.025n

* CHECK dout1_74 Vdout1_74ck13 = 0 time = 70
.meas tran vdout1_74ck13 FIND v(dout1_74) AT=70.025n

* CHECK dout1_75 Vdout1_75ck13 = 0 time = 70
.meas tran vdout1_75ck13 FIND v(dout1_75) AT=70.025n

* CHECK dout1_76 Vdout1_76ck13 = 0 time = 70
.meas tran vdout1_76ck13 FIND v(dout1_76) AT=70.025n

* CHECK dout1_77 Vdout1_77ck13 = 0.9 time = 70
.meas tran vdout1_77ck13 FIND v(dout1_77) AT=70.025n

* CHECK dout1_78 Vdout1_78ck13 = 0.9 time = 70
.meas tran vdout1_78ck13 FIND v(dout1_78) AT=70.025n

* CHECK dout1_79 Vdout1_79ck13 = 0.9 time = 70
.meas tran vdout1_79ck13 FIND v(dout1_79) AT=70.025n

* CHECK dout1_80 Vdout1_80ck13 = 0 time = 70
.meas tran vdout1_80ck13 FIND v(dout1_80) AT=70.025n

* CHECK dout1_81 Vdout1_81ck13 = 0 time = 70
.meas tran vdout1_81ck13 FIND v(dout1_81) AT=70.025n

* CHECK dout1_82 Vdout1_82ck13 = 0.9 time = 70
.meas tran vdout1_82ck13 FIND v(dout1_82) AT=70.025n

* CHECK dout1_83 Vdout1_83ck13 = 0.9 time = 70
.meas tran vdout1_83ck13 FIND v(dout1_83) AT=70.025n

* CHECK dout1_84 Vdout1_84ck13 = 0 time = 70
.meas tran vdout1_84ck13 FIND v(dout1_84) AT=70.025n

* CHECK dout1_85 Vdout1_85ck13 = 0 time = 70
.meas tran vdout1_85ck13 FIND v(dout1_85) AT=70.025n

* CHECK dout1_86 Vdout1_86ck13 = 0.9 time = 70
.meas tran vdout1_86ck13 FIND v(dout1_86) AT=70.025n

* CHECK dout1_87 Vdout1_87ck13 = 0.9 time = 70
.meas tran vdout1_87ck13 FIND v(dout1_87) AT=70.025n

* CHECK dout1_88 Vdout1_88ck13 = 0.9 time = 70
.meas tran vdout1_88ck13 FIND v(dout1_88) AT=70.025n

* CHECK dout1_89 Vdout1_89ck13 = 0.9 time = 70
.meas tran vdout1_89ck13 FIND v(dout1_89) AT=70.025n

* CHECK dout1_90 Vdout1_90ck13 = 0 time = 70
.meas tran vdout1_90ck13 FIND v(dout1_90) AT=70.025n

* CHECK dout1_91 Vdout1_91ck13 = 0 time = 70
.meas tran vdout1_91ck13 FIND v(dout1_91) AT=70.025n

* CHECK dout1_92 Vdout1_92ck13 = 0 time = 70
.meas tran vdout1_92ck13 FIND v(dout1_92) AT=70.025n

* CHECK dout1_93 Vdout1_93ck13 = 0 time = 70
.meas tran vdout1_93ck13 FIND v(dout1_93) AT=70.025n

* CHECK dout1_94 Vdout1_94ck13 = 0.9 time = 70
.meas tran vdout1_94ck13 FIND v(dout1_94) AT=70.025n

* CHECK dout1_95 Vdout1_95ck13 = 0.9 time = 70
.meas tran vdout1_95ck13 FIND v(dout1_95) AT=70.025n

* CHECK dout1_96 Vdout1_96ck13 = 0 time = 70
.meas tran vdout1_96ck13 FIND v(dout1_96) AT=70.025n

* CHECK dout1_97 Vdout1_97ck13 = 0 time = 70
.meas tran vdout1_97ck13 FIND v(dout1_97) AT=70.025n

* CHECK dout1_98 Vdout1_98ck13 = 0.9 time = 70
.meas tran vdout1_98ck13 FIND v(dout1_98) AT=70.025n

* CHECK dout1_99 Vdout1_99ck13 = 0 time = 70
.meas tran vdout1_99ck13 FIND v(dout1_99) AT=70.025n

* CHECK dout1_100 Vdout1_100ck13 = 0 time = 70
.meas tran vdout1_100ck13 FIND v(dout1_100) AT=70.025n

* CHECK dout1_101 Vdout1_101ck13 = 0 time = 70
.meas tran vdout1_101ck13 FIND v(dout1_101) AT=70.025n

* CHECK dout1_102 Vdout1_102ck13 = 0.9 time = 70
.meas tran vdout1_102ck13 FIND v(dout1_102) AT=70.025n

* CHECK dout1_103 Vdout1_103ck13 = 0.9 time = 70
.meas tran vdout1_103ck13 FIND v(dout1_103) AT=70.025n

* CHECK dout1_104 Vdout1_104ck13 = 0 time = 70
.meas tran vdout1_104ck13 FIND v(dout1_104) AT=70.025n

* CHECK dout1_105 Vdout1_105ck13 = 0 time = 70
.meas tran vdout1_105ck13 FIND v(dout1_105) AT=70.025n

* CHECK dout1_106 Vdout1_106ck13 = 0 time = 70
.meas tran vdout1_106ck13 FIND v(dout1_106) AT=70.025n

* CHECK dout1_107 Vdout1_107ck13 = 0 time = 70
.meas tran vdout1_107ck13 FIND v(dout1_107) AT=70.025n

* CHECK dout1_108 Vdout1_108ck13 = 0.9 time = 70
.meas tran vdout1_108ck13 FIND v(dout1_108) AT=70.025n

* CHECK dout1_109 Vdout1_109ck13 = 0.9 time = 70
.meas tran vdout1_109ck13 FIND v(dout1_109) AT=70.025n

* CHECK dout1_110 Vdout1_110ck13 = 0.9 time = 70
.meas tran vdout1_110ck13 FIND v(dout1_110) AT=70.025n

* CHECK dout1_111 Vdout1_111ck13 = 0.9 time = 70
.meas tran vdout1_111ck13 FIND v(dout1_111) AT=70.025n

* CHECK dout1_112 Vdout1_112ck13 = 0 time = 70
.meas tran vdout1_112ck13 FIND v(dout1_112) AT=70.025n

* CHECK dout1_113 Vdout1_113ck13 = 0.9 time = 70
.meas tran vdout1_113ck13 FIND v(dout1_113) AT=70.025n

* CHECK dout1_114 Vdout1_114ck13 = 0 time = 70
.meas tran vdout1_114ck13 FIND v(dout1_114) AT=70.025n

* CHECK dout1_115 Vdout1_115ck13 = 0.9 time = 70
.meas tran vdout1_115ck13 FIND v(dout1_115) AT=70.025n

* CHECK dout1_116 Vdout1_116ck13 = 0.9 time = 70
.meas tran vdout1_116ck13 FIND v(dout1_116) AT=70.025n

* CHECK dout1_117 Vdout1_117ck13 = 0.9 time = 70
.meas tran vdout1_117ck13 FIND v(dout1_117) AT=70.025n

* CHECK dout1_118 Vdout1_118ck13 = 0 time = 70
.meas tran vdout1_118ck13 FIND v(dout1_118) AT=70.025n

* CHECK dout1_119 Vdout1_119ck13 = 0.9 time = 70
.meas tran vdout1_119ck13 FIND v(dout1_119) AT=70.025n

* CHECK dout1_0 Vdout1_0ck14 = 0 time = 75
.meas tran vdout1_0ck14 FIND v(dout1_0) AT=75.025n

* CHECK dout1_1 Vdout1_1ck14 = 0.9 time = 75
.meas tran vdout1_1ck14 FIND v(dout1_1) AT=75.025n

* CHECK dout1_2 Vdout1_2ck14 = 0 time = 75
.meas tran vdout1_2ck14 FIND v(dout1_2) AT=75.025n

* CHECK dout1_3 Vdout1_3ck14 = 0 time = 75
.meas tran vdout1_3ck14 FIND v(dout1_3) AT=75.025n

* CHECK dout1_4 Vdout1_4ck14 = 0 time = 75
.meas tran vdout1_4ck14 FIND v(dout1_4) AT=75.025n

* CHECK dout1_5 Vdout1_5ck14 = 0 time = 75
.meas tran vdout1_5ck14 FIND v(dout1_5) AT=75.025n

* CHECK dout1_6 Vdout1_6ck14 = 0.9 time = 75
.meas tran vdout1_6ck14 FIND v(dout1_6) AT=75.025n

* CHECK dout1_7 Vdout1_7ck14 = 0 time = 75
.meas tran vdout1_7ck14 FIND v(dout1_7) AT=75.025n

* CHECK dout1_8 Vdout1_8ck14 = 0.9 time = 75
.meas tran vdout1_8ck14 FIND v(dout1_8) AT=75.025n

* CHECK dout1_9 Vdout1_9ck14 = 0 time = 75
.meas tran vdout1_9ck14 FIND v(dout1_9) AT=75.025n

* CHECK dout1_10 Vdout1_10ck14 = 0.9 time = 75
.meas tran vdout1_10ck14 FIND v(dout1_10) AT=75.025n

* CHECK dout1_11 Vdout1_11ck14 = 0 time = 75
.meas tran vdout1_11ck14 FIND v(dout1_11) AT=75.025n

* CHECK dout1_12 Vdout1_12ck14 = 0 time = 75
.meas tran vdout1_12ck14 FIND v(dout1_12) AT=75.025n

* CHECK dout1_13 Vdout1_13ck14 = 0 time = 75
.meas tran vdout1_13ck14 FIND v(dout1_13) AT=75.025n

* CHECK dout1_14 Vdout1_14ck14 = 0.9 time = 75
.meas tran vdout1_14ck14 FIND v(dout1_14) AT=75.025n

* CHECK dout1_15 Vdout1_15ck14 = 0 time = 75
.meas tran vdout1_15ck14 FIND v(dout1_15) AT=75.025n

* CHECK dout1_16 Vdout1_16ck14 = 0 time = 75
.meas tran vdout1_16ck14 FIND v(dout1_16) AT=75.025n

* CHECK dout1_17 Vdout1_17ck14 = 0.9 time = 75
.meas tran vdout1_17ck14 FIND v(dout1_17) AT=75.025n

* CHECK dout1_18 Vdout1_18ck14 = 0 time = 75
.meas tran vdout1_18ck14 FIND v(dout1_18) AT=75.025n

* CHECK dout1_19 Vdout1_19ck14 = 0.9 time = 75
.meas tran vdout1_19ck14 FIND v(dout1_19) AT=75.025n

* CHECK dout1_20 Vdout1_20ck14 = 0 time = 75
.meas tran vdout1_20ck14 FIND v(dout1_20) AT=75.025n

* CHECK dout1_21 Vdout1_21ck14 = 0 time = 75
.meas tran vdout1_21ck14 FIND v(dout1_21) AT=75.025n

* CHECK dout1_22 Vdout1_22ck14 = 0.9 time = 75
.meas tran vdout1_22ck14 FIND v(dout1_22) AT=75.025n

* CHECK dout1_23 Vdout1_23ck14 = 0 time = 75
.meas tran vdout1_23ck14 FIND v(dout1_23) AT=75.025n

* CHECK dout1_24 Vdout1_24ck14 = 0 time = 75
.meas tran vdout1_24ck14 FIND v(dout1_24) AT=75.025n

* CHECK dout1_25 Vdout1_25ck14 = 0 time = 75
.meas tran vdout1_25ck14 FIND v(dout1_25) AT=75.025n

* CHECK dout1_26 Vdout1_26ck14 = 0.9 time = 75
.meas tran vdout1_26ck14 FIND v(dout1_26) AT=75.025n

* CHECK dout1_27 Vdout1_27ck14 = 0 time = 75
.meas tran vdout1_27ck14 FIND v(dout1_27) AT=75.025n

* CHECK dout1_28 Vdout1_28ck14 = 0.9 time = 75
.meas tran vdout1_28ck14 FIND v(dout1_28) AT=75.025n

* CHECK dout1_29 Vdout1_29ck14 = 0.9 time = 75
.meas tran vdout1_29ck14 FIND v(dout1_29) AT=75.025n

* CHECK dout1_30 Vdout1_30ck14 = 0.9 time = 75
.meas tran vdout1_30ck14 FIND v(dout1_30) AT=75.025n

* CHECK dout1_31 Vdout1_31ck14 = 0.9 time = 75
.meas tran vdout1_31ck14 FIND v(dout1_31) AT=75.025n

* CHECK dout1_32 Vdout1_32ck14 = 0.9 time = 75
.meas tran vdout1_32ck14 FIND v(dout1_32) AT=75.025n

* CHECK dout1_33 Vdout1_33ck14 = 0 time = 75
.meas tran vdout1_33ck14 FIND v(dout1_33) AT=75.025n

* CHECK dout1_34 Vdout1_34ck14 = 0.9 time = 75
.meas tran vdout1_34ck14 FIND v(dout1_34) AT=75.025n

* CHECK dout1_35 Vdout1_35ck14 = 0 time = 75
.meas tran vdout1_35ck14 FIND v(dout1_35) AT=75.025n

* CHECK dout1_36 Vdout1_36ck14 = 0 time = 75
.meas tran vdout1_36ck14 FIND v(dout1_36) AT=75.025n

* CHECK dout1_37 Vdout1_37ck14 = 0.9 time = 75
.meas tran vdout1_37ck14 FIND v(dout1_37) AT=75.025n

* CHECK dout1_38 Vdout1_38ck14 = 0 time = 75
.meas tran vdout1_38ck14 FIND v(dout1_38) AT=75.025n

* CHECK dout1_39 Vdout1_39ck14 = 0.9 time = 75
.meas tran vdout1_39ck14 FIND v(dout1_39) AT=75.025n

* CHECK dout1_40 Vdout1_40ck14 = 0 time = 75
.meas tran vdout1_40ck14 FIND v(dout1_40) AT=75.025n

* CHECK dout1_41 Vdout1_41ck14 = 0 time = 75
.meas tran vdout1_41ck14 FIND v(dout1_41) AT=75.025n

* CHECK dout1_42 Vdout1_42ck14 = 0 time = 75
.meas tran vdout1_42ck14 FIND v(dout1_42) AT=75.025n

* CHECK dout1_43 Vdout1_43ck14 = 0.9 time = 75
.meas tran vdout1_43ck14 FIND v(dout1_43) AT=75.025n

* CHECK dout1_44 Vdout1_44ck14 = 0 time = 75
.meas tran vdout1_44ck14 FIND v(dout1_44) AT=75.025n

* CHECK dout1_45 Vdout1_45ck14 = 0 time = 75
.meas tran vdout1_45ck14 FIND v(dout1_45) AT=75.025n

* CHECK dout1_46 Vdout1_46ck14 = 0 time = 75
.meas tran vdout1_46ck14 FIND v(dout1_46) AT=75.025n

* CHECK dout1_47 Vdout1_47ck14 = 0 time = 75
.meas tran vdout1_47ck14 FIND v(dout1_47) AT=75.025n

* CHECK dout1_48 Vdout1_48ck14 = 0.9 time = 75
.meas tran vdout1_48ck14 FIND v(dout1_48) AT=75.025n

* CHECK dout1_49 Vdout1_49ck14 = 0.9 time = 75
.meas tran vdout1_49ck14 FIND v(dout1_49) AT=75.025n

* CHECK dout1_50 Vdout1_50ck14 = 0.9 time = 75
.meas tran vdout1_50ck14 FIND v(dout1_50) AT=75.025n

* CHECK dout1_51 Vdout1_51ck14 = 0.9 time = 75
.meas tran vdout1_51ck14 FIND v(dout1_51) AT=75.025n

* CHECK dout1_52 Vdout1_52ck14 = 0 time = 75
.meas tran vdout1_52ck14 FIND v(dout1_52) AT=75.025n

* CHECK dout1_53 Vdout1_53ck14 = 0.9 time = 75
.meas tran vdout1_53ck14 FIND v(dout1_53) AT=75.025n

* CHECK dout1_54 Vdout1_54ck14 = 0.9 time = 75
.meas tran vdout1_54ck14 FIND v(dout1_54) AT=75.025n

* CHECK dout1_55 Vdout1_55ck14 = 0.9 time = 75
.meas tran vdout1_55ck14 FIND v(dout1_55) AT=75.025n

* CHECK dout1_56 Vdout1_56ck14 = 0 time = 75
.meas tran vdout1_56ck14 FIND v(dout1_56) AT=75.025n

* CHECK dout1_57 Vdout1_57ck14 = 0.9 time = 75
.meas tran vdout1_57ck14 FIND v(dout1_57) AT=75.025n

* CHECK dout1_58 Vdout1_58ck14 = 0.9 time = 75
.meas tran vdout1_58ck14 FIND v(dout1_58) AT=75.025n

* CHECK dout1_59 Vdout1_59ck14 = 0.9 time = 75
.meas tran vdout1_59ck14 FIND v(dout1_59) AT=75.025n

* CHECK dout1_60 Vdout1_60ck14 = 0 time = 75
.meas tran vdout1_60ck14 FIND v(dout1_60) AT=75.025n

* CHECK dout1_61 Vdout1_61ck14 = 0.9 time = 75
.meas tran vdout1_61ck14 FIND v(dout1_61) AT=75.025n

* CHECK dout1_62 Vdout1_62ck14 = 0.9 time = 75
.meas tran vdout1_62ck14 FIND v(dout1_62) AT=75.025n

* CHECK dout1_63 Vdout1_63ck14 = 0.9 time = 75
.meas tran vdout1_63ck14 FIND v(dout1_63) AT=75.025n

* CHECK dout1_64 Vdout1_64ck14 = 0.9 time = 75
.meas tran vdout1_64ck14 FIND v(dout1_64) AT=75.025n

* CHECK dout1_65 Vdout1_65ck14 = 0 time = 75
.meas tran vdout1_65ck14 FIND v(dout1_65) AT=75.025n

* CHECK dout1_66 Vdout1_66ck14 = 0 time = 75
.meas tran vdout1_66ck14 FIND v(dout1_66) AT=75.025n

* CHECK dout1_67 Vdout1_67ck14 = 0.9 time = 75
.meas tran vdout1_67ck14 FIND v(dout1_67) AT=75.025n

* CHECK dout1_68 Vdout1_68ck14 = 0 time = 75
.meas tran vdout1_68ck14 FIND v(dout1_68) AT=75.025n

* CHECK dout1_69 Vdout1_69ck14 = 0.9 time = 75
.meas tran vdout1_69ck14 FIND v(dout1_69) AT=75.025n

* CHECK dout1_70 Vdout1_70ck14 = 0.9 time = 75
.meas tran vdout1_70ck14 FIND v(dout1_70) AT=75.025n

* CHECK dout1_71 Vdout1_71ck14 = 0.9 time = 75
.meas tran vdout1_71ck14 FIND v(dout1_71) AT=75.025n

* CHECK dout1_72 Vdout1_72ck14 = 0.9 time = 75
.meas tran vdout1_72ck14 FIND v(dout1_72) AT=75.025n

* CHECK dout1_73 Vdout1_73ck14 = 0.9 time = 75
.meas tran vdout1_73ck14 FIND v(dout1_73) AT=75.025n

* CHECK dout1_74 Vdout1_74ck14 = 0 time = 75
.meas tran vdout1_74ck14 FIND v(dout1_74) AT=75.025n

* CHECK dout1_75 Vdout1_75ck14 = 0 time = 75
.meas tran vdout1_75ck14 FIND v(dout1_75) AT=75.025n

* CHECK dout1_76 Vdout1_76ck14 = 0 time = 75
.meas tran vdout1_76ck14 FIND v(dout1_76) AT=75.025n

* CHECK dout1_77 Vdout1_77ck14 = 0 time = 75
.meas tran vdout1_77ck14 FIND v(dout1_77) AT=75.025n

* CHECK dout1_78 Vdout1_78ck14 = 0.9 time = 75
.meas tran vdout1_78ck14 FIND v(dout1_78) AT=75.025n

* CHECK dout1_79 Vdout1_79ck14 = 0.9 time = 75
.meas tran vdout1_79ck14 FIND v(dout1_79) AT=75.025n

* CHECK dout1_80 Vdout1_80ck14 = 0.9 time = 75
.meas tran vdout1_80ck14 FIND v(dout1_80) AT=75.025n

* CHECK dout1_81 Vdout1_81ck14 = 0 time = 75
.meas tran vdout1_81ck14 FIND v(dout1_81) AT=75.025n

* CHECK dout1_82 Vdout1_82ck14 = 0.9 time = 75
.meas tran vdout1_82ck14 FIND v(dout1_82) AT=75.025n

* CHECK dout1_83 Vdout1_83ck14 = 0 time = 75
.meas tran vdout1_83ck14 FIND v(dout1_83) AT=75.025n

* CHECK dout1_84 Vdout1_84ck14 = 0 time = 75
.meas tran vdout1_84ck14 FIND v(dout1_84) AT=75.025n

* CHECK dout1_85 Vdout1_85ck14 = 0 time = 75
.meas tran vdout1_85ck14 FIND v(dout1_85) AT=75.025n

* CHECK dout1_86 Vdout1_86ck14 = 0.9 time = 75
.meas tran vdout1_86ck14 FIND v(dout1_86) AT=75.025n

* CHECK dout1_87 Vdout1_87ck14 = 0.9 time = 75
.meas tran vdout1_87ck14 FIND v(dout1_87) AT=75.025n

* CHECK dout1_88 Vdout1_88ck14 = 0 time = 75
.meas tran vdout1_88ck14 FIND v(dout1_88) AT=75.025n

* CHECK dout1_89 Vdout1_89ck14 = 0 time = 75
.meas tran vdout1_89ck14 FIND v(dout1_89) AT=75.025n

* CHECK dout1_90 Vdout1_90ck14 = 0 time = 75
.meas tran vdout1_90ck14 FIND v(dout1_90) AT=75.025n

* CHECK dout1_91 Vdout1_91ck14 = 0.9 time = 75
.meas tran vdout1_91ck14 FIND v(dout1_91) AT=75.025n

* CHECK dout1_92 Vdout1_92ck14 = 0 time = 75
.meas tran vdout1_92ck14 FIND v(dout1_92) AT=75.025n

* CHECK dout1_93 Vdout1_93ck14 = 0 time = 75
.meas tran vdout1_93ck14 FIND v(dout1_93) AT=75.025n

* CHECK dout1_94 Vdout1_94ck14 = 0 time = 75
.meas tran vdout1_94ck14 FIND v(dout1_94) AT=75.025n

* CHECK dout1_95 Vdout1_95ck14 = 0 time = 75
.meas tran vdout1_95ck14 FIND v(dout1_95) AT=75.025n

* CHECK dout1_96 Vdout1_96ck14 = 0 time = 75
.meas tran vdout1_96ck14 FIND v(dout1_96) AT=75.025n

* CHECK dout1_97 Vdout1_97ck14 = 0 time = 75
.meas tran vdout1_97ck14 FIND v(dout1_97) AT=75.025n

* CHECK dout1_98 Vdout1_98ck14 = 0 time = 75
.meas tran vdout1_98ck14 FIND v(dout1_98) AT=75.025n

* CHECK dout1_99 Vdout1_99ck14 = 0.9 time = 75
.meas tran vdout1_99ck14 FIND v(dout1_99) AT=75.025n

* CHECK dout1_100 Vdout1_100ck14 = 0.9 time = 75
.meas tran vdout1_100ck14 FIND v(dout1_100) AT=75.025n

* CHECK dout1_101 Vdout1_101ck14 = 0 time = 75
.meas tran vdout1_101ck14 FIND v(dout1_101) AT=75.025n

* CHECK dout1_102 Vdout1_102ck14 = 0 time = 75
.meas tran vdout1_102ck14 FIND v(dout1_102) AT=75.025n

* CHECK dout1_103 Vdout1_103ck14 = 0.9 time = 75
.meas tran vdout1_103ck14 FIND v(dout1_103) AT=75.025n

* CHECK dout1_104 Vdout1_104ck14 = 0.9 time = 75
.meas tran vdout1_104ck14 FIND v(dout1_104) AT=75.025n

* CHECK dout1_105 Vdout1_105ck14 = 0.9 time = 75
.meas tran vdout1_105ck14 FIND v(dout1_105) AT=75.025n

* CHECK dout1_106 Vdout1_106ck14 = 0.9 time = 75
.meas tran vdout1_106ck14 FIND v(dout1_106) AT=75.025n

* CHECK dout1_107 Vdout1_107ck14 = 0 time = 75
.meas tran vdout1_107ck14 FIND v(dout1_107) AT=75.025n

* CHECK dout1_108 Vdout1_108ck14 = 0 time = 75
.meas tran vdout1_108ck14 FIND v(dout1_108) AT=75.025n

* CHECK dout1_109 Vdout1_109ck14 = 0.9 time = 75
.meas tran vdout1_109ck14 FIND v(dout1_109) AT=75.025n

* CHECK dout1_110 Vdout1_110ck14 = 0 time = 75
.meas tran vdout1_110ck14 FIND v(dout1_110) AT=75.025n

* CHECK dout1_111 Vdout1_111ck14 = 0.9 time = 75
.meas tran vdout1_111ck14 FIND v(dout1_111) AT=75.025n

* CHECK dout1_112 Vdout1_112ck14 = 0.9 time = 75
.meas tran vdout1_112ck14 FIND v(dout1_112) AT=75.025n

* CHECK dout1_113 Vdout1_113ck14 = 0 time = 75
.meas tran vdout1_113ck14 FIND v(dout1_113) AT=75.025n

* CHECK dout1_114 Vdout1_114ck14 = 0 time = 75
.meas tran vdout1_114ck14 FIND v(dout1_114) AT=75.025n

* CHECK dout1_115 Vdout1_115ck14 = 0.9 time = 75
.meas tran vdout1_115ck14 FIND v(dout1_115) AT=75.025n

* CHECK dout1_116 Vdout1_116ck14 = 0.9 time = 75
.meas tran vdout1_116ck14 FIND v(dout1_116) AT=75.025n

* CHECK dout1_117 Vdout1_117ck14 = 0 time = 75
.meas tran vdout1_117ck14 FIND v(dout1_117) AT=75.025n

* CHECK dout1_118 Vdout1_118ck14 = 0 time = 75
.meas tran vdout1_118ck14 FIND v(dout1_118) AT=75.025n

* CHECK dout1_119 Vdout1_119ck14 = 0 time = 75
.meas tran vdout1_119ck14 FIND v(dout1_119) AT=75.025n

* CHECK dout1_0 Vdout1_0ck15 = 0 time = 80
.meas tran vdout1_0ck15 FIND v(dout1_0) AT=80.025n

* CHECK dout1_1 Vdout1_1ck15 = 0 time = 80
.meas tran vdout1_1ck15 FIND v(dout1_1) AT=80.025n

* CHECK dout1_2 Vdout1_2ck15 = 0 time = 80
.meas tran vdout1_2ck15 FIND v(dout1_2) AT=80.025n

* CHECK dout1_3 Vdout1_3ck15 = 0.9 time = 80
.meas tran vdout1_3ck15 FIND v(dout1_3) AT=80.025n

* CHECK dout1_4 Vdout1_4ck15 = 0 time = 80
.meas tran vdout1_4ck15 FIND v(dout1_4) AT=80.025n

* CHECK dout1_5 Vdout1_5ck15 = 0.9 time = 80
.meas tran vdout1_5ck15 FIND v(dout1_5) AT=80.025n

* CHECK dout1_6 Vdout1_6ck15 = 0 time = 80
.meas tran vdout1_6ck15 FIND v(dout1_6) AT=80.025n

* CHECK dout1_7 Vdout1_7ck15 = 0 time = 80
.meas tran vdout1_7ck15 FIND v(dout1_7) AT=80.025n

* CHECK dout1_8 Vdout1_8ck15 = 0.9 time = 80
.meas tran vdout1_8ck15 FIND v(dout1_8) AT=80.025n

* CHECK dout1_9 Vdout1_9ck15 = 0.9 time = 80
.meas tran vdout1_9ck15 FIND v(dout1_9) AT=80.025n

* CHECK dout1_10 Vdout1_10ck15 = 0 time = 80
.meas tran vdout1_10ck15 FIND v(dout1_10) AT=80.025n

* CHECK dout1_11 Vdout1_11ck15 = 0.9 time = 80
.meas tran vdout1_11ck15 FIND v(dout1_11) AT=80.025n

* CHECK dout1_12 Vdout1_12ck15 = 0 time = 80
.meas tran vdout1_12ck15 FIND v(dout1_12) AT=80.025n

* CHECK dout1_13 Vdout1_13ck15 = 0 time = 80
.meas tran vdout1_13ck15 FIND v(dout1_13) AT=80.025n

* CHECK dout1_14 Vdout1_14ck15 = 0.9 time = 80
.meas tran vdout1_14ck15 FIND v(dout1_14) AT=80.025n

* CHECK dout1_15 Vdout1_15ck15 = 0.9 time = 80
.meas tran vdout1_15ck15 FIND v(dout1_15) AT=80.025n

* CHECK dout1_16 Vdout1_16ck15 = 0.9 time = 80
.meas tran vdout1_16ck15 FIND v(dout1_16) AT=80.025n

* CHECK dout1_17 Vdout1_17ck15 = 0 time = 80
.meas tran vdout1_17ck15 FIND v(dout1_17) AT=80.025n

* CHECK dout1_18 Vdout1_18ck15 = 0 time = 80
.meas tran vdout1_18ck15 FIND v(dout1_18) AT=80.025n

* CHECK dout1_19 Vdout1_19ck15 = 0 time = 80
.meas tran vdout1_19ck15 FIND v(dout1_19) AT=80.025n

* CHECK dout1_20 Vdout1_20ck15 = 0 time = 80
.meas tran vdout1_20ck15 FIND v(dout1_20) AT=80.025n

* CHECK dout1_21 Vdout1_21ck15 = 0 time = 80
.meas tran vdout1_21ck15 FIND v(dout1_21) AT=80.025n

* CHECK dout1_22 Vdout1_22ck15 = 0 time = 80
.meas tran vdout1_22ck15 FIND v(dout1_22) AT=80.025n

* CHECK dout1_23 Vdout1_23ck15 = 0 time = 80
.meas tran vdout1_23ck15 FIND v(dout1_23) AT=80.025n

* CHECK dout1_24 Vdout1_24ck15 = 0.9 time = 80
.meas tran vdout1_24ck15 FIND v(dout1_24) AT=80.025n

* CHECK dout1_25 Vdout1_25ck15 = 0 time = 80
.meas tran vdout1_25ck15 FIND v(dout1_25) AT=80.025n

* CHECK dout1_26 Vdout1_26ck15 = 0 time = 80
.meas tran vdout1_26ck15 FIND v(dout1_26) AT=80.025n

* CHECK dout1_27 Vdout1_27ck15 = 0.9 time = 80
.meas tran vdout1_27ck15 FIND v(dout1_27) AT=80.025n

* CHECK dout1_28 Vdout1_28ck15 = 0.9 time = 80
.meas tran vdout1_28ck15 FIND v(dout1_28) AT=80.025n

* CHECK dout1_29 Vdout1_29ck15 = 0.9 time = 80
.meas tran vdout1_29ck15 FIND v(dout1_29) AT=80.025n

* CHECK dout1_30 Vdout1_30ck15 = 0 time = 80
.meas tran vdout1_30ck15 FIND v(dout1_30) AT=80.025n

* CHECK dout1_31 Vdout1_31ck15 = 0 time = 80
.meas tran vdout1_31ck15 FIND v(dout1_31) AT=80.025n

* CHECK dout1_32 Vdout1_32ck15 = 0 time = 80
.meas tran vdout1_32ck15 FIND v(dout1_32) AT=80.025n

* CHECK dout1_33 Vdout1_33ck15 = 0.9 time = 80
.meas tran vdout1_33ck15 FIND v(dout1_33) AT=80.025n

* CHECK dout1_34 Vdout1_34ck15 = 0.9 time = 80
.meas tran vdout1_34ck15 FIND v(dout1_34) AT=80.025n

* CHECK dout1_35 Vdout1_35ck15 = 0 time = 80
.meas tran vdout1_35ck15 FIND v(dout1_35) AT=80.025n

* CHECK dout1_36 Vdout1_36ck15 = 0.9 time = 80
.meas tran vdout1_36ck15 FIND v(dout1_36) AT=80.025n

* CHECK dout1_37 Vdout1_37ck15 = 0.9 time = 80
.meas tran vdout1_37ck15 FIND v(dout1_37) AT=80.025n

* CHECK dout1_38 Vdout1_38ck15 = 0.9 time = 80
.meas tran vdout1_38ck15 FIND v(dout1_38) AT=80.025n

* CHECK dout1_39 Vdout1_39ck15 = 0.9 time = 80
.meas tran vdout1_39ck15 FIND v(dout1_39) AT=80.025n

* CHECK dout1_40 Vdout1_40ck15 = 0.9 time = 80
.meas tran vdout1_40ck15 FIND v(dout1_40) AT=80.025n

* CHECK dout1_41 Vdout1_41ck15 = 0.9 time = 80
.meas tran vdout1_41ck15 FIND v(dout1_41) AT=80.025n

* CHECK dout1_42 Vdout1_42ck15 = 0 time = 80
.meas tran vdout1_42ck15 FIND v(dout1_42) AT=80.025n

* CHECK dout1_43 Vdout1_43ck15 = 0.9 time = 80
.meas tran vdout1_43ck15 FIND v(dout1_43) AT=80.025n

* CHECK dout1_44 Vdout1_44ck15 = 0.9 time = 80
.meas tran vdout1_44ck15 FIND v(dout1_44) AT=80.025n

* CHECK dout1_45 Vdout1_45ck15 = 0.9 time = 80
.meas tran vdout1_45ck15 FIND v(dout1_45) AT=80.025n

* CHECK dout1_46 Vdout1_46ck15 = 0.9 time = 80
.meas tran vdout1_46ck15 FIND v(dout1_46) AT=80.025n

* CHECK dout1_47 Vdout1_47ck15 = 0 time = 80
.meas tran vdout1_47ck15 FIND v(dout1_47) AT=80.025n

* CHECK dout1_48 Vdout1_48ck15 = 0.9 time = 80
.meas tran vdout1_48ck15 FIND v(dout1_48) AT=80.025n

* CHECK dout1_49 Vdout1_49ck15 = 0 time = 80
.meas tran vdout1_49ck15 FIND v(dout1_49) AT=80.025n

* CHECK dout1_50 Vdout1_50ck15 = 0.9 time = 80
.meas tran vdout1_50ck15 FIND v(dout1_50) AT=80.025n

* CHECK dout1_51 Vdout1_51ck15 = 0 time = 80
.meas tran vdout1_51ck15 FIND v(dout1_51) AT=80.025n

* CHECK dout1_52 Vdout1_52ck15 = 0 time = 80
.meas tran vdout1_52ck15 FIND v(dout1_52) AT=80.025n

* CHECK dout1_53 Vdout1_53ck15 = 0.9 time = 80
.meas tran vdout1_53ck15 FIND v(dout1_53) AT=80.025n

* CHECK dout1_54 Vdout1_54ck15 = 0 time = 80
.meas tran vdout1_54ck15 FIND v(dout1_54) AT=80.025n

* CHECK dout1_55 Vdout1_55ck15 = 0.9 time = 80
.meas tran vdout1_55ck15 FIND v(dout1_55) AT=80.025n

* CHECK dout1_56 Vdout1_56ck15 = 0 time = 80
.meas tran vdout1_56ck15 FIND v(dout1_56) AT=80.025n

* CHECK dout1_57 Vdout1_57ck15 = 0 time = 80
.meas tran vdout1_57ck15 FIND v(dout1_57) AT=80.025n

* CHECK dout1_58 Vdout1_58ck15 = 0.9 time = 80
.meas tran vdout1_58ck15 FIND v(dout1_58) AT=80.025n

* CHECK dout1_59 Vdout1_59ck15 = 0 time = 80
.meas tran vdout1_59ck15 FIND v(dout1_59) AT=80.025n

* CHECK dout1_60 Vdout1_60ck15 = 0 time = 80
.meas tran vdout1_60ck15 FIND v(dout1_60) AT=80.025n

* CHECK dout1_61 Vdout1_61ck15 = 0.9 time = 80
.meas tran vdout1_61ck15 FIND v(dout1_61) AT=80.025n

* CHECK dout1_62 Vdout1_62ck15 = 0 time = 80
.meas tran vdout1_62ck15 FIND v(dout1_62) AT=80.025n

* CHECK dout1_63 Vdout1_63ck15 = 0 time = 80
.meas tran vdout1_63ck15 FIND v(dout1_63) AT=80.025n

* CHECK dout1_64 Vdout1_64ck15 = 0 time = 80
.meas tran vdout1_64ck15 FIND v(dout1_64) AT=80.025n

* CHECK dout1_65 Vdout1_65ck15 = 0 time = 80
.meas tran vdout1_65ck15 FIND v(dout1_65) AT=80.025n

* CHECK dout1_66 Vdout1_66ck15 = 0 time = 80
.meas tran vdout1_66ck15 FIND v(dout1_66) AT=80.025n

* CHECK dout1_67 Vdout1_67ck15 = 0 time = 80
.meas tran vdout1_67ck15 FIND v(dout1_67) AT=80.025n

* CHECK dout1_68 Vdout1_68ck15 = 0 time = 80
.meas tran vdout1_68ck15 FIND v(dout1_68) AT=80.025n

* CHECK dout1_69 Vdout1_69ck15 = 0.9 time = 80
.meas tran vdout1_69ck15 FIND v(dout1_69) AT=80.025n

* CHECK dout1_70 Vdout1_70ck15 = 0 time = 80
.meas tran vdout1_70ck15 FIND v(dout1_70) AT=80.025n

* CHECK dout1_71 Vdout1_71ck15 = 0 time = 80
.meas tran vdout1_71ck15 FIND v(dout1_71) AT=80.025n

* CHECK dout1_72 Vdout1_72ck15 = 0 time = 80
.meas tran vdout1_72ck15 FIND v(dout1_72) AT=80.025n

* CHECK dout1_73 Vdout1_73ck15 = 0 time = 80
.meas tran vdout1_73ck15 FIND v(dout1_73) AT=80.025n

* CHECK dout1_74 Vdout1_74ck15 = 0 time = 80
.meas tran vdout1_74ck15 FIND v(dout1_74) AT=80.025n

* CHECK dout1_75 Vdout1_75ck15 = 0 time = 80
.meas tran vdout1_75ck15 FIND v(dout1_75) AT=80.025n

* CHECK dout1_76 Vdout1_76ck15 = 0 time = 80
.meas tran vdout1_76ck15 FIND v(dout1_76) AT=80.025n

* CHECK dout1_77 Vdout1_77ck15 = 0.9 time = 80
.meas tran vdout1_77ck15 FIND v(dout1_77) AT=80.025n

* CHECK dout1_78 Vdout1_78ck15 = 0.9 time = 80
.meas tran vdout1_78ck15 FIND v(dout1_78) AT=80.025n

* CHECK dout1_79 Vdout1_79ck15 = 0.9 time = 80
.meas tran vdout1_79ck15 FIND v(dout1_79) AT=80.025n

* CHECK dout1_80 Vdout1_80ck15 = 0 time = 80
.meas tran vdout1_80ck15 FIND v(dout1_80) AT=80.025n

* CHECK dout1_81 Vdout1_81ck15 = 0 time = 80
.meas tran vdout1_81ck15 FIND v(dout1_81) AT=80.025n

* CHECK dout1_82 Vdout1_82ck15 = 0.9 time = 80
.meas tran vdout1_82ck15 FIND v(dout1_82) AT=80.025n

* CHECK dout1_83 Vdout1_83ck15 = 0.9 time = 80
.meas tran vdout1_83ck15 FIND v(dout1_83) AT=80.025n

* CHECK dout1_84 Vdout1_84ck15 = 0 time = 80
.meas tran vdout1_84ck15 FIND v(dout1_84) AT=80.025n

* CHECK dout1_85 Vdout1_85ck15 = 0 time = 80
.meas tran vdout1_85ck15 FIND v(dout1_85) AT=80.025n

* CHECK dout1_86 Vdout1_86ck15 = 0.9 time = 80
.meas tran vdout1_86ck15 FIND v(dout1_86) AT=80.025n

* CHECK dout1_87 Vdout1_87ck15 = 0.9 time = 80
.meas tran vdout1_87ck15 FIND v(dout1_87) AT=80.025n

* CHECK dout1_88 Vdout1_88ck15 = 0.9 time = 80
.meas tran vdout1_88ck15 FIND v(dout1_88) AT=80.025n

* CHECK dout1_89 Vdout1_89ck15 = 0.9 time = 80
.meas tran vdout1_89ck15 FIND v(dout1_89) AT=80.025n

* CHECK dout1_90 Vdout1_90ck15 = 0 time = 80
.meas tran vdout1_90ck15 FIND v(dout1_90) AT=80.025n

* CHECK dout1_91 Vdout1_91ck15 = 0 time = 80
.meas tran vdout1_91ck15 FIND v(dout1_91) AT=80.025n

* CHECK dout1_92 Vdout1_92ck15 = 0 time = 80
.meas tran vdout1_92ck15 FIND v(dout1_92) AT=80.025n

* CHECK dout1_93 Vdout1_93ck15 = 0 time = 80
.meas tran vdout1_93ck15 FIND v(dout1_93) AT=80.025n

* CHECK dout1_94 Vdout1_94ck15 = 0.9 time = 80
.meas tran vdout1_94ck15 FIND v(dout1_94) AT=80.025n

* CHECK dout1_95 Vdout1_95ck15 = 0.9 time = 80
.meas tran vdout1_95ck15 FIND v(dout1_95) AT=80.025n

* CHECK dout1_96 Vdout1_96ck15 = 0 time = 80
.meas tran vdout1_96ck15 FIND v(dout1_96) AT=80.025n

* CHECK dout1_97 Vdout1_97ck15 = 0 time = 80
.meas tran vdout1_97ck15 FIND v(dout1_97) AT=80.025n

* CHECK dout1_98 Vdout1_98ck15 = 0.9 time = 80
.meas tran vdout1_98ck15 FIND v(dout1_98) AT=80.025n

* CHECK dout1_99 Vdout1_99ck15 = 0 time = 80
.meas tran vdout1_99ck15 FIND v(dout1_99) AT=80.025n

* CHECK dout1_100 Vdout1_100ck15 = 0 time = 80
.meas tran vdout1_100ck15 FIND v(dout1_100) AT=80.025n

* CHECK dout1_101 Vdout1_101ck15 = 0 time = 80
.meas tran vdout1_101ck15 FIND v(dout1_101) AT=80.025n

* CHECK dout1_102 Vdout1_102ck15 = 0.9 time = 80
.meas tran vdout1_102ck15 FIND v(dout1_102) AT=80.025n

* CHECK dout1_103 Vdout1_103ck15 = 0.9 time = 80
.meas tran vdout1_103ck15 FIND v(dout1_103) AT=80.025n

* CHECK dout1_104 Vdout1_104ck15 = 0 time = 80
.meas tran vdout1_104ck15 FIND v(dout1_104) AT=80.025n

* CHECK dout1_105 Vdout1_105ck15 = 0 time = 80
.meas tran vdout1_105ck15 FIND v(dout1_105) AT=80.025n

* CHECK dout1_106 Vdout1_106ck15 = 0 time = 80
.meas tran vdout1_106ck15 FIND v(dout1_106) AT=80.025n

* CHECK dout1_107 Vdout1_107ck15 = 0 time = 80
.meas tran vdout1_107ck15 FIND v(dout1_107) AT=80.025n

* CHECK dout1_108 Vdout1_108ck15 = 0.9 time = 80
.meas tran vdout1_108ck15 FIND v(dout1_108) AT=80.025n

* CHECK dout1_109 Vdout1_109ck15 = 0.9 time = 80
.meas tran vdout1_109ck15 FIND v(dout1_109) AT=80.025n

* CHECK dout1_110 Vdout1_110ck15 = 0.9 time = 80
.meas tran vdout1_110ck15 FIND v(dout1_110) AT=80.025n

* CHECK dout1_111 Vdout1_111ck15 = 0.9 time = 80
.meas tran vdout1_111ck15 FIND v(dout1_111) AT=80.025n

* CHECK dout1_112 Vdout1_112ck15 = 0 time = 80
.meas tran vdout1_112ck15 FIND v(dout1_112) AT=80.025n

* CHECK dout1_113 Vdout1_113ck15 = 0.9 time = 80
.meas tran vdout1_113ck15 FIND v(dout1_113) AT=80.025n

* CHECK dout1_114 Vdout1_114ck15 = 0 time = 80
.meas tran vdout1_114ck15 FIND v(dout1_114) AT=80.025n

* CHECK dout1_115 Vdout1_115ck15 = 0.9 time = 80
.meas tran vdout1_115ck15 FIND v(dout1_115) AT=80.025n

* CHECK dout1_116 Vdout1_116ck15 = 0.9 time = 80
.meas tran vdout1_116ck15 FIND v(dout1_116) AT=80.025n

* CHECK dout1_117 Vdout1_117ck15 = 0.9 time = 80
.meas tran vdout1_117ck15 FIND v(dout1_117) AT=80.025n

* CHECK dout1_118 Vdout1_118ck15 = 0 time = 80
.meas tran vdout1_118ck15 FIND v(dout1_118) AT=80.025n

* CHECK dout1_119 Vdout1_119ck15 = 0.9 time = 80
.meas tran vdout1_119ck15 FIND v(dout1_119) AT=80.025n

* CHECK dout1_0 Vdout1_0ck20 = 0 time = 105
.meas tran vdout1_0ck20 FIND v(dout1_0) AT=105.025n

* CHECK dout1_1 Vdout1_1ck20 = 0.9 time = 105
.meas tran vdout1_1ck20 FIND v(dout1_1) AT=105.025n

* CHECK dout1_2 Vdout1_2ck20 = 0 time = 105
.meas tran vdout1_2ck20 FIND v(dout1_2) AT=105.025n

* CHECK dout1_3 Vdout1_3ck20 = 0 time = 105
.meas tran vdout1_3ck20 FIND v(dout1_3) AT=105.025n

* CHECK dout1_4 Vdout1_4ck20 = 0.9 time = 105
.meas tran vdout1_4ck20 FIND v(dout1_4) AT=105.025n

* CHECK dout1_5 Vdout1_5ck20 = 0 time = 105
.meas tran vdout1_5ck20 FIND v(dout1_5) AT=105.025n

* CHECK dout1_6 Vdout1_6ck20 = 0.9 time = 105
.meas tran vdout1_6ck20 FIND v(dout1_6) AT=105.025n

* CHECK dout1_7 Vdout1_7ck20 = 0 time = 105
.meas tran vdout1_7ck20 FIND v(dout1_7) AT=105.025n

* CHECK dout1_8 Vdout1_8ck20 = 0.9 time = 105
.meas tran vdout1_8ck20 FIND v(dout1_8) AT=105.025n

* CHECK dout1_9 Vdout1_9ck20 = 0 time = 105
.meas tran vdout1_9ck20 FIND v(dout1_9) AT=105.025n

* CHECK dout1_10 Vdout1_10ck20 = 0 time = 105
.meas tran vdout1_10ck20 FIND v(dout1_10) AT=105.025n

* CHECK dout1_11 Vdout1_11ck20 = 0 time = 105
.meas tran vdout1_11ck20 FIND v(dout1_11) AT=105.025n

* CHECK dout1_12 Vdout1_12ck20 = 0 time = 105
.meas tran vdout1_12ck20 FIND v(dout1_12) AT=105.025n

* CHECK dout1_13 Vdout1_13ck20 = 0.9 time = 105
.meas tran vdout1_13ck20 FIND v(dout1_13) AT=105.025n

* CHECK dout1_14 Vdout1_14ck20 = 0.9 time = 105
.meas tran vdout1_14ck20 FIND v(dout1_14) AT=105.025n

* CHECK dout1_15 Vdout1_15ck20 = 0 time = 105
.meas tran vdout1_15ck20 FIND v(dout1_15) AT=105.025n

* CHECK dout1_16 Vdout1_16ck20 = 0 time = 105
.meas tran vdout1_16ck20 FIND v(dout1_16) AT=105.025n

* CHECK dout1_17 Vdout1_17ck20 = 0 time = 105
.meas tran vdout1_17ck20 FIND v(dout1_17) AT=105.025n

* CHECK dout1_18 Vdout1_18ck20 = 0 time = 105
.meas tran vdout1_18ck20 FIND v(dout1_18) AT=105.025n

* CHECK dout1_19 Vdout1_19ck20 = 0.9 time = 105
.meas tran vdout1_19ck20 FIND v(dout1_19) AT=105.025n

* CHECK dout1_20 Vdout1_20ck20 = 0.9 time = 105
.meas tran vdout1_20ck20 FIND v(dout1_20) AT=105.025n

* CHECK dout1_21 Vdout1_21ck20 = 0 time = 105
.meas tran vdout1_21ck20 FIND v(dout1_21) AT=105.025n

* CHECK dout1_22 Vdout1_22ck20 = 0 time = 105
.meas tran vdout1_22ck20 FIND v(dout1_22) AT=105.025n

* CHECK dout1_23 Vdout1_23ck20 = 0.9 time = 105
.meas tran vdout1_23ck20 FIND v(dout1_23) AT=105.025n

* CHECK dout1_24 Vdout1_24ck20 = 0 time = 105
.meas tran vdout1_24ck20 FIND v(dout1_24) AT=105.025n

* CHECK dout1_25 Vdout1_25ck20 = 0.9 time = 105
.meas tran vdout1_25ck20 FIND v(dout1_25) AT=105.025n

* CHECK dout1_26 Vdout1_26ck20 = 0 time = 105
.meas tran vdout1_26ck20 FIND v(dout1_26) AT=105.025n

* CHECK dout1_27 Vdout1_27ck20 = 0 time = 105
.meas tran vdout1_27ck20 FIND v(dout1_27) AT=105.025n

* CHECK dout1_28 Vdout1_28ck20 = 0.9 time = 105
.meas tran vdout1_28ck20 FIND v(dout1_28) AT=105.025n

* CHECK dout1_29 Vdout1_29ck20 = 0 time = 105
.meas tran vdout1_29ck20 FIND v(dout1_29) AT=105.025n

* CHECK dout1_30 Vdout1_30ck20 = 0 time = 105
.meas tran vdout1_30ck20 FIND v(dout1_30) AT=105.025n

* CHECK dout1_31 Vdout1_31ck20 = 0 time = 105
.meas tran vdout1_31ck20 FIND v(dout1_31) AT=105.025n

* CHECK dout1_32 Vdout1_32ck20 = 0.9 time = 105
.meas tran vdout1_32ck20 FIND v(dout1_32) AT=105.025n

* CHECK dout1_33 Vdout1_33ck20 = 0 time = 105
.meas tran vdout1_33ck20 FIND v(dout1_33) AT=105.025n

* CHECK dout1_34 Vdout1_34ck20 = 0 time = 105
.meas tran vdout1_34ck20 FIND v(dout1_34) AT=105.025n

* CHECK dout1_35 Vdout1_35ck20 = 0 time = 105
.meas tran vdout1_35ck20 FIND v(dout1_35) AT=105.025n

* CHECK dout1_36 Vdout1_36ck20 = 0 time = 105
.meas tran vdout1_36ck20 FIND v(dout1_36) AT=105.025n

* CHECK dout1_37 Vdout1_37ck20 = 0.9 time = 105
.meas tran vdout1_37ck20 FIND v(dout1_37) AT=105.025n

* CHECK dout1_38 Vdout1_38ck20 = 0.9 time = 105
.meas tran vdout1_38ck20 FIND v(dout1_38) AT=105.025n

* CHECK dout1_39 Vdout1_39ck20 = 0 time = 105
.meas tran vdout1_39ck20 FIND v(dout1_39) AT=105.025n

* CHECK dout1_40 Vdout1_40ck20 = 0 time = 105
.meas tran vdout1_40ck20 FIND v(dout1_40) AT=105.025n

* CHECK dout1_41 Vdout1_41ck20 = 0 time = 105
.meas tran vdout1_41ck20 FIND v(dout1_41) AT=105.025n

* CHECK dout1_42 Vdout1_42ck20 = 0 time = 105
.meas tran vdout1_42ck20 FIND v(dout1_42) AT=105.025n

* CHECK dout1_43 Vdout1_43ck20 = 0.9 time = 105
.meas tran vdout1_43ck20 FIND v(dout1_43) AT=105.025n

* CHECK dout1_44 Vdout1_44ck20 = 0 time = 105
.meas tran vdout1_44ck20 FIND v(dout1_44) AT=105.025n

* CHECK dout1_45 Vdout1_45ck20 = 0 time = 105
.meas tran vdout1_45ck20 FIND v(dout1_45) AT=105.025n

* CHECK dout1_46 Vdout1_46ck20 = 0.9 time = 105
.meas tran vdout1_46ck20 FIND v(dout1_46) AT=105.025n

* CHECK dout1_47 Vdout1_47ck20 = 0.9 time = 105
.meas tran vdout1_47ck20 FIND v(dout1_47) AT=105.025n

* CHECK dout1_48 Vdout1_48ck20 = 0 time = 105
.meas tran vdout1_48ck20 FIND v(dout1_48) AT=105.025n

* CHECK dout1_49 Vdout1_49ck20 = 0 time = 105
.meas tran vdout1_49ck20 FIND v(dout1_49) AT=105.025n

* CHECK dout1_50 Vdout1_50ck20 = 0.9 time = 105
.meas tran vdout1_50ck20 FIND v(dout1_50) AT=105.025n

* CHECK dout1_51 Vdout1_51ck20 = 0 time = 105
.meas tran vdout1_51ck20 FIND v(dout1_51) AT=105.025n

* CHECK dout1_52 Vdout1_52ck20 = 0 time = 105
.meas tran vdout1_52ck20 FIND v(dout1_52) AT=105.025n

* CHECK dout1_53 Vdout1_53ck20 = 0 time = 105
.meas tran vdout1_53ck20 FIND v(dout1_53) AT=105.025n

* CHECK dout1_54 Vdout1_54ck20 = 0 time = 105
.meas tran vdout1_54ck20 FIND v(dout1_54) AT=105.025n

* CHECK dout1_55 Vdout1_55ck20 = 0 time = 105
.meas tran vdout1_55ck20 FIND v(dout1_55) AT=105.025n

* CHECK dout1_56 Vdout1_56ck20 = 0 time = 105
.meas tran vdout1_56ck20 FIND v(dout1_56) AT=105.025n

* CHECK dout1_57 Vdout1_57ck20 = 0.9 time = 105
.meas tran vdout1_57ck20 FIND v(dout1_57) AT=105.025n

* CHECK dout1_58 Vdout1_58ck20 = 0 time = 105
.meas tran vdout1_58ck20 FIND v(dout1_58) AT=105.025n

* CHECK dout1_59 Vdout1_59ck20 = 0.9 time = 105
.meas tran vdout1_59ck20 FIND v(dout1_59) AT=105.025n

* CHECK dout1_60 Vdout1_60ck20 = 0.9 time = 105
.meas tran vdout1_60ck20 FIND v(dout1_60) AT=105.025n

* CHECK dout1_61 Vdout1_61ck20 = 0 time = 105
.meas tran vdout1_61ck20 FIND v(dout1_61) AT=105.025n

* CHECK dout1_62 Vdout1_62ck20 = 0.9 time = 105
.meas tran vdout1_62ck20 FIND v(dout1_62) AT=105.025n

* CHECK dout1_63 Vdout1_63ck20 = 0 time = 105
.meas tran vdout1_63ck20 FIND v(dout1_63) AT=105.025n

* CHECK dout1_64 Vdout1_64ck20 = 0.9 time = 105
.meas tran vdout1_64ck20 FIND v(dout1_64) AT=105.025n

* CHECK dout1_65 Vdout1_65ck20 = 0 time = 105
.meas tran vdout1_65ck20 FIND v(dout1_65) AT=105.025n

* CHECK dout1_66 Vdout1_66ck20 = 0 time = 105
.meas tran vdout1_66ck20 FIND v(dout1_66) AT=105.025n

* CHECK dout1_67 Vdout1_67ck20 = 0.9 time = 105
.meas tran vdout1_67ck20 FIND v(dout1_67) AT=105.025n

* CHECK dout1_68 Vdout1_68ck20 = 0.9 time = 105
.meas tran vdout1_68ck20 FIND v(dout1_68) AT=105.025n

* CHECK dout1_69 Vdout1_69ck20 = 0 time = 105
.meas tran vdout1_69ck20 FIND v(dout1_69) AT=105.025n

* CHECK dout1_70 Vdout1_70ck20 = 0.9 time = 105
.meas tran vdout1_70ck20 FIND v(dout1_70) AT=105.025n

* CHECK dout1_71 Vdout1_71ck20 = 0 time = 105
.meas tran vdout1_71ck20 FIND v(dout1_71) AT=105.025n

* CHECK dout1_72 Vdout1_72ck20 = 0 time = 105
.meas tran vdout1_72ck20 FIND v(dout1_72) AT=105.025n

* CHECK dout1_73 Vdout1_73ck20 = 0 time = 105
.meas tran vdout1_73ck20 FIND v(dout1_73) AT=105.025n

* CHECK dout1_74 Vdout1_74ck20 = 0 time = 105
.meas tran vdout1_74ck20 FIND v(dout1_74) AT=105.025n

* CHECK dout1_75 Vdout1_75ck20 = 0 time = 105
.meas tran vdout1_75ck20 FIND v(dout1_75) AT=105.025n

* CHECK dout1_76 Vdout1_76ck20 = 0 time = 105
.meas tran vdout1_76ck20 FIND v(dout1_76) AT=105.025n

* CHECK dout1_77 Vdout1_77ck20 = 0.9 time = 105
.meas tran vdout1_77ck20 FIND v(dout1_77) AT=105.025n

* CHECK dout1_78 Vdout1_78ck20 = 0 time = 105
.meas tran vdout1_78ck20 FIND v(dout1_78) AT=105.025n

* CHECK dout1_79 Vdout1_79ck20 = 0.9 time = 105
.meas tran vdout1_79ck20 FIND v(dout1_79) AT=105.025n

* CHECK dout1_80 Vdout1_80ck20 = 0 time = 105
.meas tran vdout1_80ck20 FIND v(dout1_80) AT=105.025n

* CHECK dout1_81 Vdout1_81ck20 = 0 time = 105
.meas tran vdout1_81ck20 FIND v(dout1_81) AT=105.025n

* CHECK dout1_82 Vdout1_82ck20 = 0.9 time = 105
.meas tran vdout1_82ck20 FIND v(dout1_82) AT=105.025n

* CHECK dout1_83 Vdout1_83ck20 = 0 time = 105
.meas tran vdout1_83ck20 FIND v(dout1_83) AT=105.025n

* CHECK dout1_84 Vdout1_84ck20 = 0.9 time = 105
.meas tran vdout1_84ck20 FIND v(dout1_84) AT=105.025n

* CHECK dout1_85 Vdout1_85ck20 = 0 time = 105
.meas tran vdout1_85ck20 FIND v(dout1_85) AT=105.025n

* CHECK dout1_86 Vdout1_86ck20 = 0.9 time = 105
.meas tran vdout1_86ck20 FIND v(dout1_86) AT=105.025n

* CHECK dout1_87 Vdout1_87ck20 = 0.9 time = 105
.meas tran vdout1_87ck20 FIND v(dout1_87) AT=105.025n

* CHECK dout1_88 Vdout1_88ck20 = 0 time = 105
.meas tran vdout1_88ck20 FIND v(dout1_88) AT=105.025n

* CHECK dout1_89 Vdout1_89ck20 = 0.9 time = 105
.meas tran vdout1_89ck20 FIND v(dout1_89) AT=105.025n

* CHECK dout1_90 Vdout1_90ck20 = 0 time = 105
.meas tran vdout1_90ck20 FIND v(dout1_90) AT=105.025n

* CHECK dout1_91 Vdout1_91ck20 = 0.9 time = 105
.meas tran vdout1_91ck20 FIND v(dout1_91) AT=105.025n

* CHECK dout1_92 Vdout1_92ck20 = 0.9 time = 105
.meas tran vdout1_92ck20 FIND v(dout1_92) AT=105.025n

* CHECK dout1_93 Vdout1_93ck20 = 0 time = 105
.meas tran vdout1_93ck20 FIND v(dout1_93) AT=105.025n

* CHECK dout1_94 Vdout1_94ck20 = 0 time = 105
.meas tran vdout1_94ck20 FIND v(dout1_94) AT=105.025n

* CHECK dout1_95 Vdout1_95ck20 = 0 time = 105
.meas tran vdout1_95ck20 FIND v(dout1_95) AT=105.025n

* CHECK dout1_96 Vdout1_96ck20 = 0.9 time = 105
.meas tran vdout1_96ck20 FIND v(dout1_96) AT=105.025n

* CHECK dout1_97 Vdout1_97ck20 = 0.9 time = 105
.meas tran vdout1_97ck20 FIND v(dout1_97) AT=105.025n

* CHECK dout1_98 Vdout1_98ck20 = 0 time = 105
.meas tran vdout1_98ck20 FIND v(dout1_98) AT=105.025n

* CHECK dout1_99 Vdout1_99ck20 = 0 time = 105
.meas tran vdout1_99ck20 FIND v(dout1_99) AT=105.025n

* CHECK dout1_100 Vdout1_100ck20 = 0 time = 105
.meas tran vdout1_100ck20 FIND v(dout1_100) AT=105.025n

* CHECK dout1_101 Vdout1_101ck20 = 0 time = 105
.meas tran vdout1_101ck20 FIND v(dout1_101) AT=105.025n

* CHECK dout1_102 Vdout1_102ck20 = 0 time = 105
.meas tran vdout1_102ck20 FIND v(dout1_102) AT=105.025n

* CHECK dout1_103 Vdout1_103ck20 = 0.9 time = 105
.meas tran vdout1_103ck20 FIND v(dout1_103) AT=105.025n

* CHECK dout1_104 Vdout1_104ck20 = 0.9 time = 105
.meas tran vdout1_104ck20 FIND v(dout1_104) AT=105.025n

* CHECK dout1_105 Vdout1_105ck20 = 0 time = 105
.meas tran vdout1_105ck20 FIND v(dout1_105) AT=105.025n

* CHECK dout1_106 Vdout1_106ck20 = 0.9 time = 105
.meas tran vdout1_106ck20 FIND v(dout1_106) AT=105.025n

* CHECK dout1_107 Vdout1_107ck20 = 0 time = 105
.meas tran vdout1_107ck20 FIND v(dout1_107) AT=105.025n

* CHECK dout1_108 Vdout1_108ck20 = 0.9 time = 105
.meas tran vdout1_108ck20 FIND v(dout1_108) AT=105.025n

* CHECK dout1_109 Vdout1_109ck20 = 0.9 time = 105
.meas tran vdout1_109ck20 FIND v(dout1_109) AT=105.025n

* CHECK dout1_110 Vdout1_110ck20 = 0 time = 105
.meas tran vdout1_110ck20 FIND v(dout1_110) AT=105.025n

* CHECK dout1_111 Vdout1_111ck20 = 0.9 time = 105
.meas tran vdout1_111ck20 FIND v(dout1_111) AT=105.025n

* CHECK dout1_112 Vdout1_112ck20 = 0.9 time = 105
.meas tran vdout1_112ck20 FIND v(dout1_112) AT=105.025n

* CHECK dout1_113 Vdout1_113ck20 = 0 time = 105
.meas tran vdout1_113ck20 FIND v(dout1_113) AT=105.025n

* CHECK dout1_114 Vdout1_114ck20 = 0.9 time = 105
.meas tran vdout1_114ck20 FIND v(dout1_114) AT=105.025n

* CHECK dout1_115 Vdout1_115ck20 = 0 time = 105
.meas tran vdout1_115ck20 FIND v(dout1_115) AT=105.025n

* CHECK dout1_116 Vdout1_116ck20 = 0 time = 105
.meas tran vdout1_116ck20 FIND v(dout1_116) AT=105.025n

* CHECK dout1_117 Vdout1_117ck20 = 0 time = 105
.meas tran vdout1_117ck20 FIND v(dout1_117) AT=105.025n

* CHECK dout1_118 Vdout1_118ck20 = 0 time = 105
.meas tran vdout1_118ck20 FIND v(dout1_118) AT=105.025n

* CHECK dout1_119 Vdout1_119ck20 = 0 time = 105
.meas tran vdout1_119ck20 FIND v(dout1_119) AT=105.025n

* CHECK dout1_0 Vdout1_0ck29 = 0 time = 150
.meas tran vdout1_0ck29 FIND v(dout1_0) AT=150.025n

* CHECK dout1_1 Vdout1_1ck29 = 0.9 time = 150
.meas tran vdout1_1ck29 FIND v(dout1_1) AT=150.025n

* CHECK dout1_2 Vdout1_2ck29 = 0 time = 150
.meas tran vdout1_2ck29 FIND v(dout1_2) AT=150.025n

* CHECK dout1_3 Vdout1_3ck29 = 0 time = 150
.meas tran vdout1_3ck29 FIND v(dout1_3) AT=150.025n

* CHECK dout1_4 Vdout1_4ck29 = 0.9 time = 150
.meas tran vdout1_4ck29 FIND v(dout1_4) AT=150.025n

* CHECK dout1_5 Vdout1_5ck29 = 0 time = 150
.meas tran vdout1_5ck29 FIND v(dout1_5) AT=150.025n

* CHECK dout1_6 Vdout1_6ck29 = 0.9 time = 150
.meas tran vdout1_6ck29 FIND v(dout1_6) AT=150.025n

* CHECK dout1_7 Vdout1_7ck29 = 0 time = 150
.meas tran vdout1_7ck29 FIND v(dout1_7) AT=150.025n

* CHECK dout1_8 Vdout1_8ck29 = 0.9 time = 150
.meas tran vdout1_8ck29 FIND v(dout1_8) AT=150.025n

* CHECK dout1_9 Vdout1_9ck29 = 0 time = 150
.meas tran vdout1_9ck29 FIND v(dout1_9) AT=150.025n

* CHECK dout1_10 Vdout1_10ck29 = 0 time = 150
.meas tran vdout1_10ck29 FIND v(dout1_10) AT=150.025n

* CHECK dout1_11 Vdout1_11ck29 = 0 time = 150
.meas tran vdout1_11ck29 FIND v(dout1_11) AT=150.025n

* CHECK dout1_12 Vdout1_12ck29 = 0 time = 150
.meas tran vdout1_12ck29 FIND v(dout1_12) AT=150.025n

* CHECK dout1_13 Vdout1_13ck29 = 0.9 time = 150
.meas tran vdout1_13ck29 FIND v(dout1_13) AT=150.025n

* CHECK dout1_14 Vdout1_14ck29 = 0.9 time = 150
.meas tran vdout1_14ck29 FIND v(dout1_14) AT=150.025n

* CHECK dout1_15 Vdout1_15ck29 = 0 time = 150
.meas tran vdout1_15ck29 FIND v(dout1_15) AT=150.025n

* CHECK dout1_16 Vdout1_16ck29 = 0 time = 150
.meas tran vdout1_16ck29 FIND v(dout1_16) AT=150.025n

* CHECK dout1_17 Vdout1_17ck29 = 0 time = 150
.meas tran vdout1_17ck29 FIND v(dout1_17) AT=150.025n

* CHECK dout1_18 Vdout1_18ck29 = 0 time = 150
.meas tran vdout1_18ck29 FIND v(dout1_18) AT=150.025n

* CHECK dout1_19 Vdout1_19ck29 = 0.9 time = 150
.meas tran vdout1_19ck29 FIND v(dout1_19) AT=150.025n

* CHECK dout1_20 Vdout1_20ck29 = 0.9 time = 150
.meas tran vdout1_20ck29 FIND v(dout1_20) AT=150.025n

* CHECK dout1_21 Vdout1_21ck29 = 0 time = 150
.meas tran vdout1_21ck29 FIND v(dout1_21) AT=150.025n

* CHECK dout1_22 Vdout1_22ck29 = 0 time = 150
.meas tran vdout1_22ck29 FIND v(dout1_22) AT=150.025n

* CHECK dout1_23 Vdout1_23ck29 = 0.9 time = 150
.meas tran vdout1_23ck29 FIND v(dout1_23) AT=150.025n

* CHECK dout1_24 Vdout1_24ck29 = 0 time = 150
.meas tran vdout1_24ck29 FIND v(dout1_24) AT=150.025n

* CHECK dout1_25 Vdout1_25ck29 = 0.9 time = 150
.meas tran vdout1_25ck29 FIND v(dout1_25) AT=150.025n

* CHECK dout1_26 Vdout1_26ck29 = 0 time = 150
.meas tran vdout1_26ck29 FIND v(dout1_26) AT=150.025n

* CHECK dout1_27 Vdout1_27ck29 = 0 time = 150
.meas tran vdout1_27ck29 FIND v(dout1_27) AT=150.025n

* CHECK dout1_28 Vdout1_28ck29 = 0.9 time = 150
.meas tran vdout1_28ck29 FIND v(dout1_28) AT=150.025n

* CHECK dout1_29 Vdout1_29ck29 = 0 time = 150
.meas tran vdout1_29ck29 FIND v(dout1_29) AT=150.025n

* CHECK dout1_30 Vdout1_30ck29 = 0 time = 150
.meas tran vdout1_30ck29 FIND v(dout1_30) AT=150.025n

* CHECK dout1_31 Vdout1_31ck29 = 0 time = 150
.meas tran vdout1_31ck29 FIND v(dout1_31) AT=150.025n

* CHECK dout1_32 Vdout1_32ck29 = 0.9 time = 150
.meas tran vdout1_32ck29 FIND v(dout1_32) AT=150.025n

* CHECK dout1_33 Vdout1_33ck29 = 0 time = 150
.meas tran vdout1_33ck29 FIND v(dout1_33) AT=150.025n

* CHECK dout1_34 Vdout1_34ck29 = 0 time = 150
.meas tran vdout1_34ck29 FIND v(dout1_34) AT=150.025n

* CHECK dout1_35 Vdout1_35ck29 = 0 time = 150
.meas tran vdout1_35ck29 FIND v(dout1_35) AT=150.025n

* CHECK dout1_36 Vdout1_36ck29 = 0 time = 150
.meas tran vdout1_36ck29 FIND v(dout1_36) AT=150.025n

* CHECK dout1_37 Vdout1_37ck29 = 0.9 time = 150
.meas tran vdout1_37ck29 FIND v(dout1_37) AT=150.025n

* CHECK dout1_38 Vdout1_38ck29 = 0.9 time = 150
.meas tran vdout1_38ck29 FIND v(dout1_38) AT=150.025n

* CHECK dout1_39 Vdout1_39ck29 = 0 time = 150
.meas tran vdout1_39ck29 FIND v(dout1_39) AT=150.025n

* CHECK dout1_40 Vdout1_40ck29 = 0 time = 150
.meas tran vdout1_40ck29 FIND v(dout1_40) AT=150.025n

* CHECK dout1_41 Vdout1_41ck29 = 0 time = 150
.meas tran vdout1_41ck29 FIND v(dout1_41) AT=150.025n

* CHECK dout1_42 Vdout1_42ck29 = 0 time = 150
.meas tran vdout1_42ck29 FIND v(dout1_42) AT=150.025n

* CHECK dout1_43 Vdout1_43ck29 = 0.9 time = 150
.meas tran vdout1_43ck29 FIND v(dout1_43) AT=150.025n

* CHECK dout1_44 Vdout1_44ck29 = 0 time = 150
.meas tran vdout1_44ck29 FIND v(dout1_44) AT=150.025n

* CHECK dout1_45 Vdout1_45ck29 = 0 time = 150
.meas tran vdout1_45ck29 FIND v(dout1_45) AT=150.025n

* CHECK dout1_46 Vdout1_46ck29 = 0.9 time = 150
.meas tran vdout1_46ck29 FIND v(dout1_46) AT=150.025n

* CHECK dout1_47 Vdout1_47ck29 = 0.9 time = 150
.meas tran vdout1_47ck29 FIND v(dout1_47) AT=150.025n

* CHECK dout1_48 Vdout1_48ck29 = 0 time = 150
.meas tran vdout1_48ck29 FIND v(dout1_48) AT=150.025n

* CHECK dout1_49 Vdout1_49ck29 = 0 time = 150
.meas tran vdout1_49ck29 FIND v(dout1_49) AT=150.025n

* CHECK dout1_50 Vdout1_50ck29 = 0.9 time = 150
.meas tran vdout1_50ck29 FIND v(dout1_50) AT=150.025n

* CHECK dout1_51 Vdout1_51ck29 = 0 time = 150
.meas tran vdout1_51ck29 FIND v(dout1_51) AT=150.025n

* CHECK dout1_52 Vdout1_52ck29 = 0 time = 150
.meas tran vdout1_52ck29 FIND v(dout1_52) AT=150.025n

* CHECK dout1_53 Vdout1_53ck29 = 0 time = 150
.meas tran vdout1_53ck29 FIND v(dout1_53) AT=150.025n

* CHECK dout1_54 Vdout1_54ck29 = 0 time = 150
.meas tran vdout1_54ck29 FIND v(dout1_54) AT=150.025n

* CHECK dout1_55 Vdout1_55ck29 = 0 time = 150
.meas tran vdout1_55ck29 FIND v(dout1_55) AT=150.025n

* CHECK dout1_56 Vdout1_56ck29 = 0 time = 150
.meas tran vdout1_56ck29 FIND v(dout1_56) AT=150.025n

* CHECK dout1_57 Vdout1_57ck29 = 0.9 time = 150
.meas tran vdout1_57ck29 FIND v(dout1_57) AT=150.025n

* CHECK dout1_58 Vdout1_58ck29 = 0 time = 150
.meas tran vdout1_58ck29 FIND v(dout1_58) AT=150.025n

* CHECK dout1_59 Vdout1_59ck29 = 0.9 time = 150
.meas tran vdout1_59ck29 FIND v(dout1_59) AT=150.025n

* CHECK dout1_60 Vdout1_60ck29 = 0.9 time = 150
.meas tran vdout1_60ck29 FIND v(dout1_60) AT=150.025n

* CHECK dout1_61 Vdout1_61ck29 = 0 time = 150
.meas tran vdout1_61ck29 FIND v(dout1_61) AT=150.025n

* CHECK dout1_62 Vdout1_62ck29 = 0.9 time = 150
.meas tran vdout1_62ck29 FIND v(dout1_62) AT=150.025n

* CHECK dout1_63 Vdout1_63ck29 = 0 time = 150
.meas tran vdout1_63ck29 FIND v(dout1_63) AT=150.025n

* CHECK dout1_64 Vdout1_64ck29 = 0.9 time = 150
.meas tran vdout1_64ck29 FIND v(dout1_64) AT=150.025n

* CHECK dout1_65 Vdout1_65ck29 = 0 time = 150
.meas tran vdout1_65ck29 FIND v(dout1_65) AT=150.025n

* CHECK dout1_66 Vdout1_66ck29 = 0 time = 150
.meas tran vdout1_66ck29 FIND v(dout1_66) AT=150.025n

* CHECK dout1_67 Vdout1_67ck29 = 0.9 time = 150
.meas tran vdout1_67ck29 FIND v(dout1_67) AT=150.025n

* CHECK dout1_68 Vdout1_68ck29 = 0.9 time = 150
.meas tran vdout1_68ck29 FIND v(dout1_68) AT=150.025n

* CHECK dout1_69 Vdout1_69ck29 = 0 time = 150
.meas tran vdout1_69ck29 FIND v(dout1_69) AT=150.025n

* CHECK dout1_70 Vdout1_70ck29 = 0.9 time = 150
.meas tran vdout1_70ck29 FIND v(dout1_70) AT=150.025n

* CHECK dout1_71 Vdout1_71ck29 = 0 time = 150
.meas tran vdout1_71ck29 FIND v(dout1_71) AT=150.025n

* CHECK dout1_72 Vdout1_72ck29 = 0 time = 150
.meas tran vdout1_72ck29 FIND v(dout1_72) AT=150.025n

* CHECK dout1_73 Vdout1_73ck29 = 0 time = 150
.meas tran vdout1_73ck29 FIND v(dout1_73) AT=150.025n

* CHECK dout1_74 Vdout1_74ck29 = 0 time = 150
.meas tran vdout1_74ck29 FIND v(dout1_74) AT=150.025n

* CHECK dout1_75 Vdout1_75ck29 = 0 time = 150
.meas tran vdout1_75ck29 FIND v(dout1_75) AT=150.025n

* CHECK dout1_76 Vdout1_76ck29 = 0 time = 150
.meas tran vdout1_76ck29 FIND v(dout1_76) AT=150.025n

* CHECK dout1_77 Vdout1_77ck29 = 0.9 time = 150
.meas tran vdout1_77ck29 FIND v(dout1_77) AT=150.025n

* CHECK dout1_78 Vdout1_78ck29 = 0 time = 150
.meas tran vdout1_78ck29 FIND v(dout1_78) AT=150.025n

* CHECK dout1_79 Vdout1_79ck29 = 0.9 time = 150
.meas tran vdout1_79ck29 FIND v(dout1_79) AT=150.025n

* CHECK dout1_80 Vdout1_80ck29 = 0 time = 150
.meas tran vdout1_80ck29 FIND v(dout1_80) AT=150.025n

* CHECK dout1_81 Vdout1_81ck29 = 0 time = 150
.meas tran vdout1_81ck29 FIND v(dout1_81) AT=150.025n

* CHECK dout1_82 Vdout1_82ck29 = 0.9 time = 150
.meas tran vdout1_82ck29 FIND v(dout1_82) AT=150.025n

* CHECK dout1_83 Vdout1_83ck29 = 0 time = 150
.meas tran vdout1_83ck29 FIND v(dout1_83) AT=150.025n

* CHECK dout1_84 Vdout1_84ck29 = 0.9 time = 150
.meas tran vdout1_84ck29 FIND v(dout1_84) AT=150.025n

* CHECK dout1_85 Vdout1_85ck29 = 0 time = 150
.meas tran vdout1_85ck29 FIND v(dout1_85) AT=150.025n

* CHECK dout1_86 Vdout1_86ck29 = 0.9 time = 150
.meas tran vdout1_86ck29 FIND v(dout1_86) AT=150.025n

* CHECK dout1_87 Vdout1_87ck29 = 0.9 time = 150
.meas tran vdout1_87ck29 FIND v(dout1_87) AT=150.025n

* CHECK dout1_88 Vdout1_88ck29 = 0 time = 150
.meas tran vdout1_88ck29 FIND v(dout1_88) AT=150.025n

* CHECK dout1_89 Vdout1_89ck29 = 0.9 time = 150
.meas tran vdout1_89ck29 FIND v(dout1_89) AT=150.025n

* CHECK dout1_90 Vdout1_90ck29 = 0 time = 150
.meas tran vdout1_90ck29 FIND v(dout1_90) AT=150.025n

* CHECK dout1_91 Vdout1_91ck29 = 0.9 time = 150
.meas tran vdout1_91ck29 FIND v(dout1_91) AT=150.025n

* CHECK dout1_92 Vdout1_92ck29 = 0.9 time = 150
.meas tran vdout1_92ck29 FIND v(dout1_92) AT=150.025n

* CHECK dout1_93 Vdout1_93ck29 = 0 time = 150
.meas tran vdout1_93ck29 FIND v(dout1_93) AT=150.025n

* CHECK dout1_94 Vdout1_94ck29 = 0 time = 150
.meas tran vdout1_94ck29 FIND v(dout1_94) AT=150.025n

* CHECK dout1_95 Vdout1_95ck29 = 0 time = 150
.meas tran vdout1_95ck29 FIND v(dout1_95) AT=150.025n

* CHECK dout1_96 Vdout1_96ck29 = 0.9 time = 150
.meas tran vdout1_96ck29 FIND v(dout1_96) AT=150.025n

* CHECK dout1_97 Vdout1_97ck29 = 0.9 time = 150
.meas tran vdout1_97ck29 FIND v(dout1_97) AT=150.025n

* CHECK dout1_98 Vdout1_98ck29 = 0 time = 150
.meas tran vdout1_98ck29 FIND v(dout1_98) AT=150.025n

* CHECK dout1_99 Vdout1_99ck29 = 0 time = 150
.meas tran vdout1_99ck29 FIND v(dout1_99) AT=150.025n

* CHECK dout1_100 Vdout1_100ck29 = 0 time = 150
.meas tran vdout1_100ck29 FIND v(dout1_100) AT=150.025n

* CHECK dout1_101 Vdout1_101ck29 = 0 time = 150
.meas tran vdout1_101ck29 FIND v(dout1_101) AT=150.025n

* CHECK dout1_102 Vdout1_102ck29 = 0 time = 150
.meas tran vdout1_102ck29 FIND v(dout1_102) AT=150.025n

* CHECK dout1_103 Vdout1_103ck29 = 0.9 time = 150
.meas tran vdout1_103ck29 FIND v(dout1_103) AT=150.025n

* CHECK dout1_104 Vdout1_104ck29 = 0.9 time = 150
.meas tran vdout1_104ck29 FIND v(dout1_104) AT=150.025n

* CHECK dout1_105 Vdout1_105ck29 = 0 time = 150
.meas tran vdout1_105ck29 FIND v(dout1_105) AT=150.025n

* CHECK dout1_106 Vdout1_106ck29 = 0.9 time = 150
.meas tran vdout1_106ck29 FIND v(dout1_106) AT=150.025n

* CHECK dout1_107 Vdout1_107ck29 = 0 time = 150
.meas tran vdout1_107ck29 FIND v(dout1_107) AT=150.025n

* CHECK dout1_108 Vdout1_108ck29 = 0.9 time = 150
.meas tran vdout1_108ck29 FIND v(dout1_108) AT=150.025n

* CHECK dout1_109 Vdout1_109ck29 = 0.9 time = 150
.meas tran vdout1_109ck29 FIND v(dout1_109) AT=150.025n

* CHECK dout1_110 Vdout1_110ck29 = 0 time = 150
.meas tran vdout1_110ck29 FIND v(dout1_110) AT=150.025n

* CHECK dout1_111 Vdout1_111ck29 = 0.9 time = 150
.meas tran vdout1_111ck29 FIND v(dout1_111) AT=150.025n

* CHECK dout1_112 Vdout1_112ck29 = 0.9 time = 150
.meas tran vdout1_112ck29 FIND v(dout1_112) AT=150.025n

* CHECK dout1_113 Vdout1_113ck29 = 0 time = 150
.meas tran vdout1_113ck29 FIND v(dout1_113) AT=150.025n

* CHECK dout1_114 Vdout1_114ck29 = 0.9 time = 150
.meas tran vdout1_114ck29 FIND v(dout1_114) AT=150.025n

* CHECK dout1_115 Vdout1_115ck29 = 0 time = 150
.meas tran vdout1_115ck29 FIND v(dout1_115) AT=150.025n

* CHECK dout1_116 Vdout1_116ck29 = 0 time = 150
.meas tran vdout1_116ck29 FIND v(dout1_116) AT=150.025n

* CHECK dout1_117 Vdout1_117ck29 = 0 time = 150
.meas tran vdout1_117ck29 FIND v(dout1_117) AT=150.025n

* CHECK dout1_118 Vdout1_118ck29 = 0 time = 150
.meas tran vdout1_118ck29 FIND v(dout1_118) AT=150.025n

* CHECK dout1_119 Vdout1_119ck29 = 0 time = 150
.meas tran vdout1_119ck29 FIND v(dout1_119) AT=150.025n

* CHECK dout1_0 Vdout1_0ck32 = 0.9 time = 165
.meas tran vdout1_0ck32 FIND v(dout1_0) AT=165.025n

* CHECK dout1_1 Vdout1_1ck32 = 0 time = 165
.meas tran vdout1_1ck32 FIND v(dout1_1) AT=165.025n

* CHECK dout1_2 Vdout1_2ck32 = 0 time = 165
.meas tran vdout1_2ck32 FIND v(dout1_2) AT=165.025n

* CHECK dout1_3 Vdout1_3ck32 = 0 time = 165
.meas tran vdout1_3ck32 FIND v(dout1_3) AT=165.025n

* CHECK dout1_4 Vdout1_4ck32 = 0 time = 165
.meas tran vdout1_4ck32 FIND v(dout1_4) AT=165.025n

* CHECK dout1_5 Vdout1_5ck32 = 0.9 time = 165
.meas tran vdout1_5ck32 FIND v(dout1_5) AT=165.025n

* CHECK dout1_6 Vdout1_6ck32 = 0 time = 165
.meas tran vdout1_6ck32 FIND v(dout1_6) AT=165.025n

* CHECK dout1_7 Vdout1_7ck32 = 0.9 time = 165
.meas tran vdout1_7ck32 FIND v(dout1_7) AT=165.025n

* CHECK dout1_8 Vdout1_8ck32 = 0 time = 165
.meas tran vdout1_8ck32 FIND v(dout1_8) AT=165.025n

* CHECK dout1_9 Vdout1_9ck32 = 0.9 time = 165
.meas tran vdout1_9ck32 FIND v(dout1_9) AT=165.025n

* CHECK dout1_10 Vdout1_10ck32 = 0 time = 165
.meas tran vdout1_10ck32 FIND v(dout1_10) AT=165.025n

* CHECK dout1_11 Vdout1_11ck32 = 0.9 time = 165
.meas tran vdout1_11ck32 FIND v(dout1_11) AT=165.025n

* CHECK dout1_12 Vdout1_12ck32 = 0 time = 165
.meas tran vdout1_12ck32 FIND v(dout1_12) AT=165.025n

* CHECK dout1_13 Vdout1_13ck32 = 0.9 time = 165
.meas tran vdout1_13ck32 FIND v(dout1_13) AT=165.025n

* CHECK dout1_14 Vdout1_14ck32 = 0.9 time = 165
.meas tran vdout1_14ck32 FIND v(dout1_14) AT=165.025n

* CHECK dout1_15 Vdout1_15ck32 = 0.9 time = 165
.meas tran vdout1_15ck32 FIND v(dout1_15) AT=165.025n

* CHECK dout1_16 Vdout1_16ck32 = 0.9 time = 165
.meas tran vdout1_16ck32 FIND v(dout1_16) AT=165.025n

* CHECK dout1_17 Vdout1_17ck32 = 0.9 time = 165
.meas tran vdout1_17ck32 FIND v(dout1_17) AT=165.025n

* CHECK dout1_18 Vdout1_18ck32 = 0 time = 165
.meas tran vdout1_18ck32 FIND v(dout1_18) AT=165.025n

* CHECK dout1_19 Vdout1_19ck32 = 0 time = 165
.meas tran vdout1_19ck32 FIND v(dout1_19) AT=165.025n

* CHECK dout1_20 Vdout1_20ck32 = 0 time = 165
.meas tran vdout1_20ck32 FIND v(dout1_20) AT=165.025n

* CHECK dout1_21 Vdout1_21ck32 = 0.9 time = 165
.meas tran vdout1_21ck32 FIND v(dout1_21) AT=165.025n

* CHECK dout1_22 Vdout1_22ck32 = 0.9 time = 165
.meas tran vdout1_22ck32 FIND v(dout1_22) AT=165.025n

* CHECK dout1_23 Vdout1_23ck32 = 0 time = 165
.meas tran vdout1_23ck32 FIND v(dout1_23) AT=165.025n

* CHECK dout1_24 Vdout1_24ck32 = 0 time = 165
.meas tran vdout1_24ck32 FIND v(dout1_24) AT=165.025n

* CHECK dout1_25 Vdout1_25ck32 = 0.9 time = 165
.meas tran vdout1_25ck32 FIND v(dout1_25) AT=165.025n

* CHECK dout1_26 Vdout1_26ck32 = 0 time = 165
.meas tran vdout1_26ck32 FIND v(dout1_26) AT=165.025n

* CHECK dout1_27 Vdout1_27ck32 = 0 time = 165
.meas tran vdout1_27ck32 FIND v(dout1_27) AT=165.025n

* CHECK dout1_28 Vdout1_28ck32 = 0.9 time = 165
.meas tran vdout1_28ck32 FIND v(dout1_28) AT=165.025n

* CHECK dout1_29 Vdout1_29ck32 = 0.9 time = 165
.meas tran vdout1_29ck32 FIND v(dout1_29) AT=165.025n

* CHECK dout1_30 Vdout1_30ck32 = 0.9 time = 165
.meas tran vdout1_30ck32 FIND v(dout1_30) AT=165.025n

* CHECK dout1_31 Vdout1_31ck32 = 0.9 time = 165
.meas tran vdout1_31ck32 FIND v(dout1_31) AT=165.025n

* CHECK dout1_32 Vdout1_32ck32 = 0 time = 165
.meas tran vdout1_32ck32 FIND v(dout1_32) AT=165.025n

* CHECK dout1_33 Vdout1_33ck32 = 0.9 time = 165
.meas tran vdout1_33ck32 FIND v(dout1_33) AT=165.025n

* CHECK dout1_34 Vdout1_34ck32 = 0 time = 165
.meas tran vdout1_34ck32 FIND v(dout1_34) AT=165.025n

* CHECK dout1_35 Vdout1_35ck32 = 0 time = 165
.meas tran vdout1_35ck32 FIND v(dout1_35) AT=165.025n

* CHECK dout1_36 Vdout1_36ck32 = 0 time = 165
.meas tran vdout1_36ck32 FIND v(dout1_36) AT=165.025n

* CHECK dout1_37 Vdout1_37ck32 = 0.9 time = 165
.meas tran vdout1_37ck32 FIND v(dout1_37) AT=165.025n

* CHECK dout1_38 Vdout1_38ck32 = 0 time = 165
.meas tran vdout1_38ck32 FIND v(dout1_38) AT=165.025n

* CHECK dout1_39 Vdout1_39ck32 = 0.9 time = 165
.meas tran vdout1_39ck32 FIND v(dout1_39) AT=165.025n

* CHECK dout1_40 Vdout1_40ck32 = 0.9 time = 165
.meas tran vdout1_40ck32 FIND v(dout1_40) AT=165.025n

* CHECK dout1_41 Vdout1_41ck32 = 0 time = 165
.meas tran vdout1_41ck32 FIND v(dout1_41) AT=165.025n

* CHECK dout1_42 Vdout1_42ck32 = 0.9 time = 165
.meas tran vdout1_42ck32 FIND v(dout1_42) AT=165.025n

* CHECK dout1_43 Vdout1_43ck32 = 0.9 time = 165
.meas tran vdout1_43ck32 FIND v(dout1_43) AT=165.025n

* CHECK dout1_44 Vdout1_44ck32 = 0.9 time = 165
.meas tran vdout1_44ck32 FIND v(dout1_44) AT=165.025n

* CHECK dout1_45 Vdout1_45ck32 = 0 time = 165
.meas tran vdout1_45ck32 FIND v(dout1_45) AT=165.025n

* CHECK dout1_46 Vdout1_46ck32 = 0.9 time = 165
.meas tran vdout1_46ck32 FIND v(dout1_46) AT=165.025n

* CHECK dout1_47 Vdout1_47ck32 = 0.9 time = 165
.meas tran vdout1_47ck32 FIND v(dout1_47) AT=165.025n

* CHECK dout1_48 Vdout1_48ck32 = 0.9 time = 165
.meas tran vdout1_48ck32 FIND v(dout1_48) AT=165.025n

* CHECK dout1_49 Vdout1_49ck32 = 0.9 time = 165
.meas tran vdout1_49ck32 FIND v(dout1_49) AT=165.025n

* CHECK dout1_50 Vdout1_50ck32 = 0 time = 165
.meas tran vdout1_50ck32 FIND v(dout1_50) AT=165.025n

* CHECK dout1_51 Vdout1_51ck32 = 0.9 time = 165
.meas tran vdout1_51ck32 FIND v(dout1_51) AT=165.025n

* CHECK dout1_52 Vdout1_52ck32 = 0.9 time = 165
.meas tran vdout1_52ck32 FIND v(dout1_52) AT=165.025n

* CHECK dout1_53 Vdout1_53ck32 = 0.9 time = 165
.meas tran vdout1_53ck32 FIND v(dout1_53) AT=165.025n

* CHECK dout1_54 Vdout1_54ck32 = 0 time = 165
.meas tran vdout1_54ck32 FIND v(dout1_54) AT=165.025n

* CHECK dout1_55 Vdout1_55ck32 = 0.9 time = 165
.meas tran vdout1_55ck32 FIND v(dout1_55) AT=165.025n

* CHECK dout1_56 Vdout1_56ck32 = 0.9 time = 165
.meas tran vdout1_56ck32 FIND v(dout1_56) AT=165.025n

* CHECK dout1_57 Vdout1_57ck32 = 0.9 time = 165
.meas tran vdout1_57ck32 FIND v(dout1_57) AT=165.025n

* CHECK dout1_58 Vdout1_58ck32 = 0 time = 165
.meas tran vdout1_58ck32 FIND v(dout1_58) AT=165.025n

* CHECK dout1_59 Vdout1_59ck32 = 0.9 time = 165
.meas tran vdout1_59ck32 FIND v(dout1_59) AT=165.025n

* CHECK dout1_60 Vdout1_60ck32 = 0 time = 165
.meas tran vdout1_60ck32 FIND v(dout1_60) AT=165.025n

* CHECK dout1_61 Vdout1_61ck32 = 0 time = 165
.meas tran vdout1_61ck32 FIND v(dout1_61) AT=165.025n

* CHECK dout1_62 Vdout1_62ck32 = 0 time = 165
.meas tran vdout1_62ck32 FIND v(dout1_62) AT=165.025n

* CHECK dout1_63 Vdout1_63ck32 = 0 time = 165
.meas tran vdout1_63ck32 FIND v(dout1_63) AT=165.025n

* CHECK dout1_64 Vdout1_64ck32 = 0.9 time = 165
.meas tran vdout1_64ck32 FIND v(dout1_64) AT=165.025n

* CHECK dout1_65 Vdout1_65ck32 = 0 time = 165
.meas tran vdout1_65ck32 FIND v(dout1_65) AT=165.025n

* CHECK dout1_66 Vdout1_66ck32 = 0.9 time = 165
.meas tran vdout1_66ck32 FIND v(dout1_66) AT=165.025n

* CHECK dout1_67 Vdout1_67ck32 = 0.9 time = 165
.meas tran vdout1_67ck32 FIND v(dout1_67) AT=165.025n

* CHECK dout1_68 Vdout1_68ck32 = 0 time = 165
.meas tran vdout1_68ck32 FIND v(dout1_68) AT=165.025n

* CHECK dout1_69 Vdout1_69ck32 = 0.9 time = 165
.meas tran vdout1_69ck32 FIND v(dout1_69) AT=165.025n

* CHECK dout1_70 Vdout1_70ck32 = 0.9 time = 165
.meas tran vdout1_70ck32 FIND v(dout1_70) AT=165.025n

* CHECK dout1_71 Vdout1_71ck32 = 0.9 time = 165
.meas tran vdout1_71ck32 FIND v(dout1_71) AT=165.025n

* CHECK dout1_72 Vdout1_72ck32 = 0.9 time = 165
.meas tran vdout1_72ck32 FIND v(dout1_72) AT=165.025n

* CHECK dout1_73 Vdout1_73ck32 = 0.9 time = 165
.meas tran vdout1_73ck32 FIND v(dout1_73) AT=165.025n

* CHECK dout1_74 Vdout1_74ck32 = 0.9 time = 165
.meas tran vdout1_74ck32 FIND v(dout1_74) AT=165.025n

* CHECK dout1_75 Vdout1_75ck32 = 0 time = 165
.meas tran vdout1_75ck32 FIND v(dout1_75) AT=165.025n

* CHECK dout1_76 Vdout1_76ck32 = 0.9 time = 165
.meas tran vdout1_76ck32 FIND v(dout1_76) AT=165.025n

* CHECK dout1_77 Vdout1_77ck32 = 0.9 time = 165
.meas tran vdout1_77ck32 FIND v(dout1_77) AT=165.025n

* CHECK dout1_78 Vdout1_78ck32 = 0 time = 165
.meas tran vdout1_78ck32 FIND v(dout1_78) AT=165.025n

* CHECK dout1_79 Vdout1_79ck32 = 0.9 time = 165
.meas tran vdout1_79ck32 FIND v(dout1_79) AT=165.025n

* CHECK dout1_80 Vdout1_80ck32 = 0 time = 165
.meas tran vdout1_80ck32 FIND v(dout1_80) AT=165.025n

* CHECK dout1_81 Vdout1_81ck32 = 0.9 time = 165
.meas tran vdout1_81ck32 FIND v(dout1_81) AT=165.025n

* CHECK dout1_82 Vdout1_82ck32 = 0.9 time = 165
.meas tran vdout1_82ck32 FIND v(dout1_82) AT=165.025n

* CHECK dout1_83 Vdout1_83ck32 = 0 time = 165
.meas tran vdout1_83ck32 FIND v(dout1_83) AT=165.025n

* CHECK dout1_84 Vdout1_84ck32 = 0 time = 165
.meas tran vdout1_84ck32 FIND v(dout1_84) AT=165.025n

* CHECK dout1_85 Vdout1_85ck32 = 0.9 time = 165
.meas tran vdout1_85ck32 FIND v(dout1_85) AT=165.025n

* CHECK dout1_86 Vdout1_86ck32 = 0.9 time = 165
.meas tran vdout1_86ck32 FIND v(dout1_86) AT=165.025n

* CHECK dout1_87 Vdout1_87ck32 = 0.9 time = 165
.meas tran vdout1_87ck32 FIND v(dout1_87) AT=165.025n

* CHECK dout1_88 Vdout1_88ck32 = 0 time = 165
.meas tran vdout1_88ck32 FIND v(dout1_88) AT=165.025n

* CHECK dout1_89 Vdout1_89ck32 = 0 time = 165
.meas tran vdout1_89ck32 FIND v(dout1_89) AT=165.025n

* CHECK dout1_90 Vdout1_90ck32 = 0.9 time = 165
.meas tran vdout1_90ck32 FIND v(dout1_90) AT=165.025n

* CHECK dout1_91 Vdout1_91ck32 = 0.9 time = 165
.meas tran vdout1_91ck32 FIND v(dout1_91) AT=165.025n

* CHECK dout1_92 Vdout1_92ck32 = 0 time = 165
.meas tran vdout1_92ck32 FIND v(dout1_92) AT=165.025n

* CHECK dout1_93 Vdout1_93ck32 = 0 time = 165
.meas tran vdout1_93ck32 FIND v(dout1_93) AT=165.025n

* CHECK dout1_94 Vdout1_94ck32 = 0 time = 165
.meas tran vdout1_94ck32 FIND v(dout1_94) AT=165.025n

* CHECK dout1_95 Vdout1_95ck32 = 0 time = 165
.meas tran vdout1_95ck32 FIND v(dout1_95) AT=165.025n

* CHECK dout1_96 Vdout1_96ck32 = 0.9 time = 165
.meas tran vdout1_96ck32 FIND v(dout1_96) AT=165.025n

* CHECK dout1_97 Vdout1_97ck32 = 0.9 time = 165
.meas tran vdout1_97ck32 FIND v(dout1_97) AT=165.025n

* CHECK dout1_98 Vdout1_98ck32 = 0.9 time = 165
.meas tran vdout1_98ck32 FIND v(dout1_98) AT=165.025n

* CHECK dout1_99 Vdout1_99ck32 = 0 time = 165
.meas tran vdout1_99ck32 FIND v(dout1_99) AT=165.025n

* CHECK dout1_100 Vdout1_100ck32 = 0 time = 165
.meas tran vdout1_100ck32 FIND v(dout1_100) AT=165.025n

* CHECK dout1_101 Vdout1_101ck32 = 0.9 time = 165
.meas tran vdout1_101ck32 FIND v(dout1_101) AT=165.025n

* CHECK dout1_102 Vdout1_102ck32 = 0.9 time = 165
.meas tran vdout1_102ck32 FIND v(dout1_102) AT=165.025n

* CHECK dout1_103 Vdout1_103ck32 = 0 time = 165
.meas tran vdout1_103ck32 FIND v(dout1_103) AT=165.025n

* CHECK dout1_104 Vdout1_104ck32 = 0 time = 165
.meas tran vdout1_104ck32 FIND v(dout1_104) AT=165.025n

* CHECK dout1_105 Vdout1_105ck32 = 0 time = 165
.meas tran vdout1_105ck32 FIND v(dout1_105) AT=165.025n

* CHECK dout1_106 Vdout1_106ck32 = 0 time = 165
.meas tran vdout1_106ck32 FIND v(dout1_106) AT=165.025n

* CHECK dout1_107 Vdout1_107ck32 = 0 time = 165
.meas tran vdout1_107ck32 FIND v(dout1_107) AT=165.025n

* CHECK dout1_108 Vdout1_108ck32 = 0 time = 165
.meas tran vdout1_108ck32 FIND v(dout1_108) AT=165.025n

* CHECK dout1_109 Vdout1_109ck32 = 0.9 time = 165
.meas tran vdout1_109ck32 FIND v(dout1_109) AT=165.025n

* CHECK dout1_110 Vdout1_110ck32 = 0 time = 165
.meas tran vdout1_110ck32 FIND v(dout1_110) AT=165.025n

* CHECK dout1_111 Vdout1_111ck32 = 0 time = 165
.meas tran vdout1_111ck32 FIND v(dout1_111) AT=165.025n

* CHECK dout1_112 Vdout1_112ck32 = 0.9 time = 165
.meas tran vdout1_112ck32 FIND v(dout1_112) AT=165.025n

* CHECK dout1_113 Vdout1_113ck32 = 0.9 time = 165
.meas tran vdout1_113ck32 FIND v(dout1_113) AT=165.025n

* CHECK dout1_114 Vdout1_114ck32 = 0 time = 165
.meas tran vdout1_114ck32 FIND v(dout1_114) AT=165.025n

* CHECK dout1_115 Vdout1_115ck32 = 0.9 time = 165
.meas tran vdout1_115ck32 FIND v(dout1_115) AT=165.025n

* CHECK dout1_116 Vdout1_116ck32 = 0.9 time = 165
.meas tran vdout1_116ck32 FIND v(dout1_116) AT=165.025n

* CHECK dout1_117 Vdout1_117ck32 = 0.9 time = 165
.meas tran vdout1_117ck32 FIND v(dout1_117) AT=165.025n

* CHECK dout1_118 Vdout1_118ck32 = 0.9 time = 165
.meas tran vdout1_118ck32 FIND v(dout1_118) AT=165.025n

* CHECK dout1_119 Vdout1_119ck32 = 0.9 time = 165
.meas tran vdout1_119ck32 FIND v(dout1_119) AT=165.025n

* CHECK dout1_0 Vdout1_0ck33 = 0.9 time = 170
.meas tran vdout1_0ck33 FIND v(dout1_0) AT=170.025n

* CHECK dout1_1 Vdout1_1ck33 = 0 time = 170
.meas tran vdout1_1ck33 FIND v(dout1_1) AT=170.025n

* CHECK dout1_2 Vdout1_2ck33 = 0 time = 170
.meas tran vdout1_2ck33 FIND v(dout1_2) AT=170.025n

* CHECK dout1_3 Vdout1_3ck33 = 0 time = 170
.meas tran vdout1_3ck33 FIND v(dout1_3) AT=170.025n

* CHECK dout1_4 Vdout1_4ck33 = 0 time = 170
.meas tran vdout1_4ck33 FIND v(dout1_4) AT=170.025n

* CHECK dout1_5 Vdout1_5ck33 = 0.9 time = 170
.meas tran vdout1_5ck33 FIND v(dout1_5) AT=170.025n

* CHECK dout1_6 Vdout1_6ck33 = 0 time = 170
.meas tran vdout1_6ck33 FIND v(dout1_6) AT=170.025n

* CHECK dout1_7 Vdout1_7ck33 = 0.9 time = 170
.meas tran vdout1_7ck33 FIND v(dout1_7) AT=170.025n

* CHECK dout1_8 Vdout1_8ck33 = 0 time = 170
.meas tran vdout1_8ck33 FIND v(dout1_8) AT=170.025n

* CHECK dout1_9 Vdout1_9ck33 = 0.9 time = 170
.meas tran vdout1_9ck33 FIND v(dout1_9) AT=170.025n

* CHECK dout1_10 Vdout1_10ck33 = 0 time = 170
.meas tran vdout1_10ck33 FIND v(dout1_10) AT=170.025n

* CHECK dout1_11 Vdout1_11ck33 = 0.9 time = 170
.meas tran vdout1_11ck33 FIND v(dout1_11) AT=170.025n

* CHECK dout1_12 Vdout1_12ck33 = 0 time = 170
.meas tran vdout1_12ck33 FIND v(dout1_12) AT=170.025n

* CHECK dout1_13 Vdout1_13ck33 = 0.9 time = 170
.meas tran vdout1_13ck33 FIND v(dout1_13) AT=170.025n

* CHECK dout1_14 Vdout1_14ck33 = 0.9 time = 170
.meas tran vdout1_14ck33 FIND v(dout1_14) AT=170.025n

* CHECK dout1_15 Vdout1_15ck33 = 0.9 time = 170
.meas tran vdout1_15ck33 FIND v(dout1_15) AT=170.025n

* CHECK dout1_16 Vdout1_16ck33 = 0.9 time = 170
.meas tran vdout1_16ck33 FIND v(dout1_16) AT=170.025n

* CHECK dout1_17 Vdout1_17ck33 = 0.9 time = 170
.meas tran vdout1_17ck33 FIND v(dout1_17) AT=170.025n

* CHECK dout1_18 Vdout1_18ck33 = 0 time = 170
.meas tran vdout1_18ck33 FIND v(dout1_18) AT=170.025n

* CHECK dout1_19 Vdout1_19ck33 = 0 time = 170
.meas tran vdout1_19ck33 FIND v(dout1_19) AT=170.025n

* CHECK dout1_20 Vdout1_20ck33 = 0 time = 170
.meas tran vdout1_20ck33 FIND v(dout1_20) AT=170.025n

* CHECK dout1_21 Vdout1_21ck33 = 0.9 time = 170
.meas tran vdout1_21ck33 FIND v(dout1_21) AT=170.025n

* CHECK dout1_22 Vdout1_22ck33 = 0.9 time = 170
.meas tran vdout1_22ck33 FIND v(dout1_22) AT=170.025n

* CHECK dout1_23 Vdout1_23ck33 = 0 time = 170
.meas tran vdout1_23ck33 FIND v(dout1_23) AT=170.025n

* CHECK dout1_24 Vdout1_24ck33 = 0 time = 170
.meas tran vdout1_24ck33 FIND v(dout1_24) AT=170.025n

* CHECK dout1_25 Vdout1_25ck33 = 0.9 time = 170
.meas tran vdout1_25ck33 FIND v(dout1_25) AT=170.025n

* CHECK dout1_26 Vdout1_26ck33 = 0 time = 170
.meas tran vdout1_26ck33 FIND v(dout1_26) AT=170.025n

* CHECK dout1_27 Vdout1_27ck33 = 0 time = 170
.meas tran vdout1_27ck33 FIND v(dout1_27) AT=170.025n

* CHECK dout1_28 Vdout1_28ck33 = 0.9 time = 170
.meas tran vdout1_28ck33 FIND v(dout1_28) AT=170.025n

* CHECK dout1_29 Vdout1_29ck33 = 0.9 time = 170
.meas tran vdout1_29ck33 FIND v(dout1_29) AT=170.025n

* CHECK dout1_30 Vdout1_30ck33 = 0.9 time = 170
.meas tran vdout1_30ck33 FIND v(dout1_30) AT=170.025n

* CHECK dout1_31 Vdout1_31ck33 = 0.9 time = 170
.meas tran vdout1_31ck33 FIND v(dout1_31) AT=170.025n

* CHECK dout1_32 Vdout1_32ck33 = 0 time = 170
.meas tran vdout1_32ck33 FIND v(dout1_32) AT=170.025n

* CHECK dout1_33 Vdout1_33ck33 = 0.9 time = 170
.meas tran vdout1_33ck33 FIND v(dout1_33) AT=170.025n

* CHECK dout1_34 Vdout1_34ck33 = 0 time = 170
.meas tran vdout1_34ck33 FIND v(dout1_34) AT=170.025n

* CHECK dout1_35 Vdout1_35ck33 = 0 time = 170
.meas tran vdout1_35ck33 FIND v(dout1_35) AT=170.025n

* CHECK dout1_36 Vdout1_36ck33 = 0 time = 170
.meas tran vdout1_36ck33 FIND v(dout1_36) AT=170.025n

* CHECK dout1_37 Vdout1_37ck33 = 0.9 time = 170
.meas tran vdout1_37ck33 FIND v(dout1_37) AT=170.025n

* CHECK dout1_38 Vdout1_38ck33 = 0 time = 170
.meas tran vdout1_38ck33 FIND v(dout1_38) AT=170.025n

* CHECK dout1_39 Vdout1_39ck33 = 0.9 time = 170
.meas tran vdout1_39ck33 FIND v(dout1_39) AT=170.025n

* CHECK dout1_40 Vdout1_40ck33 = 0.9 time = 170
.meas tran vdout1_40ck33 FIND v(dout1_40) AT=170.025n

* CHECK dout1_41 Vdout1_41ck33 = 0 time = 170
.meas tran vdout1_41ck33 FIND v(dout1_41) AT=170.025n

* CHECK dout1_42 Vdout1_42ck33 = 0.9 time = 170
.meas tran vdout1_42ck33 FIND v(dout1_42) AT=170.025n

* CHECK dout1_43 Vdout1_43ck33 = 0.9 time = 170
.meas tran vdout1_43ck33 FIND v(dout1_43) AT=170.025n

* CHECK dout1_44 Vdout1_44ck33 = 0.9 time = 170
.meas tran vdout1_44ck33 FIND v(dout1_44) AT=170.025n

* CHECK dout1_45 Vdout1_45ck33 = 0 time = 170
.meas tran vdout1_45ck33 FIND v(dout1_45) AT=170.025n

* CHECK dout1_46 Vdout1_46ck33 = 0.9 time = 170
.meas tran vdout1_46ck33 FIND v(dout1_46) AT=170.025n

* CHECK dout1_47 Vdout1_47ck33 = 0.9 time = 170
.meas tran vdout1_47ck33 FIND v(dout1_47) AT=170.025n

* CHECK dout1_48 Vdout1_48ck33 = 0.9 time = 170
.meas tran vdout1_48ck33 FIND v(dout1_48) AT=170.025n

* CHECK dout1_49 Vdout1_49ck33 = 0.9 time = 170
.meas tran vdout1_49ck33 FIND v(dout1_49) AT=170.025n

* CHECK dout1_50 Vdout1_50ck33 = 0 time = 170
.meas tran vdout1_50ck33 FIND v(dout1_50) AT=170.025n

* CHECK dout1_51 Vdout1_51ck33 = 0.9 time = 170
.meas tran vdout1_51ck33 FIND v(dout1_51) AT=170.025n

* CHECK dout1_52 Vdout1_52ck33 = 0.9 time = 170
.meas tran vdout1_52ck33 FIND v(dout1_52) AT=170.025n

* CHECK dout1_53 Vdout1_53ck33 = 0.9 time = 170
.meas tran vdout1_53ck33 FIND v(dout1_53) AT=170.025n

* CHECK dout1_54 Vdout1_54ck33 = 0 time = 170
.meas tran vdout1_54ck33 FIND v(dout1_54) AT=170.025n

* CHECK dout1_55 Vdout1_55ck33 = 0.9 time = 170
.meas tran vdout1_55ck33 FIND v(dout1_55) AT=170.025n

* CHECK dout1_56 Vdout1_56ck33 = 0.9 time = 170
.meas tran vdout1_56ck33 FIND v(dout1_56) AT=170.025n

* CHECK dout1_57 Vdout1_57ck33 = 0.9 time = 170
.meas tran vdout1_57ck33 FIND v(dout1_57) AT=170.025n

* CHECK dout1_58 Vdout1_58ck33 = 0 time = 170
.meas tran vdout1_58ck33 FIND v(dout1_58) AT=170.025n

* CHECK dout1_59 Vdout1_59ck33 = 0.9 time = 170
.meas tran vdout1_59ck33 FIND v(dout1_59) AT=170.025n

* CHECK dout1_60 Vdout1_60ck33 = 0 time = 170
.meas tran vdout1_60ck33 FIND v(dout1_60) AT=170.025n

* CHECK dout1_61 Vdout1_61ck33 = 0 time = 170
.meas tran vdout1_61ck33 FIND v(dout1_61) AT=170.025n

* CHECK dout1_62 Vdout1_62ck33 = 0 time = 170
.meas tran vdout1_62ck33 FIND v(dout1_62) AT=170.025n

* CHECK dout1_63 Vdout1_63ck33 = 0 time = 170
.meas tran vdout1_63ck33 FIND v(dout1_63) AT=170.025n

* CHECK dout1_64 Vdout1_64ck33 = 0.9 time = 170
.meas tran vdout1_64ck33 FIND v(dout1_64) AT=170.025n

* CHECK dout1_65 Vdout1_65ck33 = 0 time = 170
.meas tran vdout1_65ck33 FIND v(dout1_65) AT=170.025n

* CHECK dout1_66 Vdout1_66ck33 = 0.9 time = 170
.meas tran vdout1_66ck33 FIND v(dout1_66) AT=170.025n

* CHECK dout1_67 Vdout1_67ck33 = 0.9 time = 170
.meas tran vdout1_67ck33 FIND v(dout1_67) AT=170.025n

* CHECK dout1_68 Vdout1_68ck33 = 0 time = 170
.meas tran vdout1_68ck33 FIND v(dout1_68) AT=170.025n

* CHECK dout1_69 Vdout1_69ck33 = 0.9 time = 170
.meas tran vdout1_69ck33 FIND v(dout1_69) AT=170.025n

* CHECK dout1_70 Vdout1_70ck33 = 0.9 time = 170
.meas tran vdout1_70ck33 FIND v(dout1_70) AT=170.025n

* CHECK dout1_71 Vdout1_71ck33 = 0.9 time = 170
.meas tran vdout1_71ck33 FIND v(dout1_71) AT=170.025n

* CHECK dout1_72 Vdout1_72ck33 = 0.9 time = 170
.meas tran vdout1_72ck33 FIND v(dout1_72) AT=170.025n

* CHECK dout1_73 Vdout1_73ck33 = 0.9 time = 170
.meas tran vdout1_73ck33 FIND v(dout1_73) AT=170.025n

* CHECK dout1_74 Vdout1_74ck33 = 0.9 time = 170
.meas tran vdout1_74ck33 FIND v(dout1_74) AT=170.025n

* CHECK dout1_75 Vdout1_75ck33 = 0 time = 170
.meas tran vdout1_75ck33 FIND v(dout1_75) AT=170.025n

* CHECK dout1_76 Vdout1_76ck33 = 0.9 time = 170
.meas tran vdout1_76ck33 FIND v(dout1_76) AT=170.025n

* CHECK dout1_77 Vdout1_77ck33 = 0.9 time = 170
.meas tran vdout1_77ck33 FIND v(dout1_77) AT=170.025n

* CHECK dout1_78 Vdout1_78ck33 = 0 time = 170
.meas tran vdout1_78ck33 FIND v(dout1_78) AT=170.025n

* CHECK dout1_79 Vdout1_79ck33 = 0.9 time = 170
.meas tran vdout1_79ck33 FIND v(dout1_79) AT=170.025n

* CHECK dout1_80 Vdout1_80ck33 = 0 time = 170
.meas tran vdout1_80ck33 FIND v(dout1_80) AT=170.025n

* CHECK dout1_81 Vdout1_81ck33 = 0.9 time = 170
.meas tran vdout1_81ck33 FIND v(dout1_81) AT=170.025n

* CHECK dout1_82 Vdout1_82ck33 = 0.9 time = 170
.meas tran vdout1_82ck33 FIND v(dout1_82) AT=170.025n

* CHECK dout1_83 Vdout1_83ck33 = 0 time = 170
.meas tran vdout1_83ck33 FIND v(dout1_83) AT=170.025n

* CHECK dout1_84 Vdout1_84ck33 = 0 time = 170
.meas tran vdout1_84ck33 FIND v(dout1_84) AT=170.025n

* CHECK dout1_85 Vdout1_85ck33 = 0.9 time = 170
.meas tran vdout1_85ck33 FIND v(dout1_85) AT=170.025n

* CHECK dout1_86 Vdout1_86ck33 = 0.9 time = 170
.meas tran vdout1_86ck33 FIND v(dout1_86) AT=170.025n

* CHECK dout1_87 Vdout1_87ck33 = 0.9 time = 170
.meas tran vdout1_87ck33 FIND v(dout1_87) AT=170.025n

* CHECK dout1_88 Vdout1_88ck33 = 0 time = 170
.meas tran vdout1_88ck33 FIND v(dout1_88) AT=170.025n

* CHECK dout1_89 Vdout1_89ck33 = 0 time = 170
.meas tran vdout1_89ck33 FIND v(dout1_89) AT=170.025n

* CHECK dout1_90 Vdout1_90ck33 = 0.9 time = 170
.meas tran vdout1_90ck33 FIND v(dout1_90) AT=170.025n

* CHECK dout1_91 Vdout1_91ck33 = 0.9 time = 170
.meas tran vdout1_91ck33 FIND v(dout1_91) AT=170.025n

* CHECK dout1_92 Vdout1_92ck33 = 0 time = 170
.meas tran vdout1_92ck33 FIND v(dout1_92) AT=170.025n

* CHECK dout1_93 Vdout1_93ck33 = 0 time = 170
.meas tran vdout1_93ck33 FIND v(dout1_93) AT=170.025n

* CHECK dout1_94 Vdout1_94ck33 = 0 time = 170
.meas tran vdout1_94ck33 FIND v(dout1_94) AT=170.025n

* CHECK dout1_95 Vdout1_95ck33 = 0 time = 170
.meas tran vdout1_95ck33 FIND v(dout1_95) AT=170.025n

* CHECK dout1_96 Vdout1_96ck33 = 0.9 time = 170
.meas tran vdout1_96ck33 FIND v(dout1_96) AT=170.025n

* CHECK dout1_97 Vdout1_97ck33 = 0.9 time = 170
.meas tran vdout1_97ck33 FIND v(dout1_97) AT=170.025n

* CHECK dout1_98 Vdout1_98ck33 = 0.9 time = 170
.meas tran vdout1_98ck33 FIND v(dout1_98) AT=170.025n

* CHECK dout1_99 Vdout1_99ck33 = 0 time = 170
.meas tran vdout1_99ck33 FIND v(dout1_99) AT=170.025n

* CHECK dout1_100 Vdout1_100ck33 = 0 time = 170
.meas tran vdout1_100ck33 FIND v(dout1_100) AT=170.025n

* CHECK dout1_101 Vdout1_101ck33 = 0.9 time = 170
.meas tran vdout1_101ck33 FIND v(dout1_101) AT=170.025n

* CHECK dout1_102 Vdout1_102ck33 = 0.9 time = 170
.meas tran vdout1_102ck33 FIND v(dout1_102) AT=170.025n

* CHECK dout1_103 Vdout1_103ck33 = 0 time = 170
.meas tran vdout1_103ck33 FIND v(dout1_103) AT=170.025n

* CHECK dout1_104 Vdout1_104ck33 = 0 time = 170
.meas tran vdout1_104ck33 FIND v(dout1_104) AT=170.025n

* CHECK dout1_105 Vdout1_105ck33 = 0 time = 170
.meas tran vdout1_105ck33 FIND v(dout1_105) AT=170.025n

* CHECK dout1_106 Vdout1_106ck33 = 0 time = 170
.meas tran vdout1_106ck33 FIND v(dout1_106) AT=170.025n

* CHECK dout1_107 Vdout1_107ck33 = 0 time = 170
.meas tran vdout1_107ck33 FIND v(dout1_107) AT=170.025n

* CHECK dout1_108 Vdout1_108ck33 = 0 time = 170
.meas tran vdout1_108ck33 FIND v(dout1_108) AT=170.025n

* CHECK dout1_109 Vdout1_109ck33 = 0.9 time = 170
.meas tran vdout1_109ck33 FIND v(dout1_109) AT=170.025n

* CHECK dout1_110 Vdout1_110ck33 = 0 time = 170
.meas tran vdout1_110ck33 FIND v(dout1_110) AT=170.025n

* CHECK dout1_111 Vdout1_111ck33 = 0 time = 170
.meas tran vdout1_111ck33 FIND v(dout1_111) AT=170.025n

* CHECK dout1_112 Vdout1_112ck33 = 0.9 time = 170
.meas tran vdout1_112ck33 FIND v(dout1_112) AT=170.025n

* CHECK dout1_113 Vdout1_113ck33 = 0.9 time = 170
.meas tran vdout1_113ck33 FIND v(dout1_113) AT=170.025n

* CHECK dout1_114 Vdout1_114ck33 = 0 time = 170
.meas tran vdout1_114ck33 FIND v(dout1_114) AT=170.025n

* CHECK dout1_115 Vdout1_115ck33 = 0.9 time = 170
.meas tran vdout1_115ck33 FIND v(dout1_115) AT=170.025n

* CHECK dout1_116 Vdout1_116ck33 = 0.9 time = 170
.meas tran vdout1_116ck33 FIND v(dout1_116) AT=170.025n

* CHECK dout1_117 Vdout1_117ck33 = 0.9 time = 170
.meas tran vdout1_117ck33 FIND v(dout1_117) AT=170.025n

* CHECK dout1_118 Vdout1_118ck33 = 0.9 time = 170
.meas tran vdout1_118ck33 FIND v(dout1_118) AT=170.025n

* CHECK dout1_119 Vdout1_119ck33 = 0.9 time = 170
.meas tran vdout1_119ck33 FIND v(dout1_119) AT=170.025n

* CHECK dout1_0 Vdout1_0ck34 = 0.9 time = 175
.meas tran vdout1_0ck34 FIND v(dout1_0) AT=175.025n

* CHECK dout1_1 Vdout1_1ck34 = 0 time = 175
.meas tran vdout1_1ck34 FIND v(dout1_1) AT=175.025n

* CHECK dout1_2 Vdout1_2ck34 = 0.9 time = 175
.meas tran vdout1_2ck34 FIND v(dout1_2) AT=175.025n

* CHECK dout1_3 Vdout1_3ck34 = 0 time = 175
.meas tran vdout1_3ck34 FIND v(dout1_3) AT=175.025n

* CHECK dout1_4 Vdout1_4ck34 = 0.9 time = 175
.meas tran vdout1_4ck34 FIND v(dout1_4) AT=175.025n

* CHECK dout1_5 Vdout1_5ck34 = 0 time = 175
.meas tran vdout1_5ck34 FIND v(dout1_5) AT=175.025n

* CHECK dout1_6 Vdout1_6ck34 = 0.9 time = 175
.meas tran vdout1_6ck34 FIND v(dout1_6) AT=175.025n

* CHECK dout1_7 Vdout1_7ck34 = 0.9 time = 175
.meas tran vdout1_7ck34 FIND v(dout1_7) AT=175.025n

* CHECK dout1_8 Vdout1_8ck34 = 0.9 time = 175
.meas tran vdout1_8ck34 FIND v(dout1_8) AT=175.025n

* CHECK dout1_9 Vdout1_9ck34 = 0 time = 175
.meas tran vdout1_9ck34 FIND v(dout1_9) AT=175.025n

* CHECK dout1_10 Vdout1_10ck34 = 0.9 time = 175
.meas tran vdout1_10ck34 FIND v(dout1_10) AT=175.025n

* CHECK dout1_11 Vdout1_11ck34 = 0.9 time = 175
.meas tran vdout1_11ck34 FIND v(dout1_11) AT=175.025n

* CHECK dout1_12 Vdout1_12ck34 = 0.9 time = 175
.meas tran vdout1_12ck34 FIND v(dout1_12) AT=175.025n

* CHECK dout1_13 Vdout1_13ck34 = 0.9 time = 175
.meas tran vdout1_13ck34 FIND v(dout1_13) AT=175.025n

* CHECK dout1_14 Vdout1_14ck34 = 0.9 time = 175
.meas tran vdout1_14ck34 FIND v(dout1_14) AT=175.025n

* CHECK dout1_15 Vdout1_15ck34 = 0.9 time = 175
.meas tran vdout1_15ck34 FIND v(dout1_15) AT=175.025n

* CHECK dout1_16 Vdout1_16ck34 = 0.9 time = 175
.meas tran vdout1_16ck34 FIND v(dout1_16) AT=175.025n

* CHECK dout1_17 Vdout1_17ck34 = 0.9 time = 175
.meas tran vdout1_17ck34 FIND v(dout1_17) AT=175.025n

* CHECK dout1_18 Vdout1_18ck34 = 0 time = 175
.meas tran vdout1_18ck34 FIND v(dout1_18) AT=175.025n

* CHECK dout1_19 Vdout1_19ck34 = 0.9 time = 175
.meas tran vdout1_19ck34 FIND v(dout1_19) AT=175.025n

* CHECK dout1_20 Vdout1_20ck34 = 0 time = 175
.meas tran vdout1_20ck34 FIND v(dout1_20) AT=175.025n

* CHECK dout1_21 Vdout1_21ck34 = 0.9 time = 175
.meas tran vdout1_21ck34 FIND v(dout1_21) AT=175.025n

* CHECK dout1_22 Vdout1_22ck34 = 0.9 time = 175
.meas tran vdout1_22ck34 FIND v(dout1_22) AT=175.025n

* CHECK dout1_23 Vdout1_23ck34 = 0 time = 175
.meas tran vdout1_23ck34 FIND v(dout1_23) AT=175.025n

* CHECK dout1_24 Vdout1_24ck34 = 0.9 time = 175
.meas tran vdout1_24ck34 FIND v(dout1_24) AT=175.025n

* CHECK dout1_25 Vdout1_25ck34 = 0 time = 175
.meas tran vdout1_25ck34 FIND v(dout1_25) AT=175.025n

* CHECK dout1_26 Vdout1_26ck34 = 0 time = 175
.meas tran vdout1_26ck34 FIND v(dout1_26) AT=175.025n

* CHECK dout1_27 Vdout1_27ck34 = 0.9 time = 175
.meas tran vdout1_27ck34 FIND v(dout1_27) AT=175.025n

* CHECK dout1_28 Vdout1_28ck34 = 0.9 time = 175
.meas tran vdout1_28ck34 FIND v(dout1_28) AT=175.025n

* CHECK dout1_29 Vdout1_29ck34 = 0.9 time = 175
.meas tran vdout1_29ck34 FIND v(dout1_29) AT=175.025n

* CHECK dout1_30 Vdout1_30ck34 = 0 time = 175
.meas tran vdout1_30ck34 FIND v(dout1_30) AT=175.025n

* CHECK dout1_31 Vdout1_31ck34 = 0.9 time = 175
.meas tran vdout1_31ck34 FIND v(dout1_31) AT=175.025n

* CHECK dout1_32 Vdout1_32ck34 = 0.9 time = 175
.meas tran vdout1_32ck34 FIND v(dout1_32) AT=175.025n

* CHECK dout1_33 Vdout1_33ck34 = 0.9 time = 175
.meas tran vdout1_33ck34 FIND v(dout1_33) AT=175.025n

* CHECK dout1_34 Vdout1_34ck34 = 0 time = 175
.meas tran vdout1_34ck34 FIND v(dout1_34) AT=175.025n

* CHECK dout1_35 Vdout1_35ck34 = 0.9 time = 175
.meas tran vdout1_35ck34 FIND v(dout1_35) AT=175.025n

* CHECK dout1_36 Vdout1_36ck34 = 0 time = 175
.meas tran vdout1_36ck34 FIND v(dout1_36) AT=175.025n

* CHECK dout1_37 Vdout1_37ck34 = 0 time = 175
.meas tran vdout1_37ck34 FIND v(dout1_37) AT=175.025n

* CHECK dout1_38 Vdout1_38ck34 = 0 time = 175
.meas tran vdout1_38ck34 FIND v(dout1_38) AT=175.025n

* CHECK dout1_39 Vdout1_39ck34 = 0 time = 175
.meas tran vdout1_39ck34 FIND v(dout1_39) AT=175.025n

* CHECK dout1_40 Vdout1_40ck34 = 0 time = 175
.meas tran vdout1_40ck34 FIND v(dout1_40) AT=175.025n

* CHECK dout1_41 Vdout1_41ck34 = 0 time = 175
.meas tran vdout1_41ck34 FIND v(dout1_41) AT=175.025n

* CHECK dout1_42 Vdout1_42ck34 = 0 time = 175
.meas tran vdout1_42ck34 FIND v(dout1_42) AT=175.025n

* CHECK dout1_43 Vdout1_43ck34 = 0 time = 175
.meas tran vdout1_43ck34 FIND v(dout1_43) AT=175.025n

* CHECK dout1_44 Vdout1_44ck34 = 0 time = 175
.meas tran vdout1_44ck34 FIND v(dout1_44) AT=175.025n

* CHECK dout1_45 Vdout1_45ck34 = 0 time = 175
.meas tran vdout1_45ck34 FIND v(dout1_45) AT=175.025n

* CHECK dout1_46 Vdout1_46ck34 = 0.9 time = 175
.meas tran vdout1_46ck34 FIND v(dout1_46) AT=175.025n

* CHECK dout1_47 Vdout1_47ck34 = 0.9 time = 175
.meas tran vdout1_47ck34 FIND v(dout1_47) AT=175.025n

* CHECK dout1_48 Vdout1_48ck34 = 0.9 time = 175
.meas tran vdout1_48ck34 FIND v(dout1_48) AT=175.025n

* CHECK dout1_49 Vdout1_49ck34 = 0.9 time = 175
.meas tran vdout1_49ck34 FIND v(dout1_49) AT=175.025n

* CHECK dout1_50 Vdout1_50ck34 = 0.9 time = 175
.meas tran vdout1_50ck34 FIND v(dout1_50) AT=175.025n

* CHECK dout1_51 Vdout1_51ck34 = 0 time = 175
.meas tran vdout1_51ck34 FIND v(dout1_51) AT=175.025n

* CHECK dout1_52 Vdout1_52ck34 = 0.9 time = 175
.meas tran vdout1_52ck34 FIND v(dout1_52) AT=175.025n

* CHECK dout1_53 Vdout1_53ck34 = 0 time = 175
.meas tran vdout1_53ck34 FIND v(dout1_53) AT=175.025n

* CHECK dout1_54 Vdout1_54ck34 = 0.9 time = 175
.meas tran vdout1_54ck34 FIND v(dout1_54) AT=175.025n

* CHECK dout1_55 Vdout1_55ck34 = 0.9 time = 175
.meas tran vdout1_55ck34 FIND v(dout1_55) AT=175.025n

* CHECK dout1_56 Vdout1_56ck34 = 0 time = 175
.meas tran vdout1_56ck34 FIND v(dout1_56) AT=175.025n

* CHECK dout1_57 Vdout1_57ck34 = 0 time = 175
.meas tran vdout1_57ck34 FIND v(dout1_57) AT=175.025n

* CHECK dout1_58 Vdout1_58ck34 = 0.9 time = 175
.meas tran vdout1_58ck34 FIND v(dout1_58) AT=175.025n

* CHECK dout1_59 Vdout1_59ck34 = 0 time = 175
.meas tran vdout1_59ck34 FIND v(dout1_59) AT=175.025n

* CHECK dout1_60 Vdout1_60ck34 = 0 time = 175
.meas tran vdout1_60ck34 FIND v(dout1_60) AT=175.025n

* CHECK dout1_61 Vdout1_61ck34 = 0.9 time = 175
.meas tran vdout1_61ck34 FIND v(dout1_61) AT=175.025n

* CHECK dout1_62 Vdout1_62ck34 = 0.9 time = 175
.meas tran vdout1_62ck34 FIND v(dout1_62) AT=175.025n

* CHECK dout1_63 Vdout1_63ck34 = 0 time = 175
.meas tran vdout1_63ck34 FIND v(dout1_63) AT=175.025n

* CHECK dout1_64 Vdout1_64ck34 = 0.9 time = 175
.meas tran vdout1_64ck34 FIND v(dout1_64) AT=175.025n

* CHECK dout1_65 Vdout1_65ck34 = 0.9 time = 175
.meas tran vdout1_65ck34 FIND v(dout1_65) AT=175.025n

* CHECK dout1_66 Vdout1_66ck34 = 0.9 time = 175
.meas tran vdout1_66ck34 FIND v(dout1_66) AT=175.025n

* CHECK dout1_67 Vdout1_67ck34 = 0 time = 175
.meas tran vdout1_67ck34 FIND v(dout1_67) AT=175.025n

* CHECK dout1_68 Vdout1_68ck34 = 0.9 time = 175
.meas tran vdout1_68ck34 FIND v(dout1_68) AT=175.025n

* CHECK dout1_69 Vdout1_69ck34 = 0 time = 175
.meas tran vdout1_69ck34 FIND v(dout1_69) AT=175.025n

* CHECK dout1_70 Vdout1_70ck34 = 0 time = 175
.meas tran vdout1_70ck34 FIND v(dout1_70) AT=175.025n

* CHECK dout1_71 Vdout1_71ck34 = 0 time = 175
.meas tran vdout1_71ck34 FIND v(dout1_71) AT=175.025n

* CHECK dout1_72 Vdout1_72ck34 = 0.9 time = 175
.meas tran vdout1_72ck34 FIND v(dout1_72) AT=175.025n

* CHECK dout1_73 Vdout1_73ck34 = 0.9 time = 175
.meas tran vdout1_73ck34 FIND v(dout1_73) AT=175.025n

* CHECK dout1_74 Vdout1_74ck34 = 0 time = 175
.meas tran vdout1_74ck34 FIND v(dout1_74) AT=175.025n

* CHECK dout1_75 Vdout1_75ck34 = 0 time = 175
.meas tran vdout1_75ck34 FIND v(dout1_75) AT=175.025n

* CHECK dout1_76 Vdout1_76ck34 = 0.9 time = 175
.meas tran vdout1_76ck34 FIND v(dout1_76) AT=175.025n

* CHECK dout1_77 Vdout1_77ck34 = 0 time = 175
.meas tran vdout1_77ck34 FIND v(dout1_77) AT=175.025n

* CHECK dout1_78 Vdout1_78ck34 = 0.9 time = 175
.meas tran vdout1_78ck34 FIND v(dout1_78) AT=175.025n

* CHECK dout1_79 Vdout1_79ck34 = 0 time = 175
.meas tran vdout1_79ck34 FIND v(dout1_79) AT=175.025n

* CHECK dout1_80 Vdout1_80ck34 = 0 time = 175
.meas tran vdout1_80ck34 FIND v(dout1_80) AT=175.025n

* CHECK dout1_81 Vdout1_81ck34 = 0.9 time = 175
.meas tran vdout1_81ck34 FIND v(dout1_81) AT=175.025n

* CHECK dout1_82 Vdout1_82ck34 = 0 time = 175
.meas tran vdout1_82ck34 FIND v(dout1_82) AT=175.025n

* CHECK dout1_83 Vdout1_83ck34 = 0 time = 175
.meas tran vdout1_83ck34 FIND v(dout1_83) AT=175.025n

* CHECK dout1_84 Vdout1_84ck34 = 0.9 time = 175
.meas tran vdout1_84ck34 FIND v(dout1_84) AT=175.025n

* CHECK dout1_85 Vdout1_85ck34 = 0.9 time = 175
.meas tran vdout1_85ck34 FIND v(dout1_85) AT=175.025n

* CHECK dout1_86 Vdout1_86ck34 = 0 time = 175
.meas tran vdout1_86ck34 FIND v(dout1_86) AT=175.025n

* CHECK dout1_87 Vdout1_87ck34 = 0.9 time = 175
.meas tran vdout1_87ck34 FIND v(dout1_87) AT=175.025n

* CHECK dout1_88 Vdout1_88ck34 = 0.9 time = 175
.meas tran vdout1_88ck34 FIND v(dout1_88) AT=175.025n

* CHECK dout1_89 Vdout1_89ck34 = 0.9 time = 175
.meas tran vdout1_89ck34 FIND v(dout1_89) AT=175.025n

* CHECK dout1_90 Vdout1_90ck34 = 0 time = 175
.meas tran vdout1_90ck34 FIND v(dout1_90) AT=175.025n

* CHECK dout1_91 Vdout1_91ck34 = 0.9 time = 175
.meas tran vdout1_91ck34 FIND v(dout1_91) AT=175.025n

* CHECK dout1_92 Vdout1_92ck34 = 0.9 time = 175
.meas tran vdout1_92ck34 FIND v(dout1_92) AT=175.025n

* CHECK dout1_93 Vdout1_93ck34 = 0.9 time = 175
.meas tran vdout1_93ck34 FIND v(dout1_93) AT=175.025n

* CHECK dout1_94 Vdout1_94ck34 = 0 time = 175
.meas tran vdout1_94ck34 FIND v(dout1_94) AT=175.025n

* CHECK dout1_95 Vdout1_95ck34 = 0.9 time = 175
.meas tran vdout1_95ck34 FIND v(dout1_95) AT=175.025n

* CHECK dout1_96 Vdout1_96ck34 = 0.9 time = 175
.meas tran vdout1_96ck34 FIND v(dout1_96) AT=175.025n

* CHECK dout1_97 Vdout1_97ck34 = 0.9 time = 175
.meas tran vdout1_97ck34 FIND v(dout1_97) AT=175.025n

* CHECK dout1_98 Vdout1_98ck34 = 0.9 time = 175
.meas tran vdout1_98ck34 FIND v(dout1_98) AT=175.025n

* CHECK dout1_99 Vdout1_99ck34 = 0 time = 175
.meas tran vdout1_99ck34 FIND v(dout1_99) AT=175.025n

* CHECK dout1_100 Vdout1_100ck34 = 0 time = 175
.meas tran vdout1_100ck34 FIND v(dout1_100) AT=175.025n

* CHECK dout1_101 Vdout1_101ck34 = 0 time = 175
.meas tran vdout1_101ck34 FIND v(dout1_101) AT=175.025n

* CHECK dout1_102 Vdout1_102ck34 = 0.9 time = 175
.meas tran vdout1_102ck34 FIND v(dout1_102) AT=175.025n

* CHECK dout1_103 Vdout1_103ck34 = 0 time = 175
.meas tran vdout1_103ck34 FIND v(dout1_103) AT=175.025n

* CHECK dout1_104 Vdout1_104ck34 = 0 time = 175
.meas tran vdout1_104ck34 FIND v(dout1_104) AT=175.025n

* CHECK dout1_105 Vdout1_105ck34 = 0.9 time = 175
.meas tran vdout1_105ck34 FIND v(dout1_105) AT=175.025n

* CHECK dout1_106 Vdout1_106ck34 = 0.9 time = 175
.meas tran vdout1_106ck34 FIND v(dout1_106) AT=175.025n

* CHECK dout1_107 Vdout1_107ck34 = 0 time = 175
.meas tran vdout1_107ck34 FIND v(dout1_107) AT=175.025n

* CHECK dout1_108 Vdout1_108ck34 = 0.9 time = 175
.meas tran vdout1_108ck34 FIND v(dout1_108) AT=175.025n

* CHECK dout1_109 Vdout1_109ck34 = 0.9 time = 175
.meas tran vdout1_109ck34 FIND v(dout1_109) AT=175.025n

* CHECK dout1_110 Vdout1_110ck34 = 0.9 time = 175
.meas tran vdout1_110ck34 FIND v(dout1_110) AT=175.025n

* CHECK dout1_111 Vdout1_111ck34 = 0.9 time = 175
.meas tran vdout1_111ck34 FIND v(dout1_111) AT=175.025n

* CHECK dout1_112 Vdout1_112ck34 = 0.9 time = 175
.meas tran vdout1_112ck34 FIND v(dout1_112) AT=175.025n

* CHECK dout1_113 Vdout1_113ck34 = 0 time = 175
.meas tran vdout1_113ck34 FIND v(dout1_113) AT=175.025n

* CHECK dout1_114 Vdout1_114ck34 = 0 time = 175
.meas tran vdout1_114ck34 FIND v(dout1_114) AT=175.025n

* CHECK dout1_115 Vdout1_115ck34 = 0.9 time = 175
.meas tran vdout1_115ck34 FIND v(dout1_115) AT=175.025n

* CHECK dout1_116 Vdout1_116ck34 = 0 time = 175
.meas tran vdout1_116ck34 FIND v(dout1_116) AT=175.025n

* CHECK dout1_117 Vdout1_117ck34 = 0 time = 175
.meas tran vdout1_117ck34 FIND v(dout1_117) AT=175.025n

* CHECK dout1_118 Vdout1_118ck34 = 0 time = 175
.meas tran vdout1_118ck34 FIND v(dout1_118) AT=175.025n

* CHECK dout1_119 Vdout1_119ck34 = 0 time = 175
.meas tran vdout1_119ck34 FIND v(dout1_119) AT=175.025n

* CHECK dout1_0 Vdout1_0ck35 = 0.9 time = 180
.meas tran vdout1_0ck35 FIND v(dout1_0) AT=180.025n

* CHECK dout1_1 Vdout1_1ck35 = 0 time = 180
.meas tran vdout1_1ck35 FIND v(dout1_1) AT=180.025n

* CHECK dout1_2 Vdout1_2ck35 = 0 time = 180
.meas tran vdout1_2ck35 FIND v(dout1_2) AT=180.025n

* CHECK dout1_3 Vdout1_3ck35 = 0 time = 180
.meas tran vdout1_3ck35 FIND v(dout1_3) AT=180.025n

* CHECK dout1_4 Vdout1_4ck35 = 0 time = 180
.meas tran vdout1_4ck35 FIND v(dout1_4) AT=180.025n

* CHECK dout1_5 Vdout1_5ck35 = 0.9 time = 180
.meas tran vdout1_5ck35 FIND v(dout1_5) AT=180.025n

* CHECK dout1_6 Vdout1_6ck35 = 0 time = 180
.meas tran vdout1_6ck35 FIND v(dout1_6) AT=180.025n

* CHECK dout1_7 Vdout1_7ck35 = 0.9 time = 180
.meas tran vdout1_7ck35 FIND v(dout1_7) AT=180.025n

* CHECK dout1_8 Vdout1_8ck35 = 0 time = 180
.meas tran vdout1_8ck35 FIND v(dout1_8) AT=180.025n

* CHECK dout1_9 Vdout1_9ck35 = 0.9 time = 180
.meas tran vdout1_9ck35 FIND v(dout1_9) AT=180.025n

* CHECK dout1_10 Vdout1_10ck35 = 0 time = 180
.meas tran vdout1_10ck35 FIND v(dout1_10) AT=180.025n

* CHECK dout1_11 Vdout1_11ck35 = 0.9 time = 180
.meas tran vdout1_11ck35 FIND v(dout1_11) AT=180.025n

* CHECK dout1_12 Vdout1_12ck35 = 0 time = 180
.meas tran vdout1_12ck35 FIND v(dout1_12) AT=180.025n

* CHECK dout1_13 Vdout1_13ck35 = 0.9 time = 180
.meas tran vdout1_13ck35 FIND v(dout1_13) AT=180.025n

* CHECK dout1_14 Vdout1_14ck35 = 0.9 time = 180
.meas tran vdout1_14ck35 FIND v(dout1_14) AT=180.025n

* CHECK dout1_15 Vdout1_15ck35 = 0.9 time = 180
.meas tran vdout1_15ck35 FIND v(dout1_15) AT=180.025n

* CHECK dout1_16 Vdout1_16ck35 = 0.9 time = 180
.meas tran vdout1_16ck35 FIND v(dout1_16) AT=180.025n

* CHECK dout1_17 Vdout1_17ck35 = 0.9 time = 180
.meas tran vdout1_17ck35 FIND v(dout1_17) AT=180.025n

* CHECK dout1_18 Vdout1_18ck35 = 0 time = 180
.meas tran vdout1_18ck35 FIND v(dout1_18) AT=180.025n

* CHECK dout1_19 Vdout1_19ck35 = 0 time = 180
.meas tran vdout1_19ck35 FIND v(dout1_19) AT=180.025n

* CHECK dout1_20 Vdout1_20ck35 = 0 time = 180
.meas tran vdout1_20ck35 FIND v(dout1_20) AT=180.025n

* CHECK dout1_21 Vdout1_21ck35 = 0.9 time = 180
.meas tran vdout1_21ck35 FIND v(dout1_21) AT=180.025n

* CHECK dout1_22 Vdout1_22ck35 = 0.9 time = 180
.meas tran vdout1_22ck35 FIND v(dout1_22) AT=180.025n

* CHECK dout1_23 Vdout1_23ck35 = 0 time = 180
.meas tran vdout1_23ck35 FIND v(dout1_23) AT=180.025n

* CHECK dout1_24 Vdout1_24ck35 = 0 time = 180
.meas tran vdout1_24ck35 FIND v(dout1_24) AT=180.025n

* CHECK dout1_25 Vdout1_25ck35 = 0.9 time = 180
.meas tran vdout1_25ck35 FIND v(dout1_25) AT=180.025n

* CHECK dout1_26 Vdout1_26ck35 = 0 time = 180
.meas tran vdout1_26ck35 FIND v(dout1_26) AT=180.025n

* CHECK dout1_27 Vdout1_27ck35 = 0 time = 180
.meas tran vdout1_27ck35 FIND v(dout1_27) AT=180.025n

* CHECK dout1_28 Vdout1_28ck35 = 0.9 time = 180
.meas tran vdout1_28ck35 FIND v(dout1_28) AT=180.025n

* CHECK dout1_29 Vdout1_29ck35 = 0.9 time = 180
.meas tran vdout1_29ck35 FIND v(dout1_29) AT=180.025n

* CHECK dout1_30 Vdout1_30ck35 = 0.9 time = 180
.meas tran vdout1_30ck35 FIND v(dout1_30) AT=180.025n

* CHECK dout1_31 Vdout1_31ck35 = 0.9 time = 180
.meas tran vdout1_31ck35 FIND v(dout1_31) AT=180.025n

* CHECK dout1_32 Vdout1_32ck35 = 0 time = 180
.meas tran vdout1_32ck35 FIND v(dout1_32) AT=180.025n

* CHECK dout1_33 Vdout1_33ck35 = 0.9 time = 180
.meas tran vdout1_33ck35 FIND v(dout1_33) AT=180.025n

* CHECK dout1_34 Vdout1_34ck35 = 0 time = 180
.meas tran vdout1_34ck35 FIND v(dout1_34) AT=180.025n

* CHECK dout1_35 Vdout1_35ck35 = 0 time = 180
.meas tran vdout1_35ck35 FIND v(dout1_35) AT=180.025n

* CHECK dout1_36 Vdout1_36ck35 = 0 time = 180
.meas tran vdout1_36ck35 FIND v(dout1_36) AT=180.025n

* CHECK dout1_37 Vdout1_37ck35 = 0.9 time = 180
.meas tran vdout1_37ck35 FIND v(dout1_37) AT=180.025n

* CHECK dout1_38 Vdout1_38ck35 = 0 time = 180
.meas tran vdout1_38ck35 FIND v(dout1_38) AT=180.025n

* CHECK dout1_39 Vdout1_39ck35 = 0.9 time = 180
.meas tran vdout1_39ck35 FIND v(dout1_39) AT=180.025n

* CHECK dout1_40 Vdout1_40ck35 = 0.9 time = 180
.meas tran vdout1_40ck35 FIND v(dout1_40) AT=180.025n

* CHECK dout1_41 Vdout1_41ck35 = 0 time = 180
.meas tran vdout1_41ck35 FIND v(dout1_41) AT=180.025n

* CHECK dout1_42 Vdout1_42ck35 = 0.9 time = 180
.meas tran vdout1_42ck35 FIND v(dout1_42) AT=180.025n

* CHECK dout1_43 Vdout1_43ck35 = 0.9 time = 180
.meas tran vdout1_43ck35 FIND v(dout1_43) AT=180.025n

* CHECK dout1_44 Vdout1_44ck35 = 0.9 time = 180
.meas tran vdout1_44ck35 FIND v(dout1_44) AT=180.025n

* CHECK dout1_45 Vdout1_45ck35 = 0 time = 180
.meas tran vdout1_45ck35 FIND v(dout1_45) AT=180.025n

* CHECK dout1_46 Vdout1_46ck35 = 0.9 time = 180
.meas tran vdout1_46ck35 FIND v(dout1_46) AT=180.025n

* CHECK dout1_47 Vdout1_47ck35 = 0.9 time = 180
.meas tran vdout1_47ck35 FIND v(dout1_47) AT=180.025n

* CHECK dout1_48 Vdout1_48ck35 = 0.9 time = 180
.meas tran vdout1_48ck35 FIND v(dout1_48) AT=180.025n

* CHECK dout1_49 Vdout1_49ck35 = 0.9 time = 180
.meas tran vdout1_49ck35 FIND v(dout1_49) AT=180.025n

* CHECK dout1_50 Vdout1_50ck35 = 0 time = 180
.meas tran vdout1_50ck35 FIND v(dout1_50) AT=180.025n

* CHECK dout1_51 Vdout1_51ck35 = 0.9 time = 180
.meas tran vdout1_51ck35 FIND v(dout1_51) AT=180.025n

* CHECK dout1_52 Vdout1_52ck35 = 0.9 time = 180
.meas tran vdout1_52ck35 FIND v(dout1_52) AT=180.025n

* CHECK dout1_53 Vdout1_53ck35 = 0.9 time = 180
.meas tran vdout1_53ck35 FIND v(dout1_53) AT=180.025n

* CHECK dout1_54 Vdout1_54ck35 = 0 time = 180
.meas tran vdout1_54ck35 FIND v(dout1_54) AT=180.025n

* CHECK dout1_55 Vdout1_55ck35 = 0.9 time = 180
.meas tran vdout1_55ck35 FIND v(dout1_55) AT=180.025n

* CHECK dout1_56 Vdout1_56ck35 = 0.9 time = 180
.meas tran vdout1_56ck35 FIND v(dout1_56) AT=180.025n

* CHECK dout1_57 Vdout1_57ck35 = 0.9 time = 180
.meas tran vdout1_57ck35 FIND v(dout1_57) AT=180.025n

* CHECK dout1_58 Vdout1_58ck35 = 0 time = 180
.meas tran vdout1_58ck35 FIND v(dout1_58) AT=180.025n

* CHECK dout1_59 Vdout1_59ck35 = 0.9 time = 180
.meas tran vdout1_59ck35 FIND v(dout1_59) AT=180.025n

* CHECK dout1_60 Vdout1_60ck35 = 0 time = 180
.meas tran vdout1_60ck35 FIND v(dout1_60) AT=180.025n

* CHECK dout1_61 Vdout1_61ck35 = 0 time = 180
.meas tran vdout1_61ck35 FIND v(dout1_61) AT=180.025n

* CHECK dout1_62 Vdout1_62ck35 = 0 time = 180
.meas tran vdout1_62ck35 FIND v(dout1_62) AT=180.025n

* CHECK dout1_63 Vdout1_63ck35 = 0 time = 180
.meas tran vdout1_63ck35 FIND v(dout1_63) AT=180.025n

* CHECK dout1_64 Vdout1_64ck35 = 0.9 time = 180
.meas tran vdout1_64ck35 FIND v(dout1_64) AT=180.025n

* CHECK dout1_65 Vdout1_65ck35 = 0 time = 180
.meas tran vdout1_65ck35 FIND v(dout1_65) AT=180.025n

* CHECK dout1_66 Vdout1_66ck35 = 0.9 time = 180
.meas tran vdout1_66ck35 FIND v(dout1_66) AT=180.025n

* CHECK dout1_67 Vdout1_67ck35 = 0.9 time = 180
.meas tran vdout1_67ck35 FIND v(dout1_67) AT=180.025n

* CHECK dout1_68 Vdout1_68ck35 = 0 time = 180
.meas tran vdout1_68ck35 FIND v(dout1_68) AT=180.025n

* CHECK dout1_69 Vdout1_69ck35 = 0.9 time = 180
.meas tran vdout1_69ck35 FIND v(dout1_69) AT=180.025n

* CHECK dout1_70 Vdout1_70ck35 = 0.9 time = 180
.meas tran vdout1_70ck35 FIND v(dout1_70) AT=180.025n

* CHECK dout1_71 Vdout1_71ck35 = 0.9 time = 180
.meas tran vdout1_71ck35 FIND v(dout1_71) AT=180.025n

* CHECK dout1_72 Vdout1_72ck35 = 0.9 time = 180
.meas tran vdout1_72ck35 FIND v(dout1_72) AT=180.025n

* CHECK dout1_73 Vdout1_73ck35 = 0.9 time = 180
.meas tran vdout1_73ck35 FIND v(dout1_73) AT=180.025n

* CHECK dout1_74 Vdout1_74ck35 = 0.9 time = 180
.meas tran vdout1_74ck35 FIND v(dout1_74) AT=180.025n

* CHECK dout1_75 Vdout1_75ck35 = 0 time = 180
.meas tran vdout1_75ck35 FIND v(dout1_75) AT=180.025n

* CHECK dout1_76 Vdout1_76ck35 = 0.9 time = 180
.meas tran vdout1_76ck35 FIND v(dout1_76) AT=180.025n

* CHECK dout1_77 Vdout1_77ck35 = 0.9 time = 180
.meas tran vdout1_77ck35 FIND v(dout1_77) AT=180.025n

* CHECK dout1_78 Vdout1_78ck35 = 0 time = 180
.meas tran vdout1_78ck35 FIND v(dout1_78) AT=180.025n

* CHECK dout1_79 Vdout1_79ck35 = 0.9 time = 180
.meas tran vdout1_79ck35 FIND v(dout1_79) AT=180.025n

* CHECK dout1_80 Vdout1_80ck35 = 0 time = 180
.meas tran vdout1_80ck35 FIND v(dout1_80) AT=180.025n

* CHECK dout1_81 Vdout1_81ck35 = 0.9 time = 180
.meas tran vdout1_81ck35 FIND v(dout1_81) AT=180.025n

* CHECK dout1_82 Vdout1_82ck35 = 0.9 time = 180
.meas tran vdout1_82ck35 FIND v(dout1_82) AT=180.025n

* CHECK dout1_83 Vdout1_83ck35 = 0 time = 180
.meas tran vdout1_83ck35 FIND v(dout1_83) AT=180.025n

* CHECK dout1_84 Vdout1_84ck35 = 0 time = 180
.meas tran vdout1_84ck35 FIND v(dout1_84) AT=180.025n

* CHECK dout1_85 Vdout1_85ck35 = 0.9 time = 180
.meas tran vdout1_85ck35 FIND v(dout1_85) AT=180.025n

* CHECK dout1_86 Vdout1_86ck35 = 0.9 time = 180
.meas tran vdout1_86ck35 FIND v(dout1_86) AT=180.025n

* CHECK dout1_87 Vdout1_87ck35 = 0.9 time = 180
.meas tran vdout1_87ck35 FIND v(dout1_87) AT=180.025n

* CHECK dout1_88 Vdout1_88ck35 = 0 time = 180
.meas tran vdout1_88ck35 FIND v(dout1_88) AT=180.025n

* CHECK dout1_89 Vdout1_89ck35 = 0 time = 180
.meas tran vdout1_89ck35 FIND v(dout1_89) AT=180.025n

* CHECK dout1_90 Vdout1_90ck35 = 0.9 time = 180
.meas tran vdout1_90ck35 FIND v(dout1_90) AT=180.025n

* CHECK dout1_91 Vdout1_91ck35 = 0.9 time = 180
.meas tran vdout1_91ck35 FIND v(dout1_91) AT=180.025n

* CHECK dout1_92 Vdout1_92ck35 = 0 time = 180
.meas tran vdout1_92ck35 FIND v(dout1_92) AT=180.025n

* CHECK dout1_93 Vdout1_93ck35 = 0 time = 180
.meas tran vdout1_93ck35 FIND v(dout1_93) AT=180.025n

* CHECK dout1_94 Vdout1_94ck35 = 0 time = 180
.meas tran vdout1_94ck35 FIND v(dout1_94) AT=180.025n

* CHECK dout1_95 Vdout1_95ck35 = 0 time = 180
.meas tran vdout1_95ck35 FIND v(dout1_95) AT=180.025n

* CHECK dout1_96 Vdout1_96ck35 = 0.9 time = 180
.meas tran vdout1_96ck35 FIND v(dout1_96) AT=180.025n

* CHECK dout1_97 Vdout1_97ck35 = 0.9 time = 180
.meas tran vdout1_97ck35 FIND v(dout1_97) AT=180.025n

* CHECK dout1_98 Vdout1_98ck35 = 0.9 time = 180
.meas tran vdout1_98ck35 FIND v(dout1_98) AT=180.025n

* CHECK dout1_99 Vdout1_99ck35 = 0 time = 180
.meas tran vdout1_99ck35 FIND v(dout1_99) AT=180.025n

* CHECK dout1_100 Vdout1_100ck35 = 0 time = 180
.meas tran vdout1_100ck35 FIND v(dout1_100) AT=180.025n

* CHECK dout1_101 Vdout1_101ck35 = 0.9 time = 180
.meas tran vdout1_101ck35 FIND v(dout1_101) AT=180.025n

* CHECK dout1_102 Vdout1_102ck35 = 0.9 time = 180
.meas tran vdout1_102ck35 FIND v(dout1_102) AT=180.025n

* CHECK dout1_103 Vdout1_103ck35 = 0 time = 180
.meas tran vdout1_103ck35 FIND v(dout1_103) AT=180.025n

* CHECK dout1_104 Vdout1_104ck35 = 0 time = 180
.meas tran vdout1_104ck35 FIND v(dout1_104) AT=180.025n

* CHECK dout1_105 Vdout1_105ck35 = 0 time = 180
.meas tran vdout1_105ck35 FIND v(dout1_105) AT=180.025n

* CHECK dout1_106 Vdout1_106ck35 = 0 time = 180
.meas tran vdout1_106ck35 FIND v(dout1_106) AT=180.025n

* CHECK dout1_107 Vdout1_107ck35 = 0 time = 180
.meas tran vdout1_107ck35 FIND v(dout1_107) AT=180.025n

* CHECK dout1_108 Vdout1_108ck35 = 0 time = 180
.meas tran vdout1_108ck35 FIND v(dout1_108) AT=180.025n

* CHECK dout1_109 Vdout1_109ck35 = 0.9 time = 180
.meas tran vdout1_109ck35 FIND v(dout1_109) AT=180.025n

* CHECK dout1_110 Vdout1_110ck35 = 0 time = 180
.meas tran vdout1_110ck35 FIND v(dout1_110) AT=180.025n

* CHECK dout1_111 Vdout1_111ck35 = 0 time = 180
.meas tran vdout1_111ck35 FIND v(dout1_111) AT=180.025n

* CHECK dout1_112 Vdout1_112ck35 = 0.9 time = 180
.meas tran vdout1_112ck35 FIND v(dout1_112) AT=180.025n

* CHECK dout1_113 Vdout1_113ck35 = 0.9 time = 180
.meas tran vdout1_113ck35 FIND v(dout1_113) AT=180.025n

* CHECK dout1_114 Vdout1_114ck35 = 0 time = 180
.meas tran vdout1_114ck35 FIND v(dout1_114) AT=180.025n

* CHECK dout1_115 Vdout1_115ck35 = 0.9 time = 180
.meas tran vdout1_115ck35 FIND v(dout1_115) AT=180.025n

* CHECK dout1_116 Vdout1_116ck35 = 0.9 time = 180
.meas tran vdout1_116ck35 FIND v(dout1_116) AT=180.025n

* CHECK dout1_117 Vdout1_117ck35 = 0.9 time = 180
.meas tran vdout1_117ck35 FIND v(dout1_117) AT=180.025n

* CHECK dout1_118 Vdout1_118ck35 = 0.9 time = 180
.meas tran vdout1_118ck35 FIND v(dout1_118) AT=180.025n

* CHECK dout1_119 Vdout1_119ck35 = 0.9 time = 180
.meas tran vdout1_119ck35 FIND v(dout1_119) AT=180.025n

* CHECK dout1_0 Vdout1_0ck40 = 0 time = 205
.meas tran vdout1_0ck40 FIND v(dout1_0) AT=205.025n

* CHECK dout1_1 Vdout1_1ck40 = 0.9 time = 205
.meas tran vdout1_1ck40 FIND v(dout1_1) AT=205.025n

* CHECK dout1_2 Vdout1_2ck40 = 0.9 time = 205
.meas tran vdout1_2ck40 FIND v(dout1_2) AT=205.025n

* CHECK dout1_3 Vdout1_3ck40 = 0.9 time = 205
.meas tran vdout1_3ck40 FIND v(dout1_3) AT=205.025n

* CHECK dout1_4 Vdout1_4ck40 = 0.9 time = 205
.meas tran vdout1_4ck40 FIND v(dout1_4) AT=205.025n

* CHECK dout1_5 Vdout1_5ck40 = 0.9 time = 205
.meas tran vdout1_5ck40 FIND v(dout1_5) AT=205.025n

* CHECK dout1_6 Vdout1_6ck40 = 0 time = 205
.meas tran vdout1_6ck40 FIND v(dout1_6) AT=205.025n

* CHECK dout1_7 Vdout1_7ck40 = 0 time = 205
.meas tran vdout1_7ck40 FIND v(dout1_7) AT=205.025n

* CHECK dout1_8 Vdout1_8ck40 = 0.9 time = 205
.meas tran vdout1_8ck40 FIND v(dout1_8) AT=205.025n

* CHECK dout1_9 Vdout1_9ck40 = 0.9 time = 205
.meas tran vdout1_9ck40 FIND v(dout1_9) AT=205.025n

* CHECK dout1_10 Vdout1_10ck40 = 0 time = 205
.meas tran vdout1_10ck40 FIND v(dout1_10) AT=205.025n

* CHECK dout1_11 Vdout1_11ck40 = 0 time = 205
.meas tran vdout1_11ck40 FIND v(dout1_11) AT=205.025n

* CHECK dout1_12 Vdout1_12ck40 = 0 time = 205
.meas tran vdout1_12ck40 FIND v(dout1_12) AT=205.025n

* CHECK dout1_13 Vdout1_13ck40 = 0 time = 205
.meas tran vdout1_13ck40 FIND v(dout1_13) AT=205.025n

* CHECK dout1_14 Vdout1_14ck40 = 0.9 time = 205
.meas tran vdout1_14ck40 FIND v(dout1_14) AT=205.025n

* CHECK dout1_15 Vdout1_15ck40 = 0.9 time = 205
.meas tran vdout1_15ck40 FIND v(dout1_15) AT=205.025n

* CHECK dout1_16 Vdout1_16ck40 = 0.9 time = 205
.meas tran vdout1_16ck40 FIND v(dout1_16) AT=205.025n

* CHECK dout1_17 Vdout1_17ck40 = 0.9 time = 205
.meas tran vdout1_17ck40 FIND v(dout1_17) AT=205.025n

* CHECK dout1_18 Vdout1_18ck40 = 0.9 time = 205
.meas tran vdout1_18ck40 FIND v(dout1_18) AT=205.025n

* CHECK dout1_19 Vdout1_19ck40 = 0.9 time = 205
.meas tran vdout1_19ck40 FIND v(dout1_19) AT=205.025n

* CHECK dout1_20 Vdout1_20ck40 = 0 time = 205
.meas tran vdout1_20ck40 FIND v(dout1_20) AT=205.025n

* CHECK dout1_21 Vdout1_21ck40 = 0 time = 205
.meas tran vdout1_21ck40 FIND v(dout1_21) AT=205.025n

* CHECK dout1_22 Vdout1_22ck40 = 0.9 time = 205
.meas tran vdout1_22ck40 FIND v(dout1_22) AT=205.025n

* CHECK dout1_23 Vdout1_23ck40 = 0 time = 205
.meas tran vdout1_23ck40 FIND v(dout1_23) AT=205.025n

* CHECK dout1_24 Vdout1_24ck40 = 0 time = 205
.meas tran vdout1_24ck40 FIND v(dout1_24) AT=205.025n

* CHECK dout1_25 Vdout1_25ck40 = 0.9 time = 205
.meas tran vdout1_25ck40 FIND v(dout1_25) AT=205.025n

* CHECK dout1_26 Vdout1_26ck40 = 0.9 time = 205
.meas tran vdout1_26ck40 FIND v(dout1_26) AT=205.025n

* CHECK dout1_27 Vdout1_27ck40 = 0.9 time = 205
.meas tran vdout1_27ck40 FIND v(dout1_27) AT=205.025n

* CHECK dout1_28 Vdout1_28ck40 = 0.9 time = 205
.meas tran vdout1_28ck40 FIND v(dout1_28) AT=205.025n

* CHECK dout1_29 Vdout1_29ck40 = 0.9 time = 205
.meas tran vdout1_29ck40 FIND v(dout1_29) AT=205.025n

* CHECK dout1_30 Vdout1_30ck40 = 0 time = 205
.meas tran vdout1_30ck40 FIND v(dout1_30) AT=205.025n

* CHECK dout1_31 Vdout1_31ck40 = 0.9 time = 205
.meas tran vdout1_31ck40 FIND v(dout1_31) AT=205.025n

* CHECK dout1_32 Vdout1_32ck40 = 0 time = 205
.meas tran vdout1_32ck40 FIND v(dout1_32) AT=205.025n

* CHECK dout1_33 Vdout1_33ck40 = 0.9 time = 205
.meas tran vdout1_33ck40 FIND v(dout1_33) AT=205.025n

* CHECK dout1_34 Vdout1_34ck40 = 0.9 time = 205
.meas tran vdout1_34ck40 FIND v(dout1_34) AT=205.025n

* CHECK dout1_35 Vdout1_35ck40 = 0.9 time = 205
.meas tran vdout1_35ck40 FIND v(dout1_35) AT=205.025n

* CHECK dout1_36 Vdout1_36ck40 = 0 time = 205
.meas tran vdout1_36ck40 FIND v(dout1_36) AT=205.025n

* CHECK dout1_37 Vdout1_37ck40 = 0 time = 205
.meas tran vdout1_37ck40 FIND v(dout1_37) AT=205.025n

* CHECK dout1_38 Vdout1_38ck40 = 0.9 time = 205
.meas tran vdout1_38ck40 FIND v(dout1_38) AT=205.025n

* CHECK dout1_39 Vdout1_39ck40 = 0 time = 205
.meas tran vdout1_39ck40 FIND v(dout1_39) AT=205.025n

* CHECK dout1_40 Vdout1_40ck40 = 0.9 time = 205
.meas tran vdout1_40ck40 FIND v(dout1_40) AT=205.025n

* CHECK dout1_41 Vdout1_41ck40 = 0 time = 205
.meas tran vdout1_41ck40 FIND v(dout1_41) AT=205.025n

* CHECK dout1_42 Vdout1_42ck40 = 0 time = 205
.meas tran vdout1_42ck40 FIND v(dout1_42) AT=205.025n

* CHECK dout1_43 Vdout1_43ck40 = 0.9 time = 205
.meas tran vdout1_43ck40 FIND v(dout1_43) AT=205.025n

* CHECK dout1_44 Vdout1_44ck40 = 0 time = 205
.meas tran vdout1_44ck40 FIND v(dout1_44) AT=205.025n

* CHECK dout1_45 Vdout1_45ck40 = 0.9 time = 205
.meas tran vdout1_45ck40 FIND v(dout1_45) AT=205.025n

* CHECK dout1_46 Vdout1_46ck40 = 0 time = 205
.meas tran vdout1_46ck40 FIND v(dout1_46) AT=205.025n

* CHECK dout1_47 Vdout1_47ck40 = 0.9 time = 205
.meas tran vdout1_47ck40 FIND v(dout1_47) AT=205.025n

* CHECK dout1_48 Vdout1_48ck40 = 0 time = 205
.meas tran vdout1_48ck40 FIND v(dout1_48) AT=205.025n

* CHECK dout1_49 Vdout1_49ck40 = 0 time = 205
.meas tran vdout1_49ck40 FIND v(dout1_49) AT=205.025n

* CHECK dout1_50 Vdout1_50ck40 = 0 time = 205
.meas tran vdout1_50ck40 FIND v(dout1_50) AT=205.025n

* CHECK dout1_51 Vdout1_51ck40 = 0.9 time = 205
.meas tran vdout1_51ck40 FIND v(dout1_51) AT=205.025n

* CHECK dout1_52 Vdout1_52ck40 = 0.9 time = 205
.meas tran vdout1_52ck40 FIND v(dout1_52) AT=205.025n

* CHECK dout1_53 Vdout1_53ck40 = 0.9 time = 205
.meas tran vdout1_53ck40 FIND v(dout1_53) AT=205.025n

* CHECK dout1_54 Vdout1_54ck40 = 0 time = 205
.meas tran vdout1_54ck40 FIND v(dout1_54) AT=205.025n

* CHECK dout1_55 Vdout1_55ck40 = 0.9 time = 205
.meas tran vdout1_55ck40 FIND v(dout1_55) AT=205.025n

* CHECK dout1_56 Vdout1_56ck40 = 0.9 time = 205
.meas tran vdout1_56ck40 FIND v(dout1_56) AT=205.025n

* CHECK dout1_57 Vdout1_57ck40 = 0.9 time = 205
.meas tran vdout1_57ck40 FIND v(dout1_57) AT=205.025n

* CHECK dout1_58 Vdout1_58ck40 = 0.9 time = 205
.meas tran vdout1_58ck40 FIND v(dout1_58) AT=205.025n

* CHECK dout1_59 Vdout1_59ck40 = 0 time = 205
.meas tran vdout1_59ck40 FIND v(dout1_59) AT=205.025n

* CHECK dout1_60 Vdout1_60ck40 = 0 time = 205
.meas tran vdout1_60ck40 FIND v(dout1_60) AT=205.025n

* CHECK dout1_61 Vdout1_61ck40 = 0.9 time = 205
.meas tran vdout1_61ck40 FIND v(dout1_61) AT=205.025n

* CHECK dout1_62 Vdout1_62ck40 = 0.9 time = 205
.meas tran vdout1_62ck40 FIND v(dout1_62) AT=205.025n

* CHECK dout1_63 Vdout1_63ck40 = 0.9 time = 205
.meas tran vdout1_63ck40 FIND v(dout1_63) AT=205.025n

* CHECK dout1_64 Vdout1_64ck40 = 0.9 time = 205
.meas tran vdout1_64ck40 FIND v(dout1_64) AT=205.025n

* CHECK dout1_65 Vdout1_65ck40 = 0 time = 205
.meas tran vdout1_65ck40 FIND v(dout1_65) AT=205.025n

* CHECK dout1_66 Vdout1_66ck40 = 0.9 time = 205
.meas tran vdout1_66ck40 FIND v(dout1_66) AT=205.025n

* CHECK dout1_67 Vdout1_67ck40 = 0 time = 205
.meas tran vdout1_67ck40 FIND v(dout1_67) AT=205.025n

* CHECK dout1_68 Vdout1_68ck40 = 0 time = 205
.meas tran vdout1_68ck40 FIND v(dout1_68) AT=205.025n

* CHECK dout1_69 Vdout1_69ck40 = 0 time = 205
.meas tran vdout1_69ck40 FIND v(dout1_69) AT=205.025n

* CHECK dout1_70 Vdout1_70ck40 = 0.9 time = 205
.meas tran vdout1_70ck40 FIND v(dout1_70) AT=205.025n

* CHECK dout1_71 Vdout1_71ck40 = 0.9 time = 205
.meas tran vdout1_71ck40 FIND v(dout1_71) AT=205.025n

* CHECK dout1_72 Vdout1_72ck40 = 0.9 time = 205
.meas tran vdout1_72ck40 FIND v(dout1_72) AT=205.025n

* CHECK dout1_73 Vdout1_73ck40 = 0 time = 205
.meas tran vdout1_73ck40 FIND v(dout1_73) AT=205.025n

* CHECK dout1_74 Vdout1_74ck40 = 0 time = 205
.meas tran vdout1_74ck40 FIND v(dout1_74) AT=205.025n

* CHECK dout1_75 Vdout1_75ck40 = 0 time = 205
.meas tran vdout1_75ck40 FIND v(dout1_75) AT=205.025n

* CHECK dout1_76 Vdout1_76ck40 = 0 time = 205
.meas tran vdout1_76ck40 FIND v(dout1_76) AT=205.025n

* CHECK dout1_77 Vdout1_77ck40 = 0 time = 205
.meas tran vdout1_77ck40 FIND v(dout1_77) AT=205.025n

* CHECK dout1_78 Vdout1_78ck40 = 0 time = 205
.meas tran vdout1_78ck40 FIND v(dout1_78) AT=205.025n

* CHECK dout1_79 Vdout1_79ck40 = 0 time = 205
.meas tran vdout1_79ck40 FIND v(dout1_79) AT=205.025n

* CHECK dout1_80 Vdout1_80ck40 = 0.9 time = 205
.meas tran vdout1_80ck40 FIND v(dout1_80) AT=205.025n

* CHECK dout1_81 Vdout1_81ck40 = 0 time = 205
.meas tran vdout1_81ck40 FIND v(dout1_81) AT=205.025n

* CHECK dout1_82 Vdout1_82ck40 = 0 time = 205
.meas tran vdout1_82ck40 FIND v(dout1_82) AT=205.025n

* CHECK dout1_83 Vdout1_83ck40 = 0 time = 205
.meas tran vdout1_83ck40 FIND v(dout1_83) AT=205.025n

* CHECK dout1_84 Vdout1_84ck40 = 0 time = 205
.meas tran vdout1_84ck40 FIND v(dout1_84) AT=205.025n

* CHECK dout1_85 Vdout1_85ck40 = 0.9 time = 205
.meas tran vdout1_85ck40 FIND v(dout1_85) AT=205.025n

* CHECK dout1_86 Vdout1_86ck40 = 0 time = 205
.meas tran vdout1_86ck40 FIND v(dout1_86) AT=205.025n

* CHECK dout1_87 Vdout1_87ck40 = 0.9 time = 205
.meas tran vdout1_87ck40 FIND v(dout1_87) AT=205.025n

* CHECK dout1_88 Vdout1_88ck40 = 0 time = 205
.meas tran vdout1_88ck40 FIND v(dout1_88) AT=205.025n

* CHECK dout1_89 Vdout1_89ck40 = 0.9 time = 205
.meas tran vdout1_89ck40 FIND v(dout1_89) AT=205.025n

* CHECK dout1_90 Vdout1_90ck40 = 0.9 time = 205
.meas tran vdout1_90ck40 FIND v(dout1_90) AT=205.025n

* CHECK dout1_91 Vdout1_91ck40 = 0.9 time = 205
.meas tran vdout1_91ck40 FIND v(dout1_91) AT=205.025n

* CHECK dout1_92 Vdout1_92ck40 = 0 time = 205
.meas tran vdout1_92ck40 FIND v(dout1_92) AT=205.025n

* CHECK dout1_93 Vdout1_93ck40 = 0.9 time = 205
.meas tran vdout1_93ck40 FIND v(dout1_93) AT=205.025n

* CHECK dout1_94 Vdout1_94ck40 = 0 time = 205
.meas tran vdout1_94ck40 FIND v(dout1_94) AT=205.025n

* CHECK dout1_95 Vdout1_95ck40 = 0.9 time = 205
.meas tran vdout1_95ck40 FIND v(dout1_95) AT=205.025n

* CHECK dout1_96 Vdout1_96ck40 = 0 time = 205
.meas tran vdout1_96ck40 FIND v(dout1_96) AT=205.025n

* CHECK dout1_97 Vdout1_97ck40 = 0 time = 205
.meas tran vdout1_97ck40 FIND v(dout1_97) AT=205.025n

* CHECK dout1_98 Vdout1_98ck40 = 0.9 time = 205
.meas tran vdout1_98ck40 FIND v(dout1_98) AT=205.025n

* CHECK dout1_99 Vdout1_99ck40 = 0.9 time = 205
.meas tran vdout1_99ck40 FIND v(dout1_99) AT=205.025n

* CHECK dout1_100 Vdout1_100ck40 = 0.9 time = 205
.meas tran vdout1_100ck40 FIND v(dout1_100) AT=205.025n

* CHECK dout1_101 Vdout1_101ck40 = 0.9 time = 205
.meas tran vdout1_101ck40 FIND v(dout1_101) AT=205.025n

* CHECK dout1_102 Vdout1_102ck40 = 0 time = 205
.meas tran vdout1_102ck40 FIND v(dout1_102) AT=205.025n

* CHECK dout1_103 Vdout1_103ck40 = 0.9 time = 205
.meas tran vdout1_103ck40 FIND v(dout1_103) AT=205.025n

* CHECK dout1_104 Vdout1_104ck40 = 0 time = 205
.meas tran vdout1_104ck40 FIND v(dout1_104) AT=205.025n

* CHECK dout1_105 Vdout1_105ck40 = 0 time = 205
.meas tran vdout1_105ck40 FIND v(dout1_105) AT=205.025n

* CHECK dout1_106 Vdout1_106ck40 = 0.9 time = 205
.meas tran vdout1_106ck40 FIND v(dout1_106) AT=205.025n

* CHECK dout1_107 Vdout1_107ck40 = 0.9 time = 205
.meas tran vdout1_107ck40 FIND v(dout1_107) AT=205.025n

* CHECK dout1_108 Vdout1_108ck40 = 0.9 time = 205
.meas tran vdout1_108ck40 FIND v(dout1_108) AT=205.025n

* CHECK dout1_109 Vdout1_109ck40 = 0.9 time = 205
.meas tran vdout1_109ck40 FIND v(dout1_109) AT=205.025n

* CHECK dout1_110 Vdout1_110ck40 = 0.9 time = 205
.meas tran vdout1_110ck40 FIND v(dout1_110) AT=205.025n

* CHECK dout1_111 Vdout1_111ck40 = 0.9 time = 205
.meas tran vdout1_111ck40 FIND v(dout1_111) AT=205.025n

* CHECK dout1_112 Vdout1_112ck40 = 0 time = 205
.meas tran vdout1_112ck40 FIND v(dout1_112) AT=205.025n

* CHECK dout1_113 Vdout1_113ck40 = 0.9 time = 205
.meas tran vdout1_113ck40 FIND v(dout1_113) AT=205.025n

* CHECK dout1_114 Vdout1_114ck40 = 0.9 time = 205
.meas tran vdout1_114ck40 FIND v(dout1_114) AT=205.025n

* CHECK dout1_115 Vdout1_115ck40 = 0 time = 205
.meas tran vdout1_115ck40 FIND v(dout1_115) AT=205.025n

* CHECK dout1_116 Vdout1_116ck40 = 0 time = 205
.meas tran vdout1_116ck40 FIND v(dout1_116) AT=205.025n

* CHECK dout1_117 Vdout1_117ck40 = 0 time = 205
.meas tran vdout1_117ck40 FIND v(dout1_117) AT=205.025n

* CHECK dout1_118 Vdout1_118ck40 = 0 time = 205
.meas tran vdout1_118ck40 FIND v(dout1_118) AT=205.025n

* CHECK dout1_119 Vdout1_119ck40 = 0 time = 205
.meas tran vdout1_119ck40 FIND v(dout1_119) AT=205.025n

* CHECK dout1_0 Vdout1_0ck41 = 0 time = 210
.meas tran vdout1_0ck41 FIND v(dout1_0) AT=210.025n

* CHECK dout1_1 Vdout1_1ck41 = 0.9 time = 210
.meas tran vdout1_1ck41 FIND v(dout1_1) AT=210.025n

* CHECK dout1_2 Vdout1_2ck41 = 0.9 time = 210
.meas tran vdout1_2ck41 FIND v(dout1_2) AT=210.025n

* CHECK dout1_3 Vdout1_3ck41 = 0.9 time = 210
.meas tran vdout1_3ck41 FIND v(dout1_3) AT=210.025n

* CHECK dout1_4 Vdout1_4ck41 = 0.9 time = 210
.meas tran vdout1_4ck41 FIND v(dout1_4) AT=210.025n

* CHECK dout1_5 Vdout1_5ck41 = 0.9 time = 210
.meas tran vdout1_5ck41 FIND v(dout1_5) AT=210.025n

* CHECK dout1_6 Vdout1_6ck41 = 0 time = 210
.meas tran vdout1_6ck41 FIND v(dout1_6) AT=210.025n

* CHECK dout1_7 Vdout1_7ck41 = 0 time = 210
.meas tran vdout1_7ck41 FIND v(dout1_7) AT=210.025n

* CHECK dout1_8 Vdout1_8ck41 = 0.9 time = 210
.meas tran vdout1_8ck41 FIND v(dout1_8) AT=210.025n

* CHECK dout1_9 Vdout1_9ck41 = 0.9 time = 210
.meas tran vdout1_9ck41 FIND v(dout1_9) AT=210.025n

* CHECK dout1_10 Vdout1_10ck41 = 0 time = 210
.meas tran vdout1_10ck41 FIND v(dout1_10) AT=210.025n

* CHECK dout1_11 Vdout1_11ck41 = 0 time = 210
.meas tran vdout1_11ck41 FIND v(dout1_11) AT=210.025n

* CHECK dout1_12 Vdout1_12ck41 = 0 time = 210
.meas tran vdout1_12ck41 FIND v(dout1_12) AT=210.025n

* CHECK dout1_13 Vdout1_13ck41 = 0 time = 210
.meas tran vdout1_13ck41 FIND v(dout1_13) AT=210.025n

* CHECK dout1_14 Vdout1_14ck41 = 0.9 time = 210
.meas tran vdout1_14ck41 FIND v(dout1_14) AT=210.025n

* CHECK dout1_15 Vdout1_15ck41 = 0.9 time = 210
.meas tran vdout1_15ck41 FIND v(dout1_15) AT=210.025n

* CHECK dout1_16 Vdout1_16ck41 = 0.9 time = 210
.meas tran vdout1_16ck41 FIND v(dout1_16) AT=210.025n

* CHECK dout1_17 Vdout1_17ck41 = 0.9 time = 210
.meas tran vdout1_17ck41 FIND v(dout1_17) AT=210.025n

* CHECK dout1_18 Vdout1_18ck41 = 0.9 time = 210
.meas tran vdout1_18ck41 FIND v(dout1_18) AT=210.025n

* CHECK dout1_19 Vdout1_19ck41 = 0.9 time = 210
.meas tran vdout1_19ck41 FIND v(dout1_19) AT=210.025n

* CHECK dout1_20 Vdout1_20ck41 = 0 time = 210
.meas tran vdout1_20ck41 FIND v(dout1_20) AT=210.025n

* CHECK dout1_21 Vdout1_21ck41 = 0 time = 210
.meas tran vdout1_21ck41 FIND v(dout1_21) AT=210.025n

* CHECK dout1_22 Vdout1_22ck41 = 0.9 time = 210
.meas tran vdout1_22ck41 FIND v(dout1_22) AT=210.025n

* CHECK dout1_23 Vdout1_23ck41 = 0 time = 210
.meas tran vdout1_23ck41 FIND v(dout1_23) AT=210.025n

* CHECK dout1_24 Vdout1_24ck41 = 0 time = 210
.meas tran vdout1_24ck41 FIND v(dout1_24) AT=210.025n

* CHECK dout1_25 Vdout1_25ck41 = 0.9 time = 210
.meas tran vdout1_25ck41 FIND v(dout1_25) AT=210.025n

* CHECK dout1_26 Vdout1_26ck41 = 0.9 time = 210
.meas tran vdout1_26ck41 FIND v(dout1_26) AT=210.025n

* CHECK dout1_27 Vdout1_27ck41 = 0.9 time = 210
.meas tran vdout1_27ck41 FIND v(dout1_27) AT=210.025n

* CHECK dout1_28 Vdout1_28ck41 = 0.9 time = 210
.meas tran vdout1_28ck41 FIND v(dout1_28) AT=210.025n

* CHECK dout1_29 Vdout1_29ck41 = 0.9 time = 210
.meas tran vdout1_29ck41 FIND v(dout1_29) AT=210.025n

* CHECK dout1_30 Vdout1_30ck41 = 0 time = 210
.meas tran vdout1_30ck41 FIND v(dout1_30) AT=210.025n

* CHECK dout1_31 Vdout1_31ck41 = 0.9 time = 210
.meas tran vdout1_31ck41 FIND v(dout1_31) AT=210.025n

* CHECK dout1_32 Vdout1_32ck41 = 0 time = 210
.meas tran vdout1_32ck41 FIND v(dout1_32) AT=210.025n

* CHECK dout1_33 Vdout1_33ck41 = 0.9 time = 210
.meas tran vdout1_33ck41 FIND v(dout1_33) AT=210.025n

* CHECK dout1_34 Vdout1_34ck41 = 0.9 time = 210
.meas tran vdout1_34ck41 FIND v(dout1_34) AT=210.025n

* CHECK dout1_35 Vdout1_35ck41 = 0.9 time = 210
.meas tran vdout1_35ck41 FIND v(dout1_35) AT=210.025n

* CHECK dout1_36 Vdout1_36ck41 = 0 time = 210
.meas tran vdout1_36ck41 FIND v(dout1_36) AT=210.025n

* CHECK dout1_37 Vdout1_37ck41 = 0 time = 210
.meas tran vdout1_37ck41 FIND v(dout1_37) AT=210.025n

* CHECK dout1_38 Vdout1_38ck41 = 0.9 time = 210
.meas tran vdout1_38ck41 FIND v(dout1_38) AT=210.025n

* CHECK dout1_39 Vdout1_39ck41 = 0 time = 210
.meas tran vdout1_39ck41 FIND v(dout1_39) AT=210.025n

* CHECK dout1_40 Vdout1_40ck41 = 0.9 time = 210
.meas tran vdout1_40ck41 FIND v(dout1_40) AT=210.025n

* CHECK dout1_41 Vdout1_41ck41 = 0 time = 210
.meas tran vdout1_41ck41 FIND v(dout1_41) AT=210.025n

* CHECK dout1_42 Vdout1_42ck41 = 0 time = 210
.meas tran vdout1_42ck41 FIND v(dout1_42) AT=210.025n

* CHECK dout1_43 Vdout1_43ck41 = 0.9 time = 210
.meas tran vdout1_43ck41 FIND v(dout1_43) AT=210.025n

* CHECK dout1_44 Vdout1_44ck41 = 0 time = 210
.meas tran vdout1_44ck41 FIND v(dout1_44) AT=210.025n

* CHECK dout1_45 Vdout1_45ck41 = 0.9 time = 210
.meas tran vdout1_45ck41 FIND v(dout1_45) AT=210.025n

* CHECK dout1_46 Vdout1_46ck41 = 0 time = 210
.meas tran vdout1_46ck41 FIND v(dout1_46) AT=210.025n

* CHECK dout1_47 Vdout1_47ck41 = 0.9 time = 210
.meas tran vdout1_47ck41 FIND v(dout1_47) AT=210.025n

* CHECK dout1_48 Vdout1_48ck41 = 0 time = 210
.meas tran vdout1_48ck41 FIND v(dout1_48) AT=210.025n

* CHECK dout1_49 Vdout1_49ck41 = 0 time = 210
.meas tran vdout1_49ck41 FIND v(dout1_49) AT=210.025n

* CHECK dout1_50 Vdout1_50ck41 = 0 time = 210
.meas tran vdout1_50ck41 FIND v(dout1_50) AT=210.025n

* CHECK dout1_51 Vdout1_51ck41 = 0.9 time = 210
.meas tran vdout1_51ck41 FIND v(dout1_51) AT=210.025n

* CHECK dout1_52 Vdout1_52ck41 = 0.9 time = 210
.meas tran vdout1_52ck41 FIND v(dout1_52) AT=210.025n

* CHECK dout1_53 Vdout1_53ck41 = 0.9 time = 210
.meas tran vdout1_53ck41 FIND v(dout1_53) AT=210.025n

* CHECK dout1_54 Vdout1_54ck41 = 0 time = 210
.meas tran vdout1_54ck41 FIND v(dout1_54) AT=210.025n

* CHECK dout1_55 Vdout1_55ck41 = 0.9 time = 210
.meas tran vdout1_55ck41 FIND v(dout1_55) AT=210.025n

* CHECK dout1_56 Vdout1_56ck41 = 0.9 time = 210
.meas tran vdout1_56ck41 FIND v(dout1_56) AT=210.025n

* CHECK dout1_57 Vdout1_57ck41 = 0.9 time = 210
.meas tran vdout1_57ck41 FIND v(dout1_57) AT=210.025n

* CHECK dout1_58 Vdout1_58ck41 = 0.9 time = 210
.meas tran vdout1_58ck41 FIND v(dout1_58) AT=210.025n

* CHECK dout1_59 Vdout1_59ck41 = 0 time = 210
.meas tran vdout1_59ck41 FIND v(dout1_59) AT=210.025n

* CHECK dout1_60 Vdout1_60ck41 = 0 time = 210
.meas tran vdout1_60ck41 FIND v(dout1_60) AT=210.025n

* CHECK dout1_61 Vdout1_61ck41 = 0.9 time = 210
.meas tran vdout1_61ck41 FIND v(dout1_61) AT=210.025n

* CHECK dout1_62 Vdout1_62ck41 = 0.9 time = 210
.meas tran vdout1_62ck41 FIND v(dout1_62) AT=210.025n

* CHECK dout1_63 Vdout1_63ck41 = 0.9 time = 210
.meas tran vdout1_63ck41 FIND v(dout1_63) AT=210.025n

* CHECK dout1_64 Vdout1_64ck41 = 0.9 time = 210
.meas tran vdout1_64ck41 FIND v(dout1_64) AT=210.025n

* CHECK dout1_65 Vdout1_65ck41 = 0 time = 210
.meas tran vdout1_65ck41 FIND v(dout1_65) AT=210.025n

* CHECK dout1_66 Vdout1_66ck41 = 0.9 time = 210
.meas tran vdout1_66ck41 FIND v(dout1_66) AT=210.025n

* CHECK dout1_67 Vdout1_67ck41 = 0 time = 210
.meas tran vdout1_67ck41 FIND v(dout1_67) AT=210.025n

* CHECK dout1_68 Vdout1_68ck41 = 0 time = 210
.meas tran vdout1_68ck41 FIND v(dout1_68) AT=210.025n

* CHECK dout1_69 Vdout1_69ck41 = 0 time = 210
.meas tran vdout1_69ck41 FIND v(dout1_69) AT=210.025n

* CHECK dout1_70 Vdout1_70ck41 = 0.9 time = 210
.meas tran vdout1_70ck41 FIND v(dout1_70) AT=210.025n

* CHECK dout1_71 Vdout1_71ck41 = 0.9 time = 210
.meas tran vdout1_71ck41 FIND v(dout1_71) AT=210.025n

* CHECK dout1_72 Vdout1_72ck41 = 0.9 time = 210
.meas tran vdout1_72ck41 FIND v(dout1_72) AT=210.025n

* CHECK dout1_73 Vdout1_73ck41 = 0 time = 210
.meas tran vdout1_73ck41 FIND v(dout1_73) AT=210.025n

* CHECK dout1_74 Vdout1_74ck41 = 0 time = 210
.meas tran vdout1_74ck41 FIND v(dout1_74) AT=210.025n

* CHECK dout1_75 Vdout1_75ck41 = 0 time = 210
.meas tran vdout1_75ck41 FIND v(dout1_75) AT=210.025n

* CHECK dout1_76 Vdout1_76ck41 = 0 time = 210
.meas tran vdout1_76ck41 FIND v(dout1_76) AT=210.025n

* CHECK dout1_77 Vdout1_77ck41 = 0 time = 210
.meas tran vdout1_77ck41 FIND v(dout1_77) AT=210.025n

* CHECK dout1_78 Vdout1_78ck41 = 0 time = 210
.meas tran vdout1_78ck41 FIND v(dout1_78) AT=210.025n

* CHECK dout1_79 Vdout1_79ck41 = 0 time = 210
.meas tran vdout1_79ck41 FIND v(dout1_79) AT=210.025n

* CHECK dout1_80 Vdout1_80ck41 = 0.9 time = 210
.meas tran vdout1_80ck41 FIND v(dout1_80) AT=210.025n

* CHECK dout1_81 Vdout1_81ck41 = 0 time = 210
.meas tran vdout1_81ck41 FIND v(dout1_81) AT=210.025n

* CHECK dout1_82 Vdout1_82ck41 = 0 time = 210
.meas tran vdout1_82ck41 FIND v(dout1_82) AT=210.025n

* CHECK dout1_83 Vdout1_83ck41 = 0 time = 210
.meas tran vdout1_83ck41 FIND v(dout1_83) AT=210.025n

* CHECK dout1_84 Vdout1_84ck41 = 0 time = 210
.meas tran vdout1_84ck41 FIND v(dout1_84) AT=210.025n

* CHECK dout1_85 Vdout1_85ck41 = 0.9 time = 210
.meas tran vdout1_85ck41 FIND v(dout1_85) AT=210.025n

* CHECK dout1_86 Vdout1_86ck41 = 0 time = 210
.meas tran vdout1_86ck41 FIND v(dout1_86) AT=210.025n

* CHECK dout1_87 Vdout1_87ck41 = 0.9 time = 210
.meas tran vdout1_87ck41 FIND v(dout1_87) AT=210.025n

* CHECK dout1_88 Vdout1_88ck41 = 0 time = 210
.meas tran vdout1_88ck41 FIND v(dout1_88) AT=210.025n

* CHECK dout1_89 Vdout1_89ck41 = 0.9 time = 210
.meas tran vdout1_89ck41 FIND v(dout1_89) AT=210.025n

* CHECK dout1_90 Vdout1_90ck41 = 0.9 time = 210
.meas tran vdout1_90ck41 FIND v(dout1_90) AT=210.025n

* CHECK dout1_91 Vdout1_91ck41 = 0.9 time = 210
.meas tran vdout1_91ck41 FIND v(dout1_91) AT=210.025n

* CHECK dout1_92 Vdout1_92ck41 = 0 time = 210
.meas tran vdout1_92ck41 FIND v(dout1_92) AT=210.025n

* CHECK dout1_93 Vdout1_93ck41 = 0.9 time = 210
.meas tran vdout1_93ck41 FIND v(dout1_93) AT=210.025n

* CHECK dout1_94 Vdout1_94ck41 = 0 time = 210
.meas tran vdout1_94ck41 FIND v(dout1_94) AT=210.025n

* CHECK dout1_95 Vdout1_95ck41 = 0.9 time = 210
.meas tran vdout1_95ck41 FIND v(dout1_95) AT=210.025n

* CHECK dout1_96 Vdout1_96ck41 = 0 time = 210
.meas tran vdout1_96ck41 FIND v(dout1_96) AT=210.025n

* CHECK dout1_97 Vdout1_97ck41 = 0 time = 210
.meas tran vdout1_97ck41 FIND v(dout1_97) AT=210.025n

* CHECK dout1_98 Vdout1_98ck41 = 0.9 time = 210
.meas tran vdout1_98ck41 FIND v(dout1_98) AT=210.025n

* CHECK dout1_99 Vdout1_99ck41 = 0.9 time = 210
.meas tran vdout1_99ck41 FIND v(dout1_99) AT=210.025n

* CHECK dout1_100 Vdout1_100ck41 = 0.9 time = 210
.meas tran vdout1_100ck41 FIND v(dout1_100) AT=210.025n

* CHECK dout1_101 Vdout1_101ck41 = 0.9 time = 210
.meas tran vdout1_101ck41 FIND v(dout1_101) AT=210.025n

* CHECK dout1_102 Vdout1_102ck41 = 0 time = 210
.meas tran vdout1_102ck41 FIND v(dout1_102) AT=210.025n

* CHECK dout1_103 Vdout1_103ck41 = 0.9 time = 210
.meas tran vdout1_103ck41 FIND v(dout1_103) AT=210.025n

* CHECK dout1_104 Vdout1_104ck41 = 0 time = 210
.meas tran vdout1_104ck41 FIND v(dout1_104) AT=210.025n

* CHECK dout1_105 Vdout1_105ck41 = 0 time = 210
.meas tran vdout1_105ck41 FIND v(dout1_105) AT=210.025n

* CHECK dout1_106 Vdout1_106ck41 = 0.9 time = 210
.meas tran vdout1_106ck41 FIND v(dout1_106) AT=210.025n

* CHECK dout1_107 Vdout1_107ck41 = 0.9 time = 210
.meas tran vdout1_107ck41 FIND v(dout1_107) AT=210.025n

* CHECK dout1_108 Vdout1_108ck41 = 0.9 time = 210
.meas tran vdout1_108ck41 FIND v(dout1_108) AT=210.025n

* CHECK dout1_109 Vdout1_109ck41 = 0.9 time = 210
.meas tran vdout1_109ck41 FIND v(dout1_109) AT=210.025n

* CHECK dout1_110 Vdout1_110ck41 = 0.9 time = 210
.meas tran vdout1_110ck41 FIND v(dout1_110) AT=210.025n

* CHECK dout1_111 Vdout1_111ck41 = 0.9 time = 210
.meas tran vdout1_111ck41 FIND v(dout1_111) AT=210.025n

* CHECK dout1_112 Vdout1_112ck41 = 0 time = 210
.meas tran vdout1_112ck41 FIND v(dout1_112) AT=210.025n

* CHECK dout1_113 Vdout1_113ck41 = 0.9 time = 210
.meas tran vdout1_113ck41 FIND v(dout1_113) AT=210.025n

* CHECK dout1_114 Vdout1_114ck41 = 0.9 time = 210
.meas tran vdout1_114ck41 FIND v(dout1_114) AT=210.025n

* CHECK dout1_115 Vdout1_115ck41 = 0 time = 210
.meas tran vdout1_115ck41 FIND v(dout1_115) AT=210.025n

* CHECK dout1_116 Vdout1_116ck41 = 0 time = 210
.meas tran vdout1_116ck41 FIND v(dout1_116) AT=210.025n

* CHECK dout1_117 Vdout1_117ck41 = 0 time = 210
.meas tran vdout1_117ck41 FIND v(dout1_117) AT=210.025n

* CHECK dout1_118 Vdout1_118ck41 = 0 time = 210
.meas tran vdout1_118ck41 FIND v(dout1_118) AT=210.025n

* CHECK dout1_119 Vdout1_119ck41 = 0 time = 210
.meas tran vdout1_119ck41 FIND v(dout1_119) AT=210.025n

* CHECK dout1_0 Vdout1_0ck44 = 0 time = 225
.meas tran vdout1_0ck44 FIND v(dout1_0) AT=225.025n

* CHECK dout1_1 Vdout1_1ck44 = 0.9 time = 225
.meas tran vdout1_1ck44 FIND v(dout1_1) AT=225.025n

* CHECK dout1_2 Vdout1_2ck44 = 0.9 time = 225
.meas tran vdout1_2ck44 FIND v(dout1_2) AT=225.025n

* CHECK dout1_3 Vdout1_3ck44 = 0.9 time = 225
.meas tran vdout1_3ck44 FIND v(dout1_3) AT=225.025n

* CHECK dout1_4 Vdout1_4ck44 = 0.9 time = 225
.meas tran vdout1_4ck44 FIND v(dout1_4) AT=225.025n

* CHECK dout1_5 Vdout1_5ck44 = 0.9 time = 225
.meas tran vdout1_5ck44 FIND v(dout1_5) AT=225.025n

* CHECK dout1_6 Vdout1_6ck44 = 0 time = 225
.meas tran vdout1_6ck44 FIND v(dout1_6) AT=225.025n

* CHECK dout1_7 Vdout1_7ck44 = 0 time = 225
.meas tran vdout1_7ck44 FIND v(dout1_7) AT=225.025n

* CHECK dout1_8 Vdout1_8ck44 = 0.9 time = 225
.meas tran vdout1_8ck44 FIND v(dout1_8) AT=225.025n

* CHECK dout1_9 Vdout1_9ck44 = 0.9 time = 225
.meas tran vdout1_9ck44 FIND v(dout1_9) AT=225.025n

* CHECK dout1_10 Vdout1_10ck44 = 0 time = 225
.meas tran vdout1_10ck44 FIND v(dout1_10) AT=225.025n

* CHECK dout1_11 Vdout1_11ck44 = 0 time = 225
.meas tran vdout1_11ck44 FIND v(dout1_11) AT=225.025n

* CHECK dout1_12 Vdout1_12ck44 = 0 time = 225
.meas tran vdout1_12ck44 FIND v(dout1_12) AT=225.025n

* CHECK dout1_13 Vdout1_13ck44 = 0 time = 225
.meas tran vdout1_13ck44 FIND v(dout1_13) AT=225.025n

* CHECK dout1_14 Vdout1_14ck44 = 0.9 time = 225
.meas tran vdout1_14ck44 FIND v(dout1_14) AT=225.025n

* CHECK dout1_15 Vdout1_15ck44 = 0.9 time = 225
.meas tran vdout1_15ck44 FIND v(dout1_15) AT=225.025n

* CHECK dout1_16 Vdout1_16ck44 = 0.9 time = 225
.meas tran vdout1_16ck44 FIND v(dout1_16) AT=225.025n

* CHECK dout1_17 Vdout1_17ck44 = 0.9 time = 225
.meas tran vdout1_17ck44 FIND v(dout1_17) AT=225.025n

* CHECK dout1_18 Vdout1_18ck44 = 0.9 time = 225
.meas tran vdout1_18ck44 FIND v(dout1_18) AT=225.025n

* CHECK dout1_19 Vdout1_19ck44 = 0.9 time = 225
.meas tran vdout1_19ck44 FIND v(dout1_19) AT=225.025n

* CHECK dout1_20 Vdout1_20ck44 = 0 time = 225
.meas tran vdout1_20ck44 FIND v(dout1_20) AT=225.025n

* CHECK dout1_21 Vdout1_21ck44 = 0 time = 225
.meas tran vdout1_21ck44 FIND v(dout1_21) AT=225.025n

* CHECK dout1_22 Vdout1_22ck44 = 0.9 time = 225
.meas tran vdout1_22ck44 FIND v(dout1_22) AT=225.025n

* CHECK dout1_23 Vdout1_23ck44 = 0 time = 225
.meas tran vdout1_23ck44 FIND v(dout1_23) AT=225.025n

* CHECK dout1_24 Vdout1_24ck44 = 0 time = 225
.meas tran vdout1_24ck44 FIND v(dout1_24) AT=225.025n

* CHECK dout1_25 Vdout1_25ck44 = 0.9 time = 225
.meas tran vdout1_25ck44 FIND v(dout1_25) AT=225.025n

* CHECK dout1_26 Vdout1_26ck44 = 0.9 time = 225
.meas tran vdout1_26ck44 FIND v(dout1_26) AT=225.025n

* CHECK dout1_27 Vdout1_27ck44 = 0.9 time = 225
.meas tran vdout1_27ck44 FIND v(dout1_27) AT=225.025n

* CHECK dout1_28 Vdout1_28ck44 = 0.9 time = 225
.meas tran vdout1_28ck44 FIND v(dout1_28) AT=225.025n

* CHECK dout1_29 Vdout1_29ck44 = 0.9 time = 225
.meas tran vdout1_29ck44 FIND v(dout1_29) AT=225.025n

* CHECK dout1_30 Vdout1_30ck44 = 0 time = 225
.meas tran vdout1_30ck44 FIND v(dout1_30) AT=225.025n

* CHECK dout1_31 Vdout1_31ck44 = 0.9 time = 225
.meas tran vdout1_31ck44 FIND v(dout1_31) AT=225.025n

* CHECK dout1_32 Vdout1_32ck44 = 0 time = 225
.meas tran vdout1_32ck44 FIND v(dout1_32) AT=225.025n

* CHECK dout1_33 Vdout1_33ck44 = 0.9 time = 225
.meas tran vdout1_33ck44 FIND v(dout1_33) AT=225.025n

* CHECK dout1_34 Vdout1_34ck44 = 0.9 time = 225
.meas tran vdout1_34ck44 FIND v(dout1_34) AT=225.025n

* CHECK dout1_35 Vdout1_35ck44 = 0.9 time = 225
.meas tran vdout1_35ck44 FIND v(dout1_35) AT=225.025n

* CHECK dout1_36 Vdout1_36ck44 = 0 time = 225
.meas tran vdout1_36ck44 FIND v(dout1_36) AT=225.025n

* CHECK dout1_37 Vdout1_37ck44 = 0 time = 225
.meas tran vdout1_37ck44 FIND v(dout1_37) AT=225.025n

* CHECK dout1_38 Vdout1_38ck44 = 0.9 time = 225
.meas tran vdout1_38ck44 FIND v(dout1_38) AT=225.025n

* CHECK dout1_39 Vdout1_39ck44 = 0 time = 225
.meas tran vdout1_39ck44 FIND v(dout1_39) AT=225.025n

* CHECK dout1_40 Vdout1_40ck44 = 0.9 time = 225
.meas tran vdout1_40ck44 FIND v(dout1_40) AT=225.025n

* CHECK dout1_41 Vdout1_41ck44 = 0 time = 225
.meas tran vdout1_41ck44 FIND v(dout1_41) AT=225.025n

* CHECK dout1_42 Vdout1_42ck44 = 0 time = 225
.meas tran vdout1_42ck44 FIND v(dout1_42) AT=225.025n

* CHECK dout1_43 Vdout1_43ck44 = 0.9 time = 225
.meas tran vdout1_43ck44 FIND v(dout1_43) AT=225.025n

* CHECK dout1_44 Vdout1_44ck44 = 0 time = 225
.meas tran vdout1_44ck44 FIND v(dout1_44) AT=225.025n

* CHECK dout1_45 Vdout1_45ck44 = 0.9 time = 225
.meas tran vdout1_45ck44 FIND v(dout1_45) AT=225.025n

* CHECK dout1_46 Vdout1_46ck44 = 0 time = 225
.meas tran vdout1_46ck44 FIND v(dout1_46) AT=225.025n

* CHECK dout1_47 Vdout1_47ck44 = 0.9 time = 225
.meas tran vdout1_47ck44 FIND v(dout1_47) AT=225.025n

* CHECK dout1_48 Vdout1_48ck44 = 0 time = 225
.meas tran vdout1_48ck44 FIND v(dout1_48) AT=225.025n

* CHECK dout1_49 Vdout1_49ck44 = 0 time = 225
.meas tran vdout1_49ck44 FIND v(dout1_49) AT=225.025n

* CHECK dout1_50 Vdout1_50ck44 = 0 time = 225
.meas tran vdout1_50ck44 FIND v(dout1_50) AT=225.025n

* CHECK dout1_51 Vdout1_51ck44 = 0.9 time = 225
.meas tran vdout1_51ck44 FIND v(dout1_51) AT=225.025n

* CHECK dout1_52 Vdout1_52ck44 = 0.9 time = 225
.meas tran vdout1_52ck44 FIND v(dout1_52) AT=225.025n

* CHECK dout1_53 Vdout1_53ck44 = 0.9 time = 225
.meas tran vdout1_53ck44 FIND v(dout1_53) AT=225.025n

* CHECK dout1_54 Vdout1_54ck44 = 0 time = 225
.meas tran vdout1_54ck44 FIND v(dout1_54) AT=225.025n

* CHECK dout1_55 Vdout1_55ck44 = 0.9 time = 225
.meas tran vdout1_55ck44 FIND v(dout1_55) AT=225.025n

* CHECK dout1_56 Vdout1_56ck44 = 0.9 time = 225
.meas tran vdout1_56ck44 FIND v(dout1_56) AT=225.025n

* CHECK dout1_57 Vdout1_57ck44 = 0.9 time = 225
.meas tran vdout1_57ck44 FIND v(dout1_57) AT=225.025n

* CHECK dout1_58 Vdout1_58ck44 = 0.9 time = 225
.meas tran vdout1_58ck44 FIND v(dout1_58) AT=225.025n

* CHECK dout1_59 Vdout1_59ck44 = 0 time = 225
.meas tran vdout1_59ck44 FIND v(dout1_59) AT=225.025n

* CHECK dout1_60 Vdout1_60ck44 = 0 time = 225
.meas tran vdout1_60ck44 FIND v(dout1_60) AT=225.025n

* CHECK dout1_61 Vdout1_61ck44 = 0.9 time = 225
.meas tran vdout1_61ck44 FIND v(dout1_61) AT=225.025n

* CHECK dout1_62 Vdout1_62ck44 = 0.9 time = 225
.meas tran vdout1_62ck44 FIND v(dout1_62) AT=225.025n

* CHECK dout1_63 Vdout1_63ck44 = 0.9 time = 225
.meas tran vdout1_63ck44 FIND v(dout1_63) AT=225.025n

* CHECK dout1_64 Vdout1_64ck44 = 0.9 time = 225
.meas tran vdout1_64ck44 FIND v(dout1_64) AT=225.025n

* CHECK dout1_65 Vdout1_65ck44 = 0 time = 225
.meas tran vdout1_65ck44 FIND v(dout1_65) AT=225.025n

* CHECK dout1_66 Vdout1_66ck44 = 0.9 time = 225
.meas tran vdout1_66ck44 FIND v(dout1_66) AT=225.025n

* CHECK dout1_67 Vdout1_67ck44 = 0 time = 225
.meas tran vdout1_67ck44 FIND v(dout1_67) AT=225.025n

* CHECK dout1_68 Vdout1_68ck44 = 0 time = 225
.meas tran vdout1_68ck44 FIND v(dout1_68) AT=225.025n

* CHECK dout1_69 Vdout1_69ck44 = 0 time = 225
.meas tran vdout1_69ck44 FIND v(dout1_69) AT=225.025n

* CHECK dout1_70 Vdout1_70ck44 = 0.9 time = 225
.meas tran vdout1_70ck44 FIND v(dout1_70) AT=225.025n

* CHECK dout1_71 Vdout1_71ck44 = 0.9 time = 225
.meas tran vdout1_71ck44 FIND v(dout1_71) AT=225.025n

* CHECK dout1_72 Vdout1_72ck44 = 0.9 time = 225
.meas tran vdout1_72ck44 FIND v(dout1_72) AT=225.025n

* CHECK dout1_73 Vdout1_73ck44 = 0 time = 225
.meas tran vdout1_73ck44 FIND v(dout1_73) AT=225.025n

* CHECK dout1_74 Vdout1_74ck44 = 0 time = 225
.meas tran vdout1_74ck44 FIND v(dout1_74) AT=225.025n

* CHECK dout1_75 Vdout1_75ck44 = 0 time = 225
.meas tran vdout1_75ck44 FIND v(dout1_75) AT=225.025n

* CHECK dout1_76 Vdout1_76ck44 = 0 time = 225
.meas tran vdout1_76ck44 FIND v(dout1_76) AT=225.025n

* CHECK dout1_77 Vdout1_77ck44 = 0 time = 225
.meas tran vdout1_77ck44 FIND v(dout1_77) AT=225.025n

* CHECK dout1_78 Vdout1_78ck44 = 0 time = 225
.meas tran vdout1_78ck44 FIND v(dout1_78) AT=225.025n

* CHECK dout1_79 Vdout1_79ck44 = 0 time = 225
.meas tran vdout1_79ck44 FIND v(dout1_79) AT=225.025n

* CHECK dout1_80 Vdout1_80ck44 = 0.9 time = 225
.meas tran vdout1_80ck44 FIND v(dout1_80) AT=225.025n

* CHECK dout1_81 Vdout1_81ck44 = 0 time = 225
.meas tran vdout1_81ck44 FIND v(dout1_81) AT=225.025n

* CHECK dout1_82 Vdout1_82ck44 = 0 time = 225
.meas tran vdout1_82ck44 FIND v(dout1_82) AT=225.025n

* CHECK dout1_83 Vdout1_83ck44 = 0 time = 225
.meas tran vdout1_83ck44 FIND v(dout1_83) AT=225.025n

* CHECK dout1_84 Vdout1_84ck44 = 0 time = 225
.meas tran vdout1_84ck44 FIND v(dout1_84) AT=225.025n

* CHECK dout1_85 Vdout1_85ck44 = 0.9 time = 225
.meas tran vdout1_85ck44 FIND v(dout1_85) AT=225.025n

* CHECK dout1_86 Vdout1_86ck44 = 0 time = 225
.meas tran vdout1_86ck44 FIND v(dout1_86) AT=225.025n

* CHECK dout1_87 Vdout1_87ck44 = 0.9 time = 225
.meas tran vdout1_87ck44 FIND v(dout1_87) AT=225.025n

* CHECK dout1_88 Vdout1_88ck44 = 0 time = 225
.meas tran vdout1_88ck44 FIND v(dout1_88) AT=225.025n

* CHECK dout1_89 Vdout1_89ck44 = 0.9 time = 225
.meas tran vdout1_89ck44 FIND v(dout1_89) AT=225.025n

* CHECK dout1_90 Vdout1_90ck44 = 0.9 time = 225
.meas tran vdout1_90ck44 FIND v(dout1_90) AT=225.025n

* CHECK dout1_91 Vdout1_91ck44 = 0.9 time = 225
.meas tran vdout1_91ck44 FIND v(dout1_91) AT=225.025n

* CHECK dout1_92 Vdout1_92ck44 = 0 time = 225
.meas tran vdout1_92ck44 FIND v(dout1_92) AT=225.025n

* CHECK dout1_93 Vdout1_93ck44 = 0.9 time = 225
.meas tran vdout1_93ck44 FIND v(dout1_93) AT=225.025n

* CHECK dout1_94 Vdout1_94ck44 = 0 time = 225
.meas tran vdout1_94ck44 FIND v(dout1_94) AT=225.025n

* CHECK dout1_95 Vdout1_95ck44 = 0.9 time = 225
.meas tran vdout1_95ck44 FIND v(dout1_95) AT=225.025n

* CHECK dout1_96 Vdout1_96ck44 = 0 time = 225
.meas tran vdout1_96ck44 FIND v(dout1_96) AT=225.025n

* CHECK dout1_97 Vdout1_97ck44 = 0 time = 225
.meas tran vdout1_97ck44 FIND v(dout1_97) AT=225.025n

* CHECK dout1_98 Vdout1_98ck44 = 0.9 time = 225
.meas tran vdout1_98ck44 FIND v(dout1_98) AT=225.025n

* CHECK dout1_99 Vdout1_99ck44 = 0.9 time = 225
.meas tran vdout1_99ck44 FIND v(dout1_99) AT=225.025n

* CHECK dout1_100 Vdout1_100ck44 = 0.9 time = 225
.meas tran vdout1_100ck44 FIND v(dout1_100) AT=225.025n

* CHECK dout1_101 Vdout1_101ck44 = 0.9 time = 225
.meas tran vdout1_101ck44 FIND v(dout1_101) AT=225.025n

* CHECK dout1_102 Vdout1_102ck44 = 0 time = 225
.meas tran vdout1_102ck44 FIND v(dout1_102) AT=225.025n

* CHECK dout1_103 Vdout1_103ck44 = 0.9 time = 225
.meas tran vdout1_103ck44 FIND v(dout1_103) AT=225.025n

* CHECK dout1_104 Vdout1_104ck44 = 0 time = 225
.meas tran vdout1_104ck44 FIND v(dout1_104) AT=225.025n

* CHECK dout1_105 Vdout1_105ck44 = 0 time = 225
.meas tran vdout1_105ck44 FIND v(dout1_105) AT=225.025n

* CHECK dout1_106 Vdout1_106ck44 = 0.9 time = 225
.meas tran vdout1_106ck44 FIND v(dout1_106) AT=225.025n

* CHECK dout1_107 Vdout1_107ck44 = 0.9 time = 225
.meas tran vdout1_107ck44 FIND v(dout1_107) AT=225.025n

* CHECK dout1_108 Vdout1_108ck44 = 0.9 time = 225
.meas tran vdout1_108ck44 FIND v(dout1_108) AT=225.025n

* CHECK dout1_109 Vdout1_109ck44 = 0.9 time = 225
.meas tran vdout1_109ck44 FIND v(dout1_109) AT=225.025n

* CHECK dout1_110 Vdout1_110ck44 = 0.9 time = 225
.meas tran vdout1_110ck44 FIND v(dout1_110) AT=225.025n

* CHECK dout1_111 Vdout1_111ck44 = 0.9 time = 225
.meas tran vdout1_111ck44 FIND v(dout1_111) AT=225.025n

* CHECK dout1_112 Vdout1_112ck44 = 0 time = 225
.meas tran vdout1_112ck44 FIND v(dout1_112) AT=225.025n

* CHECK dout1_113 Vdout1_113ck44 = 0.9 time = 225
.meas tran vdout1_113ck44 FIND v(dout1_113) AT=225.025n

* CHECK dout1_114 Vdout1_114ck44 = 0.9 time = 225
.meas tran vdout1_114ck44 FIND v(dout1_114) AT=225.025n

* CHECK dout1_115 Vdout1_115ck44 = 0 time = 225
.meas tran vdout1_115ck44 FIND v(dout1_115) AT=225.025n

* CHECK dout1_116 Vdout1_116ck44 = 0 time = 225
.meas tran vdout1_116ck44 FIND v(dout1_116) AT=225.025n

* CHECK dout1_117 Vdout1_117ck44 = 0 time = 225
.meas tran vdout1_117ck44 FIND v(dout1_117) AT=225.025n

* CHECK dout1_118 Vdout1_118ck44 = 0 time = 225
.meas tran vdout1_118ck44 FIND v(dout1_118) AT=225.025n

* CHECK dout1_119 Vdout1_119ck44 = 0 time = 225
.meas tran vdout1_119ck44 FIND v(dout1_119) AT=225.025n

* CHECK dout1_0 Vdout1_0ck48 = 0.9 time = 245
.meas tran vdout1_0ck48 FIND v(dout1_0) AT=245.025n

* CHECK dout1_1 Vdout1_1ck48 = 0.9 time = 245
.meas tran vdout1_1ck48 FIND v(dout1_1) AT=245.025n

* CHECK dout1_2 Vdout1_2ck48 = 0 time = 245
.meas tran vdout1_2ck48 FIND v(dout1_2) AT=245.025n

* CHECK dout1_3 Vdout1_3ck48 = 0 time = 245
.meas tran vdout1_3ck48 FIND v(dout1_3) AT=245.025n

* CHECK dout1_4 Vdout1_4ck48 = 0.9 time = 245
.meas tran vdout1_4ck48 FIND v(dout1_4) AT=245.025n

* CHECK dout1_5 Vdout1_5ck48 = 0.9 time = 245
.meas tran vdout1_5ck48 FIND v(dout1_5) AT=245.025n

* CHECK dout1_6 Vdout1_6ck48 = 0 time = 245
.meas tran vdout1_6ck48 FIND v(dout1_6) AT=245.025n

* CHECK dout1_7 Vdout1_7ck48 = 0 time = 245
.meas tran vdout1_7ck48 FIND v(dout1_7) AT=245.025n

* CHECK dout1_8 Vdout1_8ck48 = 0.9 time = 245
.meas tran vdout1_8ck48 FIND v(dout1_8) AT=245.025n

* CHECK dout1_9 Vdout1_9ck48 = 0.9 time = 245
.meas tran vdout1_9ck48 FIND v(dout1_9) AT=245.025n

* CHECK dout1_10 Vdout1_10ck48 = 0.9 time = 245
.meas tran vdout1_10ck48 FIND v(dout1_10) AT=245.025n

* CHECK dout1_11 Vdout1_11ck48 = 0.9 time = 245
.meas tran vdout1_11ck48 FIND v(dout1_11) AT=245.025n

* CHECK dout1_12 Vdout1_12ck48 = 0 time = 245
.meas tran vdout1_12ck48 FIND v(dout1_12) AT=245.025n

* CHECK dout1_13 Vdout1_13ck48 = 0 time = 245
.meas tran vdout1_13ck48 FIND v(dout1_13) AT=245.025n

* CHECK dout1_14 Vdout1_14ck48 = 0.9 time = 245
.meas tran vdout1_14ck48 FIND v(dout1_14) AT=245.025n

* CHECK dout1_15 Vdout1_15ck48 = 0 time = 245
.meas tran vdout1_15ck48 FIND v(dout1_15) AT=245.025n

* CHECK dout1_16 Vdout1_16ck48 = 0.9 time = 245
.meas tran vdout1_16ck48 FIND v(dout1_16) AT=245.025n

* CHECK dout1_17 Vdout1_17ck48 = 0 time = 245
.meas tran vdout1_17ck48 FIND v(dout1_17) AT=245.025n

* CHECK dout1_18 Vdout1_18ck48 = 0 time = 245
.meas tran vdout1_18ck48 FIND v(dout1_18) AT=245.025n

* CHECK dout1_19 Vdout1_19ck48 = 0.9 time = 245
.meas tran vdout1_19ck48 FIND v(dout1_19) AT=245.025n

* CHECK dout1_20 Vdout1_20ck48 = 0 time = 245
.meas tran vdout1_20ck48 FIND v(dout1_20) AT=245.025n

* CHECK dout1_21 Vdout1_21ck48 = 0 time = 245
.meas tran vdout1_21ck48 FIND v(dout1_21) AT=245.025n

* CHECK dout1_22 Vdout1_22ck48 = 0.9 time = 245
.meas tran vdout1_22ck48 FIND v(dout1_22) AT=245.025n

* CHECK dout1_23 Vdout1_23ck48 = 0 time = 245
.meas tran vdout1_23ck48 FIND v(dout1_23) AT=245.025n

* CHECK dout1_24 Vdout1_24ck48 = 0.9 time = 245
.meas tran vdout1_24ck48 FIND v(dout1_24) AT=245.025n

* CHECK dout1_25 Vdout1_25ck48 = 0.9 time = 245
.meas tran vdout1_25ck48 FIND v(dout1_25) AT=245.025n

* CHECK dout1_26 Vdout1_26ck48 = 0 time = 245
.meas tran vdout1_26ck48 FIND v(dout1_26) AT=245.025n

* CHECK dout1_27 Vdout1_27ck48 = 0 time = 245
.meas tran vdout1_27ck48 FIND v(dout1_27) AT=245.025n

* CHECK dout1_28 Vdout1_28ck48 = 0.9 time = 245
.meas tran vdout1_28ck48 FIND v(dout1_28) AT=245.025n

* CHECK dout1_29 Vdout1_29ck48 = 0.9 time = 245
.meas tran vdout1_29ck48 FIND v(dout1_29) AT=245.025n

* CHECK dout1_30 Vdout1_30ck48 = 0 time = 245
.meas tran vdout1_30ck48 FIND v(dout1_30) AT=245.025n

* CHECK dout1_31 Vdout1_31ck48 = 0 time = 245
.meas tran vdout1_31ck48 FIND v(dout1_31) AT=245.025n

* CHECK dout1_32 Vdout1_32ck48 = 0 time = 245
.meas tran vdout1_32ck48 FIND v(dout1_32) AT=245.025n

* CHECK dout1_33 Vdout1_33ck48 = 0.9 time = 245
.meas tran vdout1_33ck48 FIND v(dout1_33) AT=245.025n

* CHECK dout1_34 Vdout1_34ck48 = 0 time = 245
.meas tran vdout1_34ck48 FIND v(dout1_34) AT=245.025n

* CHECK dout1_35 Vdout1_35ck48 = 0 time = 245
.meas tran vdout1_35ck48 FIND v(dout1_35) AT=245.025n

* CHECK dout1_36 Vdout1_36ck48 = 0 time = 245
.meas tran vdout1_36ck48 FIND v(dout1_36) AT=245.025n

* CHECK dout1_37 Vdout1_37ck48 = 0.9 time = 245
.meas tran vdout1_37ck48 FIND v(dout1_37) AT=245.025n

* CHECK dout1_38 Vdout1_38ck48 = 0 time = 245
.meas tran vdout1_38ck48 FIND v(dout1_38) AT=245.025n

* CHECK dout1_39 Vdout1_39ck48 = 0 time = 245
.meas tran vdout1_39ck48 FIND v(dout1_39) AT=245.025n

* CHECK dout1_40 Vdout1_40ck48 = 0 time = 245
.meas tran vdout1_40ck48 FIND v(dout1_40) AT=245.025n

* CHECK dout1_41 Vdout1_41ck48 = 0 time = 245
.meas tran vdout1_41ck48 FIND v(dout1_41) AT=245.025n

* CHECK dout1_42 Vdout1_42ck48 = 0.9 time = 245
.meas tran vdout1_42ck48 FIND v(dout1_42) AT=245.025n

* CHECK dout1_43 Vdout1_43ck48 = 0 time = 245
.meas tran vdout1_43ck48 FIND v(dout1_43) AT=245.025n

* CHECK dout1_44 Vdout1_44ck48 = 0.9 time = 245
.meas tran vdout1_44ck48 FIND v(dout1_44) AT=245.025n

* CHECK dout1_45 Vdout1_45ck48 = 0 time = 245
.meas tran vdout1_45ck48 FIND v(dout1_45) AT=245.025n

* CHECK dout1_46 Vdout1_46ck48 = 0 time = 245
.meas tran vdout1_46ck48 FIND v(dout1_46) AT=245.025n

* CHECK dout1_47 Vdout1_47ck48 = 0.9 time = 245
.meas tran vdout1_47ck48 FIND v(dout1_47) AT=245.025n

* CHECK dout1_48 Vdout1_48ck48 = 0 time = 245
.meas tran vdout1_48ck48 FIND v(dout1_48) AT=245.025n

* CHECK dout1_49 Vdout1_49ck48 = 0 time = 245
.meas tran vdout1_49ck48 FIND v(dout1_49) AT=245.025n

* CHECK dout1_50 Vdout1_50ck48 = 0 time = 245
.meas tran vdout1_50ck48 FIND v(dout1_50) AT=245.025n

* CHECK dout1_51 Vdout1_51ck48 = 0 time = 245
.meas tran vdout1_51ck48 FIND v(dout1_51) AT=245.025n

* CHECK dout1_52 Vdout1_52ck48 = 0.9 time = 245
.meas tran vdout1_52ck48 FIND v(dout1_52) AT=245.025n

* CHECK dout1_53 Vdout1_53ck48 = 0.9 time = 245
.meas tran vdout1_53ck48 FIND v(dout1_53) AT=245.025n

* CHECK dout1_54 Vdout1_54ck48 = 0.9 time = 245
.meas tran vdout1_54ck48 FIND v(dout1_54) AT=245.025n

* CHECK dout1_55 Vdout1_55ck48 = 0 time = 245
.meas tran vdout1_55ck48 FIND v(dout1_55) AT=245.025n

* CHECK dout1_56 Vdout1_56ck48 = 0 time = 245
.meas tran vdout1_56ck48 FIND v(dout1_56) AT=245.025n

* CHECK dout1_57 Vdout1_57ck48 = 0.9 time = 245
.meas tran vdout1_57ck48 FIND v(dout1_57) AT=245.025n

* CHECK dout1_58 Vdout1_58ck48 = 0 time = 245
.meas tran vdout1_58ck48 FIND v(dout1_58) AT=245.025n

* CHECK dout1_59 Vdout1_59ck48 = 0 time = 245
.meas tran vdout1_59ck48 FIND v(dout1_59) AT=245.025n

* CHECK dout1_60 Vdout1_60ck48 = 0.9 time = 245
.meas tran vdout1_60ck48 FIND v(dout1_60) AT=245.025n

* CHECK dout1_61 Vdout1_61ck48 = 0.9 time = 245
.meas tran vdout1_61ck48 FIND v(dout1_61) AT=245.025n

* CHECK dout1_62 Vdout1_62ck48 = 0 time = 245
.meas tran vdout1_62ck48 FIND v(dout1_62) AT=245.025n

* CHECK dout1_63 Vdout1_63ck48 = 0.9 time = 245
.meas tran vdout1_63ck48 FIND v(dout1_63) AT=245.025n

* CHECK dout1_64 Vdout1_64ck48 = 0 time = 245
.meas tran vdout1_64ck48 FIND v(dout1_64) AT=245.025n

* CHECK dout1_65 Vdout1_65ck48 = 0 time = 245
.meas tran vdout1_65ck48 FIND v(dout1_65) AT=245.025n

* CHECK dout1_66 Vdout1_66ck48 = 0 time = 245
.meas tran vdout1_66ck48 FIND v(dout1_66) AT=245.025n

* CHECK dout1_67 Vdout1_67ck48 = 0 time = 245
.meas tran vdout1_67ck48 FIND v(dout1_67) AT=245.025n

* CHECK dout1_68 Vdout1_68ck48 = 0.9 time = 245
.meas tran vdout1_68ck48 FIND v(dout1_68) AT=245.025n

* CHECK dout1_69 Vdout1_69ck48 = 0 time = 245
.meas tran vdout1_69ck48 FIND v(dout1_69) AT=245.025n

* CHECK dout1_70 Vdout1_70ck48 = 0.9 time = 245
.meas tran vdout1_70ck48 FIND v(dout1_70) AT=245.025n

* CHECK dout1_71 Vdout1_71ck48 = 0 time = 245
.meas tran vdout1_71ck48 FIND v(dout1_71) AT=245.025n

* CHECK dout1_72 Vdout1_72ck48 = 0 time = 245
.meas tran vdout1_72ck48 FIND v(dout1_72) AT=245.025n

* CHECK dout1_73 Vdout1_73ck48 = 0 time = 245
.meas tran vdout1_73ck48 FIND v(dout1_73) AT=245.025n

* CHECK dout1_74 Vdout1_74ck48 = 0.9 time = 245
.meas tran vdout1_74ck48 FIND v(dout1_74) AT=245.025n

* CHECK dout1_75 Vdout1_75ck48 = 0.9 time = 245
.meas tran vdout1_75ck48 FIND v(dout1_75) AT=245.025n

* CHECK dout1_76 Vdout1_76ck48 = 0.9 time = 245
.meas tran vdout1_76ck48 FIND v(dout1_76) AT=245.025n

* CHECK dout1_77 Vdout1_77ck48 = 0 time = 245
.meas tran vdout1_77ck48 FIND v(dout1_77) AT=245.025n

* CHECK dout1_78 Vdout1_78ck48 = 0 time = 245
.meas tran vdout1_78ck48 FIND v(dout1_78) AT=245.025n

* CHECK dout1_79 Vdout1_79ck48 = 0 time = 245
.meas tran vdout1_79ck48 FIND v(dout1_79) AT=245.025n

* CHECK dout1_80 Vdout1_80ck48 = 0.9 time = 245
.meas tran vdout1_80ck48 FIND v(dout1_80) AT=245.025n

* CHECK dout1_81 Vdout1_81ck48 = 0 time = 245
.meas tran vdout1_81ck48 FIND v(dout1_81) AT=245.025n

* CHECK dout1_82 Vdout1_82ck48 = 0 time = 245
.meas tran vdout1_82ck48 FIND v(dout1_82) AT=245.025n

* CHECK dout1_83 Vdout1_83ck48 = 0 time = 245
.meas tran vdout1_83ck48 FIND v(dout1_83) AT=245.025n

* CHECK dout1_84 Vdout1_84ck48 = 0 time = 245
.meas tran vdout1_84ck48 FIND v(dout1_84) AT=245.025n

* CHECK dout1_85 Vdout1_85ck48 = 0 time = 245
.meas tran vdout1_85ck48 FIND v(dout1_85) AT=245.025n

* CHECK dout1_86 Vdout1_86ck48 = 0.9 time = 245
.meas tran vdout1_86ck48 FIND v(dout1_86) AT=245.025n

* CHECK dout1_87 Vdout1_87ck48 = 0 time = 245
.meas tran vdout1_87ck48 FIND v(dout1_87) AT=245.025n

* CHECK dout1_88 Vdout1_88ck48 = 0 time = 245
.meas tran vdout1_88ck48 FIND v(dout1_88) AT=245.025n

* CHECK dout1_89 Vdout1_89ck48 = 0.9 time = 245
.meas tran vdout1_89ck48 FIND v(dout1_89) AT=245.025n

* CHECK dout1_90 Vdout1_90ck48 = 0 time = 245
.meas tran vdout1_90ck48 FIND v(dout1_90) AT=245.025n

* CHECK dout1_91 Vdout1_91ck48 = 0.9 time = 245
.meas tran vdout1_91ck48 FIND v(dout1_91) AT=245.025n

* CHECK dout1_92 Vdout1_92ck48 = 0 time = 245
.meas tran vdout1_92ck48 FIND v(dout1_92) AT=245.025n

* CHECK dout1_93 Vdout1_93ck48 = 0 time = 245
.meas tran vdout1_93ck48 FIND v(dout1_93) AT=245.025n

* CHECK dout1_94 Vdout1_94ck48 = 0.9 time = 245
.meas tran vdout1_94ck48 FIND v(dout1_94) AT=245.025n

* CHECK dout1_95 Vdout1_95ck48 = 0.9 time = 245
.meas tran vdout1_95ck48 FIND v(dout1_95) AT=245.025n

* CHECK dout1_96 Vdout1_96ck48 = 0.9 time = 245
.meas tran vdout1_96ck48 FIND v(dout1_96) AT=245.025n

* CHECK dout1_97 Vdout1_97ck48 = 0.9 time = 245
.meas tran vdout1_97ck48 FIND v(dout1_97) AT=245.025n

* CHECK dout1_98 Vdout1_98ck48 = 0 time = 245
.meas tran vdout1_98ck48 FIND v(dout1_98) AT=245.025n

* CHECK dout1_99 Vdout1_99ck48 = 0.9 time = 245
.meas tran vdout1_99ck48 FIND v(dout1_99) AT=245.025n

* CHECK dout1_100 Vdout1_100ck48 = 0.9 time = 245
.meas tran vdout1_100ck48 FIND v(dout1_100) AT=245.025n

* CHECK dout1_101 Vdout1_101ck48 = 0 time = 245
.meas tran vdout1_101ck48 FIND v(dout1_101) AT=245.025n

* CHECK dout1_102 Vdout1_102ck48 = 0.9 time = 245
.meas tran vdout1_102ck48 FIND v(dout1_102) AT=245.025n

* CHECK dout1_103 Vdout1_103ck48 = 0.9 time = 245
.meas tran vdout1_103ck48 FIND v(dout1_103) AT=245.025n

* CHECK dout1_104 Vdout1_104ck48 = 0.9 time = 245
.meas tran vdout1_104ck48 FIND v(dout1_104) AT=245.025n

* CHECK dout1_105 Vdout1_105ck48 = 0 time = 245
.meas tran vdout1_105ck48 FIND v(dout1_105) AT=245.025n

* CHECK dout1_106 Vdout1_106ck48 = 0 time = 245
.meas tran vdout1_106ck48 FIND v(dout1_106) AT=245.025n

* CHECK dout1_107 Vdout1_107ck48 = 0 time = 245
.meas tran vdout1_107ck48 FIND v(dout1_107) AT=245.025n

* CHECK dout1_108 Vdout1_108ck48 = 0.9 time = 245
.meas tran vdout1_108ck48 FIND v(dout1_108) AT=245.025n

* CHECK dout1_109 Vdout1_109ck48 = 0 time = 245
.meas tran vdout1_109ck48 FIND v(dout1_109) AT=245.025n

* CHECK dout1_110 Vdout1_110ck48 = 0.9 time = 245
.meas tran vdout1_110ck48 FIND v(dout1_110) AT=245.025n

* CHECK dout1_111 Vdout1_111ck48 = 0 time = 245
.meas tran vdout1_111ck48 FIND v(dout1_111) AT=245.025n

* CHECK dout1_112 Vdout1_112ck48 = 0.9 time = 245
.meas tran vdout1_112ck48 FIND v(dout1_112) AT=245.025n

* CHECK dout1_113 Vdout1_113ck48 = 0.9 time = 245
.meas tran vdout1_113ck48 FIND v(dout1_113) AT=245.025n

* CHECK dout1_114 Vdout1_114ck48 = 0 time = 245
.meas tran vdout1_114ck48 FIND v(dout1_114) AT=245.025n

* CHECK dout1_115 Vdout1_115ck48 = 0 time = 245
.meas tran vdout1_115ck48 FIND v(dout1_115) AT=245.025n

* CHECK dout1_116 Vdout1_116ck48 = 0.9 time = 245
.meas tran vdout1_116ck48 FIND v(dout1_116) AT=245.025n

* CHECK dout1_117 Vdout1_117ck48 = 0.9 time = 245
.meas tran vdout1_117ck48 FIND v(dout1_117) AT=245.025n

* CHECK dout1_118 Vdout1_118ck48 = 0.9 time = 245
.meas tran vdout1_118ck48 FIND v(dout1_118) AT=245.025n

* CHECK dout1_119 Vdout1_119ck48 = 0.9 time = 245
.meas tran vdout1_119ck48 FIND v(dout1_119) AT=245.025n

* CHECK dout1_0 Vdout1_0ck50 = 0 time = 255
.meas tran vdout1_0ck50 FIND v(dout1_0) AT=255.025n

* CHECK dout1_1 Vdout1_1ck50 = 0.9 time = 255
.meas tran vdout1_1ck50 FIND v(dout1_1) AT=255.025n

* CHECK dout1_2 Vdout1_2ck50 = 0.9 time = 255
.meas tran vdout1_2ck50 FIND v(dout1_2) AT=255.025n

* CHECK dout1_3 Vdout1_3ck50 = 0.9 time = 255
.meas tran vdout1_3ck50 FIND v(dout1_3) AT=255.025n

* CHECK dout1_4 Vdout1_4ck50 = 0 time = 255
.meas tran vdout1_4ck50 FIND v(dout1_4) AT=255.025n

* CHECK dout1_5 Vdout1_5ck50 = 0 time = 255
.meas tran vdout1_5ck50 FIND v(dout1_5) AT=255.025n

* CHECK dout1_6 Vdout1_6ck50 = 0 time = 255
.meas tran vdout1_6ck50 FIND v(dout1_6) AT=255.025n

* CHECK dout1_7 Vdout1_7ck50 = 0 time = 255
.meas tran vdout1_7ck50 FIND v(dout1_7) AT=255.025n

* CHECK dout1_8 Vdout1_8ck50 = 0.9 time = 255
.meas tran vdout1_8ck50 FIND v(dout1_8) AT=255.025n

* CHECK dout1_9 Vdout1_9ck50 = 0.9 time = 255
.meas tran vdout1_9ck50 FIND v(dout1_9) AT=255.025n

* CHECK dout1_10 Vdout1_10ck50 = 0.9 time = 255
.meas tran vdout1_10ck50 FIND v(dout1_10) AT=255.025n

* CHECK dout1_11 Vdout1_11ck50 = 0.9 time = 255
.meas tran vdout1_11ck50 FIND v(dout1_11) AT=255.025n

* CHECK dout1_12 Vdout1_12ck50 = 0.9 time = 255
.meas tran vdout1_12ck50 FIND v(dout1_12) AT=255.025n

* CHECK dout1_13 Vdout1_13ck50 = 0.9 time = 255
.meas tran vdout1_13ck50 FIND v(dout1_13) AT=255.025n

* CHECK dout1_14 Vdout1_14ck50 = 0.9 time = 255
.meas tran vdout1_14ck50 FIND v(dout1_14) AT=255.025n

* CHECK dout1_15 Vdout1_15ck50 = 0 time = 255
.meas tran vdout1_15ck50 FIND v(dout1_15) AT=255.025n

* CHECK dout1_16 Vdout1_16ck50 = 0 time = 255
.meas tran vdout1_16ck50 FIND v(dout1_16) AT=255.025n

* CHECK dout1_17 Vdout1_17ck50 = 0.9 time = 255
.meas tran vdout1_17ck50 FIND v(dout1_17) AT=255.025n

* CHECK dout1_18 Vdout1_18ck50 = 0.9 time = 255
.meas tran vdout1_18ck50 FIND v(dout1_18) AT=255.025n

* CHECK dout1_19 Vdout1_19ck50 = 0 time = 255
.meas tran vdout1_19ck50 FIND v(dout1_19) AT=255.025n

* CHECK dout1_20 Vdout1_20ck50 = 0 time = 255
.meas tran vdout1_20ck50 FIND v(dout1_20) AT=255.025n

* CHECK dout1_21 Vdout1_21ck50 = 0.9 time = 255
.meas tran vdout1_21ck50 FIND v(dout1_21) AT=255.025n

* CHECK dout1_22 Vdout1_22ck50 = 0.9 time = 255
.meas tran vdout1_22ck50 FIND v(dout1_22) AT=255.025n

* CHECK dout1_23 Vdout1_23ck50 = 0.9 time = 255
.meas tran vdout1_23ck50 FIND v(dout1_23) AT=255.025n

* CHECK dout1_24 Vdout1_24ck50 = 0 time = 255
.meas tran vdout1_24ck50 FIND v(dout1_24) AT=255.025n

* CHECK dout1_25 Vdout1_25ck50 = 0.9 time = 255
.meas tran vdout1_25ck50 FIND v(dout1_25) AT=255.025n

* CHECK dout1_26 Vdout1_26ck50 = 0 time = 255
.meas tran vdout1_26ck50 FIND v(dout1_26) AT=255.025n

* CHECK dout1_27 Vdout1_27ck50 = 0 time = 255
.meas tran vdout1_27ck50 FIND v(dout1_27) AT=255.025n

* CHECK dout1_28 Vdout1_28ck50 = 0 time = 255
.meas tran vdout1_28ck50 FIND v(dout1_28) AT=255.025n

* CHECK dout1_29 Vdout1_29ck50 = 0.9 time = 255
.meas tran vdout1_29ck50 FIND v(dout1_29) AT=255.025n

* CHECK dout1_30 Vdout1_30ck50 = 0.9 time = 255
.meas tran vdout1_30ck50 FIND v(dout1_30) AT=255.025n

* CHECK dout1_31 Vdout1_31ck50 = 0.9 time = 255
.meas tran vdout1_31ck50 FIND v(dout1_31) AT=255.025n

* CHECK dout1_32 Vdout1_32ck50 = 0.9 time = 255
.meas tran vdout1_32ck50 FIND v(dout1_32) AT=255.025n

* CHECK dout1_33 Vdout1_33ck50 = 0 time = 255
.meas tran vdout1_33ck50 FIND v(dout1_33) AT=255.025n

* CHECK dout1_34 Vdout1_34ck50 = 0.9 time = 255
.meas tran vdout1_34ck50 FIND v(dout1_34) AT=255.025n

* CHECK dout1_35 Vdout1_35ck50 = 0 time = 255
.meas tran vdout1_35ck50 FIND v(dout1_35) AT=255.025n

* CHECK dout1_36 Vdout1_36ck50 = 0 time = 255
.meas tran vdout1_36ck50 FIND v(dout1_36) AT=255.025n

* CHECK dout1_37 Vdout1_37ck50 = 0 time = 255
.meas tran vdout1_37ck50 FIND v(dout1_37) AT=255.025n

* CHECK dout1_38 Vdout1_38ck50 = 0.9 time = 255
.meas tran vdout1_38ck50 FIND v(dout1_38) AT=255.025n

* CHECK dout1_39 Vdout1_39ck50 = 0 time = 255
.meas tran vdout1_39ck50 FIND v(dout1_39) AT=255.025n

* CHECK dout1_40 Vdout1_40ck50 = 0 time = 255
.meas tran vdout1_40ck50 FIND v(dout1_40) AT=255.025n

* CHECK dout1_41 Vdout1_41ck50 = 0.9 time = 255
.meas tran vdout1_41ck50 FIND v(dout1_41) AT=255.025n

* CHECK dout1_42 Vdout1_42ck50 = 0.9 time = 255
.meas tran vdout1_42ck50 FIND v(dout1_42) AT=255.025n

* CHECK dout1_43 Vdout1_43ck50 = 0.9 time = 255
.meas tran vdout1_43ck50 FIND v(dout1_43) AT=255.025n

* CHECK dout1_44 Vdout1_44ck50 = 0.9 time = 255
.meas tran vdout1_44ck50 FIND v(dout1_44) AT=255.025n

* CHECK dout1_45 Vdout1_45ck50 = 0 time = 255
.meas tran vdout1_45ck50 FIND v(dout1_45) AT=255.025n

* CHECK dout1_46 Vdout1_46ck50 = 0.9 time = 255
.meas tran vdout1_46ck50 FIND v(dout1_46) AT=255.025n

* CHECK dout1_47 Vdout1_47ck50 = 0.9 time = 255
.meas tran vdout1_47ck50 FIND v(dout1_47) AT=255.025n

* CHECK dout1_48 Vdout1_48ck50 = 0.9 time = 255
.meas tran vdout1_48ck50 FIND v(dout1_48) AT=255.025n

* CHECK dout1_49 Vdout1_49ck50 = 0.9 time = 255
.meas tran vdout1_49ck50 FIND v(dout1_49) AT=255.025n

* CHECK dout1_50 Vdout1_50ck50 = 0.9 time = 255
.meas tran vdout1_50ck50 FIND v(dout1_50) AT=255.025n

* CHECK dout1_51 Vdout1_51ck50 = 0.9 time = 255
.meas tran vdout1_51ck50 FIND v(dout1_51) AT=255.025n

* CHECK dout1_52 Vdout1_52ck50 = 0.9 time = 255
.meas tran vdout1_52ck50 FIND v(dout1_52) AT=255.025n

* CHECK dout1_53 Vdout1_53ck50 = 0 time = 255
.meas tran vdout1_53ck50 FIND v(dout1_53) AT=255.025n

* CHECK dout1_54 Vdout1_54ck50 = 0 time = 255
.meas tran vdout1_54ck50 FIND v(dout1_54) AT=255.025n

* CHECK dout1_55 Vdout1_55ck50 = 0.9 time = 255
.meas tran vdout1_55ck50 FIND v(dout1_55) AT=255.025n

* CHECK dout1_56 Vdout1_56ck50 = 0.9 time = 255
.meas tran vdout1_56ck50 FIND v(dout1_56) AT=255.025n

* CHECK dout1_57 Vdout1_57ck50 = 0.9 time = 255
.meas tran vdout1_57ck50 FIND v(dout1_57) AT=255.025n

* CHECK dout1_58 Vdout1_58ck50 = 0 time = 255
.meas tran vdout1_58ck50 FIND v(dout1_58) AT=255.025n

* CHECK dout1_59 Vdout1_59ck50 = 0.9 time = 255
.meas tran vdout1_59ck50 FIND v(dout1_59) AT=255.025n

* CHECK dout1_60 Vdout1_60ck50 = 0.9 time = 255
.meas tran vdout1_60ck50 FIND v(dout1_60) AT=255.025n

* CHECK dout1_61 Vdout1_61ck50 = 0.9 time = 255
.meas tran vdout1_61ck50 FIND v(dout1_61) AT=255.025n

* CHECK dout1_62 Vdout1_62ck50 = 0.9 time = 255
.meas tran vdout1_62ck50 FIND v(dout1_62) AT=255.025n

* CHECK dout1_63 Vdout1_63ck50 = 0 time = 255
.meas tran vdout1_63ck50 FIND v(dout1_63) AT=255.025n

* CHECK dout1_64 Vdout1_64ck50 = 0 time = 255
.meas tran vdout1_64ck50 FIND v(dout1_64) AT=255.025n

* CHECK dout1_65 Vdout1_65ck50 = 0.9 time = 255
.meas tran vdout1_65ck50 FIND v(dout1_65) AT=255.025n

* CHECK dout1_66 Vdout1_66ck50 = 0 time = 255
.meas tran vdout1_66ck50 FIND v(dout1_66) AT=255.025n

* CHECK dout1_67 Vdout1_67ck50 = 0.9 time = 255
.meas tran vdout1_67ck50 FIND v(dout1_67) AT=255.025n

* CHECK dout1_68 Vdout1_68ck50 = 0.9 time = 255
.meas tran vdout1_68ck50 FIND v(dout1_68) AT=255.025n

* CHECK dout1_69 Vdout1_69ck50 = 0 time = 255
.meas tran vdout1_69ck50 FIND v(dout1_69) AT=255.025n

* CHECK dout1_70 Vdout1_70ck50 = 0 time = 255
.meas tran vdout1_70ck50 FIND v(dout1_70) AT=255.025n

* CHECK dout1_71 Vdout1_71ck50 = 0.9 time = 255
.meas tran vdout1_71ck50 FIND v(dout1_71) AT=255.025n

* CHECK dout1_72 Vdout1_72ck50 = 0.9 time = 255
.meas tran vdout1_72ck50 FIND v(dout1_72) AT=255.025n

* CHECK dout1_73 Vdout1_73ck50 = 0 time = 255
.meas tran vdout1_73ck50 FIND v(dout1_73) AT=255.025n

* CHECK dout1_74 Vdout1_74ck50 = 0 time = 255
.meas tran vdout1_74ck50 FIND v(dout1_74) AT=255.025n

* CHECK dout1_75 Vdout1_75ck50 = 0 time = 255
.meas tran vdout1_75ck50 FIND v(dout1_75) AT=255.025n

* CHECK dout1_76 Vdout1_76ck50 = 0 time = 255
.meas tran vdout1_76ck50 FIND v(dout1_76) AT=255.025n

* CHECK dout1_77 Vdout1_77ck50 = 0 time = 255
.meas tran vdout1_77ck50 FIND v(dout1_77) AT=255.025n

* CHECK dout1_78 Vdout1_78ck50 = 0.9 time = 255
.meas tran vdout1_78ck50 FIND v(dout1_78) AT=255.025n

* CHECK dout1_79 Vdout1_79ck50 = 0.9 time = 255
.meas tran vdout1_79ck50 FIND v(dout1_79) AT=255.025n

* CHECK dout1_80 Vdout1_80ck50 = 0.9 time = 255
.meas tran vdout1_80ck50 FIND v(dout1_80) AT=255.025n

* CHECK dout1_81 Vdout1_81ck50 = 0 time = 255
.meas tran vdout1_81ck50 FIND v(dout1_81) AT=255.025n

* CHECK dout1_82 Vdout1_82ck50 = 0.9 time = 255
.meas tran vdout1_82ck50 FIND v(dout1_82) AT=255.025n

* CHECK dout1_83 Vdout1_83ck50 = 0 time = 255
.meas tran vdout1_83ck50 FIND v(dout1_83) AT=255.025n

* CHECK dout1_84 Vdout1_84ck50 = 0.9 time = 255
.meas tran vdout1_84ck50 FIND v(dout1_84) AT=255.025n

* CHECK dout1_85 Vdout1_85ck50 = 0 time = 255
.meas tran vdout1_85ck50 FIND v(dout1_85) AT=255.025n

* CHECK dout1_86 Vdout1_86ck50 = 0 time = 255
.meas tran vdout1_86ck50 FIND v(dout1_86) AT=255.025n

* CHECK dout1_87 Vdout1_87ck50 = 0 time = 255
.meas tran vdout1_87ck50 FIND v(dout1_87) AT=255.025n

* CHECK dout1_88 Vdout1_88ck50 = 0.9 time = 255
.meas tran vdout1_88ck50 FIND v(dout1_88) AT=255.025n

* CHECK dout1_89 Vdout1_89ck50 = 0 time = 255
.meas tran vdout1_89ck50 FIND v(dout1_89) AT=255.025n

* CHECK dout1_90 Vdout1_90ck50 = 0.9 time = 255
.meas tran vdout1_90ck50 FIND v(dout1_90) AT=255.025n

* CHECK dout1_91 Vdout1_91ck50 = 0.9 time = 255
.meas tran vdout1_91ck50 FIND v(dout1_91) AT=255.025n

* CHECK dout1_92 Vdout1_92ck50 = 0 time = 255
.meas tran vdout1_92ck50 FIND v(dout1_92) AT=255.025n

* CHECK dout1_93 Vdout1_93ck50 = 0.9 time = 255
.meas tran vdout1_93ck50 FIND v(dout1_93) AT=255.025n

* CHECK dout1_94 Vdout1_94ck50 = 0.9 time = 255
.meas tran vdout1_94ck50 FIND v(dout1_94) AT=255.025n

* CHECK dout1_95 Vdout1_95ck50 = 0 time = 255
.meas tran vdout1_95ck50 FIND v(dout1_95) AT=255.025n

* CHECK dout1_96 Vdout1_96ck50 = 0.9 time = 255
.meas tran vdout1_96ck50 FIND v(dout1_96) AT=255.025n

* CHECK dout1_97 Vdout1_97ck50 = 0.9 time = 255
.meas tran vdout1_97ck50 FIND v(dout1_97) AT=255.025n

* CHECK dout1_98 Vdout1_98ck50 = 0.9 time = 255
.meas tran vdout1_98ck50 FIND v(dout1_98) AT=255.025n

* CHECK dout1_99 Vdout1_99ck50 = 0 time = 255
.meas tran vdout1_99ck50 FIND v(dout1_99) AT=255.025n

* CHECK dout1_100 Vdout1_100ck50 = 0 time = 255
.meas tran vdout1_100ck50 FIND v(dout1_100) AT=255.025n

* CHECK dout1_101 Vdout1_101ck50 = 0.9 time = 255
.meas tran vdout1_101ck50 FIND v(dout1_101) AT=255.025n

* CHECK dout1_102 Vdout1_102ck50 = 0.9 time = 255
.meas tran vdout1_102ck50 FIND v(dout1_102) AT=255.025n

* CHECK dout1_103 Vdout1_103ck50 = 0 time = 255
.meas tran vdout1_103ck50 FIND v(dout1_103) AT=255.025n

* CHECK dout1_104 Vdout1_104ck50 = 0 time = 255
.meas tran vdout1_104ck50 FIND v(dout1_104) AT=255.025n

* CHECK dout1_105 Vdout1_105ck50 = 0.9 time = 255
.meas tran vdout1_105ck50 FIND v(dout1_105) AT=255.025n

* CHECK dout1_106 Vdout1_106ck50 = 0 time = 255
.meas tran vdout1_106ck50 FIND v(dout1_106) AT=255.025n

* CHECK dout1_107 Vdout1_107ck50 = 0 time = 255
.meas tran vdout1_107ck50 FIND v(dout1_107) AT=255.025n

* CHECK dout1_108 Vdout1_108ck50 = 0.9 time = 255
.meas tran vdout1_108ck50 FIND v(dout1_108) AT=255.025n

* CHECK dout1_109 Vdout1_109ck50 = 0 time = 255
.meas tran vdout1_109ck50 FIND v(dout1_109) AT=255.025n

* CHECK dout1_110 Vdout1_110ck50 = 0.9 time = 255
.meas tran vdout1_110ck50 FIND v(dout1_110) AT=255.025n

* CHECK dout1_111 Vdout1_111ck50 = 0 time = 255
.meas tran vdout1_111ck50 FIND v(dout1_111) AT=255.025n

* CHECK dout1_112 Vdout1_112ck50 = 0.9 time = 255
.meas tran vdout1_112ck50 FIND v(dout1_112) AT=255.025n

* CHECK dout1_113 Vdout1_113ck50 = 0.9 time = 255
.meas tran vdout1_113ck50 FIND v(dout1_113) AT=255.025n

* CHECK dout1_114 Vdout1_114ck50 = 0.9 time = 255
.meas tran vdout1_114ck50 FIND v(dout1_114) AT=255.025n

* CHECK dout1_115 Vdout1_115ck50 = 0.9 time = 255
.meas tran vdout1_115ck50 FIND v(dout1_115) AT=255.025n

* CHECK dout1_116 Vdout1_116ck50 = 0.9 time = 255
.meas tran vdout1_116ck50 FIND v(dout1_116) AT=255.025n

* CHECK dout1_117 Vdout1_117ck50 = 0.9 time = 255
.meas tran vdout1_117ck50 FIND v(dout1_117) AT=255.025n

* CHECK dout1_118 Vdout1_118ck50 = 0 time = 255
.meas tran vdout1_118ck50 FIND v(dout1_118) AT=255.025n

* CHECK dout1_119 Vdout1_119ck50 = 0.9 time = 255
.meas tran vdout1_119ck50 FIND v(dout1_119) AT=255.025n

* CHECK dout1_0 Vdout1_0ck52 = 0.9 time = 265
.meas tran vdout1_0ck52 FIND v(dout1_0) AT=265.025n

* CHECK dout1_1 Vdout1_1ck52 = 0.9 time = 265
.meas tran vdout1_1ck52 FIND v(dout1_1) AT=265.025n

* CHECK dout1_2 Vdout1_2ck52 = 0.9 time = 265
.meas tran vdout1_2ck52 FIND v(dout1_2) AT=265.025n

* CHECK dout1_3 Vdout1_3ck52 = 0 time = 265
.meas tran vdout1_3ck52 FIND v(dout1_3) AT=265.025n

* CHECK dout1_4 Vdout1_4ck52 = 0.9 time = 265
.meas tran vdout1_4ck52 FIND v(dout1_4) AT=265.025n

* CHECK dout1_5 Vdout1_5ck52 = 0 time = 265
.meas tran vdout1_5ck52 FIND v(dout1_5) AT=265.025n

* CHECK dout1_6 Vdout1_6ck52 = 0 time = 265
.meas tran vdout1_6ck52 FIND v(dout1_6) AT=265.025n

* CHECK dout1_7 Vdout1_7ck52 = 0 time = 265
.meas tran vdout1_7ck52 FIND v(dout1_7) AT=265.025n

* CHECK dout1_8 Vdout1_8ck52 = 0 time = 265
.meas tran vdout1_8ck52 FIND v(dout1_8) AT=265.025n

* CHECK dout1_9 Vdout1_9ck52 = 0.9 time = 265
.meas tran vdout1_9ck52 FIND v(dout1_9) AT=265.025n

* CHECK dout1_10 Vdout1_10ck52 = 0 time = 265
.meas tran vdout1_10ck52 FIND v(dout1_10) AT=265.025n

* CHECK dout1_11 Vdout1_11ck52 = 0.9 time = 265
.meas tran vdout1_11ck52 FIND v(dout1_11) AT=265.025n

* CHECK dout1_12 Vdout1_12ck52 = 0 time = 265
.meas tran vdout1_12ck52 FIND v(dout1_12) AT=265.025n

* CHECK dout1_13 Vdout1_13ck52 = 0 time = 265
.meas tran vdout1_13ck52 FIND v(dout1_13) AT=265.025n

* CHECK dout1_14 Vdout1_14ck52 = 0 time = 265
.meas tran vdout1_14ck52 FIND v(dout1_14) AT=265.025n

* CHECK dout1_15 Vdout1_15ck52 = 0.9 time = 265
.meas tran vdout1_15ck52 FIND v(dout1_15) AT=265.025n

* CHECK dout1_16 Vdout1_16ck52 = 0.9 time = 265
.meas tran vdout1_16ck52 FIND v(dout1_16) AT=265.025n

* CHECK dout1_17 Vdout1_17ck52 = 0.9 time = 265
.meas tran vdout1_17ck52 FIND v(dout1_17) AT=265.025n

* CHECK dout1_18 Vdout1_18ck52 = 0.9 time = 265
.meas tran vdout1_18ck52 FIND v(dout1_18) AT=265.025n

* CHECK dout1_19 Vdout1_19ck52 = 0 time = 265
.meas tran vdout1_19ck52 FIND v(dout1_19) AT=265.025n

* CHECK dout1_20 Vdout1_20ck52 = 0 time = 265
.meas tran vdout1_20ck52 FIND v(dout1_20) AT=265.025n

* CHECK dout1_21 Vdout1_21ck52 = 0.9 time = 265
.meas tran vdout1_21ck52 FIND v(dout1_21) AT=265.025n

* CHECK dout1_22 Vdout1_22ck52 = 0 time = 265
.meas tran vdout1_22ck52 FIND v(dout1_22) AT=265.025n

* CHECK dout1_23 Vdout1_23ck52 = 0.9 time = 265
.meas tran vdout1_23ck52 FIND v(dout1_23) AT=265.025n

* CHECK dout1_24 Vdout1_24ck52 = 0 time = 265
.meas tran vdout1_24ck52 FIND v(dout1_24) AT=265.025n

* CHECK dout1_25 Vdout1_25ck52 = 0 time = 265
.meas tran vdout1_25ck52 FIND v(dout1_25) AT=265.025n

* CHECK dout1_26 Vdout1_26ck52 = 0.9 time = 265
.meas tran vdout1_26ck52 FIND v(dout1_26) AT=265.025n

* CHECK dout1_27 Vdout1_27ck52 = 0.9 time = 265
.meas tran vdout1_27ck52 FIND v(dout1_27) AT=265.025n

* CHECK dout1_28 Vdout1_28ck52 = 0.9 time = 265
.meas tran vdout1_28ck52 FIND v(dout1_28) AT=265.025n

* CHECK dout1_29 Vdout1_29ck52 = 0 time = 265
.meas tran vdout1_29ck52 FIND v(dout1_29) AT=265.025n

* CHECK dout1_30 Vdout1_30ck52 = 0 time = 265
.meas tran vdout1_30ck52 FIND v(dout1_30) AT=265.025n

* CHECK dout1_31 Vdout1_31ck52 = 0 time = 265
.meas tran vdout1_31ck52 FIND v(dout1_31) AT=265.025n

* CHECK dout1_32 Vdout1_32ck52 = 0.9 time = 265
.meas tran vdout1_32ck52 FIND v(dout1_32) AT=265.025n

* CHECK dout1_33 Vdout1_33ck52 = 0.9 time = 265
.meas tran vdout1_33ck52 FIND v(dout1_33) AT=265.025n

* CHECK dout1_34 Vdout1_34ck52 = 0 time = 265
.meas tran vdout1_34ck52 FIND v(dout1_34) AT=265.025n

* CHECK dout1_35 Vdout1_35ck52 = 0 time = 265
.meas tran vdout1_35ck52 FIND v(dout1_35) AT=265.025n

* CHECK dout1_36 Vdout1_36ck52 = 0 time = 265
.meas tran vdout1_36ck52 FIND v(dout1_36) AT=265.025n

* CHECK dout1_37 Vdout1_37ck52 = 0 time = 265
.meas tran vdout1_37ck52 FIND v(dout1_37) AT=265.025n

* CHECK dout1_38 Vdout1_38ck52 = 0.9 time = 265
.meas tran vdout1_38ck52 FIND v(dout1_38) AT=265.025n

* CHECK dout1_39 Vdout1_39ck52 = 0.9 time = 265
.meas tran vdout1_39ck52 FIND v(dout1_39) AT=265.025n

* CHECK dout1_40 Vdout1_40ck52 = 0.9 time = 265
.meas tran vdout1_40ck52 FIND v(dout1_40) AT=265.025n

* CHECK dout1_41 Vdout1_41ck52 = 0.9 time = 265
.meas tran vdout1_41ck52 FIND v(dout1_41) AT=265.025n

* CHECK dout1_42 Vdout1_42ck52 = 0 time = 265
.meas tran vdout1_42ck52 FIND v(dout1_42) AT=265.025n

* CHECK dout1_43 Vdout1_43ck52 = 0 time = 265
.meas tran vdout1_43ck52 FIND v(dout1_43) AT=265.025n

* CHECK dout1_44 Vdout1_44ck52 = 0.9 time = 265
.meas tran vdout1_44ck52 FIND v(dout1_44) AT=265.025n

* CHECK dout1_45 Vdout1_45ck52 = 0.9 time = 265
.meas tran vdout1_45ck52 FIND v(dout1_45) AT=265.025n

* CHECK dout1_46 Vdout1_46ck52 = 0 time = 265
.meas tran vdout1_46ck52 FIND v(dout1_46) AT=265.025n

* CHECK dout1_47 Vdout1_47ck52 = 0 time = 265
.meas tran vdout1_47ck52 FIND v(dout1_47) AT=265.025n

* CHECK dout1_48 Vdout1_48ck52 = 0 time = 265
.meas tran vdout1_48ck52 FIND v(dout1_48) AT=265.025n

* CHECK dout1_49 Vdout1_49ck52 = 0.9 time = 265
.meas tran vdout1_49ck52 FIND v(dout1_49) AT=265.025n

* CHECK dout1_50 Vdout1_50ck52 = 0.9 time = 265
.meas tran vdout1_50ck52 FIND v(dout1_50) AT=265.025n

* CHECK dout1_51 Vdout1_51ck52 = 0 time = 265
.meas tran vdout1_51ck52 FIND v(dout1_51) AT=265.025n

* CHECK dout1_52 Vdout1_52ck52 = 0.9 time = 265
.meas tran vdout1_52ck52 FIND v(dout1_52) AT=265.025n

* CHECK dout1_53 Vdout1_53ck52 = 0.9 time = 265
.meas tran vdout1_53ck52 FIND v(dout1_53) AT=265.025n

* CHECK dout1_54 Vdout1_54ck52 = 0 time = 265
.meas tran vdout1_54ck52 FIND v(dout1_54) AT=265.025n

* CHECK dout1_55 Vdout1_55ck52 = 0.9 time = 265
.meas tran vdout1_55ck52 FIND v(dout1_55) AT=265.025n

* CHECK dout1_56 Vdout1_56ck52 = 0 time = 265
.meas tran vdout1_56ck52 FIND v(dout1_56) AT=265.025n

* CHECK dout1_57 Vdout1_57ck52 = 0 time = 265
.meas tran vdout1_57ck52 FIND v(dout1_57) AT=265.025n

* CHECK dout1_58 Vdout1_58ck52 = 0 time = 265
.meas tran vdout1_58ck52 FIND v(dout1_58) AT=265.025n

* CHECK dout1_59 Vdout1_59ck52 = 0.9 time = 265
.meas tran vdout1_59ck52 FIND v(dout1_59) AT=265.025n

* CHECK dout1_60 Vdout1_60ck52 = 0 time = 265
.meas tran vdout1_60ck52 FIND v(dout1_60) AT=265.025n

* CHECK dout1_61 Vdout1_61ck52 = 0 time = 265
.meas tran vdout1_61ck52 FIND v(dout1_61) AT=265.025n

* CHECK dout1_62 Vdout1_62ck52 = 0 time = 265
.meas tran vdout1_62ck52 FIND v(dout1_62) AT=265.025n

* CHECK dout1_63 Vdout1_63ck52 = 0.9 time = 265
.meas tran vdout1_63ck52 FIND v(dout1_63) AT=265.025n

* CHECK dout1_64 Vdout1_64ck52 = 0 time = 265
.meas tran vdout1_64ck52 FIND v(dout1_64) AT=265.025n

* CHECK dout1_65 Vdout1_65ck52 = 0.9 time = 265
.meas tran vdout1_65ck52 FIND v(dout1_65) AT=265.025n

* CHECK dout1_66 Vdout1_66ck52 = 0 time = 265
.meas tran vdout1_66ck52 FIND v(dout1_66) AT=265.025n

* CHECK dout1_67 Vdout1_67ck52 = 0 time = 265
.meas tran vdout1_67ck52 FIND v(dout1_67) AT=265.025n

* CHECK dout1_68 Vdout1_68ck52 = 0 time = 265
.meas tran vdout1_68ck52 FIND v(dout1_68) AT=265.025n

* CHECK dout1_69 Vdout1_69ck52 = 0.9 time = 265
.meas tran vdout1_69ck52 FIND v(dout1_69) AT=265.025n

* CHECK dout1_70 Vdout1_70ck52 = 0 time = 265
.meas tran vdout1_70ck52 FIND v(dout1_70) AT=265.025n

* CHECK dout1_71 Vdout1_71ck52 = 0.9 time = 265
.meas tran vdout1_71ck52 FIND v(dout1_71) AT=265.025n

* CHECK dout1_72 Vdout1_72ck52 = 0 time = 265
.meas tran vdout1_72ck52 FIND v(dout1_72) AT=265.025n

* CHECK dout1_73 Vdout1_73ck52 = 0.9 time = 265
.meas tran vdout1_73ck52 FIND v(dout1_73) AT=265.025n

* CHECK dout1_74 Vdout1_74ck52 = 0 time = 265
.meas tran vdout1_74ck52 FIND v(dout1_74) AT=265.025n

* CHECK dout1_75 Vdout1_75ck52 = 0 time = 265
.meas tran vdout1_75ck52 FIND v(dout1_75) AT=265.025n

* CHECK dout1_76 Vdout1_76ck52 = 0.9 time = 265
.meas tran vdout1_76ck52 FIND v(dout1_76) AT=265.025n

* CHECK dout1_77 Vdout1_77ck52 = 0.9 time = 265
.meas tran vdout1_77ck52 FIND v(dout1_77) AT=265.025n

* CHECK dout1_78 Vdout1_78ck52 = 0.9 time = 265
.meas tran vdout1_78ck52 FIND v(dout1_78) AT=265.025n

* CHECK dout1_79 Vdout1_79ck52 = 0.9 time = 265
.meas tran vdout1_79ck52 FIND v(dout1_79) AT=265.025n

* CHECK dout1_80 Vdout1_80ck52 = 0.9 time = 265
.meas tran vdout1_80ck52 FIND v(dout1_80) AT=265.025n

* CHECK dout1_81 Vdout1_81ck52 = 0.9 time = 265
.meas tran vdout1_81ck52 FIND v(dout1_81) AT=265.025n

* CHECK dout1_82 Vdout1_82ck52 = 0 time = 265
.meas tran vdout1_82ck52 FIND v(dout1_82) AT=265.025n

* CHECK dout1_83 Vdout1_83ck52 = 0 time = 265
.meas tran vdout1_83ck52 FIND v(dout1_83) AT=265.025n

* CHECK dout1_84 Vdout1_84ck52 = 0 time = 265
.meas tran vdout1_84ck52 FIND v(dout1_84) AT=265.025n

* CHECK dout1_85 Vdout1_85ck52 = 0 time = 265
.meas tran vdout1_85ck52 FIND v(dout1_85) AT=265.025n

* CHECK dout1_86 Vdout1_86ck52 = 0 time = 265
.meas tran vdout1_86ck52 FIND v(dout1_86) AT=265.025n

* CHECK dout1_87 Vdout1_87ck52 = 0.9 time = 265
.meas tran vdout1_87ck52 FIND v(dout1_87) AT=265.025n

* CHECK dout1_88 Vdout1_88ck52 = 0.9 time = 265
.meas tran vdout1_88ck52 FIND v(dout1_88) AT=265.025n

* CHECK dout1_89 Vdout1_89ck52 = 0.9 time = 265
.meas tran vdout1_89ck52 FIND v(dout1_89) AT=265.025n

* CHECK dout1_90 Vdout1_90ck52 = 0 time = 265
.meas tran vdout1_90ck52 FIND v(dout1_90) AT=265.025n

* CHECK dout1_91 Vdout1_91ck52 = 0 time = 265
.meas tran vdout1_91ck52 FIND v(dout1_91) AT=265.025n

* CHECK dout1_92 Vdout1_92ck52 = 0.9 time = 265
.meas tran vdout1_92ck52 FIND v(dout1_92) AT=265.025n

* CHECK dout1_93 Vdout1_93ck52 = 0 time = 265
.meas tran vdout1_93ck52 FIND v(dout1_93) AT=265.025n

* CHECK dout1_94 Vdout1_94ck52 = 0 time = 265
.meas tran vdout1_94ck52 FIND v(dout1_94) AT=265.025n

* CHECK dout1_95 Vdout1_95ck52 = 0 time = 265
.meas tran vdout1_95ck52 FIND v(dout1_95) AT=265.025n

* CHECK dout1_96 Vdout1_96ck52 = 0.9 time = 265
.meas tran vdout1_96ck52 FIND v(dout1_96) AT=265.025n

* CHECK dout1_97 Vdout1_97ck52 = 0 time = 265
.meas tran vdout1_97ck52 FIND v(dout1_97) AT=265.025n

* CHECK dout1_98 Vdout1_98ck52 = 0.9 time = 265
.meas tran vdout1_98ck52 FIND v(dout1_98) AT=265.025n

* CHECK dout1_99 Vdout1_99ck52 = 0 time = 265
.meas tran vdout1_99ck52 FIND v(dout1_99) AT=265.025n

* CHECK dout1_100 Vdout1_100ck52 = 0.9 time = 265
.meas tran vdout1_100ck52 FIND v(dout1_100) AT=265.025n

* CHECK dout1_101 Vdout1_101ck52 = 0.9 time = 265
.meas tran vdout1_101ck52 FIND v(dout1_101) AT=265.025n

* CHECK dout1_102 Vdout1_102ck52 = 0.9 time = 265
.meas tran vdout1_102ck52 FIND v(dout1_102) AT=265.025n

* CHECK dout1_103 Vdout1_103ck52 = 0 time = 265
.meas tran vdout1_103ck52 FIND v(dout1_103) AT=265.025n

* CHECK dout1_104 Vdout1_104ck52 = 0.9 time = 265
.meas tran vdout1_104ck52 FIND v(dout1_104) AT=265.025n

* CHECK dout1_105 Vdout1_105ck52 = 0 time = 265
.meas tran vdout1_105ck52 FIND v(dout1_105) AT=265.025n

* CHECK dout1_106 Vdout1_106ck52 = 0 time = 265
.meas tran vdout1_106ck52 FIND v(dout1_106) AT=265.025n

* CHECK dout1_107 Vdout1_107ck52 = 0 time = 265
.meas tran vdout1_107ck52 FIND v(dout1_107) AT=265.025n

* CHECK dout1_108 Vdout1_108ck52 = 0.9 time = 265
.meas tran vdout1_108ck52 FIND v(dout1_108) AT=265.025n

* CHECK dout1_109 Vdout1_109ck52 = 0.9 time = 265
.meas tran vdout1_109ck52 FIND v(dout1_109) AT=265.025n

* CHECK dout1_110 Vdout1_110ck52 = 0 time = 265
.meas tran vdout1_110ck52 FIND v(dout1_110) AT=265.025n

* CHECK dout1_111 Vdout1_111ck52 = 0.9 time = 265
.meas tran vdout1_111ck52 FIND v(dout1_111) AT=265.025n

* CHECK dout1_112 Vdout1_112ck52 = 0.9 time = 265
.meas tran vdout1_112ck52 FIND v(dout1_112) AT=265.025n

* CHECK dout1_113 Vdout1_113ck52 = 0 time = 265
.meas tran vdout1_113ck52 FIND v(dout1_113) AT=265.025n

* CHECK dout1_114 Vdout1_114ck52 = 0 time = 265
.meas tran vdout1_114ck52 FIND v(dout1_114) AT=265.025n

* CHECK dout1_115 Vdout1_115ck52 = 0.9 time = 265
.meas tran vdout1_115ck52 FIND v(dout1_115) AT=265.025n

* CHECK dout1_116 Vdout1_116ck52 = 0 time = 265
.meas tran vdout1_116ck52 FIND v(dout1_116) AT=265.025n

* CHECK dout1_117 Vdout1_117ck52 = 0 time = 265
.meas tran vdout1_117ck52 FIND v(dout1_117) AT=265.025n

* CHECK dout1_118 Vdout1_118ck52 = 0 time = 265
.meas tran vdout1_118ck52 FIND v(dout1_118) AT=265.025n

* CHECK dout1_119 Vdout1_119ck52 = 0 time = 265
.meas tran vdout1_119ck52 FIND v(dout1_119) AT=265.025n

* CHECK dout1_0 Vdout1_0ck54 = 0 time = 275
.meas tran vdout1_0ck54 FIND v(dout1_0) AT=275.025n

* CHECK dout1_1 Vdout1_1ck54 = 0.9 time = 275
.meas tran vdout1_1ck54 FIND v(dout1_1) AT=275.025n

* CHECK dout1_2 Vdout1_2ck54 = 0.9 time = 275
.meas tran vdout1_2ck54 FIND v(dout1_2) AT=275.025n

* CHECK dout1_3 Vdout1_3ck54 = 0.9 time = 275
.meas tran vdout1_3ck54 FIND v(dout1_3) AT=275.025n

* CHECK dout1_4 Vdout1_4ck54 = 0 time = 275
.meas tran vdout1_4ck54 FIND v(dout1_4) AT=275.025n

* CHECK dout1_5 Vdout1_5ck54 = 0 time = 275
.meas tran vdout1_5ck54 FIND v(dout1_5) AT=275.025n

* CHECK dout1_6 Vdout1_6ck54 = 0 time = 275
.meas tran vdout1_6ck54 FIND v(dout1_6) AT=275.025n

* CHECK dout1_7 Vdout1_7ck54 = 0 time = 275
.meas tran vdout1_7ck54 FIND v(dout1_7) AT=275.025n

* CHECK dout1_8 Vdout1_8ck54 = 0.9 time = 275
.meas tran vdout1_8ck54 FIND v(dout1_8) AT=275.025n

* CHECK dout1_9 Vdout1_9ck54 = 0.9 time = 275
.meas tran vdout1_9ck54 FIND v(dout1_9) AT=275.025n

* CHECK dout1_10 Vdout1_10ck54 = 0.9 time = 275
.meas tran vdout1_10ck54 FIND v(dout1_10) AT=275.025n

* CHECK dout1_11 Vdout1_11ck54 = 0.9 time = 275
.meas tran vdout1_11ck54 FIND v(dout1_11) AT=275.025n

* CHECK dout1_12 Vdout1_12ck54 = 0.9 time = 275
.meas tran vdout1_12ck54 FIND v(dout1_12) AT=275.025n

* CHECK dout1_13 Vdout1_13ck54 = 0.9 time = 275
.meas tran vdout1_13ck54 FIND v(dout1_13) AT=275.025n

* CHECK dout1_14 Vdout1_14ck54 = 0.9 time = 275
.meas tran vdout1_14ck54 FIND v(dout1_14) AT=275.025n

* CHECK dout1_15 Vdout1_15ck54 = 0 time = 275
.meas tran vdout1_15ck54 FIND v(dout1_15) AT=275.025n

* CHECK dout1_16 Vdout1_16ck54 = 0 time = 275
.meas tran vdout1_16ck54 FIND v(dout1_16) AT=275.025n

* CHECK dout1_17 Vdout1_17ck54 = 0.9 time = 275
.meas tran vdout1_17ck54 FIND v(dout1_17) AT=275.025n

* CHECK dout1_18 Vdout1_18ck54 = 0.9 time = 275
.meas tran vdout1_18ck54 FIND v(dout1_18) AT=275.025n

* CHECK dout1_19 Vdout1_19ck54 = 0 time = 275
.meas tran vdout1_19ck54 FIND v(dout1_19) AT=275.025n

* CHECK dout1_20 Vdout1_20ck54 = 0 time = 275
.meas tran vdout1_20ck54 FIND v(dout1_20) AT=275.025n

* CHECK dout1_21 Vdout1_21ck54 = 0.9 time = 275
.meas tran vdout1_21ck54 FIND v(dout1_21) AT=275.025n

* CHECK dout1_22 Vdout1_22ck54 = 0.9 time = 275
.meas tran vdout1_22ck54 FIND v(dout1_22) AT=275.025n

* CHECK dout1_23 Vdout1_23ck54 = 0.9 time = 275
.meas tran vdout1_23ck54 FIND v(dout1_23) AT=275.025n

* CHECK dout1_24 Vdout1_24ck54 = 0 time = 275
.meas tran vdout1_24ck54 FIND v(dout1_24) AT=275.025n

* CHECK dout1_25 Vdout1_25ck54 = 0.9 time = 275
.meas tran vdout1_25ck54 FIND v(dout1_25) AT=275.025n

* CHECK dout1_26 Vdout1_26ck54 = 0 time = 275
.meas tran vdout1_26ck54 FIND v(dout1_26) AT=275.025n

* CHECK dout1_27 Vdout1_27ck54 = 0 time = 275
.meas tran vdout1_27ck54 FIND v(dout1_27) AT=275.025n

* CHECK dout1_28 Vdout1_28ck54 = 0 time = 275
.meas tran vdout1_28ck54 FIND v(dout1_28) AT=275.025n

* CHECK dout1_29 Vdout1_29ck54 = 0.9 time = 275
.meas tran vdout1_29ck54 FIND v(dout1_29) AT=275.025n

* CHECK dout1_30 Vdout1_30ck54 = 0.9 time = 275
.meas tran vdout1_30ck54 FIND v(dout1_30) AT=275.025n

* CHECK dout1_31 Vdout1_31ck54 = 0.9 time = 275
.meas tran vdout1_31ck54 FIND v(dout1_31) AT=275.025n

* CHECK dout1_32 Vdout1_32ck54 = 0.9 time = 275
.meas tran vdout1_32ck54 FIND v(dout1_32) AT=275.025n

* CHECK dout1_33 Vdout1_33ck54 = 0 time = 275
.meas tran vdout1_33ck54 FIND v(dout1_33) AT=275.025n

* CHECK dout1_34 Vdout1_34ck54 = 0.9 time = 275
.meas tran vdout1_34ck54 FIND v(dout1_34) AT=275.025n

* CHECK dout1_35 Vdout1_35ck54 = 0 time = 275
.meas tran vdout1_35ck54 FIND v(dout1_35) AT=275.025n

* CHECK dout1_36 Vdout1_36ck54 = 0 time = 275
.meas tran vdout1_36ck54 FIND v(dout1_36) AT=275.025n

* CHECK dout1_37 Vdout1_37ck54 = 0 time = 275
.meas tran vdout1_37ck54 FIND v(dout1_37) AT=275.025n

* CHECK dout1_38 Vdout1_38ck54 = 0.9 time = 275
.meas tran vdout1_38ck54 FIND v(dout1_38) AT=275.025n

* CHECK dout1_39 Vdout1_39ck54 = 0 time = 275
.meas tran vdout1_39ck54 FIND v(dout1_39) AT=275.025n

* CHECK dout1_40 Vdout1_40ck54 = 0 time = 275
.meas tran vdout1_40ck54 FIND v(dout1_40) AT=275.025n

* CHECK dout1_41 Vdout1_41ck54 = 0.9 time = 275
.meas tran vdout1_41ck54 FIND v(dout1_41) AT=275.025n

* CHECK dout1_42 Vdout1_42ck54 = 0.9 time = 275
.meas tran vdout1_42ck54 FIND v(dout1_42) AT=275.025n

* CHECK dout1_43 Vdout1_43ck54 = 0.9 time = 275
.meas tran vdout1_43ck54 FIND v(dout1_43) AT=275.025n

* CHECK dout1_44 Vdout1_44ck54 = 0.9 time = 275
.meas tran vdout1_44ck54 FIND v(dout1_44) AT=275.025n

* CHECK dout1_45 Vdout1_45ck54 = 0 time = 275
.meas tran vdout1_45ck54 FIND v(dout1_45) AT=275.025n

* CHECK dout1_46 Vdout1_46ck54 = 0.9 time = 275
.meas tran vdout1_46ck54 FIND v(dout1_46) AT=275.025n

* CHECK dout1_47 Vdout1_47ck54 = 0.9 time = 275
.meas tran vdout1_47ck54 FIND v(dout1_47) AT=275.025n

* CHECK dout1_48 Vdout1_48ck54 = 0.9 time = 275
.meas tran vdout1_48ck54 FIND v(dout1_48) AT=275.025n

* CHECK dout1_49 Vdout1_49ck54 = 0.9 time = 275
.meas tran vdout1_49ck54 FIND v(dout1_49) AT=275.025n

* CHECK dout1_50 Vdout1_50ck54 = 0.9 time = 275
.meas tran vdout1_50ck54 FIND v(dout1_50) AT=275.025n

* CHECK dout1_51 Vdout1_51ck54 = 0.9 time = 275
.meas tran vdout1_51ck54 FIND v(dout1_51) AT=275.025n

* CHECK dout1_52 Vdout1_52ck54 = 0.9 time = 275
.meas tran vdout1_52ck54 FIND v(dout1_52) AT=275.025n

* CHECK dout1_53 Vdout1_53ck54 = 0 time = 275
.meas tran vdout1_53ck54 FIND v(dout1_53) AT=275.025n

* CHECK dout1_54 Vdout1_54ck54 = 0 time = 275
.meas tran vdout1_54ck54 FIND v(dout1_54) AT=275.025n

* CHECK dout1_55 Vdout1_55ck54 = 0.9 time = 275
.meas tran vdout1_55ck54 FIND v(dout1_55) AT=275.025n

* CHECK dout1_56 Vdout1_56ck54 = 0.9 time = 275
.meas tran vdout1_56ck54 FIND v(dout1_56) AT=275.025n

* CHECK dout1_57 Vdout1_57ck54 = 0.9 time = 275
.meas tran vdout1_57ck54 FIND v(dout1_57) AT=275.025n

* CHECK dout1_58 Vdout1_58ck54 = 0 time = 275
.meas tran vdout1_58ck54 FIND v(dout1_58) AT=275.025n

* CHECK dout1_59 Vdout1_59ck54 = 0.9 time = 275
.meas tran vdout1_59ck54 FIND v(dout1_59) AT=275.025n

* CHECK dout1_60 Vdout1_60ck54 = 0.9 time = 275
.meas tran vdout1_60ck54 FIND v(dout1_60) AT=275.025n

* CHECK dout1_61 Vdout1_61ck54 = 0.9 time = 275
.meas tran vdout1_61ck54 FIND v(dout1_61) AT=275.025n

* CHECK dout1_62 Vdout1_62ck54 = 0.9 time = 275
.meas tran vdout1_62ck54 FIND v(dout1_62) AT=275.025n

* CHECK dout1_63 Vdout1_63ck54 = 0 time = 275
.meas tran vdout1_63ck54 FIND v(dout1_63) AT=275.025n

* CHECK dout1_64 Vdout1_64ck54 = 0 time = 275
.meas tran vdout1_64ck54 FIND v(dout1_64) AT=275.025n

* CHECK dout1_65 Vdout1_65ck54 = 0.9 time = 275
.meas tran vdout1_65ck54 FIND v(dout1_65) AT=275.025n

* CHECK dout1_66 Vdout1_66ck54 = 0 time = 275
.meas tran vdout1_66ck54 FIND v(dout1_66) AT=275.025n

* CHECK dout1_67 Vdout1_67ck54 = 0.9 time = 275
.meas tran vdout1_67ck54 FIND v(dout1_67) AT=275.025n

* CHECK dout1_68 Vdout1_68ck54 = 0.9 time = 275
.meas tran vdout1_68ck54 FIND v(dout1_68) AT=275.025n

* CHECK dout1_69 Vdout1_69ck54 = 0 time = 275
.meas tran vdout1_69ck54 FIND v(dout1_69) AT=275.025n

* CHECK dout1_70 Vdout1_70ck54 = 0 time = 275
.meas tran vdout1_70ck54 FIND v(dout1_70) AT=275.025n

* CHECK dout1_71 Vdout1_71ck54 = 0.9 time = 275
.meas tran vdout1_71ck54 FIND v(dout1_71) AT=275.025n

* CHECK dout1_72 Vdout1_72ck54 = 0.9 time = 275
.meas tran vdout1_72ck54 FIND v(dout1_72) AT=275.025n

* CHECK dout1_73 Vdout1_73ck54 = 0 time = 275
.meas tran vdout1_73ck54 FIND v(dout1_73) AT=275.025n

* CHECK dout1_74 Vdout1_74ck54 = 0 time = 275
.meas tran vdout1_74ck54 FIND v(dout1_74) AT=275.025n

* CHECK dout1_75 Vdout1_75ck54 = 0 time = 275
.meas tran vdout1_75ck54 FIND v(dout1_75) AT=275.025n

* CHECK dout1_76 Vdout1_76ck54 = 0 time = 275
.meas tran vdout1_76ck54 FIND v(dout1_76) AT=275.025n

* CHECK dout1_77 Vdout1_77ck54 = 0 time = 275
.meas tran vdout1_77ck54 FIND v(dout1_77) AT=275.025n

* CHECK dout1_78 Vdout1_78ck54 = 0.9 time = 275
.meas tran vdout1_78ck54 FIND v(dout1_78) AT=275.025n

* CHECK dout1_79 Vdout1_79ck54 = 0.9 time = 275
.meas tran vdout1_79ck54 FIND v(dout1_79) AT=275.025n

* CHECK dout1_80 Vdout1_80ck54 = 0.9 time = 275
.meas tran vdout1_80ck54 FIND v(dout1_80) AT=275.025n

* CHECK dout1_81 Vdout1_81ck54 = 0 time = 275
.meas tran vdout1_81ck54 FIND v(dout1_81) AT=275.025n

* CHECK dout1_82 Vdout1_82ck54 = 0.9 time = 275
.meas tran vdout1_82ck54 FIND v(dout1_82) AT=275.025n

* CHECK dout1_83 Vdout1_83ck54 = 0 time = 275
.meas tran vdout1_83ck54 FIND v(dout1_83) AT=275.025n

* CHECK dout1_84 Vdout1_84ck54 = 0.9 time = 275
.meas tran vdout1_84ck54 FIND v(dout1_84) AT=275.025n

* CHECK dout1_85 Vdout1_85ck54 = 0 time = 275
.meas tran vdout1_85ck54 FIND v(dout1_85) AT=275.025n

* CHECK dout1_86 Vdout1_86ck54 = 0 time = 275
.meas tran vdout1_86ck54 FIND v(dout1_86) AT=275.025n

* CHECK dout1_87 Vdout1_87ck54 = 0 time = 275
.meas tran vdout1_87ck54 FIND v(dout1_87) AT=275.025n

* CHECK dout1_88 Vdout1_88ck54 = 0.9 time = 275
.meas tran vdout1_88ck54 FIND v(dout1_88) AT=275.025n

* CHECK dout1_89 Vdout1_89ck54 = 0 time = 275
.meas tran vdout1_89ck54 FIND v(dout1_89) AT=275.025n

* CHECK dout1_90 Vdout1_90ck54 = 0.9 time = 275
.meas tran vdout1_90ck54 FIND v(dout1_90) AT=275.025n

* CHECK dout1_91 Vdout1_91ck54 = 0.9 time = 275
.meas tran vdout1_91ck54 FIND v(dout1_91) AT=275.025n

* CHECK dout1_92 Vdout1_92ck54 = 0 time = 275
.meas tran vdout1_92ck54 FIND v(dout1_92) AT=275.025n

* CHECK dout1_93 Vdout1_93ck54 = 0.9 time = 275
.meas tran vdout1_93ck54 FIND v(dout1_93) AT=275.025n

* CHECK dout1_94 Vdout1_94ck54 = 0.9 time = 275
.meas tran vdout1_94ck54 FIND v(dout1_94) AT=275.025n

* CHECK dout1_95 Vdout1_95ck54 = 0 time = 275
.meas tran vdout1_95ck54 FIND v(dout1_95) AT=275.025n

* CHECK dout1_96 Vdout1_96ck54 = 0.9 time = 275
.meas tran vdout1_96ck54 FIND v(dout1_96) AT=275.025n

* CHECK dout1_97 Vdout1_97ck54 = 0.9 time = 275
.meas tran vdout1_97ck54 FIND v(dout1_97) AT=275.025n

* CHECK dout1_98 Vdout1_98ck54 = 0.9 time = 275
.meas tran vdout1_98ck54 FIND v(dout1_98) AT=275.025n

* CHECK dout1_99 Vdout1_99ck54 = 0 time = 275
.meas tran vdout1_99ck54 FIND v(dout1_99) AT=275.025n

* CHECK dout1_100 Vdout1_100ck54 = 0 time = 275
.meas tran vdout1_100ck54 FIND v(dout1_100) AT=275.025n

* CHECK dout1_101 Vdout1_101ck54 = 0.9 time = 275
.meas tran vdout1_101ck54 FIND v(dout1_101) AT=275.025n

* CHECK dout1_102 Vdout1_102ck54 = 0.9 time = 275
.meas tran vdout1_102ck54 FIND v(dout1_102) AT=275.025n

* CHECK dout1_103 Vdout1_103ck54 = 0 time = 275
.meas tran vdout1_103ck54 FIND v(dout1_103) AT=275.025n

* CHECK dout1_104 Vdout1_104ck54 = 0 time = 275
.meas tran vdout1_104ck54 FIND v(dout1_104) AT=275.025n

* CHECK dout1_105 Vdout1_105ck54 = 0.9 time = 275
.meas tran vdout1_105ck54 FIND v(dout1_105) AT=275.025n

* CHECK dout1_106 Vdout1_106ck54 = 0 time = 275
.meas tran vdout1_106ck54 FIND v(dout1_106) AT=275.025n

* CHECK dout1_107 Vdout1_107ck54 = 0 time = 275
.meas tran vdout1_107ck54 FIND v(dout1_107) AT=275.025n

* CHECK dout1_108 Vdout1_108ck54 = 0.9 time = 275
.meas tran vdout1_108ck54 FIND v(dout1_108) AT=275.025n

* CHECK dout1_109 Vdout1_109ck54 = 0 time = 275
.meas tran vdout1_109ck54 FIND v(dout1_109) AT=275.025n

* CHECK dout1_110 Vdout1_110ck54 = 0.9 time = 275
.meas tran vdout1_110ck54 FIND v(dout1_110) AT=275.025n

* CHECK dout1_111 Vdout1_111ck54 = 0 time = 275
.meas tran vdout1_111ck54 FIND v(dout1_111) AT=275.025n

* CHECK dout1_112 Vdout1_112ck54 = 0.9 time = 275
.meas tran vdout1_112ck54 FIND v(dout1_112) AT=275.025n

* CHECK dout1_113 Vdout1_113ck54 = 0.9 time = 275
.meas tran vdout1_113ck54 FIND v(dout1_113) AT=275.025n

* CHECK dout1_114 Vdout1_114ck54 = 0.9 time = 275
.meas tran vdout1_114ck54 FIND v(dout1_114) AT=275.025n

* CHECK dout1_115 Vdout1_115ck54 = 0.9 time = 275
.meas tran vdout1_115ck54 FIND v(dout1_115) AT=275.025n

* CHECK dout1_116 Vdout1_116ck54 = 0.9 time = 275
.meas tran vdout1_116ck54 FIND v(dout1_116) AT=275.025n

* CHECK dout1_117 Vdout1_117ck54 = 0.9 time = 275
.meas tran vdout1_117ck54 FIND v(dout1_117) AT=275.025n

* CHECK dout1_118 Vdout1_118ck54 = 0 time = 275
.meas tran vdout1_118ck54 FIND v(dout1_118) AT=275.025n

* CHECK dout1_119 Vdout1_119ck54 = 0.9 time = 275
.meas tran vdout1_119ck54 FIND v(dout1_119) AT=275.025n

* CHECK dout1_0 Vdout1_0ck61 = 0 time = 310
.meas tran vdout1_0ck61 FIND v(dout1_0) AT=310.025n

* CHECK dout1_1 Vdout1_1ck61 = 0.9 time = 310
.meas tran vdout1_1ck61 FIND v(dout1_1) AT=310.025n

* CHECK dout1_2 Vdout1_2ck61 = 0.9 time = 310
.meas tran vdout1_2ck61 FIND v(dout1_2) AT=310.025n

* CHECK dout1_3 Vdout1_3ck61 = 0 time = 310
.meas tran vdout1_3ck61 FIND v(dout1_3) AT=310.025n

* CHECK dout1_4 Vdout1_4ck61 = 0.9 time = 310
.meas tran vdout1_4ck61 FIND v(dout1_4) AT=310.025n

* CHECK dout1_5 Vdout1_5ck61 = 0 time = 310
.meas tran vdout1_5ck61 FIND v(dout1_5) AT=310.025n

* CHECK dout1_6 Vdout1_6ck61 = 0.9 time = 310
.meas tran vdout1_6ck61 FIND v(dout1_6) AT=310.025n

* CHECK dout1_7 Vdout1_7ck61 = 0.9 time = 310
.meas tran vdout1_7ck61 FIND v(dout1_7) AT=310.025n

* CHECK dout1_8 Vdout1_8ck61 = 0 time = 310
.meas tran vdout1_8ck61 FIND v(dout1_8) AT=310.025n

* CHECK dout1_9 Vdout1_9ck61 = 0 time = 310
.meas tran vdout1_9ck61 FIND v(dout1_9) AT=310.025n

* CHECK dout1_10 Vdout1_10ck61 = 0 time = 310
.meas tran vdout1_10ck61 FIND v(dout1_10) AT=310.025n

* CHECK dout1_11 Vdout1_11ck61 = 0.9 time = 310
.meas tran vdout1_11ck61 FIND v(dout1_11) AT=310.025n

* CHECK dout1_12 Vdout1_12ck61 = 0 time = 310
.meas tran vdout1_12ck61 FIND v(dout1_12) AT=310.025n

* CHECK dout1_13 Vdout1_13ck61 = 0.9 time = 310
.meas tran vdout1_13ck61 FIND v(dout1_13) AT=310.025n

* CHECK dout1_14 Vdout1_14ck61 = 0 time = 310
.meas tran vdout1_14ck61 FIND v(dout1_14) AT=310.025n

* CHECK dout1_15 Vdout1_15ck61 = 0.9 time = 310
.meas tran vdout1_15ck61 FIND v(dout1_15) AT=310.025n

* CHECK dout1_16 Vdout1_16ck61 = 0 time = 310
.meas tran vdout1_16ck61 FIND v(dout1_16) AT=310.025n

* CHECK dout1_17 Vdout1_17ck61 = 0.9 time = 310
.meas tran vdout1_17ck61 FIND v(dout1_17) AT=310.025n

* CHECK dout1_18 Vdout1_18ck61 = 0.9 time = 310
.meas tran vdout1_18ck61 FIND v(dout1_18) AT=310.025n

* CHECK dout1_19 Vdout1_19ck61 = 0.9 time = 310
.meas tran vdout1_19ck61 FIND v(dout1_19) AT=310.025n

* CHECK dout1_20 Vdout1_20ck61 = 0.9 time = 310
.meas tran vdout1_20ck61 FIND v(dout1_20) AT=310.025n

* CHECK dout1_21 Vdout1_21ck61 = 0.9 time = 310
.meas tran vdout1_21ck61 FIND v(dout1_21) AT=310.025n

* CHECK dout1_22 Vdout1_22ck61 = 0.9 time = 310
.meas tran vdout1_22ck61 FIND v(dout1_22) AT=310.025n

* CHECK dout1_23 Vdout1_23ck61 = 0 time = 310
.meas tran vdout1_23ck61 FIND v(dout1_23) AT=310.025n

* CHECK dout1_24 Vdout1_24ck61 = 0.9 time = 310
.meas tran vdout1_24ck61 FIND v(dout1_24) AT=310.025n

* CHECK dout1_25 Vdout1_25ck61 = 0 time = 310
.meas tran vdout1_25ck61 FIND v(dout1_25) AT=310.025n

* CHECK dout1_26 Vdout1_26ck61 = 0 time = 310
.meas tran vdout1_26ck61 FIND v(dout1_26) AT=310.025n

* CHECK dout1_27 Vdout1_27ck61 = 0 time = 310
.meas tran vdout1_27ck61 FIND v(dout1_27) AT=310.025n

* CHECK dout1_28 Vdout1_28ck61 = 0.9 time = 310
.meas tran vdout1_28ck61 FIND v(dout1_28) AT=310.025n

* CHECK dout1_29 Vdout1_29ck61 = 0.9 time = 310
.meas tran vdout1_29ck61 FIND v(dout1_29) AT=310.025n

* CHECK dout1_30 Vdout1_30ck61 = 0.9 time = 310
.meas tran vdout1_30ck61 FIND v(dout1_30) AT=310.025n

* CHECK dout1_31 Vdout1_31ck61 = 0.9 time = 310
.meas tran vdout1_31ck61 FIND v(dout1_31) AT=310.025n

* CHECK dout1_32 Vdout1_32ck61 = 0 time = 310
.meas tran vdout1_32ck61 FIND v(dout1_32) AT=310.025n

* CHECK dout1_33 Vdout1_33ck61 = 0.9 time = 310
.meas tran vdout1_33ck61 FIND v(dout1_33) AT=310.025n

* CHECK dout1_34 Vdout1_34ck61 = 0.9 time = 310
.meas tran vdout1_34ck61 FIND v(dout1_34) AT=310.025n

* CHECK dout1_35 Vdout1_35ck61 = 0.9 time = 310
.meas tran vdout1_35ck61 FIND v(dout1_35) AT=310.025n

* CHECK dout1_36 Vdout1_36ck61 = 0 time = 310
.meas tran vdout1_36ck61 FIND v(dout1_36) AT=310.025n

* CHECK dout1_37 Vdout1_37ck61 = 0.9 time = 310
.meas tran vdout1_37ck61 FIND v(dout1_37) AT=310.025n

* CHECK dout1_38 Vdout1_38ck61 = 0 time = 310
.meas tran vdout1_38ck61 FIND v(dout1_38) AT=310.025n

* CHECK dout1_39 Vdout1_39ck61 = 0 time = 310
.meas tran vdout1_39ck61 FIND v(dout1_39) AT=310.025n

* CHECK dout1_40 Vdout1_40ck61 = 0.9 time = 310
.meas tran vdout1_40ck61 FIND v(dout1_40) AT=310.025n

* CHECK dout1_41 Vdout1_41ck61 = 0 time = 310
.meas tran vdout1_41ck61 FIND v(dout1_41) AT=310.025n

* CHECK dout1_42 Vdout1_42ck61 = 0.9 time = 310
.meas tran vdout1_42ck61 FIND v(dout1_42) AT=310.025n

* CHECK dout1_43 Vdout1_43ck61 = 0.9 time = 310
.meas tran vdout1_43ck61 FIND v(dout1_43) AT=310.025n

* CHECK dout1_44 Vdout1_44ck61 = 0.9 time = 310
.meas tran vdout1_44ck61 FIND v(dout1_44) AT=310.025n

* CHECK dout1_45 Vdout1_45ck61 = 0 time = 310
.meas tran vdout1_45ck61 FIND v(dout1_45) AT=310.025n

* CHECK dout1_46 Vdout1_46ck61 = 0.9 time = 310
.meas tran vdout1_46ck61 FIND v(dout1_46) AT=310.025n

* CHECK dout1_47 Vdout1_47ck61 = 0 time = 310
.meas tran vdout1_47ck61 FIND v(dout1_47) AT=310.025n

* CHECK dout1_48 Vdout1_48ck61 = 0.9 time = 310
.meas tran vdout1_48ck61 FIND v(dout1_48) AT=310.025n

* CHECK dout1_49 Vdout1_49ck61 = 0 time = 310
.meas tran vdout1_49ck61 FIND v(dout1_49) AT=310.025n

* CHECK dout1_50 Vdout1_50ck61 = 0.9 time = 310
.meas tran vdout1_50ck61 FIND v(dout1_50) AT=310.025n

* CHECK dout1_51 Vdout1_51ck61 = 0.9 time = 310
.meas tran vdout1_51ck61 FIND v(dout1_51) AT=310.025n

* CHECK dout1_52 Vdout1_52ck61 = 0 time = 310
.meas tran vdout1_52ck61 FIND v(dout1_52) AT=310.025n

* CHECK dout1_53 Vdout1_53ck61 = 0 time = 310
.meas tran vdout1_53ck61 FIND v(dout1_53) AT=310.025n

* CHECK dout1_54 Vdout1_54ck61 = 0.9 time = 310
.meas tran vdout1_54ck61 FIND v(dout1_54) AT=310.025n

* CHECK dout1_55 Vdout1_55ck61 = 0.9 time = 310
.meas tran vdout1_55ck61 FIND v(dout1_55) AT=310.025n

* CHECK dout1_56 Vdout1_56ck61 = 0.9 time = 310
.meas tran vdout1_56ck61 FIND v(dout1_56) AT=310.025n

* CHECK dout1_57 Vdout1_57ck61 = 0.9 time = 310
.meas tran vdout1_57ck61 FIND v(dout1_57) AT=310.025n

* CHECK dout1_58 Vdout1_58ck61 = 0 time = 310
.meas tran vdout1_58ck61 FIND v(dout1_58) AT=310.025n

* CHECK dout1_59 Vdout1_59ck61 = 0.9 time = 310
.meas tran vdout1_59ck61 FIND v(dout1_59) AT=310.025n

* CHECK dout1_60 Vdout1_60ck61 = 0 time = 310
.meas tran vdout1_60ck61 FIND v(dout1_60) AT=310.025n

* CHECK dout1_61 Vdout1_61ck61 = 0 time = 310
.meas tran vdout1_61ck61 FIND v(dout1_61) AT=310.025n

* CHECK dout1_62 Vdout1_62ck61 = 0.9 time = 310
.meas tran vdout1_62ck61 FIND v(dout1_62) AT=310.025n

* CHECK dout1_63 Vdout1_63ck61 = 0 time = 310
.meas tran vdout1_63ck61 FIND v(dout1_63) AT=310.025n

* CHECK dout1_64 Vdout1_64ck61 = 0.9 time = 310
.meas tran vdout1_64ck61 FIND v(dout1_64) AT=310.025n

* CHECK dout1_65 Vdout1_65ck61 = 0 time = 310
.meas tran vdout1_65ck61 FIND v(dout1_65) AT=310.025n

* CHECK dout1_66 Vdout1_66ck61 = 0 time = 310
.meas tran vdout1_66ck61 FIND v(dout1_66) AT=310.025n

* CHECK dout1_67 Vdout1_67ck61 = 0.9 time = 310
.meas tran vdout1_67ck61 FIND v(dout1_67) AT=310.025n

* CHECK dout1_68 Vdout1_68ck61 = 0.9 time = 310
.meas tran vdout1_68ck61 FIND v(dout1_68) AT=310.025n

* CHECK dout1_69 Vdout1_69ck61 = 0 time = 310
.meas tran vdout1_69ck61 FIND v(dout1_69) AT=310.025n

* CHECK dout1_70 Vdout1_70ck61 = 0 time = 310
.meas tran vdout1_70ck61 FIND v(dout1_70) AT=310.025n

* CHECK dout1_71 Vdout1_71ck61 = 0 time = 310
.meas tran vdout1_71ck61 FIND v(dout1_71) AT=310.025n

* CHECK dout1_72 Vdout1_72ck61 = 0.9 time = 310
.meas tran vdout1_72ck61 FIND v(dout1_72) AT=310.025n

* CHECK dout1_73 Vdout1_73ck61 = 0.9 time = 310
.meas tran vdout1_73ck61 FIND v(dout1_73) AT=310.025n

* CHECK dout1_74 Vdout1_74ck61 = 0 time = 310
.meas tran vdout1_74ck61 FIND v(dout1_74) AT=310.025n

* CHECK dout1_75 Vdout1_75ck61 = 0.9 time = 310
.meas tran vdout1_75ck61 FIND v(dout1_75) AT=310.025n

* CHECK dout1_76 Vdout1_76ck61 = 0 time = 310
.meas tran vdout1_76ck61 FIND v(dout1_76) AT=310.025n

* CHECK dout1_77 Vdout1_77ck61 = 0 time = 310
.meas tran vdout1_77ck61 FIND v(dout1_77) AT=310.025n

* CHECK dout1_78 Vdout1_78ck61 = 0 time = 310
.meas tran vdout1_78ck61 FIND v(dout1_78) AT=310.025n

* CHECK dout1_79 Vdout1_79ck61 = 0 time = 310
.meas tran vdout1_79ck61 FIND v(dout1_79) AT=310.025n

* CHECK dout1_80 Vdout1_80ck61 = 0 time = 310
.meas tran vdout1_80ck61 FIND v(dout1_80) AT=310.025n

* CHECK dout1_81 Vdout1_81ck61 = 0.9 time = 310
.meas tran vdout1_81ck61 FIND v(dout1_81) AT=310.025n

* CHECK dout1_82 Vdout1_82ck61 = 0 time = 310
.meas tran vdout1_82ck61 FIND v(dout1_82) AT=310.025n

* CHECK dout1_83 Vdout1_83ck61 = 0.9 time = 310
.meas tran vdout1_83ck61 FIND v(dout1_83) AT=310.025n

* CHECK dout1_84 Vdout1_84ck61 = 0 time = 310
.meas tran vdout1_84ck61 FIND v(dout1_84) AT=310.025n

* CHECK dout1_85 Vdout1_85ck61 = 0 time = 310
.meas tran vdout1_85ck61 FIND v(dout1_85) AT=310.025n

* CHECK dout1_86 Vdout1_86ck61 = 0 time = 310
.meas tran vdout1_86ck61 FIND v(dout1_86) AT=310.025n

* CHECK dout1_87 Vdout1_87ck61 = 0 time = 310
.meas tran vdout1_87ck61 FIND v(dout1_87) AT=310.025n

* CHECK dout1_88 Vdout1_88ck61 = 0.9 time = 310
.meas tran vdout1_88ck61 FIND v(dout1_88) AT=310.025n

* CHECK dout1_89 Vdout1_89ck61 = 0.9 time = 310
.meas tran vdout1_89ck61 FIND v(dout1_89) AT=310.025n

* CHECK dout1_90 Vdout1_90ck61 = 0 time = 310
.meas tran vdout1_90ck61 FIND v(dout1_90) AT=310.025n

* CHECK dout1_91 Vdout1_91ck61 = 0 time = 310
.meas tran vdout1_91ck61 FIND v(dout1_91) AT=310.025n

* CHECK dout1_92 Vdout1_92ck61 = 0 time = 310
.meas tran vdout1_92ck61 FIND v(dout1_92) AT=310.025n

* CHECK dout1_93 Vdout1_93ck61 = 0.9 time = 310
.meas tran vdout1_93ck61 FIND v(dout1_93) AT=310.025n

* CHECK dout1_94 Vdout1_94ck61 = 0.9 time = 310
.meas tran vdout1_94ck61 FIND v(dout1_94) AT=310.025n

* CHECK dout1_95 Vdout1_95ck61 = 0.9 time = 310
.meas tran vdout1_95ck61 FIND v(dout1_95) AT=310.025n

* CHECK dout1_96 Vdout1_96ck61 = 0 time = 310
.meas tran vdout1_96ck61 FIND v(dout1_96) AT=310.025n

* CHECK dout1_97 Vdout1_97ck61 = 0 time = 310
.meas tran vdout1_97ck61 FIND v(dout1_97) AT=310.025n

* CHECK dout1_98 Vdout1_98ck61 = 0.9 time = 310
.meas tran vdout1_98ck61 FIND v(dout1_98) AT=310.025n

* CHECK dout1_99 Vdout1_99ck61 = 0.9 time = 310
.meas tran vdout1_99ck61 FIND v(dout1_99) AT=310.025n

* CHECK dout1_100 Vdout1_100ck61 = 0.9 time = 310
.meas tran vdout1_100ck61 FIND v(dout1_100) AT=310.025n

* CHECK dout1_101 Vdout1_101ck61 = 0.9 time = 310
.meas tran vdout1_101ck61 FIND v(dout1_101) AT=310.025n

* CHECK dout1_102 Vdout1_102ck61 = 0.9 time = 310
.meas tran vdout1_102ck61 FIND v(dout1_102) AT=310.025n

* CHECK dout1_103 Vdout1_103ck61 = 0 time = 310
.meas tran vdout1_103ck61 FIND v(dout1_103) AT=310.025n

* CHECK dout1_104 Vdout1_104ck61 = 0 time = 310
.meas tran vdout1_104ck61 FIND v(dout1_104) AT=310.025n

* CHECK dout1_105 Vdout1_105ck61 = 0.9 time = 310
.meas tran vdout1_105ck61 FIND v(dout1_105) AT=310.025n

* CHECK dout1_106 Vdout1_106ck61 = 0.9 time = 310
.meas tran vdout1_106ck61 FIND v(dout1_106) AT=310.025n

* CHECK dout1_107 Vdout1_107ck61 = 0 time = 310
.meas tran vdout1_107ck61 FIND v(dout1_107) AT=310.025n

* CHECK dout1_108 Vdout1_108ck61 = 0 time = 310
.meas tran vdout1_108ck61 FIND v(dout1_108) AT=310.025n

* CHECK dout1_109 Vdout1_109ck61 = 0 time = 310
.meas tran vdout1_109ck61 FIND v(dout1_109) AT=310.025n

* CHECK dout1_110 Vdout1_110ck61 = 0.9 time = 310
.meas tran vdout1_110ck61 FIND v(dout1_110) AT=310.025n

* CHECK dout1_111 Vdout1_111ck61 = 0 time = 310
.meas tran vdout1_111ck61 FIND v(dout1_111) AT=310.025n

* CHECK dout1_112 Vdout1_112ck61 = 0.9 time = 310
.meas tran vdout1_112ck61 FIND v(dout1_112) AT=310.025n

* CHECK dout1_113 Vdout1_113ck61 = 0 time = 310
.meas tran vdout1_113ck61 FIND v(dout1_113) AT=310.025n

* CHECK dout1_114 Vdout1_114ck61 = 0 time = 310
.meas tran vdout1_114ck61 FIND v(dout1_114) AT=310.025n

* CHECK dout1_115 Vdout1_115ck61 = 0.9 time = 310
.meas tran vdout1_115ck61 FIND v(dout1_115) AT=310.025n

* CHECK dout1_116 Vdout1_116ck61 = 0 time = 310
.meas tran vdout1_116ck61 FIND v(dout1_116) AT=310.025n

* CHECK dout1_117 Vdout1_117ck61 = 0 time = 310
.meas tran vdout1_117ck61 FIND v(dout1_117) AT=310.025n

* CHECK dout1_118 Vdout1_118ck61 = 0.9 time = 310
.meas tran vdout1_118ck61 FIND v(dout1_118) AT=310.025n

* CHECK dout1_119 Vdout1_119ck61 = 0 time = 310
.meas tran vdout1_119ck61 FIND v(dout1_119) AT=310.025n

* CHECK dout1_0 Vdout1_0ck62 = 0 time = 315
.meas tran vdout1_0ck62 FIND v(dout1_0) AT=315.025n

* CHECK dout1_1 Vdout1_1ck62 = 0.9 time = 315
.meas tran vdout1_1ck62 FIND v(dout1_1) AT=315.025n

* CHECK dout1_2 Vdout1_2ck62 = 0.9 time = 315
.meas tran vdout1_2ck62 FIND v(dout1_2) AT=315.025n

* CHECK dout1_3 Vdout1_3ck62 = 0 time = 315
.meas tran vdout1_3ck62 FIND v(dout1_3) AT=315.025n

* CHECK dout1_4 Vdout1_4ck62 = 0.9 time = 315
.meas tran vdout1_4ck62 FIND v(dout1_4) AT=315.025n

* CHECK dout1_5 Vdout1_5ck62 = 0 time = 315
.meas tran vdout1_5ck62 FIND v(dout1_5) AT=315.025n

* CHECK dout1_6 Vdout1_6ck62 = 0.9 time = 315
.meas tran vdout1_6ck62 FIND v(dout1_6) AT=315.025n

* CHECK dout1_7 Vdout1_7ck62 = 0.9 time = 315
.meas tran vdout1_7ck62 FIND v(dout1_7) AT=315.025n

* CHECK dout1_8 Vdout1_8ck62 = 0 time = 315
.meas tran vdout1_8ck62 FIND v(dout1_8) AT=315.025n

* CHECK dout1_9 Vdout1_9ck62 = 0 time = 315
.meas tran vdout1_9ck62 FIND v(dout1_9) AT=315.025n

* CHECK dout1_10 Vdout1_10ck62 = 0 time = 315
.meas tran vdout1_10ck62 FIND v(dout1_10) AT=315.025n

* CHECK dout1_11 Vdout1_11ck62 = 0.9 time = 315
.meas tran vdout1_11ck62 FIND v(dout1_11) AT=315.025n

* CHECK dout1_12 Vdout1_12ck62 = 0 time = 315
.meas tran vdout1_12ck62 FIND v(dout1_12) AT=315.025n

* CHECK dout1_13 Vdout1_13ck62 = 0.9 time = 315
.meas tran vdout1_13ck62 FIND v(dout1_13) AT=315.025n

* CHECK dout1_14 Vdout1_14ck62 = 0 time = 315
.meas tran vdout1_14ck62 FIND v(dout1_14) AT=315.025n

* CHECK dout1_15 Vdout1_15ck62 = 0.9 time = 315
.meas tran vdout1_15ck62 FIND v(dout1_15) AT=315.025n

* CHECK dout1_16 Vdout1_16ck62 = 0 time = 315
.meas tran vdout1_16ck62 FIND v(dout1_16) AT=315.025n

* CHECK dout1_17 Vdout1_17ck62 = 0.9 time = 315
.meas tran vdout1_17ck62 FIND v(dout1_17) AT=315.025n

* CHECK dout1_18 Vdout1_18ck62 = 0.9 time = 315
.meas tran vdout1_18ck62 FIND v(dout1_18) AT=315.025n

* CHECK dout1_19 Vdout1_19ck62 = 0.9 time = 315
.meas tran vdout1_19ck62 FIND v(dout1_19) AT=315.025n

* CHECK dout1_20 Vdout1_20ck62 = 0.9 time = 315
.meas tran vdout1_20ck62 FIND v(dout1_20) AT=315.025n

* CHECK dout1_21 Vdout1_21ck62 = 0.9 time = 315
.meas tran vdout1_21ck62 FIND v(dout1_21) AT=315.025n

* CHECK dout1_22 Vdout1_22ck62 = 0.9 time = 315
.meas tran vdout1_22ck62 FIND v(dout1_22) AT=315.025n

* CHECK dout1_23 Vdout1_23ck62 = 0 time = 315
.meas tran vdout1_23ck62 FIND v(dout1_23) AT=315.025n

* CHECK dout1_24 Vdout1_24ck62 = 0.9 time = 315
.meas tran vdout1_24ck62 FIND v(dout1_24) AT=315.025n

* CHECK dout1_25 Vdout1_25ck62 = 0 time = 315
.meas tran vdout1_25ck62 FIND v(dout1_25) AT=315.025n

* CHECK dout1_26 Vdout1_26ck62 = 0 time = 315
.meas tran vdout1_26ck62 FIND v(dout1_26) AT=315.025n

* CHECK dout1_27 Vdout1_27ck62 = 0 time = 315
.meas tran vdout1_27ck62 FIND v(dout1_27) AT=315.025n

* CHECK dout1_28 Vdout1_28ck62 = 0.9 time = 315
.meas tran vdout1_28ck62 FIND v(dout1_28) AT=315.025n

* CHECK dout1_29 Vdout1_29ck62 = 0.9 time = 315
.meas tran vdout1_29ck62 FIND v(dout1_29) AT=315.025n

* CHECK dout1_30 Vdout1_30ck62 = 0.9 time = 315
.meas tran vdout1_30ck62 FIND v(dout1_30) AT=315.025n

* CHECK dout1_31 Vdout1_31ck62 = 0.9 time = 315
.meas tran vdout1_31ck62 FIND v(dout1_31) AT=315.025n

* CHECK dout1_32 Vdout1_32ck62 = 0 time = 315
.meas tran vdout1_32ck62 FIND v(dout1_32) AT=315.025n

* CHECK dout1_33 Vdout1_33ck62 = 0.9 time = 315
.meas tran vdout1_33ck62 FIND v(dout1_33) AT=315.025n

* CHECK dout1_34 Vdout1_34ck62 = 0.9 time = 315
.meas tran vdout1_34ck62 FIND v(dout1_34) AT=315.025n

* CHECK dout1_35 Vdout1_35ck62 = 0.9 time = 315
.meas tran vdout1_35ck62 FIND v(dout1_35) AT=315.025n

* CHECK dout1_36 Vdout1_36ck62 = 0 time = 315
.meas tran vdout1_36ck62 FIND v(dout1_36) AT=315.025n

* CHECK dout1_37 Vdout1_37ck62 = 0.9 time = 315
.meas tran vdout1_37ck62 FIND v(dout1_37) AT=315.025n

* CHECK dout1_38 Vdout1_38ck62 = 0 time = 315
.meas tran vdout1_38ck62 FIND v(dout1_38) AT=315.025n

* CHECK dout1_39 Vdout1_39ck62 = 0 time = 315
.meas tran vdout1_39ck62 FIND v(dout1_39) AT=315.025n

* CHECK dout1_40 Vdout1_40ck62 = 0.9 time = 315
.meas tran vdout1_40ck62 FIND v(dout1_40) AT=315.025n

* CHECK dout1_41 Vdout1_41ck62 = 0 time = 315
.meas tran vdout1_41ck62 FIND v(dout1_41) AT=315.025n

* CHECK dout1_42 Vdout1_42ck62 = 0.9 time = 315
.meas tran vdout1_42ck62 FIND v(dout1_42) AT=315.025n

* CHECK dout1_43 Vdout1_43ck62 = 0.9 time = 315
.meas tran vdout1_43ck62 FIND v(dout1_43) AT=315.025n

* CHECK dout1_44 Vdout1_44ck62 = 0.9 time = 315
.meas tran vdout1_44ck62 FIND v(dout1_44) AT=315.025n

* CHECK dout1_45 Vdout1_45ck62 = 0 time = 315
.meas tran vdout1_45ck62 FIND v(dout1_45) AT=315.025n

* CHECK dout1_46 Vdout1_46ck62 = 0.9 time = 315
.meas tran vdout1_46ck62 FIND v(dout1_46) AT=315.025n

* CHECK dout1_47 Vdout1_47ck62 = 0 time = 315
.meas tran vdout1_47ck62 FIND v(dout1_47) AT=315.025n

* CHECK dout1_48 Vdout1_48ck62 = 0.9 time = 315
.meas tran vdout1_48ck62 FIND v(dout1_48) AT=315.025n

* CHECK dout1_49 Vdout1_49ck62 = 0 time = 315
.meas tran vdout1_49ck62 FIND v(dout1_49) AT=315.025n

* CHECK dout1_50 Vdout1_50ck62 = 0.9 time = 315
.meas tran vdout1_50ck62 FIND v(dout1_50) AT=315.025n

* CHECK dout1_51 Vdout1_51ck62 = 0.9 time = 315
.meas tran vdout1_51ck62 FIND v(dout1_51) AT=315.025n

* CHECK dout1_52 Vdout1_52ck62 = 0 time = 315
.meas tran vdout1_52ck62 FIND v(dout1_52) AT=315.025n

* CHECK dout1_53 Vdout1_53ck62 = 0 time = 315
.meas tran vdout1_53ck62 FIND v(dout1_53) AT=315.025n

* CHECK dout1_54 Vdout1_54ck62 = 0.9 time = 315
.meas tran vdout1_54ck62 FIND v(dout1_54) AT=315.025n

* CHECK dout1_55 Vdout1_55ck62 = 0.9 time = 315
.meas tran vdout1_55ck62 FIND v(dout1_55) AT=315.025n

* CHECK dout1_56 Vdout1_56ck62 = 0.9 time = 315
.meas tran vdout1_56ck62 FIND v(dout1_56) AT=315.025n

* CHECK dout1_57 Vdout1_57ck62 = 0.9 time = 315
.meas tran vdout1_57ck62 FIND v(dout1_57) AT=315.025n

* CHECK dout1_58 Vdout1_58ck62 = 0 time = 315
.meas tran vdout1_58ck62 FIND v(dout1_58) AT=315.025n

* CHECK dout1_59 Vdout1_59ck62 = 0.9 time = 315
.meas tran vdout1_59ck62 FIND v(dout1_59) AT=315.025n

* CHECK dout1_60 Vdout1_60ck62 = 0 time = 315
.meas tran vdout1_60ck62 FIND v(dout1_60) AT=315.025n

* CHECK dout1_61 Vdout1_61ck62 = 0 time = 315
.meas tran vdout1_61ck62 FIND v(dout1_61) AT=315.025n

* CHECK dout1_62 Vdout1_62ck62 = 0.9 time = 315
.meas tran vdout1_62ck62 FIND v(dout1_62) AT=315.025n

* CHECK dout1_63 Vdout1_63ck62 = 0 time = 315
.meas tran vdout1_63ck62 FIND v(dout1_63) AT=315.025n

* CHECK dout1_64 Vdout1_64ck62 = 0.9 time = 315
.meas tran vdout1_64ck62 FIND v(dout1_64) AT=315.025n

* CHECK dout1_65 Vdout1_65ck62 = 0 time = 315
.meas tran vdout1_65ck62 FIND v(dout1_65) AT=315.025n

* CHECK dout1_66 Vdout1_66ck62 = 0 time = 315
.meas tran vdout1_66ck62 FIND v(dout1_66) AT=315.025n

* CHECK dout1_67 Vdout1_67ck62 = 0.9 time = 315
.meas tran vdout1_67ck62 FIND v(dout1_67) AT=315.025n

* CHECK dout1_68 Vdout1_68ck62 = 0.9 time = 315
.meas tran vdout1_68ck62 FIND v(dout1_68) AT=315.025n

* CHECK dout1_69 Vdout1_69ck62 = 0 time = 315
.meas tran vdout1_69ck62 FIND v(dout1_69) AT=315.025n

* CHECK dout1_70 Vdout1_70ck62 = 0 time = 315
.meas tran vdout1_70ck62 FIND v(dout1_70) AT=315.025n

* CHECK dout1_71 Vdout1_71ck62 = 0 time = 315
.meas tran vdout1_71ck62 FIND v(dout1_71) AT=315.025n

* CHECK dout1_72 Vdout1_72ck62 = 0.9 time = 315
.meas tran vdout1_72ck62 FIND v(dout1_72) AT=315.025n

* CHECK dout1_73 Vdout1_73ck62 = 0.9 time = 315
.meas tran vdout1_73ck62 FIND v(dout1_73) AT=315.025n

* CHECK dout1_74 Vdout1_74ck62 = 0 time = 315
.meas tran vdout1_74ck62 FIND v(dout1_74) AT=315.025n

* CHECK dout1_75 Vdout1_75ck62 = 0.9 time = 315
.meas tran vdout1_75ck62 FIND v(dout1_75) AT=315.025n

* CHECK dout1_76 Vdout1_76ck62 = 0 time = 315
.meas tran vdout1_76ck62 FIND v(dout1_76) AT=315.025n

* CHECK dout1_77 Vdout1_77ck62 = 0 time = 315
.meas tran vdout1_77ck62 FIND v(dout1_77) AT=315.025n

* CHECK dout1_78 Vdout1_78ck62 = 0 time = 315
.meas tran vdout1_78ck62 FIND v(dout1_78) AT=315.025n

* CHECK dout1_79 Vdout1_79ck62 = 0 time = 315
.meas tran vdout1_79ck62 FIND v(dout1_79) AT=315.025n

* CHECK dout1_80 Vdout1_80ck62 = 0 time = 315
.meas tran vdout1_80ck62 FIND v(dout1_80) AT=315.025n

* CHECK dout1_81 Vdout1_81ck62 = 0.9 time = 315
.meas tran vdout1_81ck62 FIND v(dout1_81) AT=315.025n

* CHECK dout1_82 Vdout1_82ck62 = 0 time = 315
.meas tran vdout1_82ck62 FIND v(dout1_82) AT=315.025n

* CHECK dout1_83 Vdout1_83ck62 = 0.9 time = 315
.meas tran vdout1_83ck62 FIND v(dout1_83) AT=315.025n

* CHECK dout1_84 Vdout1_84ck62 = 0 time = 315
.meas tran vdout1_84ck62 FIND v(dout1_84) AT=315.025n

* CHECK dout1_85 Vdout1_85ck62 = 0 time = 315
.meas tran vdout1_85ck62 FIND v(dout1_85) AT=315.025n

* CHECK dout1_86 Vdout1_86ck62 = 0 time = 315
.meas tran vdout1_86ck62 FIND v(dout1_86) AT=315.025n

* CHECK dout1_87 Vdout1_87ck62 = 0 time = 315
.meas tran vdout1_87ck62 FIND v(dout1_87) AT=315.025n

* CHECK dout1_88 Vdout1_88ck62 = 0.9 time = 315
.meas tran vdout1_88ck62 FIND v(dout1_88) AT=315.025n

* CHECK dout1_89 Vdout1_89ck62 = 0.9 time = 315
.meas tran vdout1_89ck62 FIND v(dout1_89) AT=315.025n

* CHECK dout1_90 Vdout1_90ck62 = 0 time = 315
.meas tran vdout1_90ck62 FIND v(dout1_90) AT=315.025n

* CHECK dout1_91 Vdout1_91ck62 = 0 time = 315
.meas tran vdout1_91ck62 FIND v(dout1_91) AT=315.025n

* CHECK dout1_92 Vdout1_92ck62 = 0 time = 315
.meas tran vdout1_92ck62 FIND v(dout1_92) AT=315.025n

* CHECK dout1_93 Vdout1_93ck62 = 0.9 time = 315
.meas tran vdout1_93ck62 FIND v(dout1_93) AT=315.025n

* CHECK dout1_94 Vdout1_94ck62 = 0.9 time = 315
.meas tran vdout1_94ck62 FIND v(dout1_94) AT=315.025n

* CHECK dout1_95 Vdout1_95ck62 = 0.9 time = 315
.meas tran vdout1_95ck62 FIND v(dout1_95) AT=315.025n

* CHECK dout1_96 Vdout1_96ck62 = 0 time = 315
.meas tran vdout1_96ck62 FIND v(dout1_96) AT=315.025n

* CHECK dout1_97 Vdout1_97ck62 = 0 time = 315
.meas tran vdout1_97ck62 FIND v(dout1_97) AT=315.025n

* CHECK dout1_98 Vdout1_98ck62 = 0.9 time = 315
.meas tran vdout1_98ck62 FIND v(dout1_98) AT=315.025n

* CHECK dout1_99 Vdout1_99ck62 = 0.9 time = 315
.meas tran vdout1_99ck62 FIND v(dout1_99) AT=315.025n

* CHECK dout1_100 Vdout1_100ck62 = 0.9 time = 315
.meas tran vdout1_100ck62 FIND v(dout1_100) AT=315.025n

* CHECK dout1_101 Vdout1_101ck62 = 0.9 time = 315
.meas tran vdout1_101ck62 FIND v(dout1_101) AT=315.025n

* CHECK dout1_102 Vdout1_102ck62 = 0.9 time = 315
.meas tran vdout1_102ck62 FIND v(dout1_102) AT=315.025n

* CHECK dout1_103 Vdout1_103ck62 = 0 time = 315
.meas tran vdout1_103ck62 FIND v(dout1_103) AT=315.025n

* CHECK dout1_104 Vdout1_104ck62 = 0 time = 315
.meas tran vdout1_104ck62 FIND v(dout1_104) AT=315.025n

* CHECK dout1_105 Vdout1_105ck62 = 0.9 time = 315
.meas tran vdout1_105ck62 FIND v(dout1_105) AT=315.025n

* CHECK dout1_106 Vdout1_106ck62 = 0.9 time = 315
.meas tran vdout1_106ck62 FIND v(dout1_106) AT=315.025n

* CHECK dout1_107 Vdout1_107ck62 = 0 time = 315
.meas tran vdout1_107ck62 FIND v(dout1_107) AT=315.025n

* CHECK dout1_108 Vdout1_108ck62 = 0 time = 315
.meas tran vdout1_108ck62 FIND v(dout1_108) AT=315.025n

* CHECK dout1_109 Vdout1_109ck62 = 0 time = 315
.meas tran vdout1_109ck62 FIND v(dout1_109) AT=315.025n

* CHECK dout1_110 Vdout1_110ck62 = 0.9 time = 315
.meas tran vdout1_110ck62 FIND v(dout1_110) AT=315.025n

* CHECK dout1_111 Vdout1_111ck62 = 0 time = 315
.meas tran vdout1_111ck62 FIND v(dout1_111) AT=315.025n

* CHECK dout1_112 Vdout1_112ck62 = 0.9 time = 315
.meas tran vdout1_112ck62 FIND v(dout1_112) AT=315.025n

* CHECK dout1_113 Vdout1_113ck62 = 0 time = 315
.meas tran vdout1_113ck62 FIND v(dout1_113) AT=315.025n

* CHECK dout1_114 Vdout1_114ck62 = 0 time = 315
.meas tran vdout1_114ck62 FIND v(dout1_114) AT=315.025n

* CHECK dout1_115 Vdout1_115ck62 = 0.9 time = 315
.meas tran vdout1_115ck62 FIND v(dout1_115) AT=315.025n

* CHECK dout1_116 Vdout1_116ck62 = 0 time = 315
.meas tran vdout1_116ck62 FIND v(dout1_116) AT=315.025n

* CHECK dout1_117 Vdout1_117ck62 = 0 time = 315
.meas tran vdout1_117ck62 FIND v(dout1_117) AT=315.025n

* CHECK dout1_118 Vdout1_118ck62 = 0.9 time = 315
.meas tran vdout1_118ck62 FIND v(dout1_118) AT=315.025n

* CHECK dout1_119 Vdout1_119ck62 = 0 time = 315
.meas tran vdout1_119ck62 FIND v(dout1_119) AT=315.025n

* CHECK dout1_0 Vdout1_0ck66 = 0.9 time = 335
.meas tran vdout1_0ck66 FIND v(dout1_0) AT=335.025n

* CHECK dout1_1 Vdout1_1ck66 = 0.9 time = 335
.meas tran vdout1_1ck66 FIND v(dout1_1) AT=335.025n

* CHECK dout1_2 Vdout1_2ck66 = 0 time = 335
.meas tran vdout1_2ck66 FIND v(dout1_2) AT=335.025n

* CHECK dout1_3 Vdout1_3ck66 = 0.9 time = 335
.meas tran vdout1_3ck66 FIND v(dout1_3) AT=335.025n

* CHECK dout1_4 Vdout1_4ck66 = 0 time = 335
.meas tran vdout1_4ck66 FIND v(dout1_4) AT=335.025n

* CHECK dout1_5 Vdout1_5ck66 = 0.9 time = 335
.meas tran vdout1_5ck66 FIND v(dout1_5) AT=335.025n

* CHECK dout1_6 Vdout1_6ck66 = 0 time = 335
.meas tran vdout1_6ck66 FIND v(dout1_6) AT=335.025n

* CHECK dout1_7 Vdout1_7ck66 = 0.9 time = 335
.meas tran vdout1_7ck66 FIND v(dout1_7) AT=335.025n

* CHECK dout1_8 Vdout1_8ck66 = 0 time = 335
.meas tran vdout1_8ck66 FIND v(dout1_8) AT=335.025n

* CHECK dout1_9 Vdout1_9ck66 = 0.9 time = 335
.meas tran vdout1_9ck66 FIND v(dout1_9) AT=335.025n

* CHECK dout1_10 Vdout1_10ck66 = 0 time = 335
.meas tran vdout1_10ck66 FIND v(dout1_10) AT=335.025n

* CHECK dout1_11 Vdout1_11ck66 = 0.9 time = 335
.meas tran vdout1_11ck66 FIND v(dout1_11) AT=335.025n

* CHECK dout1_12 Vdout1_12ck66 = 0 time = 335
.meas tran vdout1_12ck66 FIND v(dout1_12) AT=335.025n

* CHECK dout1_13 Vdout1_13ck66 = 0.9 time = 335
.meas tran vdout1_13ck66 FIND v(dout1_13) AT=335.025n

* CHECK dout1_14 Vdout1_14ck66 = 0.9 time = 335
.meas tran vdout1_14ck66 FIND v(dout1_14) AT=335.025n

* CHECK dout1_15 Vdout1_15ck66 = 0.9 time = 335
.meas tran vdout1_15ck66 FIND v(dout1_15) AT=335.025n

* CHECK dout1_16 Vdout1_16ck66 = 0 time = 335
.meas tran vdout1_16ck66 FIND v(dout1_16) AT=335.025n

* CHECK dout1_17 Vdout1_17ck66 = 0.9 time = 335
.meas tran vdout1_17ck66 FIND v(dout1_17) AT=335.025n

* CHECK dout1_18 Vdout1_18ck66 = 0 time = 335
.meas tran vdout1_18ck66 FIND v(dout1_18) AT=335.025n

* CHECK dout1_19 Vdout1_19ck66 = 0.9 time = 335
.meas tran vdout1_19ck66 FIND v(dout1_19) AT=335.025n

* CHECK dout1_20 Vdout1_20ck66 = 0 time = 335
.meas tran vdout1_20ck66 FIND v(dout1_20) AT=335.025n

* CHECK dout1_21 Vdout1_21ck66 = 0 time = 335
.meas tran vdout1_21ck66 FIND v(dout1_21) AT=335.025n

* CHECK dout1_22 Vdout1_22ck66 = 0 time = 335
.meas tran vdout1_22ck66 FIND v(dout1_22) AT=335.025n

* CHECK dout1_23 Vdout1_23ck66 = 0 time = 335
.meas tran vdout1_23ck66 FIND v(dout1_23) AT=335.025n

* CHECK dout1_24 Vdout1_24ck66 = 0.9 time = 335
.meas tran vdout1_24ck66 FIND v(dout1_24) AT=335.025n

* CHECK dout1_25 Vdout1_25ck66 = 0 time = 335
.meas tran vdout1_25ck66 FIND v(dout1_25) AT=335.025n

* CHECK dout1_26 Vdout1_26ck66 = 0 time = 335
.meas tran vdout1_26ck66 FIND v(dout1_26) AT=335.025n

* CHECK dout1_27 Vdout1_27ck66 = 0.9 time = 335
.meas tran vdout1_27ck66 FIND v(dout1_27) AT=335.025n

* CHECK dout1_28 Vdout1_28ck66 = 0.9 time = 335
.meas tran vdout1_28ck66 FIND v(dout1_28) AT=335.025n

* CHECK dout1_29 Vdout1_29ck66 = 0.9 time = 335
.meas tran vdout1_29ck66 FIND v(dout1_29) AT=335.025n

* CHECK dout1_30 Vdout1_30ck66 = 0.9 time = 335
.meas tran vdout1_30ck66 FIND v(dout1_30) AT=335.025n

* CHECK dout1_31 Vdout1_31ck66 = 0.9 time = 335
.meas tran vdout1_31ck66 FIND v(dout1_31) AT=335.025n

* CHECK dout1_32 Vdout1_32ck66 = 0 time = 335
.meas tran vdout1_32ck66 FIND v(dout1_32) AT=335.025n

* CHECK dout1_33 Vdout1_33ck66 = 0.9 time = 335
.meas tran vdout1_33ck66 FIND v(dout1_33) AT=335.025n

* CHECK dout1_34 Vdout1_34ck66 = 0 time = 335
.meas tran vdout1_34ck66 FIND v(dout1_34) AT=335.025n

* CHECK dout1_35 Vdout1_35ck66 = 0 time = 335
.meas tran vdout1_35ck66 FIND v(dout1_35) AT=335.025n

* CHECK dout1_36 Vdout1_36ck66 = 0.9 time = 335
.meas tran vdout1_36ck66 FIND v(dout1_36) AT=335.025n

* CHECK dout1_37 Vdout1_37ck66 = 0.9 time = 335
.meas tran vdout1_37ck66 FIND v(dout1_37) AT=335.025n

* CHECK dout1_38 Vdout1_38ck66 = 0.9 time = 335
.meas tran vdout1_38ck66 FIND v(dout1_38) AT=335.025n

* CHECK dout1_39 Vdout1_39ck66 = 0 time = 335
.meas tran vdout1_39ck66 FIND v(dout1_39) AT=335.025n

* CHECK dout1_40 Vdout1_40ck66 = 0.9 time = 335
.meas tran vdout1_40ck66 FIND v(dout1_40) AT=335.025n

* CHECK dout1_41 Vdout1_41ck66 = 0 time = 335
.meas tran vdout1_41ck66 FIND v(dout1_41) AT=335.025n

* CHECK dout1_42 Vdout1_42ck66 = 0.9 time = 335
.meas tran vdout1_42ck66 FIND v(dout1_42) AT=335.025n

* CHECK dout1_43 Vdout1_43ck66 = 0.9 time = 335
.meas tran vdout1_43ck66 FIND v(dout1_43) AT=335.025n

* CHECK dout1_44 Vdout1_44ck66 = 0.9 time = 335
.meas tran vdout1_44ck66 FIND v(dout1_44) AT=335.025n

* CHECK dout1_45 Vdout1_45ck66 = 0 time = 335
.meas tran vdout1_45ck66 FIND v(dout1_45) AT=335.025n

* CHECK dout1_46 Vdout1_46ck66 = 0 time = 335
.meas tran vdout1_46ck66 FIND v(dout1_46) AT=335.025n

* CHECK dout1_47 Vdout1_47ck66 = 0 time = 335
.meas tran vdout1_47ck66 FIND v(dout1_47) AT=335.025n

* CHECK dout1_48 Vdout1_48ck66 = 0 time = 335
.meas tran vdout1_48ck66 FIND v(dout1_48) AT=335.025n

* CHECK dout1_49 Vdout1_49ck66 = 0.9 time = 335
.meas tran vdout1_49ck66 FIND v(dout1_49) AT=335.025n

* CHECK dout1_50 Vdout1_50ck66 = 0.9 time = 335
.meas tran vdout1_50ck66 FIND v(dout1_50) AT=335.025n

* CHECK dout1_51 Vdout1_51ck66 = 0 time = 335
.meas tran vdout1_51ck66 FIND v(dout1_51) AT=335.025n

* CHECK dout1_52 Vdout1_52ck66 = 0 time = 335
.meas tran vdout1_52ck66 FIND v(dout1_52) AT=335.025n

* CHECK dout1_53 Vdout1_53ck66 = 0.9 time = 335
.meas tran vdout1_53ck66 FIND v(dout1_53) AT=335.025n

* CHECK dout1_54 Vdout1_54ck66 = 0 time = 335
.meas tran vdout1_54ck66 FIND v(dout1_54) AT=335.025n

* CHECK dout1_55 Vdout1_55ck66 = 0.9 time = 335
.meas tran vdout1_55ck66 FIND v(dout1_55) AT=335.025n

* CHECK dout1_56 Vdout1_56ck66 = 0 time = 335
.meas tran vdout1_56ck66 FIND v(dout1_56) AT=335.025n

* CHECK dout1_57 Vdout1_57ck66 = 0 time = 335
.meas tran vdout1_57ck66 FIND v(dout1_57) AT=335.025n

* CHECK dout1_58 Vdout1_58ck66 = 0.9 time = 335
.meas tran vdout1_58ck66 FIND v(dout1_58) AT=335.025n

* CHECK dout1_59 Vdout1_59ck66 = 0 time = 335
.meas tran vdout1_59ck66 FIND v(dout1_59) AT=335.025n

* CHECK dout1_60 Vdout1_60ck66 = 0 time = 335
.meas tran vdout1_60ck66 FIND v(dout1_60) AT=335.025n

* CHECK dout1_61 Vdout1_61ck66 = 0 time = 335
.meas tran vdout1_61ck66 FIND v(dout1_61) AT=335.025n

* CHECK dout1_62 Vdout1_62ck66 = 0 time = 335
.meas tran vdout1_62ck66 FIND v(dout1_62) AT=335.025n

* CHECK dout1_63 Vdout1_63ck66 = 0.9 time = 335
.meas tran vdout1_63ck66 FIND v(dout1_63) AT=335.025n

* CHECK dout1_64 Vdout1_64ck66 = 0.9 time = 335
.meas tran vdout1_64ck66 FIND v(dout1_64) AT=335.025n

* CHECK dout1_65 Vdout1_65ck66 = 0.9 time = 335
.meas tran vdout1_65ck66 FIND v(dout1_65) AT=335.025n

* CHECK dout1_66 Vdout1_66ck66 = 0.9 time = 335
.meas tran vdout1_66ck66 FIND v(dout1_66) AT=335.025n

* CHECK dout1_67 Vdout1_67ck66 = 0 time = 335
.meas tran vdout1_67ck66 FIND v(dout1_67) AT=335.025n

* CHECK dout1_68 Vdout1_68ck66 = 0 time = 335
.meas tran vdout1_68ck66 FIND v(dout1_68) AT=335.025n

* CHECK dout1_69 Vdout1_69ck66 = 0.9 time = 335
.meas tran vdout1_69ck66 FIND v(dout1_69) AT=335.025n

* CHECK dout1_70 Vdout1_70ck66 = 0.9 time = 335
.meas tran vdout1_70ck66 FIND v(dout1_70) AT=335.025n

* CHECK dout1_71 Vdout1_71ck66 = 0 time = 335
.meas tran vdout1_71ck66 FIND v(dout1_71) AT=335.025n

* CHECK dout1_72 Vdout1_72ck66 = 0 time = 335
.meas tran vdout1_72ck66 FIND v(dout1_72) AT=335.025n

* CHECK dout1_73 Vdout1_73ck66 = 0 time = 335
.meas tran vdout1_73ck66 FIND v(dout1_73) AT=335.025n

* CHECK dout1_74 Vdout1_74ck66 = 0.9 time = 335
.meas tran vdout1_74ck66 FIND v(dout1_74) AT=335.025n

* CHECK dout1_75 Vdout1_75ck66 = 0.9 time = 335
.meas tran vdout1_75ck66 FIND v(dout1_75) AT=335.025n

* CHECK dout1_76 Vdout1_76ck66 = 0 time = 335
.meas tran vdout1_76ck66 FIND v(dout1_76) AT=335.025n

* CHECK dout1_77 Vdout1_77ck66 = 0.9 time = 335
.meas tran vdout1_77ck66 FIND v(dout1_77) AT=335.025n

* CHECK dout1_78 Vdout1_78ck66 = 0.9 time = 335
.meas tran vdout1_78ck66 FIND v(dout1_78) AT=335.025n

* CHECK dout1_79 Vdout1_79ck66 = 0.9 time = 335
.meas tran vdout1_79ck66 FIND v(dout1_79) AT=335.025n

* CHECK dout1_80 Vdout1_80ck66 = 0 time = 335
.meas tran vdout1_80ck66 FIND v(dout1_80) AT=335.025n

* CHECK dout1_81 Vdout1_81ck66 = 0.9 time = 335
.meas tran vdout1_81ck66 FIND v(dout1_81) AT=335.025n

* CHECK dout1_82 Vdout1_82ck66 = 0.9 time = 335
.meas tran vdout1_82ck66 FIND v(dout1_82) AT=335.025n

* CHECK dout1_83 Vdout1_83ck66 = 0.9 time = 335
.meas tran vdout1_83ck66 FIND v(dout1_83) AT=335.025n

* CHECK dout1_84 Vdout1_84ck66 = 0 time = 335
.meas tran vdout1_84ck66 FIND v(dout1_84) AT=335.025n

* CHECK dout1_85 Vdout1_85ck66 = 0 time = 335
.meas tran vdout1_85ck66 FIND v(dout1_85) AT=335.025n

* CHECK dout1_86 Vdout1_86ck66 = 0.9 time = 335
.meas tran vdout1_86ck66 FIND v(dout1_86) AT=335.025n

* CHECK dout1_87 Vdout1_87ck66 = 0 time = 335
.meas tran vdout1_87ck66 FIND v(dout1_87) AT=335.025n

* CHECK dout1_88 Vdout1_88ck66 = 0.9 time = 335
.meas tran vdout1_88ck66 FIND v(dout1_88) AT=335.025n

* CHECK dout1_89 Vdout1_89ck66 = 0.9 time = 335
.meas tran vdout1_89ck66 FIND v(dout1_89) AT=335.025n

* CHECK dout1_90 Vdout1_90ck66 = 0 time = 335
.meas tran vdout1_90ck66 FIND v(dout1_90) AT=335.025n

* CHECK dout1_91 Vdout1_91ck66 = 0 time = 335
.meas tran vdout1_91ck66 FIND v(dout1_91) AT=335.025n

* CHECK dout1_92 Vdout1_92ck66 = 0 time = 335
.meas tran vdout1_92ck66 FIND v(dout1_92) AT=335.025n

* CHECK dout1_93 Vdout1_93ck66 = 0.9 time = 335
.meas tran vdout1_93ck66 FIND v(dout1_93) AT=335.025n

* CHECK dout1_94 Vdout1_94ck66 = 0 time = 335
.meas tran vdout1_94ck66 FIND v(dout1_94) AT=335.025n

* CHECK dout1_95 Vdout1_95ck66 = 0 time = 335
.meas tran vdout1_95ck66 FIND v(dout1_95) AT=335.025n

* CHECK dout1_96 Vdout1_96ck66 = 0.9 time = 335
.meas tran vdout1_96ck66 FIND v(dout1_96) AT=335.025n

* CHECK dout1_97 Vdout1_97ck66 = 0 time = 335
.meas tran vdout1_97ck66 FIND v(dout1_97) AT=335.025n

* CHECK dout1_98 Vdout1_98ck66 = 0.9 time = 335
.meas tran vdout1_98ck66 FIND v(dout1_98) AT=335.025n

* CHECK dout1_99 Vdout1_99ck66 = 0.9 time = 335
.meas tran vdout1_99ck66 FIND v(dout1_99) AT=335.025n

* CHECK dout1_100 Vdout1_100ck66 = 0 time = 335
.meas tran vdout1_100ck66 FIND v(dout1_100) AT=335.025n

* CHECK dout1_101 Vdout1_101ck66 = 0.9 time = 335
.meas tran vdout1_101ck66 FIND v(dout1_101) AT=335.025n

* CHECK dout1_102 Vdout1_102ck66 = 0.9 time = 335
.meas tran vdout1_102ck66 FIND v(dout1_102) AT=335.025n

* CHECK dout1_103 Vdout1_103ck66 = 0.9 time = 335
.meas tran vdout1_103ck66 FIND v(dout1_103) AT=335.025n

* CHECK dout1_104 Vdout1_104ck66 = 0 time = 335
.meas tran vdout1_104ck66 FIND v(dout1_104) AT=335.025n

* CHECK dout1_105 Vdout1_105ck66 = 0 time = 335
.meas tran vdout1_105ck66 FIND v(dout1_105) AT=335.025n

* CHECK dout1_106 Vdout1_106ck66 = 0 time = 335
.meas tran vdout1_106ck66 FIND v(dout1_106) AT=335.025n

* CHECK dout1_107 Vdout1_107ck66 = 0 time = 335
.meas tran vdout1_107ck66 FIND v(dout1_107) AT=335.025n

* CHECK dout1_108 Vdout1_108ck66 = 0 time = 335
.meas tran vdout1_108ck66 FIND v(dout1_108) AT=335.025n

* CHECK dout1_109 Vdout1_109ck66 = 0.9 time = 335
.meas tran vdout1_109ck66 FIND v(dout1_109) AT=335.025n

* CHECK dout1_110 Vdout1_110ck66 = 0 time = 335
.meas tran vdout1_110ck66 FIND v(dout1_110) AT=335.025n

* CHECK dout1_111 Vdout1_111ck66 = 0 time = 335
.meas tran vdout1_111ck66 FIND v(dout1_111) AT=335.025n

* CHECK dout1_112 Vdout1_112ck66 = 0 time = 335
.meas tran vdout1_112ck66 FIND v(dout1_112) AT=335.025n

* CHECK dout1_113 Vdout1_113ck66 = 0.9 time = 335
.meas tran vdout1_113ck66 FIND v(dout1_113) AT=335.025n

* CHECK dout1_114 Vdout1_114ck66 = 0 time = 335
.meas tran vdout1_114ck66 FIND v(dout1_114) AT=335.025n

* CHECK dout1_115 Vdout1_115ck66 = 0 time = 335
.meas tran vdout1_115ck66 FIND v(dout1_115) AT=335.025n

* CHECK dout1_116 Vdout1_116ck66 = 0.9 time = 335
.meas tran vdout1_116ck66 FIND v(dout1_116) AT=335.025n

* CHECK dout1_117 Vdout1_117ck66 = 0.9 time = 335
.meas tran vdout1_117ck66 FIND v(dout1_117) AT=335.025n

* CHECK dout1_118 Vdout1_118ck66 = 0.9 time = 335
.meas tran vdout1_118ck66 FIND v(dout1_118) AT=335.025n

* CHECK dout1_119 Vdout1_119ck66 = 0.9 time = 335
.meas tran vdout1_119ck66 FIND v(dout1_119) AT=335.025n

* CHECK dout1_0 Vdout1_0ck67 = 0.9 time = 340
.meas tran vdout1_0ck67 FIND v(dout1_0) AT=340.025n

* CHECK dout1_1 Vdout1_1ck67 = 0.9 time = 340
.meas tran vdout1_1ck67 FIND v(dout1_1) AT=340.025n

* CHECK dout1_2 Vdout1_2ck67 = 0 time = 340
.meas tran vdout1_2ck67 FIND v(dout1_2) AT=340.025n

* CHECK dout1_3 Vdout1_3ck67 = 0.9 time = 340
.meas tran vdout1_3ck67 FIND v(dout1_3) AT=340.025n

* CHECK dout1_4 Vdout1_4ck67 = 0 time = 340
.meas tran vdout1_4ck67 FIND v(dout1_4) AT=340.025n

* CHECK dout1_5 Vdout1_5ck67 = 0.9 time = 340
.meas tran vdout1_5ck67 FIND v(dout1_5) AT=340.025n

* CHECK dout1_6 Vdout1_6ck67 = 0 time = 340
.meas tran vdout1_6ck67 FIND v(dout1_6) AT=340.025n

* CHECK dout1_7 Vdout1_7ck67 = 0.9 time = 340
.meas tran vdout1_7ck67 FIND v(dout1_7) AT=340.025n

* CHECK dout1_8 Vdout1_8ck67 = 0 time = 340
.meas tran vdout1_8ck67 FIND v(dout1_8) AT=340.025n

* CHECK dout1_9 Vdout1_9ck67 = 0.9 time = 340
.meas tran vdout1_9ck67 FIND v(dout1_9) AT=340.025n

* CHECK dout1_10 Vdout1_10ck67 = 0 time = 340
.meas tran vdout1_10ck67 FIND v(dout1_10) AT=340.025n

* CHECK dout1_11 Vdout1_11ck67 = 0.9 time = 340
.meas tran vdout1_11ck67 FIND v(dout1_11) AT=340.025n

* CHECK dout1_12 Vdout1_12ck67 = 0 time = 340
.meas tran vdout1_12ck67 FIND v(dout1_12) AT=340.025n

* CHECK dout1_13 Vdout1_13ck67 = 0.9 time = 340
.meas tran vdout1_13ck67 FIND v(dout1_13) AT=340.025n

* CHECK dout1_14 Vdout1_14ck67 = 0.9 time = 340
.meas tran vdout1_14ck67 FIND v(dout1_14) AT=340.025n

* CHECK dout1_15 Vdout1_15ck67 = 0.9 time = 340
.meas tran vdout1_15ck67 FIND v(dout1_15) AT=340.025n

* CHECK dout1_16 Vdout1_16ck67 = 0 time = 340
.meas tran vdout1_16ck67 FIND v(dout1_16) AT=340.025n

* CHECK dout1_17 Vdout1_17ck67 = 0.9 time = 340
.meas tran vdout1_17ck67 FIND v(dout1_17) AT=340.025n

* CHECK dout1_18 Vdout1_18ck67 = 0 time = 340
.meas tran vdout1_18ck67 FIND v(dout1_18) AT=340.025n

* CHECK dout1_19 Vdout1_19ck67 = 0.9 time = 340
.meas tran vdout1_19ck67 FIND v(dout1_19) AT=340.025n

* CHECK dout1_20 Vdout1_20ck67 = 0 time = 340
.meas tran vdout1_20ck67 FIND v(dout1_20) AT=340.025n

* CHECK dout1_21 Vdout1_21ck67 = 0 time = 340
.meas tran vdout1_21ck67 FIND v(dout1_21) AT=340.025n

* CHECK dout1_22 Vdout1_22ck67 = 0 time = 340
.meas tran vdout1_22ck67 FIND v(dout1_22) AT=340.025n

* CHECK dout1_23 Vdout1_23ck67 = 0 time = 340
.meas tran vdout1_23ck67 FIND v(dout1_23) AT=340.025n

* CHECK dout1_24 Vdout1_24ck67 = 0.9 time = 340
.meas tran vdout1_24ck67 FIND v(dout1_24) AT=340.025n

* CHECK dout1_25 Vdout1_25ck67 = 0 time = 340
.meas tran vdout1_25ck67 FIND v(dout1_25) AT=340.025n

* CHECK dout1_26 Vdout1_26ck67 = 0 time = 340
.meas tran vdout1_26ck67 FIND v(dout1_26) AT=340.025n

* CHECK dout1_27 Vdout1_27ck67 = 0.9 time = 340
.meas tran vdout1_27ck67 FIND v(dout1_27) AT=340.025n

* CHECK dout1_28 Vdout1_28ck67 = 0.9 time = 340
.meas tran vdout1_28ck67 FIND v(dout1_28) AT=340.025n

* CHECK dout1_29 Vdout1_29ck67 = 0.9 time = 340
.meas tran vdout1_29ck67 FIND v(dout1_29) AT=340.025n

* CHECK dout1_30 Vdout1_30ck67 = 0.9 time = 340
.meas tran vdout1_30ck67 FIND v(dout1_30) AT=340.025n

* CHECK dout1_31 Vdout1_31ck67 = 0.9 time = 340
.meas tran vdout1_31ck67 FIND v(dout1_31) AT=340.025n

* CHECK dout1_32 Vdout1_32ck67 = 0 time = 340
.meas tran vdout1_32ck67 FIND v(dout1_32) AT=340.025n

* CHECK dout1_33 Vdout1_33ck67 = 0.9 time = 340
.meas tran vdout1_33ck67 FIND v(dout1_33) AT=340.025n

* CHECK dout1_34 Vdout1_34ck67 = 0 time = 340
.meas tran vdout1_34ck67 FIND v(dout1_34) AT=340.025n

* CHECK dout1_35 Vdout1_35ck67 = 0 time = 340
.meas tran vdout1_35ck67 FIND v(dout1_35) AT=340.025n

* CHECK dout1_36 Vdout1_36ck67 = 0.9 time = 340
.meas tran vdout1_36ck67 FIND v(dout1_36) AT=340.025n

* CHECK dout1_37 Vdout1_37ck67 = 0.9 time = 340
.meas tran vdout1_37ck67 FIND v(dout1_37) AT=340.025n

* CHECK dout1_38 Vdout1_38ck67 = 0.9 time = 340
.meas tran vdout1_38ck67 FIND v(dout1_38) AT=340.025n

* CHECK dout1_39 Vdout1_39ck67 = 0 time = 340
.meas tran vdout1_39ck67 FIND v(dout1_39) AT=340.025n

* CHECK dout1_40 Vdout1_40ck67 = 0.9 time = 340
.meas tran vdout1_40ck67 FIND v(dout1_40) AT=340.025n

* CHECK dout1_41 Vdout1_41ck67 = 0 time = 340
.meas tran vdout1_41ck67 FIND v(dout1_41) AT=340.025n

* CHECK dout1_42 Vdout1_42ck67 = 0.9 time = 340
.meas tran vdout1_42ck67 FIND v(dout1_42) AT=340.025n

* CHECK dout1_43 Vdout1_43ck67 = 0.9 time = 340
.meas tran vdout1_43ck67 FIND v(dout1_43) AT=340.025n

* CHECK dout1_44 Vdout1_44ck67 = 0.9 time = 340
.meas tran vdout1_44ck67 FIND v(dout1_44) AT=340.025n

* CHECK dout1_45 Vdout1_45ck67 = 0 time = 340
.meas tran vdout1_45ck67 FIND v(dout1_45) AT=340.025n

* CHECK dout1_46 Vdout1_46ck67 = 0 time = 340
.meas tran vdout1_46ck67 FIND v(dout1_46) AT=340.025n

* CHECK dout1_47 Vdout1_47ck67 = 0 time = 340
.meas tran vdout1_47ck67 FIND v(dout1_47) AT=340.025n

* CHECK dout1_48 Vdout1_48ck67 = 0 time = 340
.meas tran vdout1_48ck67 FIND v(dout1_48) AT=340.025n

* CHECK dout1_49 Vdout1_49ck67 = 0.9 time = 340
.meas tran vdout1_49ck67 FIND v(dout1_49) AT=340.025n

* CHECK dout1_50 Vdout1_50ck67 = 0.9 time = 340
.meas tran vdout1_50ck67 FIND v(dout1_50) AT=340.025n

* CHECK dout1_51 Vdout1_51ck67 = 0 time = 340
.meas tran vdout1_51ck67 FIND v(dout1_51) AT=340.025n

* CHECK dout1_52 Vdout1_52ck67 = 0 time = 340
.meas tran vdout1_52ck67 FIND v(dout1_52) AT=340.025n

* CHECK dout1_53 Vdout1_53ck67 = 0.9 time = 340
.meas tran vdout1_53ck67 FIND v(dout1_53) AT=340.025n

* CHECK dout1_54 Vdout1_54ck67 = 0 time = 340
.meas tran vdout1_54ck67 FIND v(dout1_54) AT=340.025n

* CHECK dout1_55 Vdout1_55ck67 = 0.9 time = 340
.meas tran vdout1_55ck67 FIND v(dout1_55) AT=340.025n

* CHECK dout1_56 Vdout1_56ck67 = 0 time = 340
.meas tran vdout1_56ck67 FIND v(dout1_56) AT=340.025n

* CHECK dout1_57 Vdout1_57ck67 = 0 time = 340
.meas tran vdout1_57ck67 FIND v(dout1_57) AT=340.025n

* CHECK dout1_58 Vdout1_58ck67 = 0.9 time = 340
.meas tran vdout1_58ck67 FIND v(dout1_58) AT=340.025n

* CHECK dout1_59 Vdout1_59ck67 = 0 time = 340
.meas tran vdout1_59ck67 FIND v(dout1_59) AT=340.025n

* CHECK dout1_60 Vdout1_60ck67 = 0 time = 340
.meas tran vdout1_60ck67 FIND v(dout1_60) AT=340.025n

* CHECK dout1_61 Vdout1_61ck67 = 0 time = 340
.meas tran vdout1_61ck67 FIND v(dout1_61) AT=340.025n

* CHECK dout1_62 Vdout1_62ck67 = 0 time = 340
.meas tran vdout1_62ck67 FIND v(dout1_62) AT=340.025n

* CHECK dout1_63 Vdout1_63ck67 = 0.9 time = 340
.meas tran vdout1_63ck67 FIND v(dout1_63) AT=340.025n

* CHECK dout1_64 Vdout1_64ck67 = 0.9 time = 340
.meas tran vdout1_64ck67 FIND v(dout1_64) AT=340.025n

* CHECK dout1_65 Vdout1_65ck67 = 0.9 time = 340
.meas tran vdout1_65ck67 FIND v(dout1_65) AT=340.025n

* CHECK dout1_66 Vdout1_66ck67 = 0.9 time = 340
.meas tran vdout1_66ck67 FIND v(dout1_66) AT=340.025n

* CHECK dout1_67 Vdout1_67ck67 = 0 time = 340
.meas tran vdout1_67ck67 FIND v(dout1_67) AT=340.025n

* CHECK dout1_68 Vdout1_68ck67 = 0 time = 340
.meas tran vdout1_68ck67 FIND v(dout1_68) AT=340.025n

* CHECK dout1_69 Vdout1_69ck67 = 0.9 time = 340
.meas tran vdout1_69ck67 FIND v(dout1_69) AT=340.025n

* CHECK dout1_70 Vdout1_70ck67 = 0.9 time = 340
.meas tran vdout1_70ck67 FIND v(dout1_70) AT=340.025n

* CHECK dout1_71 Vdout1_71ck67 = 0 time = 340
.meas tran vdout1_71ck67 FIND v(dout1_71) AT=340.025n

* CHECK dout1_72 Vdout1_72ck67 = 0 time = 340
.meas tran vdout1_72ck67 FIND v(dout1_72) AT=340.025n

* CHECK dout1_73 Vdout1_73ck67 = 0 time = 340
.meas tran vdout1_73ck67 FIND v(dout1_73) AT=340.025n

* CHECK dout1_74 Vdout1_74ck67 = 0.9 time = 340
.meas tran vdout1_74ck67 FIND v(dout1_74) AT=340.025n

* CHECK dout1_75 Vdout1_75ck67 = 0.9 time = 340
.meas tran vdout1_75ck67 FIND v(dout1_75) AT=340.025n

* CHECK dout1_76 Vdout1_76ck67 = 0 time = 340
.meas tran vdout1_76ck67 FIND v(dout1_76) AT=340.025n

* CHECK dout1_77 Vdout1_77ck67 = 0.9 time = 340
.meas tran vdout1_77ck67 FIND v(dout1_77) AT=340.025n

* CHECK dout1_78 Vdout1_78ck67 = 0.9 time = 340
.meas tran vdout1_78ck67 FIND v(dout1_78) AT=340.025n

* CHECK dout1_79 Vdout1_79ck67 = 0.9 time = 340
.meas tran vdout1_79ck67 FIND v(dout1_79) AT=340.025n

* CHECK dout1_80 Vdout1_80ck67 = 0 time = 340
.meas tran vdout1_80ck67 FIND v(dout1_80) AT=340.025n

* CHECK dout1_81 Vdout1_81ck67 = 0.9 time = 340
.meas tran vdout1_81ck67 FIND v(dout1_81) AT=340.025n

* CHECK dout1_82 Vdout1_82ck67 = 0.9 time = 340
.meas tran vdout1_82ck67 FIND v(dout1_82) AT=340.025n

* CHECK dout1_83 Vdout1_83ck67 = 0.9 time = 340
.meas tran vdout1_83ck67 FIND v(dout1_83) AT=340.025n

* CHECK dout1_84 Vdout1_84ck67 = 0 time = 340
.meas tran vdout1_84ck67 FIND v(dout1_84) AT=340.025n

* CHECK dout1_85 Vdout1_85ck67 = 0 time = 340
.meas tran vdout1_85ck67 FIND v(dout1_85) AT=340.025n

* CHECK dout1_86 Vdout1_86ck67 = 0.9 time = 340
.meas tran vdout1_86ck67 FIND v(dout1_86) AT=340.025n

* CHECK dout1_87 Vdout1_87ck67 = 0 time = 340
.meas tran vdout1_87ck67 FIND v(dout1_87) AT=340.025n

* CHECK dout1_88 Vdout1_88ck67 = 0.9 time = 340
.meas tran vdout1_88ck67 FIND v(dout1_88) AT=340.025n

* CHECK dout1_89 Vdout1_89ck67 = 0.9 time = 340
.meas tran vdout1_89ck67 FIND v(dout1_89) AT=340.025n

* CHECK dout1_90 Vdout1_90ck67 = 0 time = 340
.meas tran vdout1_90ck67 FIND v(dout1_90) AT=340.025n

* CHECK dout1_91 Vdout1_91ck67 = 0 time = 340
.meas tran vdout1_91ck67 FIND v(dout1_91) AT=340.025n

* CHECK dout1_92 Vdout1_92ck67 = 0 time = 340
.meas tran vdout1_92ck67 FIND v(dout1_92) AT=340.025n

* CHECK dout1_93 Vdout1_93ck67 = 0.9 time = 340
.meas tran vdout1_93ck67 FIND v(dout1_93) AT=340.025n

* CHECK dout1_94 Vdout1_94ck67 = 0 time = 340
.meas tran vdout1_94ck67 FIND v(dout1_94) AT=340.025n

* CHECK dout1_95 Vdout1_95ck67 = 0 time = 340
.meas tran vdout1_95ck67 FIND v(dout1_95) AT=340.025n

* CHECK dout1_96 Vdout1_96ck67 = 0.9 time = 340
.meas tran vdout1_96ck67 FIND v(dout1_96) AT=340.025n

* CHECK dout1_97 Vdout1_97ck67 = 0 time = 340
.meas tran vdout1_97ck67 FIND v(dout1_97) AT=340.025n

* CHECK dout1_98 Vdout1_98ck67 = 0.9 time = 340
.meas tran vdout1_98ck67 FIND v(dout1_98) AT=340.025n

* CHECK dout1_99 Vdout1_99ck67 = 0.9 time = 340
.meas tran vdout1_99ck67 FIND v(dout1_99) AT=340.025n

* CHECK dout1_100 Vdout1_100ck67 = 0 time = 340
.meas tran vdout1_100ck67 FIND v(dout1_100) AT=340.025n

* CHECK dout1_101 Vdout1_101ck67 = 0.9 time = 340
.meas tran vdout1_101ck67 FIND v(dout1_101) AT=340.025n

* CHECK dout1_102 Vdout1_102ck67 = 0.9 time = 340
.meas tran vdout1_102ck67 FIND v(dout1_102) AT=340.025n

* CHECK dout1_103 Vdout1_103ck67 = 0.9 time = 340
.meas tran vdout1_103ck67 FIND v(dout1_103) AT=340.025n

* CHECK dout1_104 Vdout1_104ck67 = 0 time = 340
.meas tran vdout1_104ck67 FIND v(dout1_104) AT=340.025n

* CHECK dout1_105 Vdout1_105ck67 = 0 time = 340
.meas tran vdout1_105ck67 FIND v(dout1_105) AT=340.025n

* CHECK dout1_106 Vdout1_106ck67 = 0 time = 340
.meas tran vdout1_106ck67 FIND v(dout1_106) AT=340.025n

* CHECK dout1_107 Vdout1_107ck67 = 0 time = 340
.meas tran vdout1_107ck67 FIND v(dout1_107) AT=340.025n

* CHECK dout1_108 Vdout1_108ck67 = 0 time = 340
.meas tran vdout1_108ck67 FIND v(dout1_108) AT=340.025n

* CHECK dout1_109 Vdout1_109ck67 = 0.9 time = 340
.meas tran vdout1_109ck67 FIND v(dout1_109) AT=340.025n

* CHECK dout1_110 Vdout1_110ck67 = 0 time = 340
.meas tran vdout1_110ck67 FIND v(dout1_110) AT=340.025n

* CHECK dout1_111 Vdout1_111ck67 = 0 time = 340
.meas tran vdout1_111ck67 FIND v(dout1_111) AT=340.025n

* CHECK dout1_112 Vdout1_112ck67 = 0 time = 340
.meas tran vdout1_112ck67 FIND v(dout1_112) AT=340.025n

* CHECK dout1_113 Vdout1_113ck67 = 0.9 time = 340
.meas tran vdout1_113ck67 FIND v(dout1_113) AT=340.025n

* CHECK dout1_114 Vdout1_114ck67 = 0 time = 340
.meas tran vdout1_114ck67 FIND v(dout1_114) AT=340.025n

* CHECK dout1_115 Vdout1_115ck67 = 0 time = 340
.meas tran vdout1_115ck67 FIND v(dout1_115) AT=340.025n

* CHECK dout1_116 Vdout1_116ck67 = 0.9 time = 340
.meas tran vdout1_116ck67 FIND v(dout1_116) AT=340.025n

* CHECK dout1_117 Vdout1_117ck67 = 0.9 time = 340
.meas tran vdout1_117ck67 FIND v(dout1_117) AT=340.025n

* CHECK dout1_118 Vdout1_118ck67 = 0.9 time = 340
.meas tran vdout1_118ck67 FIND v(dout1_118) AT=340.025n

* CHECK dout1_119 Vdout1_119ck67 = 0.9 time = 340
.meas tran vdout1_119ck67 FIND v(dout1_119) AT=340.025n

* CHECK dout1_0 Vdout1_0ck71 = 0.9 time = 360
.meas tran vdout1_0ck71 FIND v(dout1_0) AT=360.025n

* CHECK dout1_1 Vdout1_1ck71 = 0 time = 360
.meas tran vdout1_1ck71 FIND v(dout1_1) AT=360.025n

* CHECK dout1_2 Vdout1_2ck71 = 0.9 time = 360
.meas tran vdout1_2ck71 FIND v(dout1_2) AT=360.025n

* CHECK dout1_3 Vdout1_3ck71 = 0 time = 360
.meas tran vdout1_3ck71 FIND v(dout1_3) AT=360.025n

* CHECK dout1_4 Vdout1_4ck71 = 0.9 time = 360
.meas tran vdout1_4ck71 FIND v(dout1_4) AT=360.025n

* CHECK dout1_5 Vdout1_5ck71 = 0 time = 360
.meas tran vdout1_5ck71 FIND v(dout1_5) AT=360.025n

* CHECK dout1_6 Vdout1_6ck71 = 0.9 time = 360
.meas tran vdout1_6ck71 FIND v(dout1_6) AT=360.025n

* CHECK dout1_7 Vdout1_7ck71 = 0.9 time = 360
.meas tran vdout1_7ck71 FIND v(dout1_7) AT=360.025n

* CHECK dout1_8 Vdout1_8ck71 = 0.9 time = 360
.meas tran vdout1_8ck71 FIND v(dout1_8) AT=360.025n

* CHECK dout1_9 Vdout1_9ck71 = 0.9 time = 360
.meas tran vdout1_9ck71 FIND v(dout1_9) AT=360.025n

* CHECK dout1_10 Vdout1_10ck71 = 0 time = 360
.meas tran vdout1_10ck71 FIND v(dout1_10) AT=360.025n

* CHECK dout1_11 Vdout1_11ck71 = 0 time = 360
.meas tran vdout1_11ck71 FIND v(dout1_11) AT=360.025n

* CHECK dout1_12 Vdout1_12ck71 = 0 time = 360
.meas tran vdout1_12ck71 FIND v(dout1_12) AT=360.025n

* CHECK dout1_13 Vdout1_13ck71 = 0 time = 360
.meas tran vdout1_13ck71 FIND v(dout1_13) AT=360.025n

* CHECK dout1_14 Vdout1_14ck71 = 0 time = 360
.meas tran vdout1_14ck71 FIND v(dout1_14) AT=360.025n

* CHECK dout1_15 Vdout1_15ck71 = 0.9 time = 360
.meas tran vdout1_15ck71 FIND v(dout1_15) AT=360.025n

* CHECK dout1_16 Vdout1_16ck71 = 0 time = 360
.meas tran vdout1_16ck71 FIND v(dout1_16) AT=360.025n

* CHECK dout1_17 Vdout1_17ck71 = 0.9 time = 360
.meas tran vdout1_17ck71 FIND v(dout1_17) AT=360.025n

* CHECK dout1_18 Vdout1_18ck71 = 0.9 time = 360
.meas tran vdout1_18ck71 FIND v(dout1_18) AT=360.025n

* CHECK dout1_19 Vdout1_19ck71 = 0 time = 360
.meas tran vdout1_19ck71 FIND v(dout1_19) AT=360.025n

* CHECK dout1_20 Vdout1_20ck71 = 0.9 time = 360
.meas tran vdout1_20ck71 FIND v(dout1_20) AT=360.025n

* CHECK dout1_21 Vdout1_21ck71 = 0 time = 360
.meas tran vdout1_21ck71 FIND v(dout1_21) AT=360.025n

* CHECK dout1_22 Vdout1_22ck71 = 0 time = 360
.meas tran vdout1_22ck71 FIND v(dout1_22) AT=360.025n

* CHECK dout1_23 Vdout1_23ck71 = 0 time = 360
.meas tran vdout1_23ck71 FIND v(dout1_23) AT=360.025n

* CHECK dout1_24 Vdout1_24ck71 = 0 time = 360
.meas tran vdout1_24ck71 FIND v(dout1_24) AT=360.025n

* CHECK dout1_25 Vdout1_25ck71 = 0.9 time = 360
.meas tran vdout1_25ck71 FIND v(dout1_25) AT=360.025n

* CHECK dout1_26 Vdout1_26ck71 = 0 time = 360
.meas tran vdout1_26ck71 FIND v(dout1_26) AT=360.025n

* CHECK dout1_27 Vdout1_27ck71 = 0 time = 360
.meas tran vdout1_27ck71 FIND v(dout1_27) AT=360.025n

* CHECK dout1_28 Vdout1_28ck71 = 0.9 time = 360
.meas tran vdout1_28ck71 FIND v(dout1_28) AT=360.025n

* CHECK dout1_29 Vdout1_29ck71 = 0 time = 360
.meas tran vdout1_29ck71 FIND v(dout1_29) AT=360.025n

* CHECK dout1_30 Vdout1_30ck71 = 0 time = 360
.meas tran vdout1_30ck71 FIND v(dout1_30) AT=360.025n

* CHECK dout1_31 Vdout1_31ck71 = 0 time = 360
.meas tran vdout1_31ck71 FIND v(dout1_31) AT=360.025n

* CHECK dout1_32 Vdout1_32ck71 = 0.9 time = 360
.meas tran vdout1_32ck71 FIND v(dout1_32) AT=360.025n

* CHECK dout1_33 Vdout1_33ck71 = 0.9 time = 360
.meas tran vdout1_33ck71 FIND v(dout1_33) AT=360.025n

* CHECK dout1_34 Vdout1_34ck71 = 0 time = 360
.meas tran vdout1_34ck71 FIND v(dout1_34) AT=360.025n

* CHECK dout1_35 Vdout1_35ck71 = 0 time = 360
.meas tran vdout1_35ck71 FIND v(dout1_35) AT=360.025n

* CHECK dout1_36 Vdout1_36ck71 = 0 time = 360
.meas tran vdout1_36ck71 FIND v(dout1_36) AT=360.025n

* CHECK dout1_37 Vdout1_37ck71 = 0 time = 360
.meas tran vdout1_37ck71 FIND v(dout1_37) AT=360.025n

* CHECK dout1_38 Vdout1_38ck71 = 0.9 time = 360
.meas tran vdout1_38ck71 FIND v(dout1_38) AT=360.025n

* CHECK dout1_39 Vdout1_39ck71 = 0 time = 360
.meas tran vdout1_39ck71 FIND v(dout1_39) AT=360.025n

* CHECK dout1_40 Vdout1_40ck71 = 0.9 time = 360
.meas tran vdout1_40ck71 FIND v(dout1_40) AT=360.025n

* CHECK dout1_41 Vdout1_41ck71 = 0.9 time = 360
.meas tran vdout1_41ck71 FIND v(dout1_41) AT=360.025n

* CHECK dout1_42 Vdout1_42ck71 = 0 time = 360
.meas tran vdout1_42ck71 FIND v(dout1_42) AT=360.025n

* CHECK dout1_43 Vdout1_43ck71 = 0 time = 360
.meas tran vdout1_43ck71 FIND v(dout1_43) AT=360.025n

* CHECK dout1_44 Vdout1_44ck71 = 0.9 time = 360
.meas tran vdout1_44ck71 FIND v(dout1_44) AT=360.025n

* CHECK dout1_45 Vdout1_45ck71 = 0.9 time = 360
.meas tran vdout1_45ck71 FIND v(dout1_45) AT=360.025n

* CHECK dout1_46 Vdout1_46ck71 = 0.9 time = 360
.meas tran vdout1_46ck71 FIND v(dout1_46) AT=360.025n

* CHECK dout1_47 Vdout1_47ck71 = 0.9 time = 360
.meas tran vdout1_47ck71 FIND v(dout1_47) AT=360.025n

* CHECK dout1_48 Vdout1_48ck71 = 0 time = 360
.meas tran vdout1_48ck71 FIND v(dout1_48) AT=360.025n

* CHECK dout1_49 Vdout1_49ck71 = 0.9 time = 360
.meas tran vdout1_49ck71 FIND v(dout1_49) AT=360.025n

* CHECK dout1_50 Vdout1_50ck71 = 0.9 time = 360
.meas tran vdout1_50ck71 FIND v(dout1_50) AT=360.025n

* CHECK dout1_51 Vdout1_51ck71 = 0 time = 360
.meas tran vdout1_51ck71 FIND v(dout1_51) AT=360.025n

* CHECK dout1_52 Vdout1_52ck71 = 0 time = 360
.meas tran vdout1_52ck71 FIND v(dout1_52) AT=360.025n

* CHECK dout1_53 Vdout1_53ck71 = 0 time = 360
.meas tran vdout1_53ck71 FIND v(dout1_53) AT=360.025n

* CHECK dout1_54 Vdout1_54ck71 = 0.9 time = 360
.meas tran vdout1_54ck71 FIND v(dout1_54) AT=360.025n

* CHECK dout1_55 Vdout1_55ck71 = 0 time = 360
.meas tran vdout1_55ck71 FIND v(dout1_55) AT=360.025n

* CHECK dout1_56 Vdout1_56ck71 = 0 time = 360
.meas tran vdout1_56ck71 FIND v(dout1_56) AT=360.025n

* CHECK dout1_57 Vdout1_57ck71 = 0 time = 360
.meas tran vdout1_57ck71 FIND v(dout1_57) AT=360.025n

* CHECK dout1_58 Vdout1_58ck71 = 0.9 time = 360
.meas tran vdout1_58ck71 FIND v(dout1_58) AT=360.025n

* CHECK dout1_59 Vdout1_59ck71 = 0.9 time = 360
.meas tran vdout1_59ck71 FIND v(dout1_59) AT=360.025n

* CHECK dout1_60 Vdout1_60ck71 = 0 time = 360
.meas tran vdout1_60ck71 FIND v(dout1_60) AT=360.025n

* CHECK dout1_61 Vdout1_61ck71 = 0.9 time = 360
.meas tran vdout1_61ck71 FIND v(dout1_61) AT=360.025n

* CHECK dout1_62 Vdout1_62ck71 = 0 time = 360
.meas tran vdout1_62ck71 FIND v(dout1_62) AT=360.025n

* CHECK dout1_63 Vdout1_63ck71 = 0.9 time = 360
.meas tran vdout1_63ck71 FIND v(dout1_63) AT=360.025n

* CHECK dout1_64 Vdout1_64ck71 = 0.9 time = 360
.meas tran vdout1_64ck71 FIND v(dout1_64) AT=360.025n

* CHECK dout1_65 Vdout1_65ck71 = 0 time = 360
.meas tran vdout1_65ck71 FIND v(dout1_65) AT=360.025n

* CHECK dout1_66 Vdout1_66ck71 = 0.9 time = 360
.meas tran vdout1_66ck71 FIND v(dout1_66) AT=360.025n

* CHECK dout1_67 Vdout1_67ck71 = 0.9 time = 360
.meas tran vdout1_67ck71 FIND v(dout1_67) AT=360.025n

* CHECK dout1_68 Vdout1_68ck71 = 0 time = 360
.meas tran vdout1_68ck71 FIND v(dout1_68) AT=360.025n

* CHECK dout1_69 Vdout1_69ck71 = 0 time = 360
.meas tran vdout1_69ck71 FIND v(dout1_69) AT=360.025n

* CHECK dout1_70 Vdout1_70ck71 = 0 time = 360
.meas tran vdout1_70ck71 FIND v(dout1_70) AT=360.025n

* CHECK dout1_71 Vdout1_71ck71 = 0.9 time = 360
.meas tran vdout1_71ck71 FIND v(dout1_71) AT=360.025n

* CHECK dout1_72 Vdout1_72ck71 = 0 time = 360
.meas tran vdout1_72ck71 FIND v(dout1_72) AT=360.025n

* CHECK dout1_73 Vdout1_73ck71 = 0.9 time = 360
.meas tran vdout1_73ck71 FIND v(dout1_73) AT=360.025n

* CHECK dout1_74 Vdout1_74ck71 = 0 time = 360
.meas tran vdout1_74ck71 FIND v(dout1_74) AT=360.025n

* CHECK dout1_75 Vdout1_75ck71 = 0 time = 360
.meas tran vdout1_75ck71 FIND v(dout1_75) AT=360.025n

* CHECK dout1_76 Vdout1_76ck71 = 0 time = 360
.meas tran vdout1_76ck71 FIND v(dout1_76) AT=360.025n

* CHECK dout1_77 Vdout1_77ck71 = 0.9 time = 360
.meas tran vdout1_77ck71 FIND v(dout1_77) AT=360.025n

* CHECK dout1_78 Vdout1_78ck71 = 0 time = 360
.meas tran vdout1_78ck71 FIND v(dout1_78) AT=360.025n

* CHECK dout1_79 Vdout1_79ck71 = 0 time = 360
.meas tran vdout1_79ck71 FIND v(dout1_79) AT=360.025n

* CHECK dout1_80 Vdout1_80ck71 = 0 time = 360
.meas tran vdout1_80ck71 FIND v(dout1_80) AT=360.025n

* CHECK dout1_81 Vdout1_81ck71 = 0.9 time = 360
.meas tran vdout1_81ck71 FIND v(dout1_81) AT=360.025n

* CHECK dout1_82 Vdout1_82ck71 = 0 time = 360
.meas tran vdout1_82ck71 FIND v(dout1_82) AT=360.025n

* CHECK dout1_83 Vdout1_83ck71 = 0 time = 360
.meas tran vdout1_83ck71 FIND v(dout1_83) AT=360.025n

* CHECK dout1_84 Vdout1_84ck71 = 0 time = 360
.meas tran vdout1_84ck71 FIND v(dout1_84) AT=360.025n

* CHECK dout1_85 Vdout1_85ck71 = 0 time = 360
.meas tran vdout1_85ck71 FIND v(dout1_85) AT=360.025n

* CHECK dout1_86 Vdout1_86ck71 = 0 time = 360
.meas tran vdout1_86ck71 FIND v(dout1_86) AT=360.025n

* CHECK dout1_87 Vdout1_87ck71 = 0 time = 360
.meas tran vdout1_87ck71 FIND v(dout1_87) AT=360.025n

* CHECK dout1_88 Vdout1_88ck71 = 0 time = 360
.meas tran vdout1_88ck71 FIND v(dout1_88) AT=360.025n

* CHECK dout1_89 Vdout1_89ck71 = 0 time = 360
.meas tran vdout1_89ck71 FIND v(dout1_89) AT=360.025n

* CHECK dout1_90 Vdout1_90ck71 = 0.9 time = 360
.meas tran vdout1_90ck71 FIND v(dout1_90) AT=360.025n

* CHECK dout1_91 Vdout1_91ck71 = 0.9 time = 360
.meas tran vdout1_91ck71 FIND v(dout1_91) AT=360.025n

* CHECK dout1_92 Vdout1_92ck71 = 0 time = 360
.meas tran vdout1_92ck71 FIND v(dout1_92) AT=360.025n

* CHECK dout1_93 Vdout1_93ck71 = 0.9 time = 360
.meas tran vdout1_93ck71 FIND v(dout1_93) AT=360.025n

* CHECK dout1_94 Vdout1_94ck71 = 0 time = 360
.meas tran vdout1_94ck71 FIND v(dout1_94) AT=360.025n

* CHECK dout1_95 Vdout1_95ck71 = 0 time = 360
.meas tran vdout1_95ck71 FIND v(dout1_95) AT=360.025n

* CHECK dout1_96 Vdout1_96ck71 = 0 time = 360
.meas tran vdout1_96ck71 FIND v(dout1_96) AT=360.025n

* CHECK dout1_97 Vdout1_97ck71 = 0.9 time = 360
.meas tran vdout1_97ck71 FIND v(dout1_97) AT=360.025n

* CHECK dout1_98 Vdout1_98ck71 = 0 time = 360
.meas tran vdout1_98ck71 FIND v(dout1_98) AT=360.025n

* CHECK dout1_99 Vdout1_99ck71 = 0.9 time = 360
.meas tran vdout1_99ck71 FIND v(dout1_99) AT=360.025n

* CHECK dout1_100 Vdout1_100ck71 = 0.9 time = 360
.meas tran vdout1_100ck71 FIND v(dout1_100) AT=360.025n

* CHECK dout1_101 Vdout1_101ck71 = 0.9 time = 360
.meas tran vdout1_101ck71 FIND v(dout1_101) AT=360.025n

* CHECK dout1_102 Vdout1_102ck71 = 0.9 time = 360
.meas tran vdout1_102ck71 FIND v(dout1_102) AT=360.025n

* CHECK dout1_103 Vdout1_103ck71 = 0 time = 360
.meas tran vdout1_103ck71 FIND v(dout1_103) AT=360.025n

* CHECK dout1_104 Vdout1_104ck71 = 0 time = 360
.meas tran vdout1_104ck71 FIND v(dout1_104) AT=360.025n

* CHECK dout1_105 Vdout1_105ck71 = 0.9 time = 360
.meas tran vdout1_105ck71 FIND v(dout1_105) AT=360.025n

* CHECK dout1_106 Vdout1_106ck71 = 0 time = 360
.meas tran vdout1_106ck71 FIND v(dout1_106) AT=360.025n

* CHECK dout1_107 Vdout1_107ck71 = 0.9 time = 360
.meas tran vdout1_107ck71 FIND v(dout1_107) AT=360.025n

* CHECK dout1_108 Vdout1_108ck71 = 0 time = 360
.meas tran vdout1_108ck71 FIND v(dout1_108) AT=360.025n

* CHECK dout1_109 Vdout1_109ck71 = 0 time = 360
.meas tran vdout1_109ck71 FIND v(dout1_109) AT=360.025n

* CHECK dout1_110 Vdout1_110ck71 = 0.9 time = 360
.meas tran vdout1_110ck71 FIND v(dout1_110) AT=360.025n

* CHECK dout1_111 Vdout1_111ck71 = 0 time = 360
.meas tran vdout1_111ck71 FIND v(dout1_111) AT=360.025n

* CHECK dout1_112 Vdout1_112ck71 = 0.9 time = 360
.meas tran vdout1_112ck71 FIND v(dout1_112) AT=360.025n

* CHECK dout1_113 Vdout1_113ck71 = 0.9 time = 360
.meas tran vdout1_113ck71 FIND v(dout1_113) AT=360.025n

* CHECK dout1_114 Vdout1_114ck71 = 0 time = 360
.meas tran vdout1_114ck71 FIND v(dout1_114) AT=360.025n

* CHECK dout1_115 Vdout1_115ck71 = 0.9 time = 360
.meas tran vdout1_115ck71 FIND v(dout1_115) AT=360.025n

* CHECK dout1_116 Vdout1_116ck71 = 0 time = 360
.meas tran vdout1_116ck71 FIND v(dout1_116) AT=360.025n

* CHECK dout1_117 Vdout1_117ck71 = 0 time = 360
.meas tran vdout1_117ck71 FIND v(dout1_117) AT=360.025n

* CHECK dout1_118 Vdout1_118ck71 = 0.9 time = 360
.meas tran vdout1_118ck71 FIND v(dout1_118) AT=360.025n

* CHECK dout1_119 Vdout1_119ck71 = 0 time = 360
.meas tran vdout1_119ck71 FIND v(dout1_119) AT=360.025n

* CHECK dout1_0 Vdout1_0ck75 = 0 time = 380
.meas tran vdout1_0ck75 FIND v(dout1_0) AT=380.025n

* CHECK dout1_1 Vdout1_1ck75 = 0 time = 380
.meas tran vdout1_1ck75 FIND v(dout1_1) AT=380.025n

* CHECK dout1_2 Vdout1_2ck75 = 0 time = 380
.meas tran vdout1_2ck75 FIND v(dout1_2) AT=380.025n

* CHECK dout1_3 Vdout1_3ck75 = 0.9 time = 380
.meas tran vdout1_3ck75 FIND v(dout1_3) AT=380.025n

* CHECK dout1_4 Vdout1_4ck75 = 0.9 time = 380
.meas tran vdout1_4ck75 FIND v(dout1_4) AT=380.025n

* CHECK dout1_5 Vdout1_5ck75 = 0 time = 380
.meas tran vdout1_5ck75 FIND v(dout1_5) AT=380.025n

* CHECK dout1_6 Vdout1_6ck75 = 0 time = 380
.meas tran vdout1_6ck75 FIND v(dout1_6) AT=380.025n

* CHECK dout1_7 Vdout1_7ck75 = 0.9 time = 380
.meas tran vdout1_7ck75 FIND v(dout1_7) AT=380.025n

* CHECK dout1_8 Vdout1_8ck75 = 0 time = 380
.meas tran vdout1_8ck75 FIND v(dout1_8) AT=380.025n

* CHECK dout1_9 Vdout1_9ck75 = 0.9 time = 380
.meas tran vdout1_9ck75 FIND v(dout1_9) AT=380.025n

* CHECK dout1_10 Vdout1_10ck75 = 0.9 time = 380
.meas tran vdout1_10ck75 FIND v(dout1_10) AT=380.025n

* CHECK dout1_11 Vdout1_11ck75 = 0.9 time = 380
.meas tran vdout1_11ck75 FIND v(dout1_11) AT=380.025n

* CHECK dout1_12 Vdout1_12ck75 = 0.9 time = 380
.meas tran vdout1_12ck75 FIND v(dout1_12) AT=380.025n

* CHECK dout1_13 Vdout1_13ck75 = 0.9 time = 380
.meas tran vdout1_13ck75 FIND v(dout1_13) AT=380.025n

* CHECK dout1_14 Vdout1_14ck75 = 0 time = 380
.meas tran vdout1_14ck75 FIND v(dout1_14) AT=380.025n

* CHECK dout1_15 Vdout1_15ck75 = 0.9 time = 380
.meas tran vdout1_15ck75 FIND v(dout1_15) AT=380.025n

* CHECK dout1_16 Vdout1_16ck75 = 0 time = 380
.meas tran vdout1_16ck75 FIND v(dout1_16) AT=380.025n

* CHECK dout1_17 Vdout1_17ck75 = 0 time = 380
.meas tran vdout1_17ck75 FIND v(dout1_17) AT=380.025n

* CHECK dout1_18 Vdout1_18ck75 = 0.9 time = 380
.meas tran vdout1_18ck75 FIND v(dout1_18) AT=380.025n

* CHECK dout1_19 Vdout1_19ck75 = 0.9 time = 380
.meas tran vdout1_19ck75 FIND v(dout1_19) AT=380.025n

* CHECK dout1_20 Vdout1_20ck75 = 0.9 time = 380
.meas tran vdout1_20ck75 FIND v(dout1_20) AT=380.025n

* CHECK dout1_21 Vdout1_21ck75 = 0.9 time = 380
.meas tran vdout1_21ck75 FIND v(dout1_21) AT=380.025n

* CHECK dout1_22 Vdout1_22ck75 = 0 time = 380
.meas tran vdout1_22ck75 FIND v(dout1_22) AT=380.025n

* CHECK dout1_23 Vdout1_23ck75 = 0.9 time = 380
.meas tran vdout1_23ck75 FIND v(dout1_23) AT=380.025n

* CHECK dout1_24 Vdout1_24ck75 = 0 time = 380
.meas tran vdout1_24ck75 FIND v(dout1_24) AT=380.025n

* CHECK dout1_25 Vdout1_25ck75 = 0.9 time = 380
.meas tran vdout1_25ck75 FIND v(dout1_25) AT=380.025n

* CHECK dout1_26 Vdout1_26ck75 = 0.9 time = 380
.meas tran vdout1_26ck75 FIND v(dout1_26) AT=380.025n

* CHECK dout1_27 Vdout1_27ck75 = 0 time = 380
.meas tran vdout1_27ck75 FIND v(dout1_27) AT=380.025n

* CHECK dout1_28 Vdout1_28ck75 = 0 time = 380
.meas tran vdout1_28ck75 FIND v(dout1_28) AT=380.025n

* CHECK dout1_29 Vdout1_29ck75 = 0.9 time = 380
.meas tran vdout1_29ck75 FIND v(dout1_29) AT=380.025n

* CHECK dout1_30 Vdout1_30ck75 = 0 time = 380
.meas tran vdout1_30ck75 FIND v(dout1_30) AT=380.025n

* CHECK dout1_31 Vdout1_31ck75 = 0.9 time = 380
.meas tran vdout1_31ck75 FIND v(dout1_31) AT=380.025n

* CHECK dout1_32 Vdout1_32ck75 = 0.9 time = 380
.meas tran vdout1_32ck75 FIND v(dout1_32) AT=380.025n

* CHECK dout1_33 Vdout1_33ck75 = 0.9 time = 380
.meas tran vdout1_33ck75 FIND v(dout1_33) AT=380.025n

* CHECK dout1_34 Vdout1_34ck75 = 0 time = 380
.meas tran vdout1_34ck75 FIND v(dout1_34) AT=380.025n

* CHECK dout1_35 Vdout1_35ck75 = 0.9 time = 380
.meas tran vdout1_35ck75 FIND v(dout1_35) AT=380.025n

* CHECK dout1_36 Vdout1_36ck75 = 0.9 time = 380
.meas tran vdout1_36ck75 FIND v(dout1_36) AT=380.025n

* CHECK dout1_37 Vdout1_37ck75 = 0 time = 380
.meas tran vdout1_37ck75 FIND v(dout1_37) AT=380.025n

* CHECK dout1_38 Vdout1_38ck75 = 0.9 time = 380
.meas tran vdout1_38ck75 FIND v(dout1_38) AT=380.025n

* CHECK dout1_39 Vdout1_39ck75 = 0.9 time = 380
.meas tran vdout1_39ck75 FIND v(dout1_39) AT=380.025n

* CHECK dout1_40 Vdout1_40ck75 = 0.9 time = 380
.meas tran vdout1_40ck75 FIND v(dout1_40) AT=380.025n

* CHECK dout1_41 Vdout1_41ck75 = 0 time = 380
.meas tran vdout1_41ck75 FIND v(dout1_41) AT=380.025n

* CHECK dout1_42 Vdout1_42ck75 = 0 time = 380
.meas tran vdout1_42ck75 FIND v(dout1_42) AT=380.025n

* CHECK dout1_43 Vdout1_43ck75 = 0.9 time = 380
.meas tran vdout1_43ck75 FIND v(dout1_43) AT=380.025n

* CHECK dout1_44 Vdout1_44ck75 = 0.9 time = 380
.meas tran vdout1_44ck75 FIND v(dout1_44) AT=380.025n

* CHECK dout1_45 Vdout1_45ck75 = 0.9 time = 380
.meas tran vdout1_45ck75 FIND v(dout1_45) AT=380.025n

* CHECK dout1_46 Vdout1_46ck75 = 0.9 time = 380
.meas tran vdout1_46ck75 FIND v(dout1_46) AT=380.025n

* CHECK dout1_47 Vdout1_47ck75 = 0.9 time = 380
.meas tran vdout1_47ck75 FIND v(dout1_47) AT=380.025n

* CHECK dout1_48 Vdout1_48ck75 = 0 time = 380
.meas tran vdout1_48ck75 FIND v(dout1_48) AT=380.025n

* CHECK dout1_49 Vdout1_49ck75 = 0 time = 380
.meas tran vdout1_49ck75 FIND v(dout1_49) AT=380.025n

* CHECK dout1_50 Vdout1_50ck75 = 0.9 time = 380
.meas tran vdout1_50ck75 FIND v(dout1_50) AT=380.025n

* CHECK dout1_51 Vdout1_51ck75 = 0 time = 380
.meas tran vdout1_51ck75 FIND v(dout1_51) AT=380.025n

* CHECK dout1_52 Vdout1_52ck75 = 0 time = 380
.meas tran vdout1_52ck75 FIND v(dout1_52) AT=380.025n

* CHECK dout1_53 Vdout1_53ck75 = 0.9 time = 380
.meas tran vdout1_53ck75 FIND v(dout1_53) AT=380.025n

* CHECK dout1_54 Vdout1_54ck75 = 0.9 time = 380
.meas tran vdout1_54ck75 FIND v(dout1_54) AT=380.025n

* CHECK dout1_55 Vdout1_55ck75 = 0.9 time = 380
.meas tran vdout1_55ck75 FIND v(dout1_55) AT=380.025n

* CHECK dout1_56 Vdout1_56ck75 = 0.9 time = 380
.meas tran vdout1_56ck75 FIND v(dout1_56) AT=380.025n

* CHECK dout1_57 Vdout1_57ck75 = 0 time = 380
.meas tran vdout1_57ck75 FIND v(dout1_57) AT=380.025n

* CHECK dout1_58 Vdout1_58ck75 = 0.9 time = 380
.meas tran vdout1_58ck75 FIND v(dout1_58) AT=380.025n

* CHECK dout1_59 Vdout1_59ck75 = 0.9 time = 380
.meas tran vdout1_59ck75 FIND v(dout1_59) AT=380.025n

* CHECK dout1_60 Vdout1_60ck75 = 0.9 time = 380
.meas tran vdout1_60ck75 FIND v(dout1_60) AT=380.025n

* CHECK dout1_61 Vdout1_61ck75 = 0.9 time = 380
.meas tran vdout1_61ck75 FIND v(dout1_61) AT=380.025n

* CHECK dout1_62 Vdout1_62ck75 = 0 time = 380
.meas tran vdout1_62ck75 FIND v(dout1_62) AT=380.025n

* CHECK dout1_63 Vdout1_63ck75 = 0.9 time = 380
.meas tran vdout1_63ck75 FIND v(dout1_63) AT=380.025n

* CHECK dout1_64 Vdout1_64ck75 = 0.9 time = 380
.meas tran vdout1_64ck75 FIND v(dout1_64) AT=380.025n

* CHECK dout1_65 Vdout1_65ck75 = 0.9 time = 380
.meas tran vdout1_65ck75 FIND v(dout1_65) AT=380.025n

* CHECK dout1_66 Vdout1_66ck75 = 0.9 time = 380
.meas tran vdout1_66ck75 FIND v(dout1_66) AT=380.025n

* CHECK dout1_67 Vdout1_67ck75 = 0.9 time = 380
.meas tran vdout1_67ck75 FIND v(dout1_67) AT=380.025n

* CHECK dout1_68 Vdout1_68ck75 = 0 time = 380
.meas tran vdout1_68ck75 FIND v(dout1_68) AT=380.025n

* CHECK dout1_69 Vdout1_69ck75 = 0.9 time = 380
.meas tran vdout1_69ck75 FIND v(dout1_69) AT=380.025n

* CHECK dout1_70 Vdout1_70ck75 = 0 time = 380
.meas tran vdout1_70ck75 FIND v(dout1_70) AT=380.025n

* CHECK dout1_71 Vdout1_71ck75 = 0.9 time = 380
.meas tran vdout1_71ck75 FIND v(dout1_71) AT=380.025n

* CHECK dout1_72 Vdout1_72ck75 = 0.9 time = 380
.meas tran vdout1_72ck75 FIND v(dout1_72) AT=380.025n

* CHECK dout1_73 Vdout1_73ck75 = 0.9 time = 380
.meas tran vdout1_73ck75 FIND v(dout1_73) AT=380.025n

* CHECK dout1_74 Vdout1_74ck75 = 0 time = 380
.meas tran vdout1_74ck75 FIND v(dout1_74) AT=380.025n

* CHECK dout1_75 Vdout1_75ck75 = 0 time = 380
.meas tran vdout1_75ck75 FIND v(dout1_75) AT=380.025n

* CHECK dout1_76 Vdout1_76ck75 = 0.9 time = 380
.meas tran vdout1_76ck75 FIND v(dout1_76) AT=380.025n

* CHECK dout1_77 Vdout1_77ck75 = 0.9 time = 380
.meas tran vdout1_77ck75 FIND v(dout1_77) AT=380.025n

* CHECK dout1_78 Vdout1_78ck75 = 0 time = 380
.meas tran vdout1_78ck75 FIND v(dout1_78) AT=380.025n

* CHECK dout1_79 Vdout1_79ck75 = 0 time = 380
.meas tran vdout1_79ck75 FIND v(dout1_79) AT=380.025n

* CHECK dout1_80 Vdout1_80ck75 = 0.9 time = 380
.meas tran vdout1_80ck75 FIND v(dout1_80) AT=380.025n

* CHECK dout1_81 Vdout1_81ck75 = 0 time = 380
.meas tran vdout1_81ck75 FIND v(dout1_81) AT=380.025n

* CHECK dout1_82 Vdout1_82ck75 = 0.9 time = 380
.meas tran vdout1_82ck75 FIND v(dout1_82) AT=380.025n

* CHECK dout1_83 Vdout1_83ck75 = 0 time = 380
.meas tran vdout1_83ck75 FIND v(dout1_83) AT=380.025n

* CHECK dout1_84 Vdout1_84ck75 = 0 time = 380
.meas tran vdout1_84ck75 FIND v(dout1_84) AT=380.025n

* CHECK dout1_85 Vdout1_85ck75 = 0 time = 380
.meas tran vdout1_85ck75 FIND v(dout1_85) AT=380.025n

* CHECK dout1_86 Vdout1_86ck75 = 0 time = 380
.meas tran vdout1_86ck75 FIND v(dout1_86) AT=380.025n

* CHECK dout1_87 Vdout1_87ck75 = 0 time = 380
.meas tran vdout1_87ck75 FIND v(dout1_87) AT=380.025n

* CHECK dout1_88 Vdout1_88ck75 = 0 time = 380
.meas tran vdout1_88ck75 FIND v(dout1_88) AT=380.025n

* CHECK dout1_89 Vdout1_89ck75 = 0.9 time = 380
.meas tran vdout1_89ck75 FIND v(dout1_89) AT=380.025n

* CHECK dout1_90 Vdout1_90ck75 = 0.9 time = 380
.meas tran vdout1_90ck75 FIND v(dout1_90) AT=380.025n

* CHECK dout1_91 Vdout1_91ck75 = 0 time = 380
.meas tran vdout1_91ck75 FIND v(dout1_91) AT=380.025n

* CHECK dout1_92 Vdout1_92ck75 = 0.9 time = 380
.meas tran vdout1_92ck75 FIND v(dout1_92) AT=380.025n

* CHECK dout1_93 Vdout1_93ck75 = 0.9 time = 380
.meas tran vdout1_93ck75 FIND v(dout1_93) AT=380.025n

* CHECK dout1_94 Vdout1_94ck75 = 0.9 time = 380
.meas tran vdout1_94ck75 FIND v(dout1_94) AT=380.025n

* CHECK dout1_95 Vdout1_95ck75 = 0.9 time = 380
.meas tran vdout1_95ck75 FIND v(dout1_95) AT=380.025n

* CHECK dout1_96 Vdout1_96ck75 = 0 time = 380
.meas tran vdout1_96ck75 FIND v(dout1_96) AT=380.025n

* CHECK dout1_97 Vdout1_97ck75 = 0 time = 380
.meas tran vdout1_97ck75 FIND v(dout1_97) AT=380.025n

* CHECK dout1_98 Vdout1_98ck75 = 0 time = 380
.meas tran vdout1_98ck75 FIND v(dout1_98) AT=380.025n

* CHECK dout1_99 Vdout1_99ck75 = 0.9 time = 380
.meas tran vdout1_99ck75 FIND v(dout1_99) AT=380.025n

* CHECK dout1_100 Vdout1_100ck75 = 0.9 time = 380
.meas tran vdout1_100ck75 FIND v(dout1_100) AT=380.025n

* CHECK dout1_101 Vdout1_101ck75 = 0 time = 380
.meas tran vdout1_101ck75 FIND v(dout1_101) AT=380.025n

* CHECK dout1_102 Vdout1_102ck75 = 0 time = 380
.meas tran vdout1_102ck75 FIND v(dout1_102) AT=380.025n

* CHECK dout1_103 Vdout1_103ck75 = 0.9 time = 380
.meas tran vdout1_103ck75 FIND v(dout1_103) AT=380.025n

* CHECK dout1_104 Vdout1_104ck75 = 0.9 time = 380
.meas tran vdout1_104ck75 FIND v(dout1_104) AT=380.025n

* CHECK dout1_105 Vdout1_105ck75 = 0.9 time = 380
.meas tran vdout1_105ck75 FIND v(dout1_105) AT=380.025n

* CHECK dout1_106 Vdout1_106ck75 = 0 time = 380
.meas tran vdout1_106ck75 FIND v(dout1_106) AT=380.025n

* CHECK dout1_107 Vdout1_107ck75 = 0.9 time = 380
.meas tran vdout1_107ck75 FIND v(dout1_107) AT=380.025n

* CHECK dout1_108 Vdout1_108ck75 = 0 time = 380
.meas tran vdout1_108ck75 FIND v(dout1_108) AT=380.025n

* CHECK dout1_109 Vdout1_109ck75 = 0 time = 380
.meas tran vdout1_109ck75 FIND v(dout1_109) AT=380.025n

* CHECK dout1_110 Vdout1_110ck75 = 0 time = 380
.meas tran vdout1_110ck75 FIND v(dout1_110) AT=380.025n

* CHECK dout1_111 Vdout1_111ck75 = 0 time = 380
.meas tran vdout1_111ck75 FIND v(dout1_111) AT=380.025n

* CHECK dout1_112 Vdout1_112ck75 = 0 time = 380
.meas tran vdout1_112ck75 FIND v(dout1_112) AT=380.025n

* CHECK dout1_113 Vdout1_113ck75 = 0.9 time = 380
.meas tran vdout1_113ck75 FIND v(dout1_113) AT=380.025n

* CHECK dout1_114 Vdout1_114ck75 = 0 time = 380
.meas tran vdout1_114ck75 FIND v(dout1_114) AT=380.025n

* CHECK dout1_115 Vdout1_115ck75 = 0 time = 380
.meas tran vdout1_115ck75 FIND v(dout1_115) AT=380.025n

* CHECK dout1_116 Vdout1_116ck75 = 0 time = 380
.meas tran vdout1_116ck75 FIND v(dout1_116) AT=380.025n

* CHECK dout1_117 Vdout1_117ck75 = 0 time = 380
.meas tran vdout1_117ck75 FIND v(dout1_117) AT=380.025n

* CHECK dout1_118 Vdout1_118ck75 = 0 time = 380
.meas tran vdout1_118ck75 FIND v(dout1_118) AT=380.025n

* CHECK dout1_119 Vdout1_119ck75 = 0 time = 380
.meas tran vdout1_119ck75 FIND v(dout1_119) AT=380.025n

* CHECK dout1_0 Vdout1_0ck78 = 0.9 time = 395
.meas tran vdout1_0ck78 FIND v(dout1_0) AT=395.025n

* CHECK dout1_1 Vdout1_1ck78 = 0.9 time = 395
.meas tran vdout1_1ck78 FIND v(dout1_1) AT=395.025n

* CHECK dout1_2 Vdout1_2ck78 = 0.9 time = 395
.meas tran vdout1_2ck78 FIND v(dout1_2) AT=395.025n

* CHECK dout1_3 Vdout1_3ck78 = 0.9 time = 395
.meas tran vdout1_3ck78 FIND v(dout1_3) AT=395.025n

* CHECK dout1_4 Vdout1_4ck78 = 0 time = 395
.meas tran vdout1_4ck78 FIND v(dout1_4) AT=395.025n

* CHECK dout1_5 Vdout1_5ck78 = 0.9 time = 395
.meas tran vdout1_5ck78 FIND v(dout1_5) AT=395.025n

* CHECK dout1_6 Vdout1_6ck78 = 0.9 time = 395
.meas tran vdout1_6ck78 FIND v(dout1_6) AT=395.025n

* CHECK dout1_7 Vdout1_7ck78 = 0.9 time = 395
.meas tran vdout1_7ck78 FIND v(dout1_7) AT=395.025n

* CHECK dout1_8 Vdout1_8ck78 = 0 time = 395
.meas tran vdout1_8ck78 FIND v(dout1_8) AT=395.025n

* CHECK dout1_9 Vdout1_9ck78 = 0.9 time = 395
.meas tran vdout1_9ck78 FIND v(dout1_9) AT=395.025n

* CHECK dout1_10 Vdout1_10ck78 = 0 time = 395
.meas tran vdout1_10ck78 FIND v(dout1_10) AT=395.025n

* CHECK dout1_11 Vdout1_11ck78 = 0.9 time = 395
.meas tran vdout1_11ck78 FIND v(dout1_11) AT=395.025n

* CHECK dout1_12 Vdout1_12ck78 = 0.9 time = 395
.meas tran vdout1_12ck78 FIND v(dout1_12) AT=395.025n

* CHECK dout1_13 Vdout1_13ck78 = 0.9 time = 395
.meas tran vdout1_13ck78 FIND v(dout1_13) AT=395.025n

* CHECK dout1_14 Vdout1_14ck78 = 0.9 time = 395
.meas tran vdout1_14ck78 FIND v(dout1_14) AT=395.025n

* CHECK dout1_15 Vdout1_15ck78 = 0.9 time = 395
.meas tran vdout1_15ck78 FIND v(dout1_15) AT=395.025n

* CHECK dout1_16 Vdout1_16ck78 = 0.9 time = 395
.meas tran vdout1_16ck78 FIND v(dout1_16) AT=395.025n

* CHECK dout1_17 Vdout1_17ck78 = 0.9 time = 395
.meas tran vdout1_17ck78 FIND v(dout1_17) AT=395.025n

* CHECK dout1_18 Vdout1_18ck78 = 0 time = 395
.meas tran vdout1_18ck78 FIND v(dout1_18) AT=395.025n

* CHECK dout1_19 Vdout1_19ck78 = 0.9 time = 395
.meas tran vdout1_19ck78 FIND v(dout1_19) AT=395.025n

* CHECK dout1_20 Vdout1_20ck78 = 0 time = 395
.meas tran vdout1_20ck78 FIND v(dout1_20) AT=395.025n

* CHECK dout1_21 Vdout1_21ck78 = 0 time = 395
.meas tran vdout1_21ck78 FIND v(dout1_21) AT=395.025n

* CHECK dout1_22 Vdout1_22ck78 = 0.9 time = 395
.meas tran vdout1_22ck78 FIND v(dout1_22) AT=395.025n

* CHECK dout1_23 Vdout1_23ck78 = 0 time = 395
.meas tran vdout1_23ck78 FIND v(dout1_23) AT=395.025n

* CHECK dout1_24 Vdout1_24ck78 = 0 time = 395
.meas tran vdout1_24ck78 FIND v(dout1_24) AT=395.025n

* CHECK dout1_25 Vdout1_25ck78 = 0 time = 395
.meas tran vdout1_25ck78 FIND v(dout1_25) AT=395.025n

* CHECK dout1_26 Vdout1_26ck78 = 0.9 time = 395
.meas tran vdout1_26ck78 FIND v(dout1_26) AT=395.025n

* CHECK dout1_27 Vdout1_27ck78 = 0 time = 395
.meas tran vdout1_27ck78 FIND v(dout1_27) AT=395.025n

* CHECK dout1_28 Vdout1_28ck78 = 0 time = 395
.meas tran vdout1_28ck78 FIND v(dout1_28) AT=395.025n

* CHECK dout1_29 Vdout1_29ck78 = 0.9 time = 395
.meas tran vdout1_29ck78 FIND v(dout1_29) AT=395.025n

* CHECK dout1_30 Vdout1_30ck78 = 0.9 time = 395
.meas tran vdout1_30ck78 FIND v(dout1_30) AT=395.025n

* CHECK dout1_31 Vdout1_31ck78 = 0 time = 395
.meas tran vdout1_31ck78 FIND v(dout1_31) AT=395.025n

* CHECK dout1_32 Vdout1_32ck78 = 0 time = 395
.meas tran vdout1_32ck78 FIND v(dout1_32) AT=395.025n

* CHECK dout1_33 Vdout1_33ck78 = 0.9 time = 395
.meas tran vdout1_33ck78 FIND v(dout1_33) AT=395.025n

* CHECK dout1_34 Vdout1_34ck78 = 0.9 time = 395
.meas tran vdout1_34ck78 FIND v(dout1_34) AT=395.025n

* CHECK dout1_35 Vdout1_35ck78 = 0.9 time = 395
.meas tran vdout1_35ck78 FIND v(dout1_35) AT=395.025n

* CHECK dout1_36 Vdout1_36ck78 = 0.9 time = 395
.meas tran vdout1_36ck78 FIND v(dout1_36) AT=395.025n

* CHECK dout1_37 Vdout1_37ck78 = 0 time = 395
.meas tran vdout1_37ck78 FIND v(dout1_37) AT=395.025n

* CHECK dout1_38 Vdout1_38ck78 = 0 time = 395
.meas tran vdout1_38ck78 FIND v(dout1_38) AT=395.025n

* CHECK dout1_39 Vdout1_39ck78 = 0 time = 395
.meas tran vdout1_39ck78 FIND v(dout1_39) AT=395.025n

* CHECK dout1_40 Vdout1_40ck78 = 0 time = 395
.meas tran vdout1_40ck78 FIND v(dout1_40) AT=395.025n

* CHECK dout1_41 Vdout1_41ck78 = 0.9 time = 395
.meas tran vdout1_41ck78 FIND v(dout1_41) AT=395.025n

* CHECK dout1_42 Vdout1_42ck78 = 0 time = 395
.meas tran vdout1_42ck78 FIND v(dout1_42) AT=395.025n

* CHECK dout1_43 Vdout1_43ck78 = 0.9 time = 395
.meas tran vdout1_43ck78 FIND v(dout1_43) AT=395.025n

* CHECK dout1_44 Vdout1_44ck78 = 0.9 time = 395
.meas tran vdout1_44ck78 FIND v(dout1_44) AT=395.025n

* CHECK dout1_45 Vdout1_45ck78 = 0 time = 395
.meas tran vdout1_45ck78 FIND v(dout1_45) AT=395.025n

* CHECK dout1_46 Vdout1_46ck78 = 0 time = 395
.meas tran vdout1_46ck78 FIND v(dout1_46) AT=395.025n

* CHECK dout1_47 Vdout1_47ck78 = 0.9 time = 395
.meas tran vdout1_47ck78 FIND v(dout1_47) AT=395.025n

* CHECK dout1_48 Vdout1_48ck78 = 0 time = 395
.meas tran vdout1_48ck78 FIND v(dout1_48) AT=395.025n

* CHECK dout1_49 Vdout1_49ck78 = 0 time = 395
.meas tran vdout1_49ck78 FIND v(dout1_49) AT=395.025n

* CHECK dout1_50 Vdout1_50ck78 = 0.9 time = 395
.meas tran vdout1_50ck78 FIND v(dout1_50) AT=395.025n

* CHECK dout1_51 Vdout1_51ck78 = 0.9 time = 395
.meas tran vdout1_51ck78 FIND v(dout1_51) AT=395.025n

* CHECK dout1_52 Vdout1_52ck78 = 0 time = 395
.meas tran vdout1_52ck78 FIND v(dout1_52) AT=395.025n

* CHECK dout1_53 Vdout1_53ck78 = 0.9 time = 395
.meas tran vdout1_53ck78 FIND v(dout1_53) AT=395.025n

* CHECK dout1_54 Vdout1_54ck78 = 0 time = 395
.meas tran vdout1_54ck78 FIND v(dout1_54) AT=395.025n

* CHECK dout1_55 Vdout1_55ck78 = 0 time = 395
.meas tran vdout1_55ck78 FIND v(dout1_55) AT=395.025n

* CHECK dout1_56 Vdout1_56ck78 = 0 time = 395
.meas tran vdout1_56ck78 FIND v(dout1_56) AT=395.025n

* CHECK dout1_57 Vdout1_57ck78 = 0.9 time = 395
.meas tran vdout1_57ck78 FIND v(dout1_57) AT=395.025n

* CHECK dout1_58 Vdout1_58ck78 = 0 time = 395
.meas tran vdout1_58ck78 FIND v(dout1_58) AT=395.025n

* CHECK dout1_59 Vdout1_59ck78 = 0 time = 395
.meas tran vdout1_59ck78 FIND v(dout1_59) AT=395.025n

* CHECK dout1_60 Vdout1_60ck78 = 0.9 time = 395
.meas tran vdout1_60ck78 FIND v(dout1_60) AT=395.025n

* CHECK dout1_61 Vdout1_61ck78 = 0 time = 395
.meas tran vdout1_61ck78 FIND v(dout1_61) AT=395.025n

* CHECK dout1_62 Vdout1_62ck78 = 0 time = 395
.meas tran vdout1_62ck78 FIND v(dout1_62) AT=395.025n

* CHECK dout1_63 Vdout1_63ck78 = 0.9 time = 395
.meas tran vdout1_63ck78 FIND v(dout1_63) AT=395.025n

* CHECK dout1_64 Vdout1_64ck78 = 0 time = 395
.meas tran vdout1_64ck78 FIND v(dout1_64) AT=395.025n

* CHECK dout1_65 Vdout1_65ck78 = 0.9 time = 395
.meas tran vdout1_65ck78 FIND v(dout1_65) AT=395.025n

* CHECK dout1_66 Vdout1_66ck78 = 0.9 time = 395
.meas tran vdout1_66ck78 FIND v(dout1_66) AT=395.025n

* CHECK dout1_67 Vdout1_67ck78 = 0 time = 395
.meas tran vdout1_67ck78 FIND v(dout1_67) AT=395.025n

* CHECK dout1_68 Vdout1_68ck78 = 0.9 time = 395
.meas tran vdout1_68ck78 FIND v(dout1_68) AT=395.025n

* CHECK dout1_69 Vdout1_69ck78 = 0.9 time = 395
.meas tran vdout1_69ck78 FIND v(dout1_69) AT=395.025n

* CHECK dout1_70 Vdout1_70ck78 = 0 time = 395
.meas tran vdout1_70ck78 FIND v(dout1_70) AT=395.025n

* CHECK dout1_71 Vdout1_71ck78 = 0.9 time = 395
.meas tran vdout1_71ck78 FIND v(dout1_71) AT=395.025n

* CHECK dout1_72 Vdout1_72ck78 = 0 time = 395
.meas tran vdout1_72ck78 FIND v(dout1_72) AT=395.025n

* CHECK dout1_73 Vdout1_73ck78 = 0.9 time = 395
.meas tran vdout1_73ck78 FIND v(dout1_73) AT=395.025n

* CHECK dout1_74 Vdout1_74ck78 = 0 time = 395
.meas tran vdout1_74ck78 FIND v(dout1_74) AT=395.025n

* CHECK dout1_75 Vdout1_75ck78 = 0.9 time = 395
.meas tran vdout1_75ck78 FIND v(dout1_75) AT=395.025n

* CHECK dout1_76 Vdout1_76ck78 = 0 time = 395
.meas tran vdout1_76ck78 FIND v(dout1_76) AT=395.025n

* CHECK dout1_77 Vdout1_77ck78 = 0.9 time = 395
.meas tran vdout1_77ck78 FIND v(dout1_77) AT=395.025n

* CHECK dout1_78 Vdout1_78ck78 = 0.9 time = 395
.meas tran vdout1_78ck78 FIND v(dout1_78) AT=395.025n

* CHECK dout1_79 Vdout1_79ck78 = 0 time = 395
.meas tran vdout1_79ck78 FIND v(dout1_79) AT=395.025n

* CHECK dout1_80 Vdout1_80ck78 = 0.9 time = 395
.meas tran vdout1_80ck78 FIND v(dout1_80) AT=395.025n

* CHECK dout1_81 Vdout1_81ck78 = 0 time = 395
.meas tran vdout1_81ck78 FIND v(dout1_81) AT=395.025n

* CHECK dout1_82 Vdout1_82ck78 = 0.9 time = 395
.meas tran vdout1_82ck78 FIND v(dout1_82) AT=395.025n

* CHECK dout1_83 Vdout1_83ck78 = 0 time = 395
.meas tran vdout1_83ck78 FIND v(dout1_83) AT=395.025n

* CHECK dout1_84 Vdout1_84ck78 = 0.9 time = 395
.meas tran vdout1_84ck78 FIND v(dout1_84) AT=395.025n

* CHECK dout1_85 Vdout1_85ck78 = 0.9 time = 395
.meas tran vdout1_85ck78 FIND v(dout1_85) AT=395.025n

* CHECK dout1_86 Vdout1_86ck78 = 0.9 time = 395
.meas tran vdout1_86ck78 FIND v(dout1_86) AT=395.025n

* CHECK dout1_87 Vdout1_87ck78 = 0 time = 395
.meas tran vdout1_87ck78 FIND v(dout1_87) AT=395.025n

* CHECK dout1_88 Vdout1_88ck78 = 0 time = 395
.meas tran vdout1_88ck78 FIND v(dout1_88) AT=395.025n

* CHECK dout1_89 Vdout1_89ck78 = 0.9 time = 395
.meas tran vdout1_89ck78 FIND v(dout1_89) AT=395.025n

* CHECK dout1_90 Vdout1_90ck78 = 0.9 time = 395
.meas tran vdout1_90ck78 FIND v(dout1_90) AT=395.025n

* CHECK dout1_91 Vdout1_91ck78 = 0 time = 395
.meas tran vdout1_91ck78 FIND v(dout1_91) AT=395.025n

* CHECK dout1_92 Vdout1_92ck78 = 0 time = 395
.meas tran vdout1_92ck78 FIND v(dout1_92) AT=395.025n

* CHECK dout1_93 Vdout1_93ck78 = 0 time = 395
.meas tran vdout1_93ck78 FIND v(dout1_93) AT=395.025n

* CHECK dout1_94 Vdout1_94ck78 = 0.9 time = 395
.meas tran vdout1_94ck78 FIND v(dout1_94) AT=395.025n

* CHECK dout1_95 Vdout1_95ck78 = 0.9 time = 395
.meas tran vdout1_95ck78 FIND v(dout1_95) AT=395.025n

* CHECK dout1_96 Vdout1_96ck78 = 0.9 time = 395
.meas tran vdout1_96ck78 FIND v(dout1_96) AT=395.025n

* CHECK dout1_97 Vdout1_97ck78 = 0.9 time = 395
.meas tran vdout1_97ck78 FIND v(dout1_97) AT=395.025n

* CHECK dout1_98 Vdout1_98ck78 = 0.9 time = 395
.meas tran vdout1_98ck78 FIND v(dout1_98) AT=395.025n

* CHECK dout1_99 Vdout1_99ck78 = 0 time = 395
.meas tran vdout1_99ck78 FIND v(dout1_99) AT=395.025n

* CHECK dout1_100 Vdout1_100ck78 = 0 time = 395
.meas tran vdout1_100ck78 FIND v(dout1_100) AT=395.025n

* CHECK dout1_101 Vdout1_101ck78 = 0.9 time = 395
.meas tran vdout1_101ck78 FIND v(dout1_101) AT=395.025n

* CHECK dout1_102 Vdout1_102ck78 = 0 time = 395
.meas tran vdout1_102ck78 FIND v(dout1_102) AT=395.025n

* CHECK dout1_103 Vdout1_103ck78 = 0 time = 395
.meas tran vdout1_103ck78 FIND v(dout1_103) AT=395.025n

* CHECK dout1_104 Vdout1_104ck78 = 0.9 time = 395
.meas tran vdout1_104ck78 FIND v(dout1_104) AT=395.025n

* CHECK dout1_105 Vdout1_105ck78 = 0.9 time = 395
.meas tran vdout1_105ck78 FIND v(dout1_105) AT=395.025n

* CHECK dout1_106 Vdout1_106ck78 = 0 time = 395
.meas tran vdout1_106ck78 FIND v(dout1_106) AT=395.025n

* CHECK dout1_107 Vdout1_107ck78 = 0 time = 395
.meas tran vdout1_107ck78 FIND v(dout1_107) AT=395.025n

* CHECK dout1_108 Vdout1_108ck78 = 0.9 time = 395
.meas tran vdout1_108ck78 FIND v(dout1_108) AT=395.025n

* CHECK dout1_109 Vdout1_109ck78 = 0 time = 395
.meas tran vdout1_109ck78 FIND v(dout1_109) AT=395.025n

* CHECK dout1_110 Vdout1_110ck78 = 0.9 time = 395
.meas tran vdout1_110ck78 FIND v(dout1_110) AT=395.025n

* CHECK dout1_111 Vdout1_111ck78 = 0 time = 395
.meas tran vdout1_111ck78 FIND v(dout1_111) AT=395.025n

* CHECK dout1_112 Vdout1_112ck78 = 0.9 time = 395
.meas tran vdout1_112ck78 FIND v(dout1_112) AT=395.025n

* CHECK dout1_113 Vdout1_113ck78 = 0 time = 395
.meas tran vdout1_113ck78 FIND v(dout1_113) AT=395.025n

* CHECK dout1_114 Vdout1_114ck78 = 0 time = 395
.meas tran vdout1_114ck78 FIND v(dout1_114) AT=395.025n

* CHECK dout1_115 Vdout1_115ck78 = 0 time = 395
.meas tran vdout1_115ck78 FIND v(dout1_115) AT=395.025n

* CHECK dout1_116 Vdout1_116ck78 = 0 time = 395
.meas tran vdout1_116ck78 FIND v(dout1_116) AT=395.025n

* CHECK dout1_117 Vdout1_117ck78 = 0 time = 395
.meas tran vdout1_117ck78 FIND v(dout1_117) AT=395.025n

* CHECK dout1_118 Vdout1_118ck78 = 0 time = 395
.meas tran vdout1_118ck78 FIND v(dout1_118) AT=395.025n

* CHECK dout1_119 Vdout1_119ck78 = 0.9 time = 395
.meas tran vdout1_119ck78 FIND v(dout1_119) AT=395.025n

* CHECK dout1_0 Vdout1_0ck79 = 0.9 time = 400
.meas tran vdout1_0ck79 FIND v(dout1_0) AT=400.025n

* CHECK dout1_1 Vdout1_1ck79 = 0.9 time = 400
.meas tran vdout1_1ck79 FIND v(dout1_1) AT=400.025n

* CHECK dout1_2 Vdout1_2ck79 = 0.9 time = 400
.meas tran vdout1_2ck79 FIND v(dout1_2) AT=400.025n

* CHECK dout1_3 Vdout1_3ck79 = 0.9 time = 400
.meas tran vdout1_3ck79 FIND v(dout1_3) AT=400.025n

* CHECK dout1_4 Vdout1_4ck79 = 0 time = 400
.meas tran vdout1_4ck79 FIND v(dout1_4) AT=400.025n

* CHECK dout1_5 Vdout1_5ck79 = 0.9 time = 400
.meas tran vdout1_5ck79 FIND v(dout1_5) AT=400.025n

* CHECK dout1_6 Vdout1_6ck79 = 0.9 time = 400
.meas tran vdout1_6ck79 FIND v(dout1_6) AT=400.025n

* CHECK dout1_7 Vdout1_7ck79 = 0.9 time = 400
.meas tran vdout1_7ck79 FIND v(dout1_7) AT=400.025n

* CHECK dout1_8 Vdout1_8ck79 = 0 time = 400
.meas tran vdout1_8ck79 FIND v(dout1_8) AT=400.025n

* CHECK dout1_9 Vdout1_9ck79 = 0.9 time = 400
.meas tran vdout1_9ck79 FIND v(dout1_9) AT=400.025n

* CHECK dout1_10 Vdout1_10ck79 = 0 time = 400
.meas tran vdout1_10ck79 FIND v(dout1_10) AT=400.025n

* CHECK dout1_11 Vdout1_11ck79 = 0.9 time = 400
.meas tran vdout1_11ck79 FIND v(dout1_11) AT=400.025n

* CHECK dout1_12 Vdout1_12ck79 = 0.9 time = 400
.meas tran vdout1_12ck79 FIND v(dout1_12) AT=400.025n

* CHECK dout1_13 Vdout1_13ck79 = 0.9 time = 400
.meas tran vdout1_13ck79 FIND v(dout1_13) AT=400.025n

* CHECK dout1_14 Vdout1_14ck79 = 0.9 time = 400
.meas tran vdout1_14ck79 FIND v(dout1_14) AT=400.025n

* CHECK dout1_15 Vdout1_15ck79 = 0.9 time = 400
.meas tran vdout1_15ck79 FIND v(dout1_15) AT=400.025n

* CHECK dout1_16 Vdout1_16ck79 = 0.9 time = 400
.meas tran vdout1_16ck79 FIND v(dout1_16) AT=400.025n

* CHECK dout1_17 Vdout1_17ck79 = 0.9 time = 400
.meas tran vdout1_17ck79 FIND v(dout1_17) AT=400.025n

* CHECK dout1_18 Vdout1_18ck79 = 0 time = 400
.meas tran vdout1_18ck79 FIND v(dout1_18) AT=400.025n

* CHECK dout1_19 Vdout1_19ck79 = 0.9 time = 400
.meas tran vdout1_19ck79 FIND v(dout1_19) AT=400.025n

* CHECK dout1_20 Vdout1_20ck79 = 0 time = 400
.meas tran vdout1_20ck79 FIND v(dout1_20) AT=400.025n

* CHECK dout1_21 Vdout1_21ck79 = 0 time = 400
.meas tran vdout1_21ck79 FIND v(dout1_21) AT=400.025n

* CHECK dout1_22 Vdout1_22ck79 = 0.9 time = 400
.meas tran vdout1_22ck79 FIND v(dout1_22) AT=400.025n

* CHECK dout1_23 Vdout1_23ck79 = 0 time = 400
.meas tran vdout1_23ck79 FIND v(dout1_23) AT=400.025n

* CHECK dout1_24 Vdout1_24ck79 = 0 time = 400
.meas tran vdout1_24ck79 FIND v(dout1_24) AT=400.025n

* CHECK dout1_25 Vdout1_25ck79 = 0 time = 400
.meas tran vdout1_25ck79 FIND v(dout1_25) AT=400.025n

* CHECK dout1_26 Vdout1_26ck79 = 0.9 time = 400
.meas tran vdout1_26ck79 FIND v(dout1_26) AT=400.025n

* CHECK dout1_27 Vdout1_27ck79 = 0 time = 400
.meas tran vdout1_27ck79 FIND v(dout1_27) AT=400.025n

* CHECK dout1_28 Vdout1_28ck79 = 0 time = 400
.meas tran vdout1_28ck79 FIND v(dout1_28) AT=400.025n

* CHECK dout1_29 Vdout1_29ck79 = 0.9 time = 400
.meas tran vdout1_29ck79 FIND v(dout1_29) AT=400.025n

* CHECK dout1_30 Vdout1_30ck79 = 0.9 time = 400
.meas tran vdout1_30ck79 FIND v(dout1_30) AT=400.025n

* CHECK dout1_31 Vdout1_31ck79 = 0 time = 400
.meas tran vdout1_31ck79 FIND v(dout1_31) AT=400.025n

* CHECK dout1_32 Vdout1_32ck79 = 0 time = 400
.meas tran vdout1_32ck79 FIND v(dout1_32) AT=400.025n

* CHECK dout1_33 Vdout1_33ck79 = 0.9 time = 400
.meas tran vdout1_33ck79 FIND v(dout1_33) AT=400.025n

* CHECK dout1_34 Vdout1_34ck79 = 0.9 time = 400
.meas tran vdout1_34ck79 FIND v(dout1_34) AT=400.025n

* CHECK dout1_35 Vdout1_35ck79 = 0.9 time = 400
.meas tran vdout1_35ck79 FIND v(dout1_35) AT=400.025n

* CHECK dout1_36 Vdout1_36ck79 = 0.9 time = 400
.meas tran vdout1_36ck79 FIND v(dout1_36) AT=400.025n

* CHECK dout1_37 Vdout1_37ck79 = 0 time = 400
.meas tran vdout1_37ck79 FIND v(dout1_37) AT=400.025n

* CHECK dout1_38 Vdout1_38ck79 = 0 time = 400
.meas tran vdout1_38ck79 FIND v(dout1_38) AT=400.025n

* CHECK dout1_39 Vdout1_39ck79 = 0 time = 400
.meas tran vdout1_39ck79 FIND v(dout1_39) AT=400.025n

* CHECK dout1_40 Vdout1_40ck79 = 0 time = 400
.meas tran vdout1_40ck79 FIND v(dout1_40) AT=400.025n

* CHECK dout1_41 Vdout1_41ck79 = 0.9 time = 400
.meas tran vdout1_41ck79 FIND v(dout1_41) AT=400.025n

* CHECK dout1_42 Vdout1_42ck79 = 0 time = 400
.meas tran vdout1_42ck79 FIND v(dout1_42) AT=400.025n

* CHECK dout1_43 Vdout1_43ck79 = 0.9 time = 400
.meas tran vdout1_43ck79 FIND v(dout1_43) AT=400.025n

* CHECK dout1_44 Vdout1_44ck79 = 0.9 time = 400
.meas tran vdout1_44ck79 FIND v(dout1_44) AT=400.025n

* CHECK dout1_45 Vdout1_45ck79 = 0 time = 400
.meas tran vdout1_45ck79 FIND v(dout1_45) AT=400.025n

* CHECK dout1_46 Vdout1_46ck79 = 0 time = 400
.meas tran vdout1_46ck79 FIND v(dout1_46) AT=400.025n

* CHECK dout1_47 Vdout1_47ck79 = 0.9 time = 400
.meas tran vdout1_47ck79 FIND v(dout1_47) AT=400.025n

* CHECK dout1_48 Vdout1_48ck79 = 0 time = 400
.meas tran vdout1_48ck79 FIND v(dout1_48) AT=400.025n

* CHECK dout1_49 Vdout1_49ck79 = 0 time = 400
.meas tran vdout1_49ck79 FIND v(dout1_49) AT=400.025n

* CHECK dout1_50 Vdout1_50ck79 = 0.9 time = 400
.meas tran vdout1_50ck79 FIND v(dout1_50) AT=400.025n

* CHECK dout1_51 Vdout1_51ck79 = 0.9 time = 400
.meas tran vdout1_51ck79 FIND v(dout1_51) AT=400.025n

* CHECK dout1_52 Vdout1_52ck79 = 0 time = 400
.meas tran vdout1_52ck79 FIND v(dout1_52) AT=400.025n

* CHECK dout1_53 Vdout1_53ck79 = 0.9 time = 400
.meas tran vdout1_53ck79 FIND v(dout1_53) AT=400.025n

* CHECK dout1_54 Vdout1_54ck79 = 0 time = 400
.meas tran vdout1_54ck79 FIND v(dout1_54) AT=400.025n

* CHECK dout1_55 Vdout1_55ck79 = 0 time = 400
.meas tran vdout1_55ck79 FIND v(dout1_55) AT=400.025n

* CHECK dout1_56 Vdout1_56ck79 = 0 time = 400
.meas tran vdout1_56ck79 FIND v(dout1_56) AT=400.025n

* CHECK dout1_57 Vdout1_57ck79 = 0.9 time = 400
.meas tran vdout1_57ck79 FIND v(dout1_57) AT=400.025n

* CHECK dout1_58 Vdout1_58ck79 = 0 time = 400
.meas tran vdout1_58ck79 FIND v(dout1_58) AT=400.025n

* CHECK dout1_59 Vdout1_59ck79 = 0 time = 400
.meas tran vdout1_59ck79 FIND v(dout1_59) AT=400.025n

* CHECK dout1_60 Vdout1_60ck79 = 0.9 time = 400
.meas tran vdout1_60ck79 FIND v(dout1_60) AT=400.025n

* CHECK dout1_61 Vdout1_61ck79 = 0 time = 400
.meas tran vdout1_61ck79 FIND v(dout1_61) AT=400.025n

* CHECK dout1_62 Vdout1_62ck79 = 0 time = 400
.meas tran vdout1_62ck79 FIND v(dout1_62) AT=400.025n

* CHECK dout1_63 Vdout1_63ck79 = 0.9 time = 400
.meas tran vdout1_63ck79 FIND v(dout1_63) AT=400.025n

* CHECK dout1_64 Vdout1_64ck79 = 0 time = 400
.meas tran vdout1_64ck79 FIND v(dout1_64) AT=400.025n

* CHECK dout1_65 Vdout1_65ck79 = 0.9 time = 400
.meas tran vdout1_65ck79 FIND v(dout1_65) AT=400.025n

* CHECK dout1_66 Vdout1_66ck79 = 0.9 time = 400
.meas tran vdout1_66ck79 FIND v(dout1_66) AT=400.025n

* CHECK dout1_67 Vdout1_67ck79 = 0 time = 400
.meas tran vdout1_67ck79 FIND v(dout1_67) AT=400.025n

* CHECK dout1_68 Vdout1_68ck79 = 0.9 time = 400
.meas tran vdout1_68ck79 FIND v(dout1_68) AT=400.025n

* CHECK dout1_69 Vdout1_69ck79 = 0.9 time = 400
.meas tran vdout1_69ck79 FIND v(dout1_69) AT=400.025n

* CHECK dout1_70 Vdout1_70ck79 = 0 time = 400
.meas tran vdout1_70ck79 FIND v(dout1_70) AT=400.025n

* CHECK dout1_71 Vdout1_71ck79 = 0.9 time = 400
.meas tran vdout1_71ck79 FIND v(dout1_71) AT=400.025n

* CHECK dout1_72 Vdout1_72ck79 = 0 time = 400
.meas tran vdout1_72ck79 FIND v(dout1_72) AT=400.025n

* CHECK dout1_73 Vdout1_73ck79 = 0.9 time = 400
.meas tran vdout1_73ck79 FIND v(dout1_73) AT=400.025n

* CHECK dout1_74 Vdout1_74ck79 = 0 time = 400
.meas tran vdout1_74ck79 FIND v(dout1_74) AT=400.025n

* CHECK dout1_75 Vdout1_75ck79 = 0.9 time = 400
.meas tran vdout1_75ck79 FIND v(dout1_75) AT=400.025n

* CHECK dout1_76 Vdout1_76ck79 = 0 time = 400
.meas tran vdout1_76ck79 FIND v(dout1_76) AT=400.025n

* CHECK dout1_77 Vdout1_77ck79 = 0.9 time = 400
.meas tran vdout1_77ck79 FIND v(dout1_77) AT=400.025n

* CHECK dout1_78 Vdout1_78ck79 = 0.9 time = 400
.meas tran vdout1_78ck79 FIND v(dout1_78) AT=400.025n

* CHECK dout1_79 Vdout1_79ck79 = 0 time = 400
.meas tran vdout1_79ck79 FIND v(dout1_79) AT=400.025n

* CHECK dout1_80 Vdout1_80ck79 = 0.9 time = 400
.meas tran vdout1_80ck79 FIND v(dout1_80) AT=400.025n

* CHECK dout1_81 Vdout1_81ck79 = 0 time = 400
.meas tran vdout1_81ck79 FIND v(dout1_81) AT=400.025n

* CHECK dout1_82 Vdout1_82ck79 = 0.9 time = 400
.meas tran vdout1_82ck79 FIND v(dout1_82) AT=400.025n

* CHECK dout1_83 Vdout1_83ck79 = 0 time = 400
.meas tran vdout1_83ck79 FIND v(dout1_83) AT=400.025n

* CHECK dout1_84 Vdout1_84ck79 = 0.9 time = 400
.meas tran vdout1_84ck79 FIND v(dout1_84) AT=400.025n

* CHECK dout1_85 Vdout1_85ck79 = 0.9 time = 400
.meas tran vdout1_85ck79 FIND v(dout1_85) AT=400.025n

* CHECK dout1_86 Vdout1_86ck79 = 0.9 time = 400
.meas tran vdout1_86ck79 FIND v(dout1_86) AT=400.025n

* CHECK dout1_87 Vdout1_87ck79 = 0 time = 400
.meas tran vdout1_87ck79 FIND v(dout1_87) AT=400.025n

* CHECK dout1_88 Vdout1_88ck79 = 0 time = 400
.meas tran vdout1_88ck79 FIND v(dout1_88) AT=400.025n

* CHECK dout1_89 Vdout1_89ck79 = 0.9 time = 400
.meas tran vdout1_89ck79 FIND v(dout1_89) AT=400.025n

* CHECK dout1_90 Vdout1_90ck79 = 0.9 time = 400
.meas tran vdout1_90ck79 FIND v(dout1_90) AT=400.025n

* CHECK dout1_91 Vdout1_91ck79 = 0 time = 400
.meas tran vdout1_91ck79 FIND v(dout1_91) AT=400.025n

* CHECK dout1_92 Vdout1_92ck79 = 0 time = 400
.meas tran vdout1_92ck79 FIND v(dout1_92) AT=400.025n

* CHECK dout1_93 Vdout1_93ck79 = 0 time = 400
.meas tran vdout1_93ck79 FIND v(dout1_93) AT=400.025n

* CHECK dout1_94 Vdout1_94ck79 = 0.9 time = 400
.meas tran vdout1_94ck79 FIND v(dout1_94) AT=400.025n

* CHECK dout1_95 Vdout1_95ck79 = 0.9 time = 400
.meas tran vdout1_95ck79 FIND v(dout1_95) AT=400.025n

* CHECK dout1_96 Vdout1_96ck79 = 0.9 time = 400
.meas tran vdout1_96ck79 FIND v(dout1_96) AT=400.025n

* CHECK dout1_97 Vdout1_97ck79 = 0.9 time = 400
.meas tran vdout1_97ck79 FIND v(dout1_97) AT=400.025n

* CHECK dout1_98 Vdout1_98ck79 = 0.9 time = 400
.meas tran vdout1_98ck79 FIND v(dout1_98) AT=400.025n

* CHECK dout1_99 Vdout1_99ck79 = 0 time = 400
.meas tran vdout1_99ck79 FIND v(dout1_99) AT=400.025n

* CHECK dout1_100 Vdout1_100ck79 = 0 time = 400
.meas tran vdout1_100ck79 FIND v(dout1_100) AT=400.025n

* CHECK dout1_101 Vdout1_101ck79 = 0.9 time = 400
.meas tran vdout1_101ck79 FIND v(dout1_101) AT=400.025n

* CHECK dout1_102 Vdout1_102ck79 = 0 time = 400
.meas tran vdout1_102ck79 FIND v(dout1_102) AT=400.025n

* CHECK dout1_103 Vdout1_103ck79 = 0 time = 400
.meas tran vdout1_103ck79 FIND v(dout1_103) AT=400.025n

* CHECK dout1_104 Vdout1_104ck79 = 0.9 time = 400
.meas tran vdout1_104ck79 FIND v(dout1_104) AT=400.025n

* CHECK dout1_105 Vdout1_105ck79 = 0.9 time = 400
.meas tran vdout1_105ck79 FIND v(dout1_105) AT=400.025n

* CHECK dout1_106 Vdout1_106ck79 = 0 time = 400
.meas tran vdout1_106ck79 FIND v(dout1_106) AT=400.025n

* CHECK dout1_107 Vdout1_107ck79 = 0 time = 400
.meas tran vdout1_107ck79 FIND v(dout1_107) AT=400.025n

* CHECK dout1_108 Vdout1_108ck79 = 0.9 time = 400
.meas tran vdout1_108ck79 FIND v(dout1_108) AT=400.025n

* CHECK dout1_109 Vdout1_109ck79 = 0 time = 400
.meas tran vdout1_109ck79 FIND v(dout1_109) AT=400.025n

* CHECK dout1_110 Vdout1_110ck79 = 0.9 time = 400
.meas tran vdout1_110ck79 FIND v(dout1_110) AT=400.025n

* CHECK dout1_111 Vdout1_111ck79 = 0 time = 400
.meas tran vdout1_111ck79 FIND v(dout1_111) AT=400.025n

* CHECK dout1_112 Vdout1_112ck79 = 0.9 time = 400
.meas tran vdout1_112ck79 FIND v(dout1_112) AT=400.025n

* CHECK dout1_113 Vdout1_113ck79 = 0 time = 400
.meas tran vdout1_113ck79 FIND v(dout1_113) AT=400.025n

* CHECK dout1_114 Vdout1_114ck79 = 0 time = 400
.meas tran vdout1_114ck79 FIND v(dout1_114) AT=400.025n

* CHECK dout1_115 Vdout1_115ck79 = 0 time = 400
.meas tran vdout1_115ck79 FIND v(dout1_115) AT=400.025n

* CHECK dout1_116 Vdout1_116ck79 = 0 time = 400
.meas tran vdout1_116ck79 FIND v(dout1_116) AT=400.025n

* CHECK dout1_117 Vdout1_117ck79 = 0 time = 400
.meas tran vdout1_117ck79 FIND v(dout1_117) AT=400.025n

* CHECK dout1_118 Vdout1_118ck79 = 0 time = 400
.meas tran vdout1_118ck79 FIND v(dout1_118) AT=400.025n

* CHECK dout1_119 Vdout1_119ck79 = 0.9 time = 400
.meas tran vdout1_119ck79 FIND v(dout1_119) AT=400.025n

* CHECK dout1_0 Vdout1_0ck80 = 0.9 time = 405
.meas tran vdout1_0ck80 FIND v(dout1_0) AT=405.025n

* CHECK dout1_1 Vdout1_1ck80 = 0.9 time = 405
.meas tran vdout1_1ck80 FIND v(dout1_1) AT=405.025n

* CHECK dout1_2 Vdout1_2ck80 = 0 time = 405
.meas tran vdout1_2ck80 FIND v(dout1_2) AT=405.025n

* CHECK dout1_3 Vdout1_3ck80 = 0.9 time = 405
.meas tran vdout1_3ck80 FIND v(dout1_3) AT=405.025n

* CHECK dout1_4 Vdout1_4ck80 = 0 time = 405
.meas tran vdout1_4ck80 FIND v(dout1_4) AT=405.025n

* CHECK dout1_5 Vdout1_5ck80 = 0 time = 405
.meas tran vdout1_5ck80 FIND v(dout1_5) AT=405.025n

* CHECK dout1_6 Vdout1_6ck80 = 0 time = 405
.meas tran vdout1_6ck80 FIND v(dout1_6) AT=405.025n

* CHECK dout1_7 Vdout1_7ck80 = 0.9 time = 405
.meas tran vdout1_7ck80 FIND v(dout1_7) AT=405.025n

* CHECK dout1_8 Vdout1_8ck80 = 0.9 time = 405
.meas tran vdout1_8ck80 FIND v(dout1_8) AT=405.025n

* CHECK dout1_9 Vdout1_9ck80 = 0.9 time = 405
.meas tran vdout1_9ck80 FIND v(dout1_9) AT=405.025n

* CHECK dout1_10 Vdout1_10ck80 = 0.9 time = 405
.meas tran vdout1_10ck80 FIND v(dout1_10) AT=405.025n

* CHECK dout1_11 Vdout1_11ck80 = 0 time = 405
.meas tran vdout1_11ck80 FIND v(dout1_11) AT=405.025n

* CHECK dout1_12 Vdout1_12ck80 = 0.9 time = 405
.meas tran vdout1_12ck80 FIND v(dout1_12) AT=405.025n

* CHECK dout1_13 Vdout1_13ck80 = 0.9 time = 405
.meas tran vdout1_13ck80 FIND v(dout1_13) AT=405.025n

* CHECK dout1_14 Vdout1_14ck80 = 0.9 time = 405
.meas tran vdout1_14ck80 FIND v(dout1_14) AT=405.025n

* CHECK dout1_15 Vdout1_15ck80 = 0.9 time = 405
.meas tran vdout1_15ck80 FIND v(dout1_15) AT=405.025n

* CHECK dout1_16 Vdout1_16ck80 = 0.9 time = 405
.meas tran vdout1_16ck80 FIND v(dout1_16) AT=405.025n

* CHECK dout1_17 Vdout1_17ck80 = 0.9 time = 405
.meas tran vdout1_17ck80 FIND v(dout1_17) AT=405.025n

* CHECK dout1_18 Vdout1_18ck80 = 0.9 time = 405
.meas tran vdout1_18ck80 FIND v(dout1_18) AT=405.025n

* CHECK dout1_19 Vdout1_19ck80 = 0 time = 405
.meas tran vdout1_19ck80 FIND v(dout1_19) AT=405.025n

* CHECK dout1_20 Vdout1_20ck80 = 0 time = 405
.meas tran vdout1_20ck80 FIND v(dout1_20) AT=405.025n

* CHECK dout1_21 Vdout1_21ck80 = 0.9 time = 405
.meas tran vdout1_21ck80 FIND v(dout1_21) AT=405.025n

* CHECK dout1_22 Vdout1_22ck80 = 0.9 time = 405
.meas tran vdout1_22ck80 FIND v(dout1_22) AT=405.025n

* CHECK dout1_23 Vdout1_23ck80 = 0 time = 405
.meas tran vdout1_23ck80 FIND v(dout1_23) AT=405.025n

* CHECK dout1_24 Vdout1_24ck80 = 0.9 time = 405
.meas tran vdout1_24ck80 FIND v(dout1_24) AT=405.025n

* CHECK dout1_25 Vdout1_25ck80 = 0.9 time = 405
.meas tran vdout1_25ck80 FIND v(dout1_25) AT=405.025n

* CHECK dout1_26 Vdout1_26ck80 = 0.9 time = 405
.meas tran vdout1_26ck80 FIND v(dout1_26) AT=405.025n

* CHECK dout1_27 Vdout1_27ck80 = 0.9 time = 405
.meas tran vdout1_27ck80 FIND v(dout1_27) AT=405.025n

* CHECK dout1_28 Vdout1_28ck80 = 0 time = 405
.meas tran vdout1_28ck80 FIND v(dout1_28) AT=405.025n

* CHECK dout1_29 Vdout1_29ck80 = 0.9 time = 405
.meas tran vdout1_29ck80 FIND v(dout1_29) AT=405.025n

* CHECK dout1_30 Vdout1_30ck80 = 0.9 time = 405
.meas tran vdout1_30ck80 FIND v(dout1_30) AT=405.025n

* CHECK dout1_31 Vdout1_31ck80 = 0.9 time = 405
.meas tran vdout1_31ck80 FIND v(dout1_31) AT=405.025n

* CHECK dout1_32 Vdout1_32ck80 = 0 time = 405
.meas tran vdout1_32ck80 FIND v(dout1_32) AT=405.025n

* CHECK dout1_33 Vdout1_33ck80 = 0 time = 405
.meas tran vdout1_33ck80 FIND v(dout1_33) AT=405.025n

* CHECK dout1_34 Vdout1_34ck80 = 0 time = 405
.meas tran vdout1_34ck80 FIND v(dout1_34) AT=405.025n

* CHECK dout1_35 Vdout1_35ck80 = 0.9 time = 405
.meas tran vdout1_35ck80 FIND v(dout1_35) AT=405.025n

* CHECK dout1_36 Vdout1_36ck80 = 0 time = 405
.meas tran vdout1_36ck80 FIND v(dout1_36) AT=405.025n

* CHECK dout1_37 Vdout1_37ck80 = 0.9 time = 405
.meas tran vdout1_37ck80 FIND v(dout1_37) AT=405.025n

* CHECK dout1_38 Vdout1_38ck80 = 0 time = 405
.meas tran vdout1_38ck80 FIND v(dout1_38) AT=405.025n

* CHECK dout1_39 Vdout1_39ck80 = 0.9 time = 405
.meas tran vdout1_39ck80 FIND v(dout1_39) AT=405.025n

* CHECK dout1_40 Vdout1_40ck80 = 0 time = 405
.meas tran vdout1_40ck80 FIND v(dout1_40) AT=405.025n

* CHECK dout1_41 Vdout1_41ck80 = 0.9 time = 405
.meas tran vdout1_41ck80 FIND v(dout1_41) AT=405.025n

* CHECK dout1_42 Vdout1_42ck80 = 0 time = 405
.meas tran vdout1_42ck80 FIND v(dout1_42) AT=405.025n

* CHECK dout1_43 Vdout1_43ck80 = 0 time = 405
.meas tran vdout1_43ck80 FIND v(dout1_43) AT=405.025n

* CHECK dout1_44 Vdout1_44ck80 = 0 time = 405
.meas tran vdout1_44ck80 FIND v(dout1_44) AT=405.025n

* CHECK dout1_45 Vdout1_45ck80 = 0.9 time = 405
.meas tran vdout1_45ck80 FIND v(dout1_45) AT=405.025n

* CHECK dout1_46 Vdout1_46ck80 = 0 time = 405
.meas tran vdout1_46ck80 FIND v(dout1_46) AT=405.025n

* CHECK dout1_47 Vdout1_47ck80 = 0 time = 405
.meas tran vdout1_47ck80 FIND v(dout1_47) AT=405.025n

* CHECK dout1_48 Vdout1_48ck80 = 0.9 time = 405
.meas tran vdout1_48ck80 FIND v(dout1_48) AT=405.025n

* CHECK dout1_49 Vdout1_49ck80 = 0.9 time = 405
.meas tran vdout1_49ck80 FIND v(dout1_49) AT=405.025n

* CHECK dout1_50 Vdout1_50ck80 = 0 time = 405
.meas tran vdout1_50ck80 FIND v(dout1_50) AT=405.025n

* CHECK dout1_51 Vdout1_51ck80 = 0 time = 405
.meas tran vdout1_51ck80 FIND v(dout1_51) AT=405.025n

* CHECK dout1_52 Vdout1_52ck80 = 0 time = 405
.meas tran vdout1_52ck80 FIND v(dout1_52) AT=405.025n

* CHECK dout1_53 Vdout1_53ck80 = 0.9 time = 405
.meas tran vdout1_53ck80 FIND v(dout1_53) AT=405.025n

* CHECK dout1_54 Vdout1_54ck80 = 0.9 time = 405
.meas tran vdout1_54ck80 FIND v(dout1_54) AT=405.025n

* CHECK dout1_55 Vdout1_55ck80 = 0.9 time = 405
.meas tran vdout1_55ck80 FIND v(dout1_55) AT=405.025n

* CHECK dout1_56 Vdout1_56ck80 = 0.9 time = 405
.meas tran vdout1_56ck80 FIND v(dout1_56) AT=405.025n

* CHECK dout1_57 Vdout1_57ck80 = 0.9 time = 405
.meas tran vdout1_57ck80 FIND v(dout1_57) AT=405.025n

* CHECK dout1_58 Vdout1_58ck80 = 0 time = 405
.meas tran vdout1_58ck80 FIND v(dout1_58) AT=405.025n

* CHECK dout1_59 Vdout1_59ck80 = 0.9 time = 405
.meas tran vdout1_59ck80 FIND v(dout1_59) AT=405.025n

* CHECK dout1_60 Vdout1_60ck80 = 0 time = 405
.meas tran vdout1_60ck80 FIND v(dout1_60) AT=405.025n

* CHECK dout1_61 Vdout1_61ck80 = 0 time = 405
.meas tran vdout1_61ck80 FIND v(dout1_61) AT=405.025n

* CHECK dout1_62 Vdout1_62ck80 = 0 time = 405
.meas tran vdout1_62ck80 FIND v(dout1_62) AT=405.025n

* CHECK dout1_63 Vdout1_63ck80 = 0.9 time = 405
.meas tran vdout1_63ck80 FIND v(dout1_63) AT=405.025n

* CHECK dout1_64 Vdout1_64ck80 = 0 time = 405
.meas tran vdout1_64ck80 FIND v(dout1_64) AT=405.025n

* CHECK dout1_65 Vdout1_65ck80 = 0 time = 405
.meas tran vdout1_65ck80 FIND v(dout1_65) AT=405.025n

* CHECK dout1_66 Vdout1_66ck80 = 0.9 time = 405
.meas tran vdout1_66ck80 FIND v(dout1_66) AT=405.025n

* CHECK dout1_67 Vdout1_67ck80 = 0 time = 405
.meas tran vdout1_67ck80 FIND v(dout1_67) AT=405.025n

* CHECK dout1_68 Vdout1_68ck80 = 0 time = 405
.meas tran vdout1_68ck80 FIND v(dout1_68) AT=405.025n

* CHECK dout1_69 Vdout1_69ck80 = 0 time = 405
.meas tran vdout1_69ck80 FIND v(dout1_69) AT=405.025n

* CHECK dout1_70 Vdout1_70ck80 = 0.9 time = 405
.meas tran vdout1_70ck80 FIND v(dout1_70) AT=405.025n

* CHECK dout1_71 Vdout1_71ck80 = 0 time = 405
.meas tran vdout1_71ck80 FIND v(dout1_71) AT=405.025n

* CHECK dout1_72 Vdout1_72ck80 = 0 time = 405
.meas tran vdout1_72ck80 FIND v(dout1_72) AT=405.025n

* CHECK dout1_73 Vdout1_73ck80 = 0 time = 405
.meas tran vdout1_73ck80 FIND v(dout1_73) AT=405.025n

* CHECK dout1_74 Vdout1_74ck80 = 0.9 time = 405
.meas tran vdout1_74ck80 FIND v(dout1_74) AT=405.025n

* CHECK dout1_75 Vdout1_75ck80 = 0 time = 405
.meas tran vdout1_75ck80 FIND v(dout1_75) AT=405.025n

* CHECK dout1_76 Vdout1_76ck80 = 0 time = 405
.meas tran vdout1_76ck80 FIND v(dout1_76) AT=405.025n

* CHECK dout1_77 Vdout1_77ck80 = 0.9 time = 405
.meas tran vdout1_77ck80 FIND v(dout1_77) AT=405.025n

* CHECK dout1_78 Vdout1_78ck80 = 0 time = 405
.meas tran vdout1_78ck80 FIND v(dout1_78) AT=405.025n

* CHECK dout1_79 Vdout1_79ck80 = 0 time = 405
.meas tran vdout1_79ck80 FIND v(dout1_79) AT=405.025n

* CHECK dout1_80 Vdout1_80ck80 = 0.9 time = 405
.meas tran vdout1_80ck80 FIND v(dout1_80) AT=405.025n

* CHECK dout1_81 Vdout1_81ck80 = 0.9 time = 405
.meas tran vdout1_81ck80 FIND v(dout1_81) AT=405.025n

* CHECK dout1_82 Vdout1_82ck80 = 0.9 time = 405
.meas tran vdout1_82ck80 FIND v(dout1_82) AT=405.025n

* CHECK dout1_83 Vdout1_83ck80 = 0 time = 405
.meas tran vdout1_83ck80 FIND v(dout1_83) AT=405.025n

* CHECK dout1_84 Vdout1_84ck80 = 0 time = 405
.meas tran vdout1_84ck80 FIND v(dout1_84) AT=405.025n

* CHECK dout1_85 Vdout1_85ck80 = 0.9 time = 405
.meas tran vdout1_85ck80 FIND v(dout1_85) AT=405.025n

* CHECK dout1_86 Vdout1_86ck80 = 0 time = 405
.meas tran vdout1_86ck80 FIND v(dout1_86) AT=405.025n

* CHECK dout1_87 Vdout1_87ck80 = 0.9 time = 405
.meas tran vdout1_87ck80 FIND v(dout1_87) AT=405.025n

* CHECK dout1_88 Vdout1_88ck80 = 0 time = 405
.meas tran vdout1_88ck80 FIND v(dout1_88) AT=405.025n

* CHECK dout1_89 Vdout1_89ck80 = 0 time = 405
.meas tran vdout1_89ck80 FIND v(dout1_89) AT=405.025n

* CHECK dout1_90 Vdout1_90ck80 = 0 time = 405
.meas tran vdout1_90ck80 FIND v(dout1_90) AT=405.025n

* CHECK dout1_91 Vdout1_91ck80 = 0.9 time = 405
.meas tran vdout1_91ck80 FIND v(dout1_91) AT=405.025n

* CHECK dout1_92 Vdout1_92ck80 = 0.9 time = 405
.meas tran vdout1_92ck80 FIND v(dout1_92) AT=405.025n

* CHECK dout1_93 Vdout1_93ck80 = 0 time = 405
.meas tran vdout1_93ck80 FIND v(dout1_93) AT=405.025n

* CHECK dout1_94 Vdout1_94ck80 = 0.9 time = 405
.meas tran vdout1_94ck80 FIND v(dout1_94) AT=405.025n

* CHECK dout1_95 Vdout1_95ck80 = 0 time = 405
.meas tran vdout1_95ck80 FIND v(dout1_95) AT=405.025n

* CHECK dout1_96 Vdout1_96ck80 = 0 time = 405
.meas tran vdout1_96ck80 FIND v(dout1_96) AT=405.025n

* CHECK dout1_97 Vdout1_97ck80 = 0 time = 405
.meas tran vdout1_97ck80 FIND v(dout1_97) AT=405.025n

* CHECK dout1_98 Vdout1_98ck80 = 0 time = 405
.meas tran vdout1_98ck80 FIND v(dout1_98) AT=405.025n

* CHECK dout1_99 Vdout1_99ck80 = 0 time = 405
.meas tran vdout1_99ck80 FIND v(dout1_99) AT=405.025n

* CHECK dout1_100 Vdout1_100ck80 = 0 time = 405
.meas tran vdout1_100ck80 FIND v(dout1_100) AT=405.025n

* CHECK dout1_101 Vdout1_101ck80 = 0.9 time = 405
.meas tran vdout1_101ck80 FIND v(dout1_101) AT=405.025n

* CHECK dout1_102 Vdout1_102ck80 = 0 time = 405
.meas tran vdout1_102ck80 FIND v(dout1_102) AT=405.025n

* CHECK dout1_103 Vdout1_103ck80 = 0.9 time = 405
.meas tran vdout1_103ck80 FIND v(dout1_103) AT=405.025n

* CHECK dout1_104 Vdout1_104ck80 = 0 time = 405
.meas tran vdout1_104ck80 FIND v(dout1_104) AT=405.025n

* CHECK dout1_105 Vdout1_105ck80 = 0 time = 405
.meas tran vdout1_105ck80 FIND v(dout1_105) AT=405.025n

* CHECK dout1_106 Vdout1_106ck80 = 0 time = 405
.meas tran vdout1_106ck80 FIND v(dout1_106) AT=405.025n

* CHECK dout1_107 Vdout1_107ck80 = 0.9 time = 405
.meas tran vdout1_107ck80 FIND v(dout1_107) AT=405.025n

* CHECK dout1_108 Vdout1_108ck80 = 0 time = 405
.meas tran vdout1_108ck80 FIND v(dout1_108) AT=405.025n

* CHECK dout1_109 Vdout1_109ck80 = 0 time = 405
.meas tran vdout1_109ck80 FIND v(dout1_109) AT=405.025n

* CHECK dout1_110 Vdout1_110ck80 = 0.9 time = 405
.meas tran vdout1_110ck80 FIND v(dout1_110) AT=405.025n

* CHECK dout1_111 Vdout1_111ck80 = 0.9 time = 405
.meas tran vdout1_111ck80 FIND v(dout1_111) AT=405.025n

* CHECK dout1_112 Vdout1_112ck80 = 0 time = 405
.meas tran vdout1_112ck80 FIND v(dout1_112) AT=405.025n

* CHECK dout1_113 Vdout1_113ck80 = 0.9 time = 405
.meas tran vdout1_113ck80 FIND v(dout1_113) AT=405.025n

* CHECK dout1_114 Vdout1_114ck80 = 0 time = 405
.meas tran vdout1_114ck80 FIND v(dout1_114) AT=405.025n

* CHECK dout1_115 Vdout1_115ck80 = 0 time = 405
.meas tran vdout1_115ck80 FIND v(dout1_115) AT=405.025n

* CHECK dout1_116 Vdout1_116ck80 = 0 time = 405
.meas tran vdout1_116ck80 FIND v(dout1_116) AT=405.025n

* CHECK dout1_117 Vdout1_117ck80 = 0 time = 405
.meas tran vdout1_117ck80 FIND v(dout1_117) AT=405.025n

* CHECK dout1_118 Vdout1_118ck80 = 0 time = 405
.meas tran vdout1_118ck80 FIND v(dout1_118) AT=405.025n

* CHECK dout1_119 Vdout1_119ck80 = 0 time = 405
.meas tran vdout1_119ck80 FIND v(dout1_119) AT=405.025n

* CHECK dout1_0 Vdout1_0ck84 = 0 time = 425
.meas tran vdout1_0ck84 FIND v(dout1_0) AT=425.025n

* CHECK dout1_1 Vdout1_1ck84 = 0 time = 425
.meas tran vdout1_1ck84 FIND v(dout1_1) AT=425.025n

* CHECK dout1_2 Vdout1_2ck84 = 0 time = 425
.meas tran vdout1_2ck84 FIND v(dout1_2) AT=425.025n

* CHECK dout1_3 Vdout1_3ck84 = 0.9 time = 425
.meas tran vdout1_3ck84 FIND v(dout1_3) AT=425.025n

* CHECK dout1_4 Vdout1_4ck84 = 0.9 time = 425
.meas tran vdout1_4ck84 FIND v(dout1_4) AT=425.025n

* CHECK dout1_5 Vdout1_5ck84 = 0.9 time = 425
.meas tran vdout1_5ck84 FIND v(dout1_5) AT=425.025n

* CHECK dout1_6 Vdout1_6ck84 = 0 time = 425
.meas tran vdout1_6ck84 FIND v(dout1_6) AT=425.025n

* CHECK dout1_7 Vdout1_7ck84 = 0.9 time = 425
.meas tran vdout1_7ck84 FIND v(dout1_7) AT=425.025n

* CHECK dout1_8 Vdout1_8ck84 = 0 time = 425
.meas tran vdout1_8ck84 FIND v(dout1_8) AT=425.025n

* CHECK dout1_9 Vdout1_9ck84 = 0 time = 425
.meas tran vdout1_9ck84 FIND v(dout1_9) AT=425.025n

* CHECK dout1_10 Vdout1_10ck84 = 0 time = 425
.meas tran vdout1_10ck84 FIND v(dout1_10) AT=425.025n

* CHECK dout1_11 Vdout1_11ck84 = 0 time = 425
.meas tran vdout1_11ck84 FIND v(dout1_11) AT=425.025n

* CHECK dout1_12 Vdout1_12ck84 = 0 time = 425
.meas tran vdout1_12ck84 FIND v(dout1_12) AT=425.025n

* CHECK dout1_13 Vdout1_13ck84 = 0 time = 425
.meas tran vdout1_13ck84 FIND v(dout1_13) AT=425.025n

* CHECK dout1_14 Vdout1_14ck84 = 0 time = 425
.meas tran vdout1_14ck84 FIND v(dout1_14) AT=425.025n

* CHECK dout1_15 Vdout1_15ck84 = 0.9 time = 425
.meas tran vdout1_15ck84 FIND v(dout1_15) AT=425.025n

* CHECK dout1_16 Vdout1_16ck84 = 0.9 time = 425
.meas tran vdout1_16ck84 FIND v(dout1_16) AT=425.025n

* CHECK dout1_17 Vdout1_17ck84 = 0.9 time = 425
.meas tran vdout1_17ck84 FIND v(dout1_17) AT=425.025n

* CHECK dout1_18 Vdout1_18ck84 = 0 time = 425
.meas tran vdout1_18ck84 FIND v(dout1_18) AT=425.025n

* CHECK dout1_19 Vdout1_19ck84 = 0 time = 425
.meas tran vdout1_19ck84 FIND v(dout1_19) AT=425.025n

* CHECK dout1_20 Vdout1_20ck84 = 0.9 time = 425
.meas tran vdout1_20ck84 FIND v(dout1_20) AT=425.025n

* CHECK dout1_21 Vdout1_21ck84 = 0 time = 425
.meas tran vdout1_21ck84 FIND v(dout1_21) AT=425.025n

* CHECK dout1_22 Vdout1_22ck84 = 0 time = 425
.meas tran vdout1_22ck84 FIND v(dout1_22) AT=425.025n

* CHECK dout1_23 Vdout1_23ck84 = 0.9 time = 425
.meas tran vdout1_23ck84 FIND v(dout1_23) AT=425.025n

* CHECK dout1_24 Vdout1_24ck84 = 0.9 time = 425
.meas tran vdout1_24ck84 FIND v(dout1_24) AT=425.025n

* CHECK dout1_25 Vdout1_25ck84 = 0 time = 425
.meas tran vdout1_25ck84 FIND v(dout1_25) AT=425.025n

* CHECK dout1_26 Vdout1_26ck84 = 0.9 time = 425
.meas tran vdout1_26ck84 FIND v(dout1_26) AT=425.025n

* CHECK dout1_27 Vdout1_27ck84 = 0.9 time = 425
.meas tran vdout1_27ck84 FIND v(dout1_27) AT=425.025n

* CHECK dout1_28 Vdout1_28ck84 = 0.9 time = 425
.meas tran vdout1_28ck84 FIND v(dout1_28) AT=425.025n

* CHECK dout1_29 Vdout1_29ck84 = 0.9 time = 425
.meas tran vdout1_29ck84 FIND v(dout1_29) AT=425.025n

* CHECK dout1_30 Vdout1_30ck84 = 0 time = 425
.meas tran vdout1_30ck84 FIND v(dout1_30) AT=425.025n

* CHECK dout1_31 Vdout1_31ck84 = 0.9 time = 425
.meas tran vdout1_31ck84 FIND v(dout1_31) AT=425.025n

* CHECK dout1_32 Vdout1_32ck84 = 0.9 time = 425
.meas tran vdout1_32ck84 FIND v(dout1_32) AT=425.025n

* CHECK dout1_33 Vdout1_33ck84 = 0 time = 425
.meas tran vdout1_33ck84 FIND v(dout1_33) AT=425.025n

* CHECK dout1_34 Vdout1_34ck84 = 0 time = 425
.meas tran vdout1_34ck84 FIND v(dout1_34) AT=425.025n

* CHECK dout1_35 Vdout1_35ck84 = 0 time = 425
.meas tran vdout1_35ck84 FIND v(dout1_35) AT=425.025n

* CHECK dout1_36 Vdout1_36ck84 = 0.9 time = 425
.meas tran vdout1_36ck84 FIND v(dout1_36) AT=425.025n

* CHECK dout1_37 Vdout1_37ck84 = 0.9 time = 425
.meas tran vdout1_37ck84 FIND v(dout1_37) AT=425.025n

* CHECK dout1_38 Vdout1_38ck84 = 0.9 time = 425
.meas tran vdout1_38ck84 FIND v(dout1_38) AT=425.025n

* CHECK dout1_39 Vdout1_39ck84 = 0 time = 425
.meas tran vdout1_39ck84 FIND v(dout1_39) AT=425.025n

* CHECK dout1_40 Vdout1_40ck84 = 0 time = 425
.meas tran vdout1_40ck84 FIND v(dout1_40) AT=425.025n

* CHECK dout1_41 Vdout1_41ck84 = 0 time = 425
.meas tran vdout1_41ck84 FIND v(dout1_41) AT=425.025n

* CHECK dout1_42 Vdout1_42ck84 = 0.9 time = 425
.meas tran vdout1_42ck84 FIND v(dout1_42) AT=425.025n

* CHECK dout1_43 Vdout1_43ck84 = 0.9 time = 425
.meas tran vdout1_43ck84 FIND v(dout1_43) AT=425.025n

* CHECK dout1_44 Vdout1_44ck84 = 0.9 time = 425
.meas tran vdout1_44ck84 FIND v(dout1_44) AT=425.025n

* CHECK dout1_45 Vdout1_45ck84 = 0 time = 425
.meas tran vdout1_45ck84 FIND v(dout1_45) AT=425.025n

* CHECK dout1_46 Vdout1_46ck84 = 0 time = 425
.meas tran vdout1_46ck84 FIND v(dout1_46) AT=425.025n

* CHECK dout1_47 Vdout1_47ck84 = 0.9 time = 425
.meas tran vdout1_47ck84 FIND v(dout1_47) AT=425.025n

* CHECK dout1_48 Vdout1_48ck84 = 0.9 time = 425
.meas tran vdout1_48ck84 FIND v(dout1_48) AT=425.025n

* CHECK dout1_49 Vdout1_49ck84 = 0.9 time = 425
.meas tran vdout1_49ck84 FIND v(dout1_49) AT=425.025n

* CHECK dout1_50 Vdout1_50ck84 = 0 time = 425
.meas tran vdout1_50ck84 FIND v(dout1_50) AT=425.025n

* CHECK dout1_51 Vdout1_51ck84 = 0 time = 425
.meas tran vdout1_51ck84 FIND v(dout1_51) AT=425.025n

* CHECK dout1_52 Vdout1_52ck84 = 0.9 time = 425
.meas tran vdout1_52ck84 FIND v(dout1_52) AT=425.025n

* CHECK dout1_53 Vdout1_53ck84 = 0 time = 425
.meas tran vdout1_53ck84 FIND v(dout1_53) AT=425.025n

* CHECK dout1_54 Vdout1_54ck84 = 0 time = 425
.meas tran vdout1_54ck84 FIND v(dout1_54) AT=425.025n

* CHECK dout1_55 Vdout1_55ck84 = 0 time = 425
.meas tran vdout1_55ck84 FIND v(dout1_55) AT=425.025n

* CHECK dout1_56 Vdout1_56ck84 = 0 time = 425
.meas tran vdout1_56ck84 FIND v(dout1_56) AT=425.025n

* CHECK dout1_57 Vdout1_57ck84 = 0 time = 425
.meas tran vdout1_57ck84 FIND v(dout1_57) AT=425.025n

* CHECK dout1_58 Vdout1_58ck84 = 0 time = 425
.meas tran vdout1_58ck84 FIND v(dout1_58) AT=425.025n

* CHECK dout1_59 Vdout1_59ck84 = 0 time = 425
.meas tran vdout1_59ck84 FIND v(dout1_59) AT=425.025n

* CHECK dout1_60 Vdout1_60ck84 = 0.9 time = 425
.meas tran vdout1_60ck84 FIND v(dout1_60) AT=425.025n

* CHECK dout1_61 Vdout1_61ck84 = 0.9 time = 425
.meas tran vdout1_61ck84 FIND v(dout1_61) AT=425.025n

* CHECK dout1_62 Vdout1_62ck84 = 0.9 time = 425
.meas tran vdout1_62ck84 FIND v(dout1_62) AT=425.025n

* CHECK dout1_63 Vdout1_63ck84 = 0 time = 425
.meas tran vdout1_63ck84 FIND v(dout1_63) AT=425.025n

* CHECK dout1_64 Vdout1_64ck84 = 0 time = 425
.meas tran vdout1_64ck84 FIND v(dout1_64) AT=425.025n

* CHECK dout1_65 Vdout1_65ck84 = 0.9 time = 425
.meas tran vdout1_65ck84 FIND v(dout1_65) AT=425.025n

* CHECK dout1_66 Vdout1_66ck84 = 0.9 time = 425
.meas tran vdout1_66ck84 FIND v(dout1_66) AT=425.025n

* CHECK dout1_67 Vdout1_67ck84 = 0 time = 425
.meas tran vdout1_67ck84 FIND v(dout1_67) AT=425.025n

* CHECK dout1_68 Vdout1_68ck84 = 0.9 time = 425
.meas tran vdout1_68ck84 FIND v(dout1_68) AT=425.025n

* CHECK dout1_69 Vdout1_69ck84 = 0 time = 425
.meas tran vdout1_69ck84 FIND v(dout1_69) AT=425.025n

* CHECK dout1_70 Vdout1_70ck84 = 0 time = 425
.meas tran vdout1_70ck84 FIND v(dout1_70) AT=425.025n

* CHECK dout1_71 Vdout1_71ck84 = 0.9 time = 425
.meas tran vdout1_71ck84 FIND v(dout1_71) AT=425.025n

* CHECK dout1_72 Vdout1_72ck84 = 0 time = 425
.meas tran vdout1_72ck84 FIND v(dout1_72) AT=425.025n

* CHECK dout1_73 Vdout1_73ck84 = 0.9 time = 425
.meas tran vdout1_73ck84 FIND v(dout1_73) AT=425.025n

* CHECK dout1_74 Vdout1_74ck84 = 0 time = 425
.meas tran vdout1_74ck84 FIND v(dout1_74) AT=425.025n

* CHECK dout1_75 Vdout1_75ck84 = 0.9 time = 425
.meas tran vdout1_75ck84 FIND v(dout1_75) AT=425.025n

* CHECK dout1_76 Vdout1_76ck84 = 0 time = 425
.meas tran vdout1_76ck84 FIND v(dout1_76) AT=425.025n

* CHECK dout1_77 Vdout1_77ck84 = 0 time = 425
.meas tran vdout1_77ck84 FIND v(dout1_77) AT=425.025n

* CHECK dout1_78 Vdout1_78ck84 = 0.9 time = 425
.meas tran vdout1_78ck84 FIND v(dout1_78) AT=425.025n

* CHECK dout1_79 Vdout1_79ck84 = 0 time = 425
.meas tran vdout1_79ck84 FIND v(dout1_79) AT=425.025n

* CHECK dout1_80 Vdout1_80ck84 = 0 time = 425
.meas tran vdout1_80ck84 FIND v(dout1_80) AT=425.025n

* CHECK dout1_81 Vdout1_81ck84 = 0.9 time = 425
.meas tran vdout1_81ck84 FIND v(dout1_81) AT=425.025n

* CHECK dout1_82 Vdout1_82ck84 = 0 time = 425
.meas tran vdout1_82ck84 FIND v(dout1_82) AT=425.025n

* CHECK dout1_83 Vdout1_83ck84 = 0.9 time = 425
.meas tran vdout1_83ck84 FIND v(dout1_83) AT=425.025n

* CHECK dout1_84 Vdout1_84ck84 = 0.9 time = 425
.meas tran vdout1_84ck84 FIND v(dout1_84) AT=425.025n

* CHECK dout1_85 Vdout1_85ck84 = 0 time = 425
.meas tran vdout1_85ck84 FIND v(dout1_85) AT=425.025n

* CHECK dout1_86 Vdout1_86ck84 = 0.9 time = 425
.meas tran vdout1_86ck84 FIND v(dout1_86) AT=425.025n

* CHECK dout1_87 Vdout1_87ck84 = 0 time = 425
.meas tran vdout1_87ck84 FIND v(dout1_87) AT=425.025n

* CHECK dout1_88 Vdout1_88ck84 = 0 time = 425
.meas tran vdout1_88ck84 FIND v(dout1_88) AT=425.025n

* CHECK dout1_89 Vdout1_89ck84 = 0 time = 425
.meas tran vdout1_89ck84 FIND v(dout1_89) AT=425.025n

* CHECK dout1_90 Vdout1_90ck84 = 0.9 time = 425
.meas tran vdout1_90ck84 FIND v(dout1_90) AT=425.025n

* CHECK dout1_91 Vdout1_91ck84 = 0 time = 425
.meas tran vdout1_91ck84 FIND v(dout1_91) AT=425.025n

* CHECK dout1_92 Vdout1_92ck84 = 0 time = 425
.meas tran vdout1_92ck84 FIND v(dout1_92) AT=425.025n

* CHECK dout1_93 Vdout1_93ck84 = 0.9 time = 425
.meas tran vdout1_93ck84 FIND v(dout1_93) AT=425.025n

* CHECK dout1_94 Vdout1_94ck84 = 0.9 time = 425
.meas tran vdout1_94ck84 FIND v(dout1_94) AT=425.025n

* CHECK dout1_95 Vdout1_95ck84 = 0 time = 425
.meas tran vdout1_95ck84 FIND v(dout1_95) AT=425.025n

* CHECK dout1_96 Vdout1_96ck84 = 0.9 time = 425
.meas tran vdout1_96ck84 FIND v(dout1_96) AT=425.025n

* CHECK dout1_97 Vdout1_97ck84 = 0 time = 425
.meas tran vdout1_97ck84 FIND v(dout1_97) AT=425.025n

* CHECK dout1_98 Vdout1_98ck84 = 0 time = 425
.meas tran vdout1_98ck84 FIND v(dout1_98) AT=425.025n

* CHECK dout1_99 Vdout1_99ck84 = 0 time = 425
.meas tran vdout1_99ck84 FIND v(dout1_99) AT=425.025n

* CHECK dout1_100 Vdout1_100ck84 = 0 time = 425
.meas tran vdout1_100ck84 FIND v(dout1_100) AT=425.025n

* CHECK dout1_101 Vdout1_101ck84 = 0.9 time = 425
.meas tran vdout1_101ck84 FIND v(dout1_101) AT=425.025n

* CHECK dout1_102 Vdout1_102ck84 = 0 time = 425
.meas tran vdout1_102ck84 FIND v(dout1_102) AT=425.025n

* CHECK dout1_103 Vdout1_103ck84 = 0.9 time = 425
.meas tran vdout1_103ck84 FIND v(dout1_103) AT=425.025n

* CHECK dout1_104 Vdout1_104ck84 = 0.9 time = 425
.meas tran vdout1_104ck84 FIND v(dout1_104) AT=425.025n

* CHECK dout1_105 Vdout1_105ck84 = 0.9 time = 425
.meas tran vdout1_105ck84 FIND v(dout1_105) AT=425.025n

* CHECK dout1_106 Vdout1_106ck84 = 0.9 time = 425
.meas tran vdout1_106ck84 FIND v(dout1_106) AT=425.025n

* CHECK dout1_107 Vdout1_107ck84 = 0 time = 425
.meas tran vdout1_107ck84 FIND v(dout1_107) AT=425.025n

* CHECK dout1_108 Vdout1_108ck84 = 0 time = 425
.meas tran vdout1_108ck84 FIND v(dout1_108) AT=425.025n

* CHECK dout1_109 Vdout1_109ck84 = 0 time = 425
.meas tran vdout1_109ck84 FIND v(dout1_109) AT=425.025n

* CHECK dout1_110 Vdout1_110ck84 = 0.9 time = 425
.meas tran vdout1_110ck84 FIND v(dout1_110) AT=425.025n

* CHECK dout1_111 Vdout1_111ck84 = 0.9 time = 425
.meas tran vdout1_111ck84 FIND v(dout1_111) AT=425.025n

* CHECK dout1_112 Vdout1_112ck84 = 0 time = 425
.meas tran vdout1_112ck84 FIND v(dout1_112) AT=425.025n

* CHECK dout1_113 Vdout1_113ck84 = 0 time = 425
.meas tran vdout1_113ck84 FIND v(dout1_113) AT=425.025n

* CHECK dout1_114 Vdout1_114ck84 = 0 time = 425
.meas tran vdout1_114ck84 FIND v(dout1_114) AT=425.025n

* CHECK dout1_115 Vdout1_115ck84 = 0 time = 425
.meas tran vdout1_115ck84 FIND v(dout1_115) AT=425.025n

* CHECK dout1_116 Vdout1_116ck84 = 0 time = 425
.meas tran vdout1_116ck84 FIND v(dout1_116) AT=425.025n

* CHECK dout1_117 Vdout1_117ck84 = 0 time = 425
.meas tran vdout1_117ck84 FIND v(dout1_117) AT=425.025n

* CHECK dout1_118 Vdout1_118ck84 = 0 time = 425
.meas tran vdout1_118ck84 FIND v(dout1_118) AT=425.025n

* CHECK dout1_119 Vdout1_119ck84 = 0 time = 425
.meas tran vdout1_119ck84 FIND v(dout1_119) AT=425.025n

* CHECK dout1_0 Vdout1_0ck90 = 0.9 time = 455
.meas tran vdout1_0ck90 FIND v(dout1_0) AT=455.025n

* CHECK dout1_1 Vdout1_1ck90 = 0 time = 455
.meas tran vdout1_1ck90 FIND v(dout1_1) AT=455.025n

* CHECK dout1_2 Vdout1_2ck90 = 0.9 time = 455
.meas tran vdout1_2ck90 FIND v(dout1_2) AT=455.025n

* CHECK dout1_3 Vdout1_3ck90 = 0.9 time = 455
.meas tran vdout1_3ck90 FIND v(dout1_3) AT=455.025n

* CHECK dout1_4 Vdout1_4ck90 = 0.9 time = 455
.meas tran vdout1_4ck90 FIND v(dout1_4) AT=455.025n

* CHECK dout1_5 Vdout1_5ck90 = 0.9 time = 455
.meas tran vdout1_5ck90 FIND v(dout1_5) AT=455.025n

* CHECK dout1_6 Vdout1_6ck90 = 0 time = 455
.meas tran vdout1_6ck90 FIND v(dout1_6) AT=455.025n

* CHECK dout1_7 Vdout1_7ck90 = 0.9 time = 455
.meas tran vdout1_7ck90 FIND v(dout1_7) AT=455.025n

* CHECK dout1_8 Vdout1_8ck90 = 0 time = 455
.meas tran vdout1_8ck90 FIND v(dout1_8) AT=455.025n

* CHECK dout1_9 Vdout1_9ck90 = 0 time = 455
.meas tran vdout1_9ck90 FIND v(dout1_9) AT=455.025n

* CHECK dout1_10 Vdout1_10ck90 = 0 time = 455
.meas tran vdout1_10ck90 FIND v(dout1_10) AT=455.025n

* CHECK dout1_11 Vdout1_11ck90 = 0 time = 455
.meas tran vdout1_11ck90 FIND v(dout1_11) AT=455.025n

* CHECK dout1_12 Vdout1_12ck90 = 0 time = 455
.meas tran vdout1_12ck90 FIND v(dout1_12) AT=455.025n

* CHECK dout1_13 Vdout1_13ck90 = 0.9 time = 455
.meas tran vdout1_13ck90 FIND v(dout1_13) AT=455.025n

* CHECK dout1_14 Vdout1_14ck90 = 0 time = 455
.meas tran vdout1_14ck90 FIND v(dout1_14) AT=455.025n

* CHECK dout1_15 Vdout1_15ck90 = 0 time = 455
.meas tran vdout1_15ck90 FIND v(dout1_15) AT=455.025n

* CHECK dout1_16 Vdout1_16ck90 = 0 time = 455
.meas tran vdout1_16ck90 FIND v(dout1_16) AT=455.025n

* CHECK dout1_17 Vdout1_17ck90 = 0.9 time = 455
.meas tran vdout1_17ck90 FIND v(dout1_17) AT=455.025n

* CHECK dout1_18 Vdout1_18ck90 = 0 time = 455
.meas tran vdout1_18ck90 FIND v(dout1_18) AT=455.025n

* CHECK dout1_19 Vdout1_19ck90 = 0.9 time = 455
.meas tran vdout1_19ck90 FIND v(dout1_19) AT=455.025n

* CHECK dout1_20 Vdout1_20ck90 = 0 time = 455
.meas tran vdout1_20ck90 FIND v(dout1_20) AT=455.025n

* CHECK dout1_21 Vdout1_21ck90 = 0 time = 455
.meas tran vdout1_21ck90 FIND v(dout1_21) AT=455.025n

* CHECK dout1_22 Vdout1_22ck90 = 0 time = 455
.meas tran vdout1_22ck90 FIND v(dout1_22) AT=455.025n

* CHECK dout1_23 Vdout1_23ck90 = 0.9 time = 455
.meas tran vdout1_23ck90 FIND v(dout1_23) AT=455.025n

* CHECK dout1_24 Vdout1_24ck90 = 0.9 time = 455
.meas tran vdout1_24ck90 FIND v(dout1_24) AT=455.025n

* CHECK dout1_25 Vdout1_25ck90 = 0.9 time = 455
.meas tran vdout1_25ck90 FIND v(dout1_25) AT=455.025n

* CHECK dout1_26 Vdout1_26ck90 = 0 time = 455
.meas tran vdout1_26ck90 FIND v(dout1_26) AT=455.025n

* CHECK dout1_27 Vdout1_27ck90 = 0.9 time = 455
.meas tran vdout1_27ck90 FIND v(dout1_27) AT=455.025n

* CHECK dout1_28 Vdout1_28ck90 = 0 time = 455
.meas tran vdout1_28ck90 FIND v(dout1_28) AT=455.025n

* CHECK dout1_29 Vdout1_29ck90 = 0 time = 455
.meas tran vdout1_29ck90 FIND v(dout1_29) AT=455.025n

* CHECK dout1_30 Vdout1_30ck90 = 0 time = 455
.meas tran vdout1_30ck90 FIND v(dout1_30) AT=455.025n

* CHECK dout1_31 Vdout1_31ck90 = 0.9 time = 455
.meas tran vdout1_31ck90 FIND v(dout1_31) AT=455.025n

* CHECK dout1_32 Vdout1_32ck90 = 0 time = 455
.meas tran vdout1_32ck90 FIND v(dout1_32) AT=455.025n

* CHECK dout1_33 Vdout1_33ck90 = 0.9 time = 455
.meas tran vdout1_33ck90 FIND v(dout1_33) AT=455.025n

* CHECK dout1_34 Vdout1_34ck90 = 0.9 time = 455
.meas tran vdout1_34ck90 FIND v(dout1_34) AT=455.025n

* CHECK dout1_35 Vdout1_35ck90 = 0 time = 455
.meas tran vdout1_35ck90 FIND v(dout1_35) AT=455.025n

* CHECK dout1_36 Vdout1_36ck90 = 0.9 time = 455
.meas tran vdout1_36ck90 FIND v(dout1_36) AT=455.025n

* CHECK dout1_37 Vdout1_37ck90 = 0.9 time = 455
.meas tran vdout1_37ck90 FIND v(dout1_37) AT=455.025n

* CHECK dout1_38 Vdout1_38ck90 = 0.9 time = 455
.meas tran vdout1_38ck90 FIND v(dout1_38) AT=455.025n

* CHECK dout1_39 Vdout1_39ck90 = 0 time = 455
.meas tran vdout1_39ck90 FIND v(dout1_39) AT=455.025n

* CHECK dout1_40 Vdout1_40ck90 = 0 time = 455
.meas tran vdout1_40ck90 FIND v(dout1_40) AT=455.025n

* CHECK dout1_41 Vdout1_41ck90 = 0 time = 455
.meas tran vdout1_41ck90 FIND v(dout1_41) AT=455.025n

* CHECK dout1_42 Vdout1_42ck90 = 0 time = 455
.meas tran vdout1_42ck90 FIND v(dout1_42) AT=455.025n

* CHECK dout1_43 Vdout1_43ck90 = 0.9 time = 455
.meas tran vdout1_43ck90 FIND v(dout1_43) AT=455.025n

* CHECK dout1_44 Vdout1_44ck90 = 0 time = 455
.meas tran vdout1_44ck90 FIND v(dout1_44) AT=455.025n

* CHECK dout1_45 Vdout1_45ck90 = 0.9 time = 455
.meas tran vdout1_45ck90 FIND v(dout1_45) AT=455.025n

* CHECK dout1_46 Vdout1_46ck90 = 0.9 time = 455
.meas tran vdout1_46ck90 FIND v(dout1_46) AT=455.025n

* CHECK dout1_47 Vdout1_47ck90 = 0.9 time = 455
.meas tran vdout1_47ck90 FIND v(dout1_47) AT=455.025n

* CHECK dout1_48 Vdout1_48ck90 = 0 time = 455
.meas tran vdout1_48ck90 FIND v(dout1_48) AT=455.025n

* CHECK dout1_49 Vdout1_49ck90 = 0 time = 455
.meas tran vdout1_49ck90 FIND v(dout1_49) AT=455.025n

* CHECK dout1_50 Vdout1_50ck90 = 0.9 time = 455
.meas tran vdout1_50ck90 FIND v(dout1_50) AT=455.025n

* CHECK dout1_51 Vdout1_51ck90 = 0 time = 455
.meas tran vdout1_51ck90 FIND v(dout1_51) AT=455.025n

* CHECK dout1_52 Vdout1_52ck90 = 0 time = 455
.meas tran vdout1_52ck90 FIND v(dout1_52) AT=455.025n

* CHECK dout1_53 Vdout1_53ck90 = 0.9 time = 455
.meas tran vdout1_53ck90 FIND v(dout1_53) AT=455.025n

* CHECK dout1_54 Vdout1_54ck90 = 0.9 time = 455
.meas tran vdout1_54ck90 FIND v(dout1_54) AT=455.025n

* CHECK dout1_55 Vdout1_55ck90 = 0.9 time = 455
.meas tran vdout1_55ck90 FIND v(dout1_55) AT=455.025n

* CHECK dout1_56 Vdout1_56ck90 = 0.9 time = 455
.meas tran vdout1_56ck90 FIND v(dout1_56) AT=455.025n

* CHECK dout1_57 Vdout1_57ck90 = 0.9 time = 455
.meas tran vdout1_57ck90 FIND v(dout1_57) AT=455.025n

* CHECK dout1_58 Vdout1_58ck90 = 0.9 time = 455
.meas tran vdout1_58ck90 FIND v(dout1_58) AT=455.025n

* CHECK dout1_59 Vdout1_59ck90 = 0 time = 455
.meas tran vdout1_59ck90 FIND v(dout1_59) AT=455.025n

* CHECK dout1_60 Vdout1_60ck90 = 0.9 time = 455
.meas tran vdout1_60ck90 FIND v(dout1_60) AT=455.025n

* CHECK dout1_61 Vdout1_61ck90 = 0.9 time = 455
.meas tran vdout1_61ck90 FIND v(dout1_61) AT=455.025n

* CHECK dout1_62 Vdout1_62ck90 = 0.9 time = 455
.meas tran vdout1_62ck90 FIND v(dout1_62) AT=455.025n

* CHECK dout1_63 Vdout1_63ck90 = 0.9 time = 455
.meas tran vdout1_63ck90 FIND v(dout1_63) AT=455.025n

* CHECK dout1_64 Vdout1_64ck90 = 0 time = 455
.meas tran vdout1_64ck90 FIND v(dout1_64) AT=455.025n

* CHECK dout1_65 Vdout1_65ck90 = 0.9 time = 455
.meas tran vdout1_65ck90 FIND v(dout1_65) AT=455.025n

* CHECK dout1_66 Vdout1_66ck90 = 0.9 time = 455
.meas tran vdout1_66ck90 FIND v(dout1_66) AT=455.025n

* CHECK dout1_67 Vdout1_67ck90 = 0.9 time = 455
.meas tran vdout1_67ck90 FIND v(dout1_67) AT=455.025n

* CHECK dout1_68 Vdout1_68ck90 = 0.9 time = 455
.meas tran vdout1_68ck90 FIND v(dout1_68) AT=455.025n

* CHECK dout1_69 Vdout1_69ck90 = 0.9 time = 455
.meas tran vdout1_69ck90 FIND v(dout1_69) AT=455.025n

* CHECK dout1_70 Vdout1_70ck90 = 0 time = 455
.meas tran vdout1_70ck90 FIND v(dout1_70) AT=455.025n

* CHECK dout1_71 Vdout1_71ck90 = 0.9 time = 455
.meas tran vdout1_71ck90 FIND v(dout1_71) AT=455.025n

* CHECK dout1_72 Vdout1_72ck90 = 0.9 time = 455
.meas tran vdout1_72ck90 FIND v(dout1_72) AT=455.025n

* CHECK dout1_73 Vdout1_73ck90 = 0.9 time = 455
.meas tran vdout1_73ck90 FIND v(dout1_73) AT=455.025n

* CHECK dout1_74 Vdout1_74ck90 = 0 time = 455
.meas tran vdout1_74ck90 FIND v(dout1_74) AT=455.025n

* CHECK dout1_75 Vdout1_75ck90 = 0 time = 455
.meas tran vdout1_75ck90 FIND v(dout1_75) AT=455.025n

* CHECK dout1_76 Vdout1_76ck90 = 0 time = 455
.meas tran vdout1_76ck90 FIND v(dout1_76) AT=455.025n

* CHECK dout1_77 Vdout1_77ck90 = 0 time = 455
.meas tran vdout1_77ck90 FIND v(dout1_77) AT=455.025n

* CHECK dout1_78 Vdout1_78ck90 = 0.9 time = 455
.meas tran vdout1_78ck90 FIND v(dout1_78) AT=455.025n

* CHECK dout1_79 Vdout1_79ck90 = 0.9 time = 455
.meas tran vdout1_79ck90 FIND v(dout1_79) AT=455.025n

* CHECK dout1_80 Vdout1_80ck90 = 0 time = 455
.meas tran vdout1_80ck90 FIND v(dout1_80) AT=455.025n

* CHECK dout1_81 Vdout1_81ck90 = 0 time = 455
.meas tran vdout1_81ck90 FIND v(dout1_81) AT=455.025n

* CHECK dout1_82 Vdout1_82ck90 = 0.9 time = 455
.meas tran vdout1_82ck90 FIND v(dout1_82) AT=455.025n

* CHECK dout1_83 Vdout1_83ck90 = 0 time = 455
.meas tran vdout1_83ck90 FIND v(dout1_83) AT=455.025n

* CHECK dout1_84 Vdout1_84ck90 = 0.9 time = 455
.meas tran vdout1_84ck90 FIND v(dout1_84) AT=455.025n

* CHECK dout1_85 Vdout1_85ck90 = 0.9 time = 455
.meas tran vdout1_85ck90 FIND v(dout1_85) AT=455.025n

* CHECK dout1_86 Vdout1_86ck90 = 0.9 time = 455
.meas tran vdout1_86ck90 FIND v(dout1_86) AT=455.025n

* CHECK dout1_87 Vdout1_87ck90 = 0 time = 455
.meas tran vdout1_87ck90 FIND v(dout1_87) AT=455.025n

* CHECK dout1_88 Vdout1_88ck90 = 0.9 time = 455
.meas tran vdout1_88ck90 FIND v(dout1_88) AT=455.025n

* CHECK dout1_89 Vdout1_89ck90 = 0.9 time = 455
.meas tran vdout1_89ck90 FIND v(dout1_89) AT=455.025n

* CHECK dout1_90 Vdout1_90ck90 = 0 time = 455
.meas tran vdout1_90ck90 FIND v(dout1_90) AT=455.025n

* CHECK dout1_91 Vdout1_91ck90 = 0 time = 455
.meas tran vdout1_91ck90 FIND v(dout1_91) AT=455.025n

* CHECK dout1_92 Vdout1_92ck90 = 0 time = 455
.meas tran vdout1_92ck90 FIND v(dout1_92) AT=455.025n

* CHECK dout1_93 Vdout1_93ck90 = 0.9 time = 455
.meas tran vdout1_93ck90 FIND v(dout1_93) AT=455.025n

* CHECK dout1_94 Vdout1_94ck90 = 0.9 time = 455
.meas tran vdout1_94ck90 FIND v(dout1_94) AT=455.025n

* CHECK dout1_95 Vdout1_95ck90 = 0.9 time = 455
.meas tran vdout1_95ck90 FIND v(dout1_95) AT=455.025n

* CHECK dout1_96 Vdout1_96ck90 = 0 time = 455
.meas tran vdout1_96ck90 FIND v(dout1_96) AT=455.025n

* CHECK dout1_97 Vdout1_97ck90 = 0 time = 455
.meas tran vdout1_97ck90 FIND v(dout1_97) AT=455.025n

* CHECK dout1_98 Vdout1_98ck90 = 0 time = 455
.meas tran vdout1_98ck90 FIND v(dout1_98) AT=455.025n

* CHECK dout1_99 Vdout1_99ck90 = 0 time = 455
.meas tran vdout1_99ck90 FIND v(dout1_99) AT=455.025n

* CHECK dout1_100 Vdout1_100ck90 = 0 time = 455
.meas tran vdout1_100ck90 FIND v(dout1_100) AT=455.025n

* CHECK dout1_101 Vdout1_101ck90 = 0 time = 455
.meas tran vdout1_101ck90 FIND v(dout1_101) AT=455.025n

* CHECK dout1_102 Vdout1_102ck90 = 0 time = 455
.meas tran vdout1_102ck90 FIND v(dout1_102) AT=455.025n

* CHECK dout1_103 Vdout1_103ck90 = 0.9 time = 455
.meas tran vdout1_103ck90 FIND v(dout1_103) AT=455.025n

* CHECK dout1_104 Vdout1_104ck90 = 0.9 time = 455
.meas tran vdout1_104ck90 FIND v(dout1_104) AT=455.025n

* CHECK dout1_105 Vdout1_105ck90 = 0 time = 455
.meas tran vdout1_105ck90 FIND v(dout1_105) AT=455.025n

* CHECK dout1_106 Vdout1_106ck90 = 0 time = 455
.meas tran vdout1_106ck90 FIND v(dout1_106) AT=455.025n

* CHECK dout1_107 Vdout1_107ck90 = 0.9 time = 455
.meas tran vdout1_107ck90 FIND v(dout1_107) AT=455.025n

* CHECK dout1_108 Vdout1_108ck90 = 0.9 time = 455
.meas tran vdout1_108ck90 FIND v(dout1_108) AT=455.025n

* CHECK dout1_109 Vdout1_109ck90 = 0 time = 455
.meas tran vdout1_109ck90 FIND v(dout1_109) AT=455.025n

* CHECK dout1_110 Vdout1_110ck90 = 0.9 time = 455
.meas tran vdout1_110ck90 FIND v(dout1_110) AT=455.025n

* CHECK dout1_111 Vdout1_111ck90 = 0.9 time = 455
.meas tran vdout1_111ck90 FIND v(dout1_111) AT=455.025n

* CHECK dout1_112 Vdout1_112ck90 = 0.9 time = 455
.meas tran vdout1_112ck90 FIND v(dout1_112) AT=455.025n

* CHECK dout1_113 Vdout1_113ck90 = 0 time = 455
.meas tran vdout1_113ck90 FIND v(dout1_113) AT=455.025n

* CHECK dout1_114 Vdout1_114ck90 = 0 time = 455
.meas tran vdout1_114ck90 FIND v(dout1_114) AT=455.025n

* CHECK dout1_115 Vdout1_115ck90 = 0.9 time = 455
.meas tran vdout1_115ck90 FIND v(dout1_115) AT=455.025n

* CHECK dout1_116 Vdout1_116ck90 = 0 time = 455
.meas tran vdout1_116ck90 FIND v(dout1_116) AT=455.025n

* CHECK dout1_117 Vdout1_117ck90 = 0.9 time = 455
.meas tran vdout1_117ck90 FIND v(dout1_117) AT=455.025n

* CHECK dout1_118 Vdout1_118ck90 = 0.9 time = 455
.meas tran vdout1_118ck90 FIND v(dout1_118) AT=455.025n

* CHECK dout1_119 Vdout1_119ck90 = 0 time = 455
.meas tran vdout1_119ck90 FIND v(dout1_119) AT=455.025n

* CHECK dout1_0 Vdout1_0ck92 = 0.9 time = 465
.meas tran vdout1_0ck92 FIND v(dout1_0) AT=465.025n

* CHECK dout1_1 Vdout1_1ck92 = 0 time = 465
.meas tran vdout1_1ck92 FIND v(dout1_1) AT=465.025n

* CHECK dout1_2 Vdout1_2ck92 = 0.9 time = 465
.meas tran vdout1_2ck92 FIND v(dout1_2) AT=465.025n

* CHECK dout1_3 Vdout1_3ck92 = 0.9 time = 465
.meas tran vdout1_3ck92 FIND v(dout1_3) AT=465.025n

* CHECK dout1_4 Vdout1_4ck92 = 0 time = 465
.meas tran vdout1_4ck92 FIND v(dout1_4) AT=465.025n

* CHECK dout1_5 Vdout1_5ck92 = 0.9 time = 465
.meas tran vdout1_5ck92 FIND v(dout1_5) AT=465.025n

* CHECK dout1_6 Vdout1_6ck92 = 0.9 time = 465
.meas tran vdout1_6ck92 FIND v(dout1_6) AT=465.025n

* CHECK dout1_7 Vdout1_7ck92 = 0.9 time = 465
.meas tran vdout1_7ck92 FIND v(dout1_7) AT=465.025n

* CHECK dout1_8 Vdout1_8ck92 = 0 time = 465
.meas tran vdout1_8ck92 FIND v(dout1_8) AT=465.025n

* CHECK dout1_9 Vdout1_9ck92 = 0.9 time = 465
.meas tran vdout1_9ck92 FIND v(dout1_9) AT=465.025n

* CHECK dout1_10 Vdout1_10ck92 = 0.9 time = 465
.meas tran vdout1_10ck92 FIND v(dout1_10) AT=465.025n

* CHECK dout1_11 Vdout1_11ck92 = 0 time = 465
.meas tran vdout1_11ck92 FIND v(dout1_11) AT=465.025n

* CHECK dout1_12 Vdout1_12ck92 = 0 time = 465
.meas tran vdout1_12ck92 FIND v(dout1_12) AT=465.025n

* CHECK dout1_13 Vdout1_13ck92 = 0 time = 465
.meas tran vdout1_13ck92 FIND v(dout1_13) AT=465.025n

* CHECK dout1_14 Vdout1_14ck92 = 0 time = 465
.meas tran vdout1_14ck92 FIND v(dout1_14) AT=465.025n

* CHECK dout1_15 Vdout1_15ck92 = 0.9 time = 465
.meas tran vdout1_15ck92 FIND v(dout1_15) AT=465.025n

* CHECK dout1_16 Vdout1_16ck92 = 0.9 time = 465
.meas tran vdout1_16ck92 FIND v(dout1_16) AT=465.025n

* CHECK dout1_17 Vdout1_17ck92 = 0.9 time = 465
.meas tran vdout1_17ck92 FIND v(dout1_17) AT=465.025n

* CHECK dout1_18 Vdout1_18ck92 = 0.9 time = 465
.meas tran vdout1_18ck92 FIND v(dout1_18) AT=465.025n

* CHECK dout1_19 Vdout1_19ck92 = 0.9 time = 465
.meas tran vdout1_19ck92 FIND v(dout1_19) AT=465.025n

* CHECK dout1_20 Vdout1_20ck92 = 0.9 time = 465
.meas tran vdout1_20ck92 FIND v(dout1_20) AT=465.025n

* CHECK dout1_21 Vdout1_21ck92 = 0.9 time = 465
.meas tran vdout1_21ck92 FIND v(dout1_21) AT=465.025n

* CHECK dout1_22 Vdout1_22ck92 = 0.9 time = 465
.meas tran vdout1_22ck92 FIND v(dout1_22) AT=465.025n

* CHECK dout1_23 Vdout1_23ck92 = 0 time = 465
.meas tran vdout1_23ck92 FIND v(dout1_23) AT=465.025n

* CHECK dout1_24 Vdout1_24ck92 = 0 time = 465
.meas tran vdout1_24ck92 FIND v(dout1_24) AT=465.025n

* CHECK dout1_25 Vdout1_25ck92 = 0 time = 465
.meas tran vdout1_25ck92 FIND v(dout1_25) AT=465.025n

* CHECK dout1_26 Vdout1_26ck92 = 0.9 time = 465
.meas tran vdout1_26ck92 FIND v(dout1_26) AT=465.025n

* CHECK dout1_27 Vdout1_27ck92 = 0 time = 465
.meas tran vdout1_27ck92 FIND v(dout1_27) AT=465.025n

* CHECK dout1_28 Vdout1_28ck92 = 0.9 time = 465
.meas tran vdout1_28ck92 FIND v(dout1_28) AT=465.025n

* CHECK dout1_29 Vdout1_29ck92 = 0 time = 465
.meas tran vdout1_29ck92 FIND v(dout1_29) AT=465.025n

* CHECK dout1_30 Vdout1_30ck92 = 0.9 time = 465
.meas tran vdout1_30ck92 FIND v(dout1_30) AT=465.025n

* CHECK dout1_31 Vdout1_31ck92 = 0 time = 465
.meas tran vdout1_31ck92 FIND v(dout1_31) AT=465.025n

* CHECK dout1_32 Vdout1_32ck92 = 0.9 time = 465
.meas tran vdout1_32ck92 FIND v(dout1_32) AT=465.025n

* CHECK dout1_33 Vdout1_33ck92 = 0.9 time = 465
.meas tran vdout1_33ck92 FIND v(dout1_33) AT=465.025n

* CHECK dout1_34 Vdout1_34ck92 = 0.9 time = 465
.meas tran vdout1_34ck92 FIND v(dout1_34) AT=465.025n

* CHECK dout1_35 Vdout1_35ck92 = 0 time = 465
.meas tran vdout1_35ck92 FIND v(dout1_35) AT=465.025n

* CHECK dout1_36 Vdout1_36ck92 = 0.9 time = 465
.meas tran vdout1_36ck92 FIND v(dout1_36) AT=465.025n

* CHECK dout1_37 Vdout1_37ck92 = 0.9 time = 465
.meas tran vdout1_37ck92 FIND v(dout1_37) AT=465.025n

* CHECK dout1_38 Vdout1_38ck92 = 0.9 time = 465
.meas tran vdout1_38ck92 FIND v(dout1_38) AT=465.025n

* CHECK dout1_39 Vdout1_39ck92 = 0.9 time = 465
.meas tran vdout1_39ck92 FIND v(dout1_39) AT=465.025n

* CHECK dout1_40 Vdout1_40ck92 = 0.9 time = 465
.meas tran vdout1_40ck92 FIND v(dout1_40) AT=465.025n

* CHECK dout1_41 Vdout1_41ck92 = 0 time = 465
.meas tran vdout1_41ck92 FIND v(dout1_41) AT=465.025n

* CHECK dout1_42 Vdout1_42ck92 = 0.9 time = 465
.meas tran vdout1_42ck92 FIND v(dout1_42) AT=465.025n

* CHECK dout1_43 Vdout1_43ck92 = 0.9 time = 465
.meas tran vdout1_43ck92 FIND v(dout1_43) AT=465.025n

* CHECK dout1_44 Vdout1_44ck92 = 0.9 time = 465
.meas tran vdout1_44ck92 FIND v(dout1_44) AT=465.025n

* CHECK dout1_45 Vdout1_45ck92 = 0.9 time = 465
.meas tran vdout1_45ck92 FIND v(dout1_45) AT=465.025n

* CHECK dout1_46 Vdout1_46ck92 = 0.9 time = 465
.meas tran vdout1_46ck92 FIND v(dout1_46) AT=465.025n

* CHECK dout1_47 Vdout1_47ck92 = 0.9 time = 465
.meas tran vdout1_47ck92 FIND v(dout1_47) AT=465.025n

* CHECK dout1_48 Vdout1_48ck92 = 0 time = 465
.meas tran vdout1_48ck92 FIND v(dout1_48) AT=465.025n

* CHECK dout1_49 Vdout1_49ck92 = 0.9 time = 465
.meas tran vdout1_49ck92 FIND v(dout1_49) AT=465.025n

* CHECK dout1_50 Vdout1_50ck92 = 0 time = 465
.meas tran vdout1_50ck92 FIND v(dout1_50) AT=465.025n

* CHECK dout1_51 Vdout1_51ck92 = 0.9 time = 465
.meas tran vdout1_51ck92 FIND v(dout1_51) AT=465.025n

* CHECK dout1_52 Vdout1_52ck92 = 0.9 time = 465
.meas tran vdout1_52ck92 FIND v(dout1_52) AT=465.025n

* CHECK dout1_53 Vdout1_53ck92 = 0.9 time = 465
.meas tran vdout1_53ck92 FIND v(dout1_53) AT=465.025n

* CHECK dout1_54 Vdout1_54ck92 = 0 time = 465
.meas tran vdout1_54ck92 FIND v(dout1_54) AT=465.025n

* CHECK dout1_55 Vdout1_55ck92 = 0 time = 465
.meas tran vdout1_55ck92 FIND v(dout1_55) AT=465.025n

* CHECK dout1_56 Vdout1_56ck92 = 0 time = 465
.meas tran vdout1_56ck92 FIND v(dout1_56) AT=465.025n

* CHECK dout1_57 Vdout1_57ck92 = 0.9 time = 465
.meas tran vdout1_57ck92 FIND v(dout1_57) AT=465.025n

* CHECK dout1_58 Vdout1_58ck92 = 0.9 time = 465
.meas tran vdout1_58ck92 FIND v(dout1_58) AT=465.025n

* CHECK dout1_59 Vdout1_59ck92 = 0.9 time = 465
.meas tran vdout1_59ck92 FIND v(dout1_59) AT=465.025n

* CHECK dout1_60 Vdout1_60ck92 = 0 time = 465
.meas tran vdout1_60ck92 FIND v(dout1_60) AT=465.025n

* CHECK dout1_61 Vdout1_61ck92 = 0 time = 465
.meas tran vdout1_61ck92 FIND v(dout1_61) AT=465.025n

* CHECK dout1_62 Vdout1_62ck92 = 0 time = 465
.meas tran vdout1_62ck92 FIND v(dout1_62) AT=465.025n

* CHECK dout1_63 Vdout1_63ck92 = 0.9 time = 465
.meas tran vdout1_63ck92 FIND v(dout1_63) AT=465.025n

* CHECK dout1_64 Vdout1_64ck92 = 0.9 time = 465
.meas tran vdout1_64ck92 FIND v(dout1_64) AT=465.025n

* CHECK dout1_65 Vdout1_65ck92 = 0.9 time = 465
.meas tran vdout1_65ck92 FIND v(dout1_65) AT=465.025n

* CHECK dout1_66 Vdout1_66ck92 = 0 time = 465
.meas tran vdout1_66ck92 FIND v(dout1_66) AT=465.025n

* CHECK dout1_67 Vdout1_67ck92 = 0 time = 465
.meas tran vdout1_67ck92 FIND v(dout1_67) AT=465.025n

* CHECK dout1_68 Vdout1_68ck92 = 0 time = 465
.meas tran vdout1_68ck92 FIND v(dout1_68) AT=465.025n

* CHECK dout1_69 Vdout1_69ck92 = 0 time = 465
.meas tran vdout1_69ck92 FIND v(dout1_69) AT=465.025n

* CHECK dout1_70 Vdout1_70ck92 = 0.9 time = 465
.meas tran vdout1_70ck92 FIND v(dout1_70) AT=465.025n

* CHECK dout1_71 Vdout1_71ck92 = 0.9 time = 465
.meas tran vdout1_71ck92 FIND v(dout1_71) AT=465.025n

* CHECK dout1_72 Vdout1_72ck92 = 0.9 time = 465
.meas tran vdout1_72ck92 FIND v(dout1_72) AT=465.025n

* CHECK dout1_73 Vdout1_73ck92 = 0.9 time = 465
.meas tran vdout1_73ck92 FIND v(dout1_73) AT=465.025n

* CHECK dout1_74 Vdout1_74ck92 = 0.9 time = 465
.meas tran vdout1_74ck92 FIND v(dout1_74) AT=465.025n

* CHECK dout1_75 Vdout1_75ck92 = 0 time = 465
.meas tran vdout1_75ck92 FIND v(dout1_75) AT=465.025n

* CHECK dout1_76 Vdout1_76ck92 = 0 time = 465
.meas tran vdout1_76ck92 FIND v(dout1_76) AT=465.025n

* CHECK dout1_77 Vdout1_77ck92 = 0.9 time = 465
.meas tran vdout1_77ck92 FIND v(dout1_77) AT=465.025n

* CHECK dout1_78 Vdout1_78ck92 = 0.9 time = 465
.meas tran vdout1_78ck92 FIND v(dout1_78) AT=465.025n

* CHECK dout1_79 Vdout1_79ck92 = 0 time = 465
.meas tran vdout1_79ck92 FIND v(dout1_79) AT=465.025n

* CHECK dout1_80 Vdout1_80ck92 = 0.9 time = 465
.meas tran vdout1_80ck92 FIND v(dout1_80) AT=465.025n

* CHECK dout1_81 Vdout1_81ck92 = 0.9 time = 465
.meas tran vdout1_81ck92 FIND v(dout1_81) AT=465.025n

* CHECK dout1_82 Vdout1_82ck92 = 0.9 time = 465
.meas tran vdout1_82ck92 FIND v(dout1_82) AT=465.025n

* CHECK dout1_83 Vdout1_83ck92 = 0.9 time = 465
.meas tran vdout1_83ck92 FIND v(dout1_83) AT=465.025n

* CHECK dout1_84 Vdout1_84ck92 = 0 time = 465
.meas tran vdout1_84ck92 FIND v(dout1_84) AT=465.025n

* CHECK dout1_85 Vdout1_85ck92 = 0.9 time = 465
.meas tran vdout1_85ck92 FIND v(dout1_85) AT=465.025n

* CHECK dout1_86 Vdout1_86ck92 = 0 time = 465
.meas tran vdout1_86ck92 FIND v(dout1_86) AT=465.025n

* CHECK dout1_87 Vdout1_87ck92 = 0 time = 465
.meas tran vdout1_87ck92 FIND v(dout1_87) AT=465.025n

* CHECK dout1_88 Vdout1_88ck92 = 0.9 time = 465
.meas tran vdout1_88ck92 FIND v(dout1_88) AT=465.025n

* CHECK dout1_89 Vdout1_89ck92 = 0 time = 465
.meas tran vdout1_89ck92 FIND v(dout1_89) AT=465.025n

* CHECK dout1_90 Vdout1_90ck92 = 0.9 time = 465
.meas tran vdout1_90ck92 FIND v(dout1_90) AT=465.025n

* CHECK dout1_91 Vdout1_91ck92 = 0 time = 465
.meas tran vdout1_91ck92 FIND v(dout1_91) AT=465.025n

* CHECK dout1_92 Vdout1_92ck92 = 0.9 time = 465
.meas tran vdout1_92ck92 FIND v(dout1_92) AT=465.025n

* CHECK dout1_93 Vdout1_93ck92 = 0.9 time = 465
.meas tran vdout1_93ck92 FIND v(dout1_93) AT=465.025n

* CHECK dout1_94 Vdout1_94ck92 = 0.9 time = 465
.meas tran vdout1_94ck92 FIND v(dout1_94) AT=465.025n

* CHECK dout1_95 Vdout1_95ck92 = 0 time = 465
.meas tran vdout1_95ck92 FIND v(dout1_95) AT=465.025n

* CHECK dout1_96 Vdout1_96ck92 = 0 time = 465
.meas tran vdout1_96ck92 FIND v(dout1_96) AT=465.025n

* CHECK dout1_97 Vdout1_97ck92 = 0 time = 465
.meas tran vdout1_97ck92 FIND v(dout1_97) AT=465.025n

* CHECK dout1_98 Vdout1_98ck92 = 0 time = 465
.meas tran vdout1_98ck92 FIND v(dout1_98) AT=465.025n

* CHECK dout1_99 Vdout1_99ck92 = 0 time = 465
.meas tran vdout1_99ck92 FIND v(dout1_99) AT=465.025n

* CHECK dout1_100 Vdout1_100ck92 = 0.9 time = 465
.meas tran vdout1_100ck92 FIND v(dout1_100) AT=465.025n

* CHECK dout1_101 Vdout1_101ck92 = 0.9 time = 465
.meas tran vdout1_101ck92 FIND v(dout1_101) AT=465.025n

* CHECK dout1_102 Vdout1_102ck92 = 0.9 time = 465
.meas tran vdout1_102ck92 FIND v(dout1_102) AT=465.025n

* CHECK dout1_103 Vdout1_103ck92 = 0 time = 465
.meas tran vdout1_103ck92 FIND v(dout1_103) AT=465.025n

* CHECK dout1_104 Vdout1_104ck92 = 0.9 time = 465
.meas tran vdout1_104ck92 FIND v(dout1_104) AT=465.025n

* CHECK dout1_105 Vdout1_105ck92 = 0 time = 465
.meas tran vdout1_105ck92 FIND v(dout1_105) AT=465.025n

* CHECK dout1_106 Vdout1_106ck92 = 0 time = 465
.meas tran vdout1_106ck92 FIND v(dout1_106) AT=465.025n

* CHECK dout1_107 Vdout1_107ck92 = 0 time = 465
.meas tran vdout1_107ck92 FIND v(dout1_107) AT=465.025n

* CHECK dout1_108 Vdout1_108ck92 = 0.9 time = 465
.meas tran vdout1_108ck92 FIND v(dout1_108) AT=465.025n

* CHECK dout1_109 Vdout1_109ck92 = 0.9 time = 465
.meas tran vdout1_109ck92 FIND v(dout1_109) AT=465.025n

* CHECK dout1_110 Vdout1_110ck92 = 0.9 time = 465
.meas tran vdout1_110ck92 FIND v(dout1_110) AT=465.025n

* CHECK dout1_111 Vdout1_111ck92 = 0.9 time = 465
.meas tran vdout1_111ck92 FIND v(dout1_111) AT=465.025n

* CHECK dout1_112 Vdout1_112ck92 = 0.9 time = 465
.meas tran vdout1_112ck92 FIND v(dout1_112) AT=465.025n

* CHECK dout1_113 Vdout1_113ck92 = 0.9 time = 465
.meas tran vdout1_113ck92 FIND v(dout1_113) AT=465.025n

* CHECK dout1_114 Vdout1_114ck92 = 0 time = 465
.meas tran vdout1_114ck92 FIND v(dout1_114) AT=465.025n

* CHECK dout1_115 Vdout1_115ck92 = 0.9 time = 465
.meas tran vdout1_115ck92 FIND v(dout1_115) AT=465.025n

* CHECK dout1_116 Vdout1_116ck92 = 0 time = 465
.meas tran vdout1_116ck92 FIND v(dout1_116) AT=465.025n

* CHECK dout1_117 Vdout1_117ck92 = 0 time = 465
.meas tran vdout1_117ck92 FIND v(dout1_117) AT=465.025n

* CHECK dout1_118 Vdout1_118ck92 = 0 time = 465
.meas tran vdout1_118ck92 FIND v(dout1_118) AT=465.025n

* CHECK dout1_119 Vdout1_119ck92 = 0 time = 465
.meas tran vdout1_119ck92 FIND v(dout1_119) AT=465.025n

* CHECK dout1_0 Vdout1_0ck94 = 0 time = 475
.meas tran vdout1_0ck94 FIND v(dout1_0) AT=475.025n

* CHECK dout1_1 Vdout1_1ck94 = 0 time = 475
.meas tran vdout1_1ck94 FIND v(dout1_1) AT=475.025n

* CHECK dout1_2 Vdout1_2ck94 = 0.9 time = 475
.meas tran vdout1_2ck94 FIND v(dout1_2) AT=475.025n

* CHECK dout1_3 Vdout1_3ck94 = 0.9 time = 475
.meas tran vdout1_3ck94 FIND v(dout1_3) AT=475.025n

* CHECK dout1_4 Vdout1_4ck94 = 0.9 time = 475
.meas tran vdout1_4ck94 FIND v(dout1_4) AT=475.025n

* CHECK dout1_5 Vdout1_5ck94 = 0.9 time = 475
.meas tran vdout1_5ck94 FIND v(dout1_5) AT=475.025n

* CHECK dout1_6 Vdout1_6ck94 = 0 time = 475
.meas tran vdout1_6ck94 FIND v(dout1_6) AT=475.025n

* CHECK dout1_7 Vdout1_7ck94 = 0.9 time = 475
.meas tran vdout1_7ck94 FIND v(dout1_7) AT=475.025n

* CHECK dout1_8 Vdout1_8ck94 = 0 time = 475
.meas tran vdout1_8ck94 FIND v(dout1_8) AT=475.025n

* CHECK dout1_9 Vdout1_9ck94 = 0 time = 475
.meas tran vdout1_9ck94 FIND v(dout1_9) AT=475.025n

* CHECK dout1_10 Vdout1_10ck94 = 0 time = 475
.meas tran vdout1_10ck94 FIND v(dout1_10) AT=475.025n

* CHECK dout1_11 Vdout1_11ck94 = 0 time = 475
.meas tran vdout1_11ck94 FIND v(dout1_11) AT=475.025n

* CHECK dout1_12 Vdout1_12ck94 = 0.9 time = 475
.meas tran vdout1_12ck94 FIND v(dout1_12) AT=475.025n

* CHECK dout1_13 Vdout1_13ck94 = 0.9 time = 475
.meas tran vdout1_13ck94 FIND v(dout1_13) AT=475.025n

* CHECK dout1_14 Vdout1_14ck94 = 0 time = 475
.meas tran vdout1_14ck94 FIND v(dout1_14) AT=475.025n

* CHECK dout1_15 Vdout1_15ck94 = 0.9 time = 475
.meas tran vdout1_15ck94 FIND v(dout1_15) AT=475.025n

* CHECK dout1_16 Vdout1_16ck94 = 0.9 time = 475
.meas tran vdout1_16ck94 FIND v(dout1_16) AT=475.025n

* CHECK dout1_17 Vdout1_17ck94 = 0 time = 475
.meas tran vdout1_17ck94 FIND v(dout1_17) AT=475.025n

* CHECK dout1_18 Vdout1_18ck94 = 0 time = 475
.meas tran vdout1_18ck94 FIND v(dout1_18) AT=475.025n

* CHECK dout1_19 Vdout1_19ck94 = 0 time = 475
.meas tran vdout1_19ck94 FIND v(dout1_19) AT=475.025n

* CHECK dout1_20 Vdout1_20ck94 = 0 time = 475
.meas tran vdout1_20ck94 FIND v(dout1_20) AT=475.025n

* CHECK dout1_21 Vdout1_21ck94 = 0 time = 475
.meas tran vdout1_21ck94 FIND v(dout1_21) AT=475.025n

* CHECK dout1_22 Vdout1_22ck94 = 0 time = 475
.meas tran vdout1_22ck94 FIND v(dout1_22) AT=475.025n

* CHECK dout1_23 Vdout1_23ck94 = 0.9 time = 475
.meas tran vdout1_23ck94 FIND v(dout1_23) AT=475.025n

* CHECK dout1_24 Vdout1_24ck94 = 0 time = 475
.meas tran vdout1_24ck94 FIND v(dout1_24) AT=475.025n

* CHECK dout1_25 Vdout1_25ck94 = 0 time = 475
.meas tran vdout1_25ck94 FIND v(dout1_25) AT=475.025n

* CHECK dout1_26 Vdout1_26ck94 = 0 time = 475
.meas tran vdout1_26ck94 FIND v(dout1_26) AT=475.025n

* CHECK dout1_27 Vdout1_27ck94 = 0 time = 475
.meas tran vdout1_27ck94 FIND v(dout1_27) AT=475.025n

* CHECK dout1_28 Vdout1_28ck94 = 0 time = 475
.meas tran vdout1_28ck94 FIND v(dout1_28) AT=475.025n

* CHECK dout1_29 Vdout1_29ck94 = 0 time = 475
.meas tran vdout1_29ck94 FIND v(dout1_29) AT=475.025n

* CHECK dout1_30 Vdout1_30ck94 = 0 time = 475
.meas tran vdout1_30ck94 FIND v(dout1_30) AT=475.025n

* CHECK dout1_31 Vdout1_31ck94 = 0 time = 475
.meas tran vdout1_31ck94 FIND v(dout1_31) AT=475.025n

* CHECK dout1_32 Vdout1_32ck94 = 0 time = 475
.meas tran vdout1_32ck94 FIND v(dout1_32) AT=475.025n

* CHECK dout1_33 Vdout1_33ck94 = 0 time = 475
.meas tran vdout1_33ck94 FIND v(dout1_33) AT=475.025n

* CHECK dout1_34 Vdout1_34ck94 = 0 time = 475
.meas tran vdout1_34ck94 FIND v(dout1_34) AT=475.025n

* CHECK dout1_35 Vdout1_35ck94 = 0.9 time = 475
.meas tran vdout1_35ck94 FIND v(dout1_35) AT=475.025n

* CHECK dout1_36 Vdout1_36ck94 = 0 time = 475
.meas tran vdout1_36ck94 FIND v(dout1_36) AT=475.025n

* CHECK dout1_37 Vdout1_37ck94 = 0 time = 475
.meas tran vdout1_37ck94 FIND v(dout1_37) AT=475.025n

* CHECK dout1_38 Vdout1_38ck94 = 0 time = 475
.meas tran vdout1_38ck94 FIND v(dout1_38) AT=475.025n

* CHECK dout1_39 Vdout1_39ck94 = 0 time = 475
.meas tran vdout1_39ck94 FIND v(dout1_39) AT=475.025n

* CHECK dout1_40 Vdout1_40ck94 = 0.9 time = 475
.meas tran vdout1_40ck94 FIND v(dout1_40) AT=475.025n

* CHECK dout1_41 Vdout1_41ck94 = 0 time = 475
.meas tran vdout1_41ck94 FIND v(dout1_41) AT=475.025n

* CHECK dout1_42 Vdout1_42ck94 = 0.9 time = 475
.meas tran vdout1_42ck94 FIND v(dout1_42) AT=475.025n

* CHECK dout1_43 Vdout1_43ck94 = 0.9 time = 475
.meas tran vdout1_43ck94 FIND v(dout1_43) AT=475.025n

* CHECK dout1_44 Vdout1_44ck94 = 0.9 time = 475
.meas tran vdout1_44ck94 FIND v(dout1_44) AT=475.025n

* CHECK dout1_45 Vdout1_45ck94 = 0.9 time = 475
.meas tran vdout1_45ck94 FIND v(dout1_45) AT=475.025n

* CHECK dout1_46 Vdout1_46ck94 = 0.9 time = 475
.meas tran vdout1_46ck94 FIND v(dout1_46) AT=475.025n

* CHECK dout1_47 Vdout1_47ck94 = 0 time = 475
.meas tran vdout1_47ck94 FIND v(dout1_47) AT=475.025n

* CHECK dout1_48 Vdout1_48ck94 = 0.9 time = 475
.meas tran vdout1_48ck94 FIND v(dout1_48) AT=475.025n

* CHECK dout1_49 Vdout1_49ck94 = 0.9 time = 475
.meas tran vdout1_49ck94 FIND v(dout1_49) AT=475.025n

* CHECK dout1_50 Vdout1_50ck94 = 0 time = 475
.meas tran vdout1_50ck94 FIND v(dout1_50) AT=475.025n

* CHECK dout1_51 Vdout1_51ck94 = 0 time = 475
.meas tran vdout1_51ck94 FIND v(dout1_51) AT=475.025n

* CHECK dout1_52 Vdout1_52ck94 = 0 time = 475
.meas tran vdout1_52ck94 FIND v(dout1_52) AT=475.025n

* CHECK dout1_53 Vdout1_53ck94 = 0.9 time = 475
.meas tran vdout1_53ck94 FIND v(dout1_53) AT=475.025n

* CHECK dout1_54 Vdout1_54ck94 = 0.9 time = 475
.meas tran vdout1_54ck94 FIND v(dout1_54) AT=475.025n

* CHECK dout1_55 Vdout1_55ck94 = 0 time = 475
.meas tran vdout1_55ck94 FIND v(dout1_55) AT=475.025n

* CHECK dout1_56 Vdout1_56ck94 = 0.9 time = 475
.meas tran vdout1_56ck94 FIND v(dout1_56) AT=475.025n

* CHECK dout1_57 Vdout1_57ck94 = 0 time = 475
.meas tran vdout1_57ck94 FIND v(dout1_57) AT=475.025n

* CHECK dout1_58 Vdout1_58ck94 = 0 time = 475
.meas tran vdout1_58ck94 FIND v(dout1_58) AT=475.025n

* CHECK dout1_59 Vdout1_59ck94 = 0.9 time = 475
.meas tran vdout1_59ck94 FIND v(dout1_59) AT=475.025n

* CHECK dout1_60 Vdout1_60ck94 = 0 time = 475
.meas tran vdout1_60ck94 FIND v(dout1_60) AT=475.025n

* CHECK dout1_61 Vdout1_61ck94 = 0.9 time = 475
.meas tran vdout1_61ck94 FIND v(dout1_61) AT=475.025n

* CHECK dout1_62 Vdout1_62ck94 = 0 time = 475
.meas tran vdout1_62ck94 FIND v(dout1_62) AT=475.025n

* CHECK dout1_63 Vdout1_63ck94 = 0.9 time = 475
.meas tran vdout1_63ck94 FIND v(dout1_63) AT=475.025n

* CHECK dout1_64 Vdout1_64ck94 = 0 time = 475
.meas tran vdout1_64ck94 FIND v(dout1_64) AT=475.025n

* CHECK dout1_65 Vdout1_65ck94 = 0 time = 475
.meas tran vdout1_65ck94 FIND v(dout1_65) AT=475.025n

* CHECK dout1_66 Vdout1_66ck94 = 0.9 time = 475
.meas tran vdout1_66ck94 FIND v(dout1_66) AT=475.025n

* CHECK dout1_67 Vdout1_67ck94 = 0.9 time = 475
.meas tran vdout1_67ck94 FIND v(dout1_67) AT=475.025n

* CHECK dout1_68 Vdout1_68ck94 = 0.9 time = 475
.meas tran vdout1_68ck94 FIND v(dout1_68) AT=475.025n

* CHECK dout1_69 Vdout1_69ck94 = 0.9 time = 475
.meas tran vdout1_69ck94 FIND v(dout1_69) AT=475.025n

* CHECK dout1_70 Vdout1_70ck94 = 0.9 time = 475
.meas tran vdout1_70ck94 FIND v(dout1_70) AT=475.025n

* CHECK dout1_71 Vdout1_71ck94 = 0 time = 475
.meas tran vdout1_71ck94 FIND v(dout1_71) AT=475.025n

* CHECK dout1_72 Vdout1_72ck94 = 0.9 time = 475
.meas tran vdout1_72ck94 FIND v(dout1_72) AT=475.025n

* CHECK dout1_73 Vdout1_73ck94 = 0.9 time = 475
.meas tran vdout1_73ck94 FIND v(dout1_73) AT=475.025n

* CHECK dout1_74 Vdout1_74ck94 = 0 time = 475
.meas tran vdout1_74ck94 FIND v(dout1_74) AT=475.025n

* CHECK dout1_75 Vdout1_75ck94 = 0 time = 475
.meas tran vdout1_75ck94 FIND v(dout1_75) AT=475.025n

* CHECK dout1_76 Vdout1_76ck94 = 0 time = 475
.meas tran vdout1_76ck94 FIND v(dout1_76) AT=475.025n

* CHECK dout1_77 Vdout1_77ck94 = 0 time = 475
.meas tran vdout1_77ck94 FIND v(dout1_77) AT=475.025n

* CHECK dout1_78 Vdout1_78ck94 = 0.9 time = 475
.meas tran vdout1_78ck94 FIND v(dout1_78) AT=475.025n

* CHECK dout1_79 Vdout1_79ck94 = 0.9 time = 475
.meas tran vdout1_79ck94 FIND v(dout1_79) AT=475.025n

* CHECK dout1_80 Vdout1_80ck94 = 0.9 time = 475
.meas tran vdout1_80ck94 FIND v(dout1_80) AT=475.025n

* CHECK dout1_81 Vdout1_81ck94 = 0 time = 475
.meas tran vdout1_81ck94 FIND v(dout1_81) AT=475.025n

* CHECK dout1_82 Vdout1_82ck94 = 0.9 time = 475
.meas tran vdout1_82ck94 FIND v(dout1_82) AT=475.025n

* CHECK dout1_83 Vdout1_83ck94 = 0.9 time = 475
.meas tran vdout1_83ck94 FIND v(dout1_83) AT=475.025n

* CHECK dout1_84 Vdout1_84ck94 = 0.9 time = 475
.meas tran vdout1_84ck94 FIND v(dout1_84) AT=475.025n

* CHECK dout1_85 Vdout1_85ck94 = 0.9 time = 475
.meas tran vdout1_85ck94 FIND v(dout1_85) AT=475.025n

* CHECK dout1_86 Vdout1_86ck94 = 0 time = 475
.meas tran vdout1_86ck94 FIND v(dout1_86) AT=475.025n

* CHECK dout1_87 Vdout1_87ck94 = 0.9 time = 475
.meas tran vdout1_87ck94 FIND v(dout1_87) AT=475.025n

* CHECK dout1_88 Vdout1_88ck94 = 0 time = 475
.meas tran vdout1_88ck94 FIND v(dout1_88) AT=475.025n

* CHECK dout1_89 Vdout1_89ck94 = 0.9 time = 475
.meas tran vdout1_89ck94 FIND v(dout1_89) AT=475.025n

* CHECK dout1_90 Vdout1_90ck94 = 0.9 time = 475
.meas tran vdout1_90ck94 FIND v(dout1_90) AT=475.025n

* CHECK dout1_91 Vdout1_91ck94 = 0 time = 475
.meas tran vdout1_91ck94 FIND v(dout1_91) AT=475.025n

* CHECK dout1_92 Vdout1_92ck94 = 0.9 time = 475
.meas tran vdout1_92ck94 FIND v(dout1_92) AT=475.025n

* CHECK dout1_93 Vdout1_93ck94 = 0.9 time = 475
.meas tran vdout1_93ck94 FIND v(dout1_93) AT=475.025n

* CHECK dout1_94 Vdout1_94ck94 = 0.9 time = 475
.meas tran vdout1_94ck94 FIND v(dout1_94) AT=475.025n

* CHECK dout1_95 Vdout1_95ck94 = 0.9 time = 475
.meas tran vdout1_95ck94 FIND v(dout1_95) AT=475.025n

* CHECK dout1_96 Vdout1_96ck94 = 0.9 time = 475
.meas tran vdout1_96ck94 FIND v(dout1_96) AT=475.025n

* CHECK dout1_97 Vdout1_97ck94 = 0 time = 475
.meas tran vdout1_97ck94 FIND v(dout1_97) AT=475.025n

* CHECK dout1_98 Vdout1_98ck94 = 0 time = 475
.meas tran vdout1_98ck94 FIND v(dout1_98) AT=475.025n

* CHECK dout1_99 Vdout1_99ck94 = 0 time = 475
.meas tran vdout1_99ck94 FIND v(dout1_99) AT=475.025n

* CHECK dout1_100 Vdout1_100ck94 = 0 time = 475
.meas tran vdout1_100ck94 FIND v(dout1_100) AT=475.025n

* CHECK dout1_101 Vdout1_101ck94 = 0.9 time = 475
.meas tran vdout1_101ck94 FIND v(dout1_101) AT=475.025n

* CHECK dout1_102 Vdout1_102ck94 = 0.9 time = 475
.meas tran vdout1_102ck94 FIND v(dout1_102) AT=475.025n

* CHECK dout1_103 Vdout1_103ck94 = 0 time = 475
.meas tran vdout1_103ck94 FIND v(dout1_103) AT=475.025n

* CHECK dout1_104 Vdout1_104ck94 = 0 time = 475
.meas tran vdout1_104ck94 FIND v(dout1_104) AT=475.025n

* CHECK dout1_105 Vdout1_105ck94 = 0 time = 475
.meas tran vdout1_105ck94 FIND v(dout1_105) AT=475.025n

* CHECK dout1_106 Vdout1_106ck94 = 0.9 time = 475
.meas tran vdout1_106ck94 FIND v(dout1_106) AT=475.025n

* CHECK dout1_107 Vdout1_107ck94 = 0 time = 475
.meas tran vdout1_107ck94 FIND v(dout1_107) AT=475.025n

* CHECK dout1_108 Vdout1_108ck94 = 0 time = 475
.meas tran vdout1_108ck94 FIND v(dout1_108) AT=475.025n

* CHECK dout1_109 Vdout1_109ck94 = 0.9 time = 475
.meas tran vdout1_109ck94 FIND v(dout1_109) AT=475.025n

* CHECK dout1_110 Vdout1_110ck94 = 0 time = 475
.meas tran vdout1_110ck94 FIND v(dout1_110) AT=475.025n

* CHECK dout1_111 Vdout1_111ck94 = 0.9 time = 475
.meas tran vdout1_111ck94 FIND v(dout1_111) AT=475.025n

* CHECK dout1_112 Vdout1_112ck94 = 0 time = 475
.meas tran vdout1_112ck94 FIND v(dout1_112) AT=475.025n

* CHECK dout1_113 Vdout1_113ck94 = 0.9 time = 475
.meas tran vdout1_113ck94 FIND v(dout1_113) AT=475.025n

* CHECK dout1_114 Vdout1_114ck94 = 0 time = 475
.meas tran vdout1_114ck94 FIND v(dout1_114) AT=475.025n

* CHECK dout1_115 Vdout1_115ck94 = 0 time = 475
.meas tran vdout1_115ck94 FIND v(dout1_115) AT=475.025n

* CHECK dout1_116 Vdout1_116ck94 = 0.9 time = 475
.meas tran vdout1_116ck94 FIND v(dout1_116) AT=475.025n

* CHECK dout1_117 Vdout1_117ck94 = 0 time = 475
.meas tran vdout1_117ck94 FIND v(dout1_117) AT=475.025n

* CHECK dout1_118 Vdout1_118ck94 = 0 time = 475
.meas tran vdout1_118ck94 FIND v(dout1_118) AT=475.025n

* CHECK dout1_119 Vdout1_119ck94 = 0.9 time = 475
.meas tran vdout1_119ck94 FIND v(dout1_119) AT=475.025n

* CHECK dout1_0 Vdout1_0ck97 = 0 time = 490
.meas tran vdout1_0ck97 FIND v(dout1_0) AT=490.025n

* CHECK dout1_1 Vdout1_1ck97 = 0 time = 490
.meas tran vdout1_1ck97 FIND v(dout1_1) AT=490.025n

* CHECK dout1_2 Vdout1_2ck97 = 0 time = 490
.meas tran vdout1_2ck97 FIND v(dout1_2) AT=490.025n

* CHECK dout1_3 Vdout1_3ck97 = 0 time = 490
.meas tran vdout1_3ck97 FIND v(dout1_3) AT=490.025n

* CHECK dout1_4 Vdout1_4ck97 = 0.9 time = 490
.meas tran vdout1_4ck97 FIND v(dout1_4) AT=490.025n

* CHECK dout1_5 Vdout1_5ck97 = 0 time = 490
.meas tran vdout1_5ck97 FIND v(dout1_5) AT=490.025n

* CHECK dout1_6 Vdout1_6ck97 = 0.9 time = 490
.meas tran vdout1_6ck97 FIND v(dout1_6) AT=490.025n

* CHECK dout1_7 Vdout1_7ck97 = 0 time = 490
.meas tran vdout1_7ck97 FIND v(dout1_7) AT=490.025n

* CHECK dout1_8 Vdout1_8ck97 = 0.9 time = 490
.meas tran vdout1_8ck97 FIND v(dout1_8) AT=490.025n

* CHECK dout1_9 Vdout1_9ck97 = 0.9 time = 490
.meas tran vdout1_9ck97 FIND v(dout1_9) AT=490.025n

* CHECK dout1_10 Vdout1_10ck97 = 0 time = 490
.meas tran vdout1_10ck97 FIND v(dout1_10) AT=490.025n

* CHECK dout1_11 Vdout1_11ck97 = 0 time = 490
.meas tran vdout1_11ck97 FIND v(dout1_11) AT=490.025n

* CHECK dout1_12 Vdout1_12ck97 = 0 time = 490
.meas tran vdout1_12ck97 FIND v(dout1_12) AT=490.025n

* CHECK dout1_13 Vdout1_13ck97 = 0.9 time = 490
.meas tran vdout1_13ck97 FIND v(dout1_13) AT=490.025n

* CHECK dout1_14 Vdout1_14ck97 = 0 time = 490
.meas tran vdout1_14ck97 FIND v(dout1_14) AT=490.025n

* CHECK dout1_15 Vdout1_15ck97 = 0.9 time = 490
.meas tran vdout1_15ck97 FIND v(dout1_15) AT=490.025n

* CHECK dout1_16 Vdout1_16ck97 = 0.9 time = 490
.meas tran vdout1_16ck97 FIND v(dout1_16) AT=490.025n

* CHECK dout1_17 Vdout1_17ck97 = 0 time = 490
.meas tran vdout1_17ck97 FIND v(dout1_17) AT=490.025n

* CHECK dout1_18 Vdout1_18ck97 = 0 time = 490
.meas tran vdout1_18ck97 FIND v(dout1_18) AT=490.025n

* CHECK dout1_19 Vdout1_19ck97 = 0 time = 490
.meas tran vdout1_19ck97 FIND v(dout1_19) AT=490.025n

* CHECK dout1_20 Vdout1_20ck97 = 0.9 time = 490
.meas tran vdout1_20ck97 FIND v(dout1_20) AT=490.025n

* CHECK dout1_21 Vdout1_21ck97 = 0 time = 490
.meas tran vdout1_21ck97 FIND v(dout1_21) AT=490.025n

* CHECK dout1_22 Vdout1_22ck97 = 0.9 time = 490
.meas tran vdout1_22ck97 FIND v(dout1_22) AT=490.025n

* CHECK dout1_23 Vdout1_23ck97 = 0.9 time = 490
.meas tran vdout1_23ck97 FIND v(dout1_23) AT=490.025n

* CHECK dout1_24 Vdout1_24ck97 = 0.9 time = 490
.meas tran vdout1_24ck97 FIND v(dout1_24) AT=490.025n

* CHECK dout1_25 Vdout1_25ck97 = 0.9 time = 490
.meas tran vdout1_25ck97 FIND v(dout1_25) AT=490.025n

* CHECK dout1_26 Vdout1_26ck97 = 0.9 time = 490
.meas tran vdout1_26ck97 FIND v(dout1_26) AT=490.025n

* CHECK dout1_27 Vdout1_27ck97 = 0 time = 490
.meas tran vdout1_27ck97 FIND v(dout1_27) AT=490.025n

* CHECK dout1_28 Vdout1_28ck97 = 0.9 time = 490
.meas tran vdout1_28ck97 FIND v(dout1_28) AT=490.025n

* CHECK dout1_29 Vdout1_29ck97 = 0 time = 490
.meas tran vdout1_29ck97 FIND v(dout1_29) AT=490.025n

* CHECK dout1_30 Vdout1_30ck97 = 0.9 time = 490
.meas tran vdout1_30ck97 FIND v(dout1_30) AT=490.025n

* CHECK dout1_31 Vdout1_31ck97 = 0.9 time = 490
.meas tran vdout1_31ck97 FIND v(dout1_31) AT=490.025n

* CHECK dout1_32 Vdout1_32ck97 = 0 time = 490
.meas tran vdout1_32ck97 FIND v(dout1_32) AT=490.025n

* CHECK dout1_33 Vdout1_33ck97 = 0 time = 490
.meas tran vdout1_33ck97 FIND v(dout1_33) AT=490.025n

* CHECK dout1_34 Vdout1_34ck97 = 0.9 time = 490
.meas tran vdout1_34ck97 FIND v(dout1_34) AT=490.025n

* CHECK dout1_35 Vdout1_35ck97 = 0.9 time = 490
.meas tran vdout1_35ck97 FIND v(dout1_35) AT=490.025n

* CHECK dout1_36 Vdout1_36ck97 = 0 time = 490
.meas tran vdout1_36ck97 FIND v(dout1_36) AT=490.025n

* CHECK dout1_37 Vdout1_37ck97 = 0 time = 490
.meas tran vdout1_37ck97 FIND v(dout1_37) AT=490.025n

* CHECK dout1_38 Vdout1_38ck97 = 0.9 time = 490
.meas tran vdout1_38ck97 FIND v(dout1_38) AT=490.025n

* CHECK dout1_39 Vdout1_39ck97 = 0 time = 490
.meas tran vdout1_39ck97 FIND v(dout1_39) AT=490.025n

* CHECK dout1_40 Vdout1_40ck97 = 0 time = 490
.meas tran vdout1_40ck97 FIND v(dout1_40) AT=490.025n

* CHECK dout1_41 Vdout1_41ck97 = 0.9 time = 490
.meas tran vdout1_41ck97 FIND v(dout1_41) AT=490.025n

* CHECK dout1_42 Vdout1_42ck97 = 0 time = 490
.meas tran vdout1_42ck97 FIND v(dout1_42) AT=490.025n

* CHECK dout1_43 Vdout1_43ck97 = 0.9 time = 490
.meas tran vdout1_43ck97 FIND v(dout1_43) AT=490.025n

* CHECK dout1_44 Vdout1_44ck97 = 0.9 time = 490
.meas tran vdout1_44ck97 FIND v(dout1_44) AT=490.025n

* CHECK dout1_45 Vdout1_45ck97 = 0 time = 490
.meas tran vdout1_45ck97 FIND v(dout1_45) AT=490.025n

* CHECK dout1_46 Vdout1_46ck97 = 0.9 time = 490
.meas tran vdout1_46ck97 FIND v(dout1_46) AT=490.025n

* CHECK dout1_47 Vdout1_47ck97 = 0 time = 490
.meas tran vdout1_47ck97 FIND v(dout1_47) AT=490.025n

* CHECK dout1_48 Vdout1_48ck97 = 0.9 time = 490
.meas tran vdout1_48ck97 FIND v(dout1_48) AT=490.025n

* CHECK dout1_49 Vdout1_49ck97 = 0.9 time = 490
.meas tran vdout1_49ck97 FIND v(dout1_49) AT=490.025n

* CHECK dout1_50 Vdout1_50ck97 = 0.9 time = 490
.meas tran vdout1_50ck97 FIND v(dout1_50) AT=490.025n

* CHECK dout1_51 Vdout1_51ck97 = 0 time = 490
.meas tran vdout1_51ck97 FIND v(dout1_51) AT=490.025n

* CHECK dout1_52 Vdout1_52ck97 = 0.9 time = 490
.meas tran vdout1_52ck97 FIND v(dout1_52) AT=490.025n

* CHECK dout1_53 Vdout1_53ck97 = 0.9 time = 490
.meas tran vdout1_53ck97 FIND v(dout1_53) AT=490.025n

* CHECK dout1_54 Vdout1_54ck97 = 0.9 time = 490
.meas tran vdout1_54ck97 FIND v(dout1_54) AT=490.025n

* CHECK dout1_55 Vdout1_55ck97 = 0 time = 490
.meas tran vdout1_55ck97 FIND v(dout1_55) AT=490.025n

* CHECK dout1_56 Vdout1_56ck97 = 0 time = 490
.meas tran vdout1_56ck97 FIND v(dout1_56) AT=490.025n

* CHECK dout1_57 Vdout1_57ck97 = 0 time = 490
.meas tran vdout1_57ck97 FIND v(dout1_57) AT=490.025n

* CHECK dout1_58 Vdout1_58ck97 = 0.9 time = 490
.meas tran vdout1_58ck97 FIND v(dout1_58) AT=490.025n

* CHECK dout1_59 Vdout1_59ck97 = 0.9 time = 490
.meas tran vdout1_59ck97 FIND v(dout1_59) AT=490.025n

* CHECK dout1_60 Vdout1_60ck97 = 0 time = 490
.meas tran vdout1_60ck97 FIND v(dout1_60) AT=490.025n

* CHECK dout1_61 Vdout1_61ck97 = 0.9 time = 490
.meas tran vdout1_61ck97 FIND v(dout1_61) AT=490.025n

* CHECK dout1_62 Vdout1_62ck97 = 0 time = 490
.meas tran vdout1_62ck97 FIND v(dout1_62) AT=490.025n

* CHECK dout1_63 Vdout1_63ck97 = 0 time = 490
.meas tran vdout1_63ck97 FIND v(dout1_63) AT=490.025n

* CHECK dout1_64 Vdout1_64ck97 = 0.9 time = 490
.meas tran vdout1_64ck97 FIND v(dout1_64) AT=490.025n

* CHECK dout1_65 Vdout1_65ck97 = 0.9 time = 490
.meas tran vdout1_65ck97 FIND v(dout1_65) AT=490.025n

* CHECK dout1_66 Vdout1_66ck97 = 0 time = 490
.meas tran vdout1_66ck97 FIND v(dout1_66) AT=490.025n

* CHECK dout1_67 Vdout1_67ck97 = 0 time = 490
.meas tran vdout1_67ck97 FIND v(dout1_67) AT=490.025n

* CHECK dout1_68 Vdout1_68ck97 = 0 time = 490
.meas tran vdout1_68ck97 FIND v(dout1_68) AT=490.025n

* CHECK dout1_69 Vdout1_69ck97 = 0 time = 490
.meas tran vdout1_69ck97 FIND v(dout1_69) AT=490.025n

* CHECK dout1_70 Vdout1_70ck97 = 0 time = 490
.meas tran vdout1_70ck97 FIND v(dout1_70) AT=490.025n

* CHECK dout1_71 Vdout1_71ck97 = 0.9 time = 490
.meas tran vdout1_71ck97 FIND v(dout1_71) AT=490.025n

* CHECK dout1_72 Vdout1_72ck97 = 0.9 time = 490
.meas tran vdout1_72ck97 FIND v(dout1_72) AT=490.025n

* CHECK dout1_73 Vdout1_73ck97 = 0 time = 490
.meas tran vdout1_73ck97 FIND v(dout1_73) AT=490.025n

* CHECK dout1_74 Vdout1_74ck97 = 0 time = 490
.meas tran vdout1_74ck97 FIND v(dout1_74) AT=490.025n

* CHECK dout1_75 Vdout1_75ck97 = 0.9 time = 490
.meas tran vdout1_75ck97 FIND v(dout1_75) AT=490.025n

* CHECK dout1_76 Vdout1_76ck97 = 0.9 time = 490
.meas tran vdout1_76ck97 FIND v(dout1_76) AT=490.025n

* CHECK dout1_77 Vdout1_77ck97 = 0.9 time = 490
.meas tran vdout1_77ck97 FIND v(dout1_77) AT=490.025n

* CHECK dout1_78 Vdout1_78ck97 = 0 time = 490
.meas tran vdout1_78ck97 FIND v(dout1_78) AT=490.025n

* CHECK dout1_79 Vdout1_79ck97 = 0 time = 490
.meas tran vdout1_79ck97 FIND v(dout1_79) AT=490.025n

* CHECK dout1_80 Vdout1_80ck97 = 0 time = 490
.meas tran vdout1_80ck97 FIND v(dout1_80) AT=490.025n

* CHECK dout1_81 Vdout1_81ck97 = 0 time = 490
.meas tran vdout1_81ck97 FIND v(dout1_81) AT=490.025n

* CHECK dout1_82 Vdout1_82ck97 = 0 time = 490
.meas tran vdout1_82ck97 FIND v(dout1_82) AT=490.025n

* CHECK dout1_83 Vdout1_83ck97 = 0 time = 490
.meas tran vdout1_83ck97 FIND v(dout1_83) AT=490.025n

* CHECK dout1_84 Vdout1_84ck97 = 0 time = 490
.meas tran vdout1_84ck97 FIND v(dout1_84) AT=490.025n

* CHECK dout1_85 Vdout1_85ck97 = 0 time = 490
.meas tran vdout1_85ck97 FIND v(dout1_85) AT=490.025n

* CHECK dout1_86 Vdout1_86ck97 = 0 time = 490
.meas tran vdout1_86ck97 FIND v(dout1_86) AT=490.025n

* CHECK dout1_87 Vdout1_87ck97 = 0 time = 490
.meas tran vdout1_87ck97 FIND v(dout1_87) AT=490.025n

* CHECK dout1_88 Vdout1_88ck97 = 0 time = 490
.meas tran vdout1_88ck97 FIND v(dout1_88) AT=490.025n

* CHECK dout1_89 Vdout1_89ck97 = 0 time = 490
.meas tran vdout1_89ck97 FIND v(dout1_89) AT=490.025n

* CHECK dout1_90 Vdout1_90ck97 = 0.9 time = 490
.meas tran vdout1_90ck97 FIND v(dout1_90) AT=490.025n

* CHECK dout1_91 Vdout1_91ck97 = 0 time = 490
.meas tran vdout1_91ck97 FIND v(dout1_91) AT=490.025n

* CHECK dout1_92 Vdout1_92ck97 = 0.9 time = 490
.meas tran vdout1_92ck97 FIND v(dout1_92) AT=490.025n

* CHECK dout1_93 Vdout1_93ck97 = 0 time = 490
.meas tran vdout1_93ck97 FIND v(dout1_93) AT=490.025n

* CHECK dout1_94 Vdout1_94ck97 = 0.9 time = 490
.meas tran vdout1_94ck97 FIND v(dout1_94) AT=490.025n

* CHECK dout1_95 Vdout1_95ck97 = 0.9 time = 490
.meas tran vdout1_95ck97 FIND v(dout1_95) AT=490.025n

* CHECK dout1_96 Vdout1_96ck97 = 0.9 time = 490
.meas tran vdout1_96ck97 FIND v(dout1_96) AT=490.025n

* CHECK dout1_97 Vdout1_97ck97 = 0 time = 490
.meas tran vdout1_97ck97 FIND v(dout1_97) AT=490.025n

* CHECK dout1_98 Vdout1_98ck97 = 0.9 time = 490
.meas tran vdout1_98ck97 FIND v(dout1_98) AT=490.025n

* CHECK dout1_99 Vdout1_99ck97 = 0.9 time = 490
.meas tran vdout1_99ck97 FIND v(dout1_99) AT=490.025n

* CHECK dout1_100 Vdout1_100ck97 = 0.9 time = 490
.meas tran vdout1_100ck97 FIND v(dout1_100) AT=490.025n

* CHECK dout1_101 Vdout1_101ck97 = 0.9 time = 490
.meas tran vdout1_101ck97 FIND v(dout1_101) AT=490.025n

* CHECK dout1_102 Vdout1_102ck97 = 0.9 time = 490
.meas tran vdout1_102ck97 FIND v(dout1_102) AT=490.025n

* CHECK dout1_103 Vdout1_103ck97 = 0.9 time = 490
.meas tran vdout1_103ck97 FIND v(dout1_103) AT=490.025n

* CHECK dout1_104 Vdout1_104ck97 = 0 time = 490
.meas tran vdout1_104ck97 FIND v(dout1_104) AT=490.025n

* CHECK dout1_105 Vdout1_105ck97 = 0 time = 490
.meas tran vdout1_105ck97 FIND v(dout1_105) AT=490.025n

* CHECK dout1_106 Vdout1_106ck97 = 0.9 time = 490
.meas tran vdout1_106ck97 FIND v(dout1_106) AT=490.025n

* CHECK dout1_107 Vdout1_107ck97 = 0.9 time = 490
.meas tran vdout1_107ck97 FIND v(dout1_107) AT=490.025n

* CHECK dout1_108 Vdout1_108ck97 = 0.9 time = 490
.meas tran vdout1_108ck97 FIND v(dout1_108) AT=490.025n

* CHECK dout1_109 Vdout1_109ck97 = 0 time = 490
.meas tran vdout1_109ck97 FIND v(dout1_109) AT=490.025n

* CHECK dout1_110 Vdout1_110ck97 = 0 time = 490
.meas tran vdout1_110ck97 FIND v(dout1_110) AT=490.025n

* CHECK dout1_111 Vdout1_111ck97 = 0 time = 490
.meas tran vdout1_111ck97 FIND v(dout1_111) AT=490.025n

* CHECK dout1_112 Vdout1_112ck97 = 0.9 time = 490
.meas tran vdout1_112ck97 FIND v(dout1_112) AT=490.025n

* CHECK dout1_113 Vdout1_113ck97 = 0.9 time = 490
.meas tran vdout1_113ck97 FIND v(dout1_113) AT=490.025n

* CHECK dout1_114 Vdout1_114ck97 = 0 time = 490
.meas tran vdout1_114ck97 FIND v(dout1_114) AT=490.025n

* CHECK dout1_115 Vdout1_115ck97 = 0 time = 490
.meas tran vdout1_115ck97 FIND v(dout1_115) AT=490.025n

* CHECK dout1_116 Vdout1_116ck97 = 0 time = 490
.meas tran vdout1_116ck97 FIND v(dout1_116) AT=490.025n

* CHECK dout1_117 Vdout1_117ck97 = 0.9 time = 490
.meas tran vdout1_117ck97 FIND v(dout1_117) AT=490.025n

* CHECK dout1_118 Vdout1_118ck97 = 0 time = 490
.meas tran vdout1_118ck97 FIND v(dout1_118) AT=490.025n

* CHECK dout1_119 Vdout1_119ck97 = 0 time = 490
.meas tran vdout1_119ck97 FIND v(dout1_119) AT=490.025n

* CHECK dout1_0 Vdout1_0ck98 = 0 time = 495
.meas tran vdout1_0ck98 FIND v(dout1_0) AT=495.025n

* CHECK dout1_1 Vdout1_1ck98 = 0 time = 495
.meas tran vdout1_1ck98 FIND v(dout1_1) AT=495.025n

* CHECK dout1_2 Vdout1_2ck98 = 0 time = 495
.meas tran vdout1_2ck98 FIND v(dout1_2) AT=495.025n

* CHECK dout1_3 Vdout1_3ck98 = 0 time = 495
.meas tran vdout1_3ck98 FIND v(dout1_3) AT=495.025n

* CHECK dout1_4 Vdout1_4ck98 = 0.9 time = 495
.meas tran vdout1_4ck98 FIND v(dout1_4) AT=495.025n

* CHECK dout1_5 Vdout1_5ck98 = 0 time = 495
.meas tran vdout1_5ck98 FIND v(dout1_5) AT=495.025n

* CHECK dout1_6 Vdout1_6ck98 = 0.9 time = 495
.meas tran vdout1_6ck98 FIND v(dout1_6) AT=495.025n

* CHECK dout1_7 Vdout1_7ck98 = 0 time = 495
.meas tran vdout1_7ck98 FIND v(dout1_7) AT=495.025n

* CHECK dout1_8 Vdout1_8ck98 = 0.9 time = 495
.meas tran vdout1_8ck98 FIND v(dout1_8) AT=495.025n

* CHECK dout1_9 Vdout1_9ck98 = 0.9 time = 495
.meas tran vdout1_9ck98 FIND v(dout1_9) AT=495.025n

* CHECK dout1_10 Vdout1_10ck98 = 0 time = 495
.meas tran vdout1_10ck98 FIND v(dout1_10) AT=495.025n

* CHECK dout1_11 Vdout1_11ck98 = 0 time = 495
.meas tran vdout1_11ck98 FIND v(dout1_11) AT=495.025n

* CHECK dout1_12 Vdout1_12ck98 = 0 time = 495
.meas tran vdout1_12ck98 FIND v(dout1_12) AT=495.025n

* CHECK dout1_13 Vdout1_13ck98 = 0.9 time = 495
.meas tran vdout1_13ck98 FIND v(dout1_13) AT=495.025n

* CHECK dout1_14 Vdout1_14ck98 = 0 time = 495
.meas tran vdout1_14ck98 FIND v(dout1_14) AT=495.025n

* CHECK dout1_15 Vdout1_15ck98 = 0.9 time = 495
.meas tran vdout1_15ck98 FIND v(dout1_15) AT=495.025n

* CHECK dout1_16 Vdout1_16ck98 = 0.9 time = 495
.meas tran vdout1_16ck98 FIND v(dout1_16) AT=495.025n

* CHECK dout1_17 Vdout1_17ck98 = 0 time = 495
.meas tran vdout1_17ck98 FIND v(dout1_17) AT=495.025n

* CHECK dout1_18 Vdout1_18ck98 = 0 time = 495
.meas tran vdout1_18ck98 FIND v(dout1_18) AT=495.025n

* CHECK dout1_19 Vdout1_19ck98 = 0 time = 495
.meas tran vdout1_19ck98 FIND v(dout1_19) AT=495.025n

* CHECK dout1_20 Vdout1_20ck98 = 0.9 time = 495
.meas tran vdout1_20ck98 FIND v(dout1_20) AT=495.025n

* CHECK dout1_21 Vdout1_21ck98 = 0 time = 495
.meas tran vdout1_21ck98 FIND v(dout1_21) AT=495.025n

* CHECK dout1_22 Vdout1_22ck98 = 0.9 time = 495
.meas tran vdout1_22ck98 FIND v(dout1_22) AT=495.025n

* CHECK dout1_23 Vdout1_23ck98 = 0.9 time = 495
.meas tran vdout1_23ck98 FIND v(dout1_23) AT=495.025n

* CHECK dout1_24 Vdout1_24ck98 = 0.9 time = 495
.meas tran vdout1_24ck98 FIND v(dout1_24) AT=495.025n

* CHECK dout1_25 Vdout1_25ck98 = 0.9 time = 495
.meas tran vdout1_25ck98 FIND v(dout1_25) AT=495.025n

* CHECK dout1_26 Vdout1_26ck98 = 0.9 time = 495
.meas tran vdout1_26ck98 FIND v(dout1_26) AT=495.025n

* CHECK dout1_27 Vdout1_27ck98 = 0 time = 495
.meas tran vdout1_27ck98 FIND v(dout1_27) AT=495.025n

* CHECK dout1_28 Vdout1_28ck98 = 0.9 time = 495
.meas tran vdout1_28ck98 FIND v(dout1_28) AT=495.025n

* CHECK dout1_29 Vdout1_29ck98 = 0 time = 495
.meas tran vdout1_29ck98 FIND v(dout1_29) AT=495.025n

* CHECK dout1_30 Vdout1_30ck98 = 0.9 time = 495
.meas tran vdout1_30ck98 FIND v(dout1_30) AT=495.025n

* CHECK dout1_31 Vdout1_31ck98 = 0.9 time = 495
.meas tran vdout1_31ck98 FIND v(dout1_31) AT=495.025n

* CHECK dout1_32 Vdout1_32ck98 = 0 time = 495
.meas tran vdout1_32ck98 FIND v(dout1_32) AT=495.025n

* CHECK dout1_33 Vdout1_33ck98 = 0 time = 495
.meas tran vdout1_33ck98 FIND v(dout1_33) AT=495.025n

* CHECK dout1_34 Vdout1_34ck98 = 0.9 time = 495
.meas tran vdout1_34ck98 FIND v(dout1_34) AT=495.025n

* CHECK dout1_35 Vdout1_35ck98 = 0.9 time = 495
.meas tran vdout1_35ck98 FIND v(dout1_35) AT=495.025n

* CHECK dout1_36 Vdout1_36ck98 = 0 time = 495
.meas tran vdout1_36ck98 FIND v(dout1_36) AT=495.025n

* CHECK dout1_37 Vdout1_37ck98 = 0 time = 495
.meas tran vdout1_37ck98 FIND v(dout1_37) AT=495.025n

* CHECK dout1_38 Vdout1_38ck98 = 0.9 time = 495
.meas tran vdout1_38ck98 FIND v(dout1_38) AT=495.025n

* CHECK dout1_39 Vdout1_39ck98 = 0 time = 495
.meas tran vdout1_39ck98 FIND v(dout1_39) AT=495.025n

* CHECK dout1_40 Vdout1_40ck98 = 0 time = 495
.meas tran vdout1_40ck98 FIND v(dout1_40) AT=495.025n

* CHECK dout1_41 Vdout1_41ck98 = 0.9 time = 495
.meas tran vdout1_41ck98 FIND v(dout1_41) AT=495.025n

* CHECK dout1_42 Vdout1_42ck98 = 0 time = 495
.meas tran vdout1_42ck98 FIND v(dout1_42) AT=495.025n

* CHECK dout1_43 Vdout1_43ck98 = 0.9 time = 495
.meas tran vdout1_43ck98 FIND v(dout1_43) AT=495.025n

* CHECK dout1_44 Vdout1_44ck98 = 0.9 time = 495
.meas tran vdout1_44ck98 FIND v(dout1_44) AT=495.025n

* CHECK dout1_45 Vdout1_45ck98 = 0 time = 495
.meas tran vdout1_45ck98 FIND v(dout1_45) AT=495.025n

* CHECK dout1_46 Vdout1_46ck98 = 0.9 time = 495
.meas tran vdout1_46ck98 FIND v(dout1_46) AT=495.025n

* CHECK dout1_47 Vdout1_47ck98 = 0 time = 495
.meas tran vdout1_47ck98 FIND v(dout1_47) AT=495.025n

* CHECK dout1_48 Vdout1_48ck98 = 0.9 time = 495
.meas tran vdout1_48ck98 FIND v(dout1_48) AT=495.025n

* CHECK dout1_49 Vdout1_49ck98 = 0.9 time = 495
.meas tran vdout1_49ck98 FIND v(dout1_49) AT=495.025n

* CHECK dout1_50 Vdout1_50ck98 = 0.9 time = 495
.meas tran vdout1_50ck98 FIND v(dout1_50) AT=495.025n

* CHECK dout1_51 Vdout1_51ck98 = 0 time = 495
.meas tran vdout1_51ck98 FIND v(dout1_51) AT=495.025n

* CHECK dout1_52 Vdout1_52ck98 = 0.9 time = 495
.meas tran vdout1_52ck98 FIND v(dout1_52) AT=495.025n

* CHECK dout1_53 Vdout1_53ck98 = 0.9 time = 495
.meas tran vdout1_53ck98 FIND v(dout1_53) AT=495.025n

* CHECK dout1_54 Vdout1_54ck98 = 0.9 time = 495
.meas tran vdout1_54ck98 FIND v(dout1_54) AT=495.025n

* CHECK dout1_55 Vdout1_55ck98 = 0 time = 495
.meas tran vdout1_55ck98 FIND v(dout1_55) AT=495.025n

* CHECK dout1_56 Vdout1_56ck98 = 0 time = 495
.meas tran vdout1_56ck98 FIND v(dout1_56) AT=495.025n

* CHECK dout1_57 Vdout1_57ck98 = 0 time = 495
.meas tran vdout1_57ck98 FIND v(dout1_57) AT=495.025n

* CHECK dout1_58 Vdout1_58ck98 = 0.9 time = 495
.meas tran vdout1_58ck98 FIND v(dout1_58) AT=495.025n

* CHECK dout1_59 Vdout1_59ck98 = 0.9 time = 495
.meas tran vdout1_59ck98 FIND v(dout1_59) AT=495.025n

* CHECK dout1_60 Vdout1_60ck98 = 0 time = 495
.meas tran vdout1_60ck98 FIND v(dout1_60) AT=495.025n

* CHECK dout1_61 Vdout1_61ck98 = 0.9 time = 495
.meas tran vdout1_61ck98 FIND v(dout1_61) AT=495.025n

* CHECK dout1_62 Vdout1_62ck98 = 0 time = 495
.meas tran vdout1_62ck98 FIND v(dout1_62) AT=495.025n

* CHECK dout1_63 Vdout1_63ck98 = 0 time = 495
.meas tran vdout1_63ck98 FIND v(dout1_63) AT=495.025n

* CHECK dout1_64 Vdout1_64ck98 = 0.9 time = 495
.meas tran vdout1_64ck98 FIND v(dout1_64) AT=495.025n

* CHECK dout1_65 Vdout1_65ck98 = 0.9 time = 495
.meas tran vdout1_65ck98 FIND v(dout1_65) AT=495.025n

* CHECK dout1_66 Vdout1_66ck98 = 0 time = 495
.meas tran vdout1_66ck98 FIND v(dout1_66) AT=495.025n

* CHECK dout1_67 Vdout1_67ck98 = 0 time = 495
.meas tran vdout1_67ck98 FIND v(dout1_67) AT=495.025n

* CHECK dout1_68 Vdout1_68ck98 = 0 time = 495
.meas tran vdout1_68ck98 FIND v(dout1_68) AT=495.025n

* CHECK dout1_69 Vdout1_69ck98 = 0 time = 495
.meas tran vdout1_69ck98 FIND v(dout1_69) AT=495.025n

* CHECK dout1_70 Vdout1_70ck98 = 0 time = 495
.meas tran vdout1_70ck98 FIND v(dout1_70) AT=495.025n

* CHECK dout1_71 Vdout1_71ck98 = 0.9 time = 495
.meas tran vdout1_71ck98 FIND v(dout1_71) AT=495.025n

* CHECK dout1_72 Vdout1_72ck98 = 0.9 time = 495
.meas tran vdout1_72ck98 FIND v(dout1_72) AT=495.025n

* CHECK dout1_73 Vdout1_73ck98 = 0 time = 495
.meas tran vdout1_73ck98 FIND v(dout1_73) AT=495.025n

* CHECK dout1_74 Vdout1_74ck98 = 0 time = 495
.meas tran vdout1_74ck98 FIND v(dout1_74) AT=495.025n

* CHECK dout1_75 Vdout1_75ck98 = 0.9 time = 495
.meas tran vdout1_75ck98 FIND v(dout1_75) AT=495.025n

* CHECK dout1_76 Vdout1_76ck98 = 0.9 time = 495
.meas tran vdout1_76ck98 FIND v(dout1_76) AT=495.025n

* CHECK dout1_77 Vdout1_77ck98 = 0.9 time = 495
.meas tran vdout1_77ck98 FIND v(dout1_77) AT=495.025n

* CHECK dout1_78 Vdout1_78ck98 = 0 time = 495
.meas tran vdout1_78ck98 FIND v(dout1_78) AT=495.025n

* CHECK dout1_79 Vdout1_79ck98 = 0 time = 495
.meas tran vdout1_79ck98 FIND v(dout1_79) AT=495.025n

* CHECK dout1_80 Vdout1_80ck98 = 0 time = 495
.meas tran vdout1_80ck98 FIND v(dout1_80) AT=495.025n

* CHECK dout1_81 Vdout1_81ck98 = 0 time = 495
.meas tran vdout1_81ck98 FIND v(dout1_81) AT=495.025n

* CHECK dout1_82 Vdout1_82ck98 = 0 time = 495
.meas tran vdout1_82ck98 FIND v(dout1_82) AT=495.025n

* CHECK dout1_83 Vdout1_83ck98 = 0 time = 495
.meas tran vdout1_83ck98 FIND v(dout1_83) AT=495.025n

* CHECK dout1_84 Vdout1_84ck98 = 0 time = 495
.meas tran vdout1_84ck98 FIND v(dout1_84) AT=495.025n

* CHECK dout1_85 Vdout1_85ck98 = 0 time = 495
.meas tran vdout1_85ck98 FIND v(dout1_85) AT=495.025n

* CHECK dout1_86 Vdout1_86ck98 = 0 time = 495
.meas tran vdout1_86ck98 FIND v(dout1_86) AT=495.025n

* CHECK dout1_87 Vdout1_87ck98 = 0 time = 495
.meas tran vdout1_87ck98 FIND v(dout1_87) AT=495.025n

* CHECK dout1_88 Vdout1_88ck98 = 0 time = 495
.meas tran vdout1_88ck98 FIND v(dout1_88) AT=495.025n

* CHECK dout1_89 Vdout1_89ck98 = 0 time = 495
.meas tran vdout1_89ck98 FIND v(dout1_89) AT=495.025n

* CHECK dout1_90 Vdout1_90ck98 = 0.9 time = 495
.meas tran vdout1_90ck98 FIND v(dout1_90) AT=495.025n

* CHECK dout1_91 Vdout1_91ck98 = 0 time = 495
.meas tran vdout1_91ck98 FIND v(dout1_91) AT=495.025n

* CHECK dout1_92 Vdout1_92ck98 = 0.9 time = 495
.meas tran vdout1_92ck98 FIND v(dout1_92) AT=495.025n

* CHECK dout1_93 Vdout1_93ck98 = 0 time = 495
.meas tran vdout1_93ck98 FIND v(dout1_93) AT=495.025n

* CHECK dout1_94 Vdout1_94ck98 = 0.9 time = 495
.meas tran vdout1_94ck98 FIND v(dout1_94) AT=495.025n

* CHECK dout1_95 Vdout1_95ck98 = 0.9 time = 495
.meas tran vdout1_95ck98 FIND v(dout1_95) AT=495.025n

* CHECK dout1_96 Vdout1_96ck98 = 0.9 time = 495
.meas tran vdout1_96ck98 FIND v(dout1_96) AT=495.025n

* CHECK dout1_97 Vdout1_97ck98 = 0 time = 495
.meas tran vdout1_97ck98 FIND v(dout1_97) AT=495.025n

* CHECK dout1_98 Vdout1_98ck98 = 0.9 time = 495
.meas tran vdout1_98ck98 FIND v(dout1_98) AT=495.025n

* CHECK dout1_99 Vdout1_99ck98 = 0.9 time = 495
.meas tran vdout1_99ck98 FIND v(dout1_99) AT=495.025n

* CHECK dout1_100 Vdout1_100ck98 = 0.9 time = 495
.meas tran vdout1_100ck98 FIND v(dout1_100) AT=495.025n

* CHECK dout1_101 Vdout1_101ck98 = 0.9 time = 495
.meas tran vdout1_101ck98 FIND v(dout1_101) AT=495.025n

* CHECK dout1_102 Vdout1_102ck98 = 0.9 time = 495
.meas tran vdout1_102ck98 FIND v(dout1_102) AT=495.025n

* CHECK dout1_103 Vdout1_103ck98 = 0.9 time = 495
.meas tran vdout1_103ck98 FIND v(dout1_103) AT=495.025n

* CHECK dout1_104 Vdout1_104ck98 = 0 time = 495
.meas tran vdout1_104ck98 FIND v(dout1_104) AT=495.025n

* CHECK dout1_105 Vdout1_105ck98 = 0 time = 495
.meas tran vdout1_105ck98 FIND v(dout1_105) AT=495.025n

* CHECK dout1_106 Vdout1_106ck98 = 0.9 time = 495
.meas tran vdout1_106ck98 FIND v(dout1_106) AT=495.025n

* CHECK dout1_107 Vdout1_107ck98 = 0.9 time = 495
.meas tran vdout1_107ck98 FIND v(dout1_107) AT=495.025n

* CHECK dout1_108 Vdout1_108ck98 = 0.9 time = 495
.meas tran vdout1_108ck98 FIND v(dout1_108) AT=495.025n

* CHECK dout1_109 Vdout1_109ck98 = 0 time = 495
.meas tran vdout1_109ck98 FIND v(dout1_109) AT=495.025n

* CHECK dout1_110 Vdout1_110ck98 = 0 time = 495
.meas tran vdout1_110ck98 FIND v(dout1_110) AT=495.025n

* CHECK dout1_111 Vdout1_111ck98 = 0 time = 495
.meas tran vdout1_111ck98 FIND v(dout1_111) AT=495.025n

* CHECK dout1_112 Vdout1_112ck98 = 0.9 time = 495
.meas tran vdout1_112ck98 FIND v(dout1_112) AT=495.025n

* CHECK dout1_113 Vdout1_113ck98 = 0.9 time = 495
.meas tran vdout1_113ck98 FIND v(dout1_113) AT=495.025n

* CHECK dout1_114 Vdout1_114ck98 = 0 time = 495
.meas tran vdout1_114ck98 FIND v(dout1_114) AT=495.025n

* CHECK dout1_115 Vdout1_115ck98 = 0 time = 495
.meas tran vdout1_115ck98 FIND v(dout1_115) AT=495.025n

* CHECK dout1_116 Vdout1_116ck98 = 0 time = 495
.meas tran vdout1_116ck98 FIND v(dout1_116) AT=495.025n

* CHECK dout1_117 Vdout1_117ck98 = 0.9 time = 495
.meas tran vdout1_117ck98 FIND v(dout1_117) AT=495.025n

* CHECK dout1_118 Vdout1_118ck98 = 0 time = 495
.meas tran vdout1_118ck98 FIND v(dout1_118) AT=495.025n

* CHECK dout1_119 Vdout1_119ck98 = 0 time = 495
.meas tran vdout1_119ck98 FIND v(dout1_119) AT=495.025n

* CHECK dout1_0 Vdout1_0ck103 = 0 time = 520
.meas tran vdout1_0ck103 FIND v(dout1_0) AT=520.025n

* CHECK dout1_1 Vdout1_1ck103 = 0.9 time = 520
.meas tran vdout1_1ck103 FIND v(dout1_1) AT=520.025n

* CHECK dout1_2 Vdout1_2ck103 = 0.9 time = 520
.meas tran vdout1_2ck103 FIND v(dout1_2) AT=520.025n

* CHECK dout1_3 Vdout1_3ck103 = 0 time = 520
.meas tran vdout1_3ck103 FIND v(dout1_3) AT=520.025n

* CHECK dout1_4 Vdout1_4ck103 = 0.9 time = 520
.meas tran vdout1_4ck103 FIND v(dout1_4) AT=520.025n

* CHECK dout1_5 Vdout1_5ck103 = 0 time = 520
.meas tran vdout1_5ck103 FIND v(dout1_5) AT=520.025n

* CHECK dout1_6 Vdout1_6ck103 = 0.9 time = 520
.meas tran vdout1_6ck103 FIND v(dout1_6) AT=520.025n

* CHECK dout1_7 Vdout1_7ck103 = 0.9 time = 520
.meas tran vdout1_7ck103 FIND v(dout1_7) AT=520.025n

* CHECK dout1_8 Vdout1_8ck103 = 0 time = 520
.meas tran vdout1_8ck103 FIND v(dout1_8) AT=520.025n

* CHECK dout1_9 Vdout1_9ck103 = 0 time = 520
.meas tran vdout1_9ck103 FIND v(dout1_9) AT=520.025n

* CHECK dout1_10 Vdout1_10ck103 = 0.9 time = 520
.meas tran vdout1_10ck103 FIND v(dout1_10) AT=520.025n

* CHECK dout1_11 Vdout1_11ck103 = 0 time = 520
.meas tran vdout1_11ck103 FIND v(dout1_11) AT=520.025n

* CHECK dout1_12 Vdout1_12ck103 = 0 time = 520
.meas tran vdout1_12ck103 FIND v(dout1_12) AT=520.025n

* CHECK dout1_13 Vdout1_13ck103 = 0 time = 520
.meas tran vdout1_13ck103 FIND v(dout1_13) AT=520.025n

* CHECK dout1_14 Vdout1_14ck103 = 0.9 time = 520
.meas tran vdout1_14ck103 FIND v(dout1_14) AT=520.025n

* CHECK dout1_15 Vdout1_15ck103 = 0.9 time = 520
.meas tran vdout1_15ck103 FIND v(dout1_15) AT=520.025n

* CHECK dout1_16 Vdout1_16ck103 = 0 time = 520
.meas tran vdout1_16ck103 FIND v(dout1_16) AT=520.025n

* CHECK dout1_17 Vdout1_17ck103 = 0 time = 520
.meas tran vdout1_17ck103 FIND v(dout1_17) AT=520.025n

* CHECK dout1_18 Vdout1_18ck103 = 0 time = 520
.meas tran vdout1_18ck103 FIND v(dout1_18) AT=520.025n

* CHECK dout1_19 Vdout1_19ck103 = 0 time = 520
.meas tran vdout1_19ck103 FIND v(dout1_19) AT=520.025n

* CHECK dout1_20 Vdout1_20ck103 = 0.9 time = 520
.meas tran vdout1_20ck103 FIND v(dout1_20) AT=520.025n

* CHECK dout1_21 Vdout1_21ck103 = 0.9 time = 520
.meas tran vdout1_21ck103 FIND v(dout1_21) AT=520.025n

* CHECK dout1_22 Vdout1_22ck103 = 0 time = 520
.meas tran vdout1_22ck103 FIND v(dout1_22) AT=520.025n

* CHECK dout1_23 Vdout1_23ck103 = 0.9 time = 520
.meas tran vdout1_23ck103 FIND v(dout1_23) AT=520.025n

* CHECK dout1_24 Vdout1_24ck103 = 0 time = 520
.meas tran vdout1_24ck103 FIND v(dout1_24) AT=520.025n

* CHECK dout1_25 Vdout1_25ck103 = 0.9 time = 520
.meas tran vdout1_25ck103 FIND v(dout1_25) AT=520.025n

* CHECK dout1_26 Vdout1_26ck103 = 0.9 time = 520
.meas tran vdout1_26ck103 FIND v(dout1_26) AT=520.025n

* CHECK dout1_27 Vdout1_27ck103 = 0 time = 520
.meas tran vdout1_27ck103 FIND v(dout1_27) AT=520.025n

* CHECK dout1_28 Vdout1_28ck103 = 0 time = 520
.meas tran vdout1_28ck103 FIND v(dout1_28) AT=520.025n

* CHECK dout1_29 Vdout1_29ck103 = 0.9 time = 520
.meas tran vdout1_29ck103 FIND v(dout1_29) AT=520.025n

* CHECK dout1_30 Vdout1_30ck103 = 0.9 time = 520
.meas tran vdout1_30ck103 FIND v(dout1_30) AT=520.025n

* CHECK dout1_31 Vdout1_31ck103 = 0 time = 520
.meas tran vdout1_31ck103 FIND v(dout1_31) AT=520.025n

* CHECK dout1_32 Vdout1_32ck103 = 0 time = 520
.meas tran vdout1_32ck103 FIND v(dout1_32) AT=520.025n

* CHECK dout1_33 Vdout1_33ck103 = 0.9 time = 520
.meas tran vdout1_33ck103 FIND v(dout1_33) AT=520.025n

* CHECK dout1_34 Vdout1_34ck103 = 0.9 time = 520
.meas tran vdout1_34ck103 FIND v(dout1_34) AT=520.025n

* CHECK dout1_35 Vdout1_35ck103 = 0 time = 520
.meas tran vdout1_35ck103 FIND v(dout1_35) AT=520.025n

* CHECK dout1_36 Vdout1_36ck103 = 0.9 time = 520
.meas tran vdout1_36ck103 FIND v(dout1_36) AT=520.025n

* CHECK dout1_37 Vdout1_37ck103 = 0.9 time = 520
.meas tran vdout1_37ck103 FIND v(dout1_37) AT=520.025n

* CHECK dout1_38 Vdout1_38ck103 = 0 time = 520
.meas tran vdout1_38ck103 FIND v(dout1_38) AT=520.025n

* CHECK dout1_39 Vdout1_39ck103 = 0 time = 520
.meas tran vdout1_39ck103 FIND v(dout1_39) AT=520.025n

* CHECK dout1_40 Vdout1_40ck103 = 0 time = 520
.meas tran vdout1_40ck103 FIND v(dout1_40) AT=520.025n

* CHECK dout1_41 Vdout1_41ck103 = 0 time = 520
.meas tran vdout1_41ck103 FIND v(dout1_41) AT=520.025n

* CHECK dout1_42 Vdout1_42ck103 = 0 time = 520
.meas tran vdout1_42ck103 FIND v(dout1_42) AT=520.025n

* CHECK dout1_43 Vdout1_43ck103 = 0.9 time = 520
.meas tran vdout1_43ck103 FIND v(dout1_43) AT=520.025n

* CHECK dout1_44 Vdout1_44ck103 = 0.9 time = 520
.meas tran vdout1_44ck103 FIND v(dout1_44) AT=520.025n

* CHECK dout1_45 Vdout1_45ck103 = 0.9 time = 520
.meas tran vdout1_45ck103 FIND v(dout1_45) AT=520.025n

* CHECK dout1_46 Vdout1_46ck103 = 0.9 time = 520
.meas tran vdout1_46ck103 FIND v(dout1_46) AT=520.025n

* CHECK dout1_47 Vdout1_47ck103 = 0.9 time = 520
.meas tran vdout1_47ck103 FIND v(dout1_47) AT=520.025n

* CHECK dout1_48 Vdout1_48ck103 = 0.9 time = 520
.meas tran vdout1_48ck103 FIND v(dout1_48) AT=520.025n

* CHECK dout1_49 Vdout1_49ck103 = 0.9 time = 520
.meas tran vdout1_49ck103 FIND v(dout1_49) AT=520.025n

* CHECK dout1_50 Vdout1_50ck103 = 0 time = 520
.meas tran vdout1_50ck103 FIND v(dout1_50) AT=520.025n

* CHECK dout1_51 Vdout1_51ck103 = 0.9 time = 520
.meas tran vdout1_51ck103 FIND v(dout1_51) AT=520.025n

* CHECK dout1_52 Vdout1_52ck103 = 0.9 time = 520
.meas tran vdout1_52ck103 FIND v(dout1_52) AT=520.025n

* CHECK dout1_53 Vdout1_53ck103 = 0.9 time = 520
.meas tran vdout1_53ck103 FIND v(dout1_53) AT=520.025n

* CHECK dout1_54 Vdout1_54ck103 = 0.9 time = 520
.meas tran vdout1_54ck103 FIND v(dout1_54) AT=520.025n

* CHECK dout1_55 Vdout1_55ck103 = 0 time = 520
.meas tran vdout1_55ck103 FIND v(dout1_55) AT=520.025n

* CHECK dout1_56 Vdout1_56ck103 = 0.9 time = 520
.meas tran vdout1_56ck103 FIND v(dout1_56) AT=520.025n

* CHECK dout1_57 Vdout1_57ck103 = 0.9 time = 520
.meas tran vdout1_57ck103 FIND v(dout1_57) AT=520.025n

* CHECK dout1_58 Vdout1_58ck103 = 0.9 time = 520
.meas tran vdout1_58ck103 FIND v(dout1_58) AT=520.025n

* CHECK dout1_59 Vdout1_59ck103 = 0.9 time = 520
.meas tran vdout1_59ck103 FIND v(dout1_59) AT=520.025n

* CHECK dout1_60 Vdout1_60ck103 = 0 time = 520
.meas tran vdout1_60ck103 FIND v(dout1_60) AT=520.025n

* CHECK dout1_61 Vdout1_61ck103 = 0 time = 520
.meas tran vdout1_61ck103 FIND v(dout1_61) AT=520.025n

* CHECK dout1_62 Vdout1_62ck103 = 0.9 time = 520
.meas tran vdout1_62ck103 FIND v(dout1_62) AT=520.025n

* CHECK dout1_63 Vdout1_63ck103 = 0 time = 520
.meas tran vdout1_63ck103 FIND v(dout1_63) AT=520.025n

* CHECK dout1_64 Vdout1_64ck103 = 0.9 time = 520
.meas tran vdout1_64ck103 FIND v(dout1_64) AT=520.025n

* CHECK dout1_65 Vdout1_65ck103 = 0 time = 520
.meas tran vdout1_65ck103 FIND v(dout1_65) AT=520.025n

* CHECK dout1_66 Vdout1_66ck103 = 0 time = 520
.meas tran vdout1_66ck103 FIND v(dout1_66) AT=520.025n

* CHECK dout1_67 Vdout1_67ck103 = 0 time = 520
.meas tran vdout1_67ck103 FIND v(dout1_67) AT=520.025n

* CHECK dout1_68 Vdout1_68ck103 = 0.9 time = 520
.meas tran vdout1_68ck103 FIND v(dout1_68) AT=520.025n

* CHECK dout1_69 Vdout1_69ck103 = 0.9 time = 520
.meas tran vdout1_69ck103 FIND v(dout1_69) AT=520.025n

* CHECK dout1_70 Vdout1_70ck103 = 0 time = 520
.meas tran vdout1_70ck103 FIND v(dout1_70) AT=520.025n

* CHECK dout1_71 Vdout1_71ck103 = 0 time = 520
.meas tran vdout1_71ck103 FIND v(dout1_71) AT=520.025n

* CHECK dout1_72 Vdout1_72ck103 = 0.9 time = 520
.meas tran vdout1_72ck103 FIND v(dout1_72) AT=520.025n

* CHECK dout1_73 Vdout1_73ck103 = 0 time = 520
.meas tran vdout1_73ck103 FIND v(dout1_73) AT=520.025n

* CHECK dout1_74 Vdout1_74ck103 = 0.9 time = 520
.meas tran vdout1_74ck103 FIND v(dout1_74) AT=520.025n

* CHECK dout1_75 Vdout1_75ck103 = 0.9 time = 520
.meas tran vdout1_75ck103 FIND v(dout1_75) AT=520.025n

* CHECK dout1_76 Vdout1_76ck103 = 0.9 time = 520
.meas tran vdout1_76ck103 FIND v(dout1_76) AT=520.025n

* CHECK dout1_77 Vdout1_77ck103 = 0.9 time = 520
.meas tran vdout1_77ck103 FIND v(dout1_77) AT=520.025n

* CHECK dout1_78 Vdout1_78ck103 = 0.9 time = 520
.meas tran vdout1_78ck103 FIND v(dout1_78) AT=520.025n

* CHECK dout1_79 Vdout1_79ck103 = 0.9 time = 520
.meas tran vdout1_79ck103 FIND v(dout1_79) AT=520.025n

* CHECK dout1_80 Vdout1_80ck103 = 0.9 time = 520
.meas tran vdout1_80ck103 FIND v(dout1_80) AT=520.025n

* CHECK dout1_81 Vdout1_81ck103 = 0.9 time = 520
.meas tran vdout1_81ck103 FIND v(dout1_81) AT=520.025n

* CHECK dout1_82 Vdout1_82ck103 = 0 time = 520
.meas tran vdout1_82ck103 FIND v(dout1_82) AT=520.025n

* CHECK dout1_83 Vdout1_83ck103 = 0.9 time = 520
.meas tran vdout1_83ck103 FIND v(dout1_83) AT=520.025n

* CHECK dout1_84 Vdout1_84ck103 = 0 time = 520
.meas tran vdout1_84ck103 FIND v(dout1_84) AT=520.025n

* CHECK dout1_85 Vdout1_85ck103 = 0.9 time = 520
.meas tran vdout1_85ck103 FIND v(dout1_85) AT=520.025n

* CHECK dout1_86 Vdout1_86ck103 = 0 time = 520
.meas tran vdout1_86ck103 FIND v(dout1_86) AT=520.025n

* CHECK dout1_87 Vdout1_87ck103 = 0 time = 520
.meas tran vdout1_87ck103 FIND v(dout1_87) AT=520.025n

* CHECK dout1_88 Vdout1_88ck103 = 0.9 time = 520
.meas tran vdout1_88ck103 FIND v(dout1_88) AT=520.025n

* CHECK dout1_89 Vdout1_89ck103 = 0 time = 520
.meas tran vdout1_89ck103 FIND v(dout1_89) AT=520.025n

* CHECK dout1_90 Vdout1_90ck103 = 0.9 time = 520
.meas tran vdout1_90ck103 FIND v(dout1_90) AT=520.025n

* CHECK dout1_91 Vdout1_91ck103 = 0 time = 520
.meas tran vdout1_91ck103 FIND v(dout1_91) AT=520.025n

* CHECK dout1_92 Vdout1_92ck103 = 0.9 time = 520
.meas tran vdout1_92ck103 FIND v(dout1_92) AT=520.025n

* CHECK dout1_93 Vdout1_93ck103 = 0 time = 520
.meas tran vdout1_93ck103 FIND v(dout1_93) AT=520.025n

* CHECK dout1_94 Vdout1_94ck103 = 0.9 time = 520
.meas tran vdout1_94ck103 FIND v(dout1_94) AT=520.025n

* CHECK dout1_95 Vdout1_95ck103 = 0 time = 520
.meas tran vdout1_95ck103 FIND v(dout1_95) AT=520.025n

* CHECK dout1_96 Vdout1_96ck103 = 0.9 time = 520
.meas tran vdout1_96ck103 FIND v(dout1_96) AT=520.025n

* CHECK dout1_97 Vdout1_97ck103 = 0 time = 520
.meas tran vdout1_97ck103 FIND v(dout1_97) AT=520.025n

* CHECK dout1_98 Vdout1_98ck103 = 0.9 time = 520
.meas tran vdout1_98ck103 FIND v(dout1_98) AT=520.025n

* CHECK dout1_99 Vdout1_99ck103 = 0.9 time = 520
.meas tran vdout1_99ck103 FIND v(dout1_99) AT=520.025n

* CHECK dout1_100 Vdout1_100ck103 = 0 time = 520
.meas tran vdout1_100ck103 FIND v(dout1_100) AT=520.025n

* CHECK dout1_101 Vdout1_101ck103 = 0 time = 520
.meas tran vdout1_101ck103 FIND v(dout1_101) AT=520.025n

* CHECK dout1_102 Vdout1_102ck103 = 0.9 time = 520
.meas tran vdout1_102ck103 FIND v(dout1_102) AT=520.025n

* CHECK dout1_103 Vdout1_103ck103 = 0 time = 520
.meas tran vdout1_103ck103 FIND v(dout1_103) AT=520.025n

* CHECK dout1_104 Vdout1_104ck103 = 0 time = 520
.meas tran vdout1_104ck103 FIND v(dout1_104) AT=520.025n

* CHECK dout1_105 Vdout1_105ck103 = 0 time = 520
.meas tran vdout1_105ck103 FIND v(dout1_105) AT=520.025n

* CHECK dout1_106 Vdout1_106ck103 = 0.9 time = 520
.meas tran vdout1_106ck103 FIND v(dout1_106) AT=520.025n

* CHECK dout1_107 Vdout1_107ck103 = 0.9 time = 520
.meas tran vdout1_107ck103 FIND v(dout1_107) AT=520.025n

* CHECK dout1_108 Vdout1_108ck103 = 0 time = 520
.meas tran vdout1_108ck103 FIND v(dout1_108) AT=520.025n

* CHECK dout1_109 Vdout1_109ck103 = 0.9 time = 520
.meas tran vdout1_109ck103 FIND v(dout1_109) AT=520.025n

* CHECK dout1_110 Vdout1_110ck103 = 0.9 time = 520
.meas tran vdout1_110ck103 FIND v(dout1_110) AT=520.025n

* CHECK dout1_111 Vdout1_111ck103 = 0 time = 520
.meas tran vdout1_111ck103 FIND v(dout1_111) AT=520.025n

* CHECK dout1_112 Vdout1_112ck103 = 0.9 time = 520
.meas tran vdout1_112ck103 FIND v(dout1_112) AT=520.025n

* CHECK dout1_113 Vdout1_113ck103 = 0.9 time = 520
.meas tran vdout1_113ck103 FIND v(dout1_113) AT=520.025n

* CHECK dout1_114 Vdout1_114ck103 = 0.9 time = 520
.meas tran vdout1_114ck103 FIND v(dout1_114) AT=520.025n

* CHECK dout1_115 Vdout1_115ck103 = 0 time = 520
.meas tran vdout1_115ck103 FIND v(dout1_115) AT=520.025n

* CHECK dout1_116 Vdout1_116ck103 = 0.9 time = 520
.meas tran vdout1_116ck103 FIND v(dout1_116) AT=520.025n

* CHECK dout1_117 Vdout1_117ck103 = 0.9 time = 520
.meas tran vdout1_117ck103 FIND v(dout1_117) AT=520.025n

* CHECK dout1_118 Vdout1_118ck103 = 0.9 time = 520
.meas tran vdout1_118ck103 FIND v(dout1_118) AT=520.025n

* CHECK dout1_119 Vdout1_119ck103 = 0 time = 520
.meas tran vdout1_119ck103 FIND v(dout1_119) AT=520.025n

* CHECK dout1_0 Vdout1_0ck108 = 0.9 time = 545
.meas tran vdout1_0ck108 FIND v(dout1_0) AT=545.025n

* CHECK dout1_1 Vdout1_1ck108 = 0.9 time = 545
.meas tran vdout1_1ck108 FIND v(dout1_1) AT=545.025n

* CHECK dout1_2 Vdout1_2ck108 = 0 time = 545
.meas tran vdout1_2ck108 FIND v(dout1_2) AT=545.025n

* CHECK dout1_3 Vdout1_3ck108 = 0.9 time = 545
.meas tran vdout1_3ck108 FIND v(dout1_3) AT=545.025n

* CHECK dout1_4 Vdout1_4ck108 = 0 time = 545
.meas tran vdout1_4ck108 FIND v(dout1_4) AT=545.025n

* CHECK dout1_5 Vdout1_5ck108 = 0 time = 545
.meas tran vdout1_5ck108 FIND v(dout1_5) AT=545.025n

* CHECK dout1_6 Vdout1_6ck108 = 0.9 time = 545
.meas tran vdout1_6ck108 FIND v(dout1_6) AT=545.025n

* CHECK dout1_7 Vdout1_7ck108 = 0 time = 545
.meas tran vdout1_7ck108 FIND v(dout1_7) AT=545.025n

* CHECK dout1_8 Vdout1_8ck108 = 0 time = 545
.meas tran vdout1_8ck108 FIND v(dout1_8) AT=545.025n

* CHECK dout1_9 Vdout1_9ck108 = 0 time = 545
.meas tran vdout1_9ck108 FIND v(dout1_9) AT=545.025n

* CHECK dout1_10 Vdout1_10ck108 = 0 time = 545
.meas tran vdout1_10ck108 FIND v(dout1_10) AT=545.025n

* CHECK dout1_11 Vdout1_11ck108 = 0 time = 545
.meas tran vdout1_11ck108 FIND v(dout1_11) AT=545.025n

* CHECK dout1_12 Vdout1_12ck108 = 0.9 time = 545
.meas tran vdout1_12ck108 FIND v(dout1_12) AT=545.025n

* CHECK dout1_13 Vdout1_13ck108 = 0.9 time = 545
.meas tran vdout1_13ck108 FIND v(dout1_13) AT=545.025n

* CHECK dout1_14 Vdout1_14ck108 = 0.9 time = 545
.meas tran vdout1_14ck108 FIND v(dout1_14) AT=545.025n

* CHECK dout1_15 Vdout1_15ck108 = 0 time = 545
.meas tran vdout1_15ck108 FIND v(dout1_15) AT=545.025n

* CHECK dout1_16 Vdout1_16ck108 = 0.9 time = 545
.meas tran vdout1_16ck108 FIND v(dout1_16) AT=545.025n

* CHECK dout1_17 Vdout1_17ck108 = 0 time = 545
.meas tran vdout1_17ck108 FIND v(dout1_17) AT=545.025n

* CHECK dout1_18 Vdout1_18ck108 = 0 time = 545
.meas tran vdout1_18ck108 FIND v(dout1_18) AT=545.025n

* CHECK dout1_19 Vdout1_19ck108 = 0.9 time = 545
.meas tran vdout1_19ck108 FIND v(dout1_19) AT=545.025n

* CHECK dout1_20 Vdout1_20ck108 = 0 time = 545
.meas tran vdout1_20ck108 FIND v(dout1_20) AT=545.025n

* CHECK dout1_21 Vdout1_21ck108 = 0.9 time = 545
.meas tran vdout1_21ck108 FIND v(dout1_21) AT=545.025n

* CHECK dout1_22 Vdout1_22ck108 = 0 time = 545
.meas tran vdout1_22ck108 FIND v(dout1_22) AT=545.025n

* CHECK dout1_23 Vdout1_23ck108 = 0.9 time = 545
.meas tran vdout1_23ck108 FIND v(dout1_23) AT=545.025n

* CHECK dout1_24 Vdout1_24ck108 = 0 time = 545
.meas tran vdout1_24ck108 FIND v(dout1_24) AT=545.025n

* CHECK dout1_25 Vdout1_25ck108 = 0.9 time = 545
.meas tran vdout1_25ck108 FIND v(dout1_25) AT=545.025n

* CHECK dout1_26 Vdout1_26ck108 = 0 time = 545
.meas tran vdout1_26ck108 FIND v(dout1_26) AT=545.025n

* CHECK dout1_27 Vdout1_27ck108 = 0 time = 545
.meas tran vdout1_27ck108 FIND v(dout1_27) AT=545.025n

* CHECK dout1_28 Vdout1_28ck108 = 0.9 time = 545
.meas tran vdout1_28ck108 FIND v(dout1_28) AT=545.025n

* CHECK dout1_29 Vdout1_29ck108 = 0 time = 545
.meas tran vdout1_29ck108 FIND v(dout1_29) AT=545.025n

* CHECK dout1_30 Vdout1_30ck108 = 0 time = 545
.meas tran vdout1_30ck108 FIND v(dout1_30) AT=545.025n

* CHECK dout1_31 Vdout1_31ck108 = 0.9 time = 545
.meas tran vdout1_31ck108 FIND v(dout1_31) AT=545.025n

* CHECK dout1_32 Vdout1_32ck108 = 0 time = 545
.meas tran vdout1_32ck108 FIND v(dout1_32) AT=545.025n

* CHECK dout1_33 Vdout1_33ck108 = 0.9 time = 545
.meas tran vdout1_33ck108 FIND v(dout1_33) AT=545.025n

* CHECK dout1_34 Vdout1_34ck108 = 0 time = 545
.meas tran vdout1_34ck108 FIND v(dout1_34) AT=545.025n

* CHECK dout1_35 Vdout1_35ck108 = 0 time = 545
.meas tran vdout1_35ck108 FIND v(dout1_35) AT=545.025n

* CHECK dout1_36 Vdout1_36ck108 = 0 time = 545
.meas tran vdout1_36ck108 FIND v(dout1_36) AT=545.025n

* CHECK dout1_37 Vdout1_37ck108 = 0.9 time = 545
.meas tran vdout1_37ck108 FIND v(dout1_37) AT=545.025n

* CHECK dout1_38 Vdout1_38ck108 = 0.9 time = 545
.meas tran vdout1_38ck108 FIND v(dout1_38) AT=545.025n

* CHECK dout1_39 Vdout1_39ck108 = 0.9 time = 545
.meas tran vdout1_39ck108 FIND v(dout1_39) AT=545.025n

* CHECK dout1_40 Vdout1_40ck108 = 0.9 time = 545
.meas tran vdout1_40ck108 FIND v(dout1_40) AT=545.025n

* CHECK dout1_41 Vdout1_41ck108 = 0 time = 545
.meas tran vdout1_41ck108 FIND v(dout1_41) AT=545.025n

* CHECK dout1_42 Vdout1_42ck108 = 0.9 time = 545
.meas tran vdout1_42ck108 FIND v(dout1_42) AT=545.025n

* CHECK dout1_43 Vdout1_43ck108 = 0.9 time = 545
.meas tran vdout1_43ck108 FIND v(dout1_43) AT=545.025n

* CHECK dout1_44 Vdout1_44ck108 = 0 time = 545
.meas tran vdout1_44ck108 FIND v(dout1_44) AT=545.025n

* CHECK dout1_45 Vdout1_45ck108 = 0.9 time = 545
.meas tran vdout1_45ck108 FIND v(dout1_45) AT=545.025n

* CHECK dout1_46 Vdout1_46ck108 = 0 time = 545
.meas tran vdout1_46ck108 FIND v(dout1_46) AT=545.025n

* CHECK dout1_47 Vdout1_47ck108 = 0.9 time = 545
.meas tran vdout1_47ck108 FIND v(dout1_47) AT=545.025n

* CHECK dout1_48 Vdout1_48ck108 = 0 time = 545
.meas tran vdout1_48ck108 FIND v(dout1_48) AT=545.025n

* CHECK dout1_49 Vdout1_49ck108 = 0.9 time = 545
.meas tran vdout1_49ck108 FIND v(dout1_49) AT=545.025n

* CHECK dout1_50 Vdout1_50ck108 = 0.9 time = 545
.meas tran vdout1_50ck108 FIND v(dout1_50) AT=545.025n

* CHECK dout1_51 Vdout1_51ck108 = 0.9 time = 545
.meas tran vdout1_51ck108 FIND v(dout1_51) AT=545.025n

* CHECK dout1_52 Vdout1_52ck108 = 0.9 time = 545
.meas tran vdout1_52ck108 FIND v(dout1_52) AT=545.025n

* CHECK dout1_53 Vdout1_53ck108 = 0 time = 545
.meas tran vdout1_53ck108 FIND v(dout1_53) AT=545.025n

* CHECK dout1_54 Vdout1_54ck108 = 0 time = 545
.meas tran vdout1_54ck108 FIND v(dout1_54) AT=545.025n

* CHECK dout1_55 Vdout1_55ck108 = 0 time = 545
.meas tran vdout1_55ck108 FIND v(dout1_55) AT=545.025n

* CHECK dout1_56 Vdout1_56ck108 = 0 time = 545
.meas tran vdout1_56ck108 FIND v(dout1_56) AT=545.025n

* CHECK dout1_57 Vdout1_57ck108 = 0.9 time = 545
.meas tran vdout1_57ck108 FIND v(dout1_57) AT=545.025n

* CHECK dout1_58 Vdout1_58ck108 = 0.9 time = 545
.meas tran vdout1_58ck108 FIND v(dout1_58) AT=545.025n

* CHECK dout1_59 Vdout1_59ck108 = 0.9 time = 545
.meas tran vdout1_59ck108 FIND v(dout1_59) AT=545.025n

* CHECK dout1_60 Vdout1_60ck108 = 0 time = 545
.meas tran vdout1_60ck108 FIND v(dout1_60) AT=545.025n

* CHECK dout1_61 Vdout1_61ck108 = 0 time = 545
.meas tran vdout1_61ck108 FIND v(dout1_61) AT=545.025n

* CHECK dout1_62 Vdout1_62ck108 = 0.9 time = 545
.meas tran vdout1_62ck108 FIND v(dout1_62) AT=545.025n

* CHECK dout1_63 Vdout1_63ck108 = 0 time = 545
.meas tran vdout1_63ck108 FIND v(dout1_63) AT=545.025n

* CHECK dout1_64 Vdout1_64ck108 = 0 time = 545
.meas tran vdout1_64ck108 FIND v(dout1_64) AT=545.025n

* CHECK dout1_65 Vdout1_65ck108 = 0 time = 545
.meas tran vdout1_65ck108 FIND v(dout1_65) AT=545.025n

* CHECK dout1_66 Vdout1_66ck108 = 0.9 time = 545
.meas tran vdout1_66ck108 FIND v(dout1_66) AT=545.025n

* CHECK dout1_67 Vdout1_67ck108 = 0.9 time = 545
.meas tran vdout1_67ck108 FIND v(dout1_67) AT=545.025n

* CHECK dout1_68 Vdout1_68ck108 = 0 time = 545
.meas tran vdout1_68ck108 FIND v(dout1_68) AT=545.025n

* CHECK dout1_69 Vdout1_69ck108 = 0.9 time = 545
.meas tran vdout1_69ck108 FIND v(dout1_69) AT=545.025n

* CHECK dout1_70 Vdout1_70ck108 = 0 time = 545
.meas tran vdout1_70ck108 FIND v(dout1_70) AT=545.025n

* CHECK dout1_71 Vdout1_71ck108 = 0.9 time = 545
.meas tran vdout1_71ck108 FIND v(dout1_71) AT=545.025n

* CHECK dout1_72 Vdout1_72ck108 = 0 time = 545
.meas tran vdout1_72ck108 FIND v(dout1_72) AT=545.025n

* CHECK dout1_73 Vdout1_73ck108 = 0.9 time = 545
.meas tran vdout1_73ck108 FIND v(dout1_73) AT=545.025n

* CHECK dout1_74 Vdout1_74ck108 = 0 time = 545
.meas tran vdout1_74ck108 FIND v(dout1_74) AT=545.025n

* CHECK dout1_75 Vdout1_75ck108 = 0.9 time = 545
.meas tran vdout1_75ck108 FIND v(dout1_75) AT=545.025n

* CHECK dout1_76 Vdout1_76ck108 = 0 time = 545
.meas tran vdout1_76ck108 FIND v(dout1_76) AT=545.025n

* CHECK dout1_77 Vdout1_77ck108 = 0 time = 545
.meas tran vdout1_77ck108 FIND v(dout1_77) AT=545.025n

* CHECK dout1_78 Vdout1_78ck108 = 0.9 time = 545
.meas tran vdout1_78ck108 FIND v(dout1_78) AT=545.025n

* CHECK dout1_79 Vdout1_79ck108 = 0 time = 545
.meas tran vdout1_79ck108 FIND v(dout1_79) AT=545.025n

* CHECK dout1_80 Vdout1_80ck108 = 0 time = 545
.meas tran vdout1_80ck108 FIND v(dout1_80) AT=545.025n

* CHECK dout1_81 Vdout1_81ck108 = 0.9 time = 545
.meas tran vdout1_81ck108 FIND v(dout1_81) AT=545.025n

* CHECK dout1_82 Vdout1_82ck108 = 0.9 time = 545
.meas tran vdout1_82ck108 FIND v(dout1_82) AT=545.025n

* CHECK dout1_83 Vdout1_83ck108 = 0 time = 545
.meas tran vdout1_83ck108 FIND v(dout1_83) AT=545.025n

* CHECK dout1_84 Vdout1_84ck108 = 0 time = 545
.meas tran vdout1_84ck108 FIND v(dout1_84) AT=545.025n

* CHECK dout1_85 Vdout1_85ck108 = 0 time = 545
.meas tran vdout1_85ck108 FIND v(dout1_85) AT=545.025n

* CHECK dout1_86 Vdout1_86ck108 = 0.9 time = 545
.meas tran vdout1_86ck108 FIND v(dout1_86) AT=545.025n

* CHECK dout1_87 Vdout1_87ck108 = 0 time = 545
.meas tran vdout1_87ck108 FIND v(dout1_87) AT=545.025n

* CHECK dout1_88 Vdout1_88ck108 = 0 time = 545
.meas tran vdout1_88ck108 FIND v(dout1_88) AT=545.025n

* CHECK dout1_89 Vdout1_89ck108 = 0 time = 545
.meas tran vdout1_89ck108 FIND v(dout1_89) AT=545.025n

* CHECK dout1_90 Vdout1_90ck108 = 0 time = 545
.meas tran vdout1_90ck108 FIND v(dout1_90) AT=545.025n

* CHECK dout1_91 Vdout1_91ck108 = 0 time = 545
.meas tran vdout1_91ck108 FIND v(dout1_91) AT=545.025n

* CHECK dout1_92 Vdout1_92ck108 = 0 time = 545
.meas tran vdout1_92ck108 FIND v(dout1_92) AT=545.025n

* CHECK dout1_93 Vdout1_93ck108 = 0 time = 545
.meas tran vdout1_93ck108 FIND v(dout1_93) AT=545.025n

* CHECK dout1_94 Vdout1_94ck108 = 0 time = 545
.meas tran vdout1_94ck108 FIND v(dout1_94) AT=545.025n

* CHECK dout1_95 Vdout1_95ck108 = 0.9 time = 545
.meas tran vdout1_95ck108 FIND v(dout1_95) AT=545.025n

* CHECK dout1_96 Vdout1_96ck108 = 0 time = 545
.meas tran vdout1_96ck108 FIND v(dout1_96) AT=545.025n

* CHECK dout1_97 Vdout1_97ck108 = 0.9 time = 545
.meas tran vdout1_97ck108 FIND v(dout1_97) AT=545.025n

* CHECK dout1_98 Vdout1_98ck108 = 0.9 time = 545
.meas tran vdout1_98ck108 FIND v(dout1_98) AT=545.025n

* CHECK dout1_99 Vdout1_99ck108 = 0 time = 545
.meas tran vdout1_99ck108 FIND v(dout1_99) AT=545.025n

* CHECK dout1_100 Vdout1_100ck108 = 0 time = 545
.meas tran vdout1_100ck108 FIND v(dout1_100) AT=545.025n

* CHECK dout1_101 Vdout1_101ck108 = 0 time = 545
.meas tran vdout1_101ck108 FIND v(dout1_101) AT=545.025n

* CHECK dout1_102 Vdout1_102ck108 = 0 time = 545
.meas tran vdout1_102ck108 FIND v(dout1_102) AT=545.025n

* CHECK dout1_103 Vdout1_103ck108 = 0 time = 545
.meas tran vdout1_103ck108 FIND v(dout1_103) AT=545.025n

* CHECK dout1_104 Vdout1_104ck108 = 0 time = 545
.meas tran vdout1_104ck108 FIND v(dout1_104) AT=545.025n

* CHECK dout1_105 Vdout1_105ck108 = 0.9 time = 545
.meas tran vdout1_105ck108 FIND v(dout1_105) AT=545.025n

* CHECK dout1_106 Vdout1_106ck108 = 0.9 time = 545
.meas tran vdout1_106ck108 FIND v(dout1_106) AT=545.025n

* CHECK dout1_107 Vdout1_107ck108 = 0 time = 545
.meas tran vdout1_107ck108 FIND v(dout1_107) AT=545.025n

* CHECK dout1_108 Vdout1_108ck108 = 0 time = 545
.meas tran vdout1_108ck108 FIND v(dout1_108) AT=545.025n

* CHECK dout1_109 Vdout1_109ck108 = 0 time = 545
.meas tran vdout1_109ck108 FIND v(dout1_109) AT=545.025n

* CHECK dout1_110 Vdout1_110ck108 = 0 time = 545
.meas tran vdout1_110ck108 FIND v(dout1_110) AT=545.025n

* CHECK dout1_111 Vdout1_111ck108 = 0 time = 545
.meas tran vdout1_111ck108 FIND v(dout1_111) AT=545.025n

* CHECK dout1_112 Vdout1_112ck108 = 0.9 time = 545
.meas tran vdout1_112ck108 FIND v(dout1_112) AT=545.025n

* CHECK dout1_113 Vdout1_113ck108 = 0.9 time = 545
.meas tran vdout1_113ck108 FIND v(dout1_113) AT=545.025n

* CHECK dout1_114 Vdout1_114ck108 = 0.9 time = 545
.meas tran vdout1_114ck108 FIND v(dout1_114) AT=545.025n

* CHECK dout1_115 Vdout1_115ck108 = 0.9 time = 545
.meas tran vdout1_115ck108 FIND v(dout1_115) AT=545.025n

* CHECK dout1_116 Vdout1_116ck108 = 0.9 time = 545
.meas tran vdout1_116ck108 FIND v(dout1_116) AT=545.025n

* CHECK dout1_117 Vdout1_117ck108 = 0.9 time = 545
.meas tran vdout1_117ck108 FIND v(dout1_117) AT=545.025n

* CHECK dout1_118 Vdout1_118ck108 = 0.9 time = 545
.meas tran vdout1_118ck108 FIND v(dout1_118) AT=545.025n

* CHECK dout1_119 Vdout1_119ck108 = 0.9 time = 545
.meas tran vdout1_119ck108 FIND v(dout1_119) AT=545.025n

* CHECK dout1_0 Vdout1_0ck109 = 0.9 time = 550
.meas tran vdout1_0ck109 FIND v(dout1_0) AT=550.025n

* CHECK dout1_1 Vdout1_1ck109 = 0.9 time = 550
.meas tran vdout1_1ck109 FIND v(dout1_1) AT=550.025n

* CHECK dout1_2 Vdout1_2ck109 = 0 time = 550
.meas tran vdout1_2ck109 FIND v(dout1_2) AT=550.025n

* CHECK dout1_3 Vdout1_3ck109 = 0.9 time = 550
.meas tran vdout1_3ck109 FIND v(dout1_3) AT=550.025n

* CHECK dout1_4 Vdout1_4ck109 = 0 time = 550
.meas tran vdout1_4ck109 FIND v(dout1_4) AT=550.025n

* CHECK dout1_5 Vdout1_5ck109 = 0 time = 550
.meas tran vdout1_5ck109 FIND v(dout1_5) AT=550.025n

* CHECK dout1_6 Vdout1_6ck109 = 0.9 time = 550
.meas tran vdout1_6ck109 FIND v(dout1_6) AT=550.025n

* CHECK dout1_7 Vdout1_7ck109 = 0 time = 550
.meas tran vdout1_7ck109 FIND v(dout1_7) AT=550.025n

* CHECK dout1_8 Vdout1_8ck109 = 0 time = 550
.meas tran vdout1_8ck109 FIND v(dout1_8) AT=550.025n

* CHECK dout1_9 Vdout1_9ck109 = 0 time = 550
.meas tran vdout1_9ck109 FIND v(dout1_9) AT=550.025n

* CHECK dout1_10 Vdout1_10ck109 = 0 time = 550
.meas tran vdout1_10ck109 FIND v(dout1_10) AT=550.025n

* CHECK dout1_11 Vdout1_11ck109 = 0 time = 550
.meas tran vdout1_11ck109 FIND v(dout1_11) AT=550.025n

* CHECK dout1_12 Vdout1_12ck109 = 0.9 time = 550
.meas tran vdout1_12ck109 FIND v(dout1_12) AT=550.025n

* CHECK dout1_13 Vdout1_13ck109 = 0.9 time = 550
.meas tran vdout1_13ck109 FIND v(dout1_13) AT=550.025n

* CHECK dout1_14 Vdout1_14ck109 = 0.9 time = 550
.meas tran vdout1_14ck109 FIND v(dout1_14) AT=550.025n

* CHECK dout1_15 Vdout1_15ck109 = 0 time = 550
.meas tran vdout1_15ck109 FIND v(dout1_15) AT=550.025n

* CHECK dout1_16 Vdout1_16ck109 = 0.9 time = 550
.meas tran vdout1_16ck109 FIND v(dout1_16) AT=550.025n

* CHECK dout1_17 Vdout1_17ck109 = 0 time = 550
.meas tran vdout1_17ck109 FIND v(dout1_17) AT=550.025n

* CHECK dout1_18 Vdout1_18ck109 = 0 time = 550
.meas tran vdout1_18ck109 FIND v(dout1_18) AT=550.025n

* CHECK dout1_19 Vdout1_19ck109 = 0.9 time = 550
.meas tran vdout1_19ck109 FIND v(dout1_19) AT=550.025n

* CHECK dout1_20 Vdout1_20ck109 = 0 time = 550
.meas tran vdout1_20ck109 FIND v(dout1_20) AT=550.025n

* CHECK dout1_21 Vdout1_21ck109 = 0.9 time = 550
.meas tran vdout1_21ck109 FIND v(dout1_21) AT=550.025n

* CHECK dout1_22 Vdout1_22ck109 = 0 time = 550
.meas tran vdout1_22ck109 FIND v(dout1_22) AT=550.025n

* CHECK dout1_23 Vdout1_23ck109 = 0.9 time = 550
.meas tran vdout1_23ck109 FIND v(dout1_23) AT=550.025n

* CHECK dout1_24 Vdout1_24ck109 = 0 time = 550
.meas tran vdout1_24ck109 FIND v(dout1_24) AT=550.025n

* CHECK dout1_25 Vdout1_25ck109 = 0.9 time = 550
.meas tran vdout1_25ck109 FIND v(dout1_25) AT=550.025n

* CHECK dout1_26 Vdout1_26ck109 = 0 time = 550
.meas tran vdout1_26ck109 FIND v(dout1_26) AT=550.025n

* CHECK dout1_27 Vdout1_27ck109 = 0 time = 550
.meas tran vdout1_27ck109 FIND v(dout1_27) AT=550.025n

* CHECK dout1_28 Vdout1_28ck109 = 0.9 time = 550
.meas tran vdout1_28ck109 FIND v(dout1_28) AT=550.025n

* CHECK dout1_29 Vdout1_29ck109 = 0 time = 550
.meas tran vdout1_29ck109 FIND v(dout1_29) AT=550.025n

* CHECK dout1_30 Vdout1_30ck109 = 0 time = 550
.meas tran vdout1_30ck109 FIND v(dout1_30) AT=550.025n

* CHECK dout1_31 Vdout1_31ck109 = 0.9 time = 550
.meas tran vdout1_31ck109 FIND v(dout1_31) AT=550.025n

* CHECK dout1_32 Vdout1_32ck109 = 0 time = 550
.meas tran vdout1_32ck109 FIND v(dout1_32) AT=550.025n

* CHECK dout1_33 Vdout1_33ck109 = 0.9 time = 550
.meas tran vdout1_33ck109 FIND v(dout1_33) AT=550.025n

* CHECK dout1_34 Vdout1_34ck109 = 0 time = 550
.meas tran vdout1_34ck109 FIND v(dout1_34) AT=550.025n

* CHECK dout1_35 Vdout1_35ck109 = 0 time = 550
.meas tran vdout1_35ck109 FIND v(dout1_35) AT=550.025n

* CHECK dout1_36 Vdout1_36ck109 = 0 time = 550
.meas tran vdout1_36ck109 FIND v(dout1_36) AT=550.025n

* CHECK dout1_37 Vdout1_37ck109 = 0.9 time = 550
.meas tran vdout1_37ck109 FIND v(dout1_37) AT=550.025n

* CHECK dout1_38 Vdout1_38ck109 = 0.9 time = 550
.meas tran vdout1_38ck109 FIND v(dout1_38) AT=550.025n

* CHECK dout1_39 Vdout1_39ck109 = 0.9 time = 550
.meas tran vdout1_39ck109 FIND v(dout1_39) AT=550.025n

* CHECK dout1_40 Vdout1_40ck109 = 0.9 time = 550
.meas tran vdout1_40ck109 FIND v(dout1_40) AT=550.025n

* CHECK dout1_41 Vdout1_41ck109 = 0 time = 550
.meas tran vdout1_41ck109 FIND v(dout1_41) AT=550.025n

* CHECK dout1_42 Vdout1_42ck109 = 0.9 time = 550
.meas tran vdout1_42ck109 FIND v(dout1_42) AT=550.025n

* CHECK dout1_43 Vdout1_43ck109 = 0.9 time = 550
.meas tran vdout1_43ck109 FIND v(dout1_43) AT=550.025n

* CHECK dout1_44 Vdout1_44ck109 = 0 time = 550
.meas tran vdout1_44ck109 FIND v(dout1_44) AT=550.025n

* CHECK dout1_45 Vdout1_45ck109 = 0.9 time = 550
.meas tran vdout1_45ck109 FIND v(dout1_45) AT=550.025n

* CHECK dout1_46 Vdout1_46ck109 = 0 time = 550
.meas tran vdout1_46ck109 FIND v(dout1_46) AT=550.025n

* CHECK dout1_47 Vdout1_47ck109 = 0.9 time = 550
.meas tran vdout1_47ck109 FIND v(dout1_47) AT=550.025n

* CHECK dout1_48 Vdout1_48ck109 = 0 time = 550
.meas tran vdout1_48ck109 FIND v(dout1_48) AT=550.025n

* CHECK dout1_49 Vdout1_49ck109 = 0.9 time = 550
.meas tran vdout1_49ck109 FIND v(dout1_49) AT=550.025n

* CHECK dout1_50 Vdout1_50ck109 = 0.9 time = 550
.meas tran vdout1_50ck109 FIND v(dout1_50) AT=550.025n

* CHECK dout1_51 Vdout1_51ck109 = 0.9 time = 550
.meas tran vdout1_51ck109 FIND v(dout1_51) AT=550.025n

* CHECK dout1_52 Vdout1_52ck109 = 0.9 time = 550
.meas tran vdout1_52ck109 FIND v(dout1_52) AT=550.025n

* CHECK dout1_53 Vdout1_53ck109 = 0 time = 550
.meas tran vdout1_53ck109 FIND v(dout1_53) AT=550.025n

* CHECK dout1_54 Vdout1_54ck109 = 0 time = 550
.meas tran vdout1_54ck109 FIND v(dout1_54) AT=550.025n

* CHECK dout1_55 Vdout1_55ck109 = 0 time = 550
.meas tran vdout1_55ck109 FIND v(dout1_55) AT=550.025n

* CHECK dout1_56 Vdout1_56ck109 = 0 time = 550
.meas tran vdout1_56ck109 FIND v(dout1_56) AT=550.025n

* CHECK dout1_57 Vdout1_57ck109 = 0.9 time = 550
.meas tran vdout1_57ck109 FIND v(dout1_57) AT=550.025n

* CHECK dout1_58 Vdout1_58ck109 = 0.9 time = 550
.meas tran vdout1_58ck109 FIND v(dout1_58) AT=550.025n

* CHECK dout1_59 Vdout1_59ck109 = 0.9 time = 550
.meas tran vdout1_59ck109 FIND v(dout1_59) AT=550.025n

* CHECK dout1_60 Vdout1_60ck109 = 0 time = 550
.meas tran vdout1_60ck109 FIND v(dout1_60) AT=550.025n

* CHECK dout1_61 Vdout1_61ck109 = 0 time = 550
.meas tran vdout1_61ck109 FIND v(dout1_61) AT=550.025n

* CHECK dout1_62 Vdout1_62ck109 = 0.9 time = 550
.meas tran vdout1_62ck109 FIND v(dout1_62) AT=550.025n

* CHECK dout1_63 Vdout1_63ck109 = 0 time = 550
.meas tran vdout1_63ck109 FIND v(dout1_63) AT=550.025n

* CHECK dout1_64 Vdout1_64ck109 = 0 time = 550
.meas tran vdout1_64ck109 FIND v(dout1_64) AT=550.025n

* CHECK dout1_65 Vdout1_65ck109 = 0 time = 550
.meas tran vdout1_65ck109 FIND v(dout1_65) AT=550.025n

* CHECK dout1_66 Vdout1_66ck109 = 0.9 time = 550
.meas tran vdout1_66ck109 FIND v(dout1_66) AT=550.025n

* CHECK dout1_67 Vdout1_67ck109 = 0.9 time = 550
.meas tran vdout1_67ck109 FIND v(dout1_67) AT=550.025n

* CHECK dout1_68 Vdout1_68ck109 = 0 time = 550
.meas tran vdout1_68ck109 FIND v(dout1_68) AT=550.025n

* CHECK dout1_69 Vdout1_69ck109 = 0.9 time = 550
.meas tran vdout1_69ck109 FIND v(dout1_69) AT=550.025n

* CHECK dout1_70 Vdout1_70ck109 = 0 time = 550
.meas tran vdout1_70ck109 FIND v(dout1_70) AT=550.025n

* CHECK dout1_71 Vdout1_71ck109 = 0.9 time = 550
.meas tran vdout1_71ck109 FIND v(dout1_71) AT=550.025n

* CHECK dout1_72 Vdout1_72ck109 = 0 time = 550
.meas tran vdout1_72ck109 FIND v(dout1_72) AT=550.025n

* CHECK dout1_73 Vdout1_73ck109 = 0.9 time = 550
.meas tran vdout1_73ck109 FIND v(dout1_73) AT=550.025n

* CHECK dout1_74 Vdout1_74ck109 = 0 time = 550
.meas tran vdout1_74ck109 FIND v(dout1_74) AT=550.025n

* CHECK dout1_75 Vdout1_75ck109 = 0.9 time = 550
.meas tran vdout1_75ck109 FIND v(dout1_75) AT=550.025n

* CHECK dout1_76 Vdout1_76ck109 = 0 time = 550
.meas tran vdout1_76ck109 FIND v(dout1_76) AT=550.025n

* CHECK dout1_77 Vdout1_77ck109 = 0 time = 550
.meas tran vdout1_77ck109 FIND v(dout1_77) AT=550.025n

* CHECK dout1_78 Vdout1_78ck109 = 0.9 time = 550
.meas tran vdout1_78ck109 FIND v(dout1_78) AT=550.025n

* CHECK dout1_79 Vdout1_79ck109 = 0 time = 550
.meas tran vdout1_79ck109 FIND v(dout1_79) AT=550.025n

* CHECK dout1_80 Vdout1_80ck109 = 0 time = 550
.meas tran vdout1_80ck109 FIND v(dout1_80) AT=550.025n

* CHECK dout1_81 Vdout1_81ck109 = 0.9 time = 550
.meas tran vdout1_81ck109 FIND v(dout1_81) AT=550.025n

* CHECK dout1_82 Vdout1_82ck109 = 0.9 time = 550
.meas tran vdout1_82ck109 FIND v(dout1_82) AT=550.025n

* CHECK dout1_83 Vdout1_83ck109 = 0 time = 550
.meas tran vdout1_83ck109 FIND v(dout1_83) AT=550.025n

* CHECK dout1_84 Vdout1_84ck109 = 0 time = 550
.meas tran vdout1_84ck109 FIND v(dout1_84) AT=550.025n

* CHECK dout1_85 Vdout1_85ck109 = 0 time = 550
.meas tran vdout1_85ck109 FIND v(dout1_85) AT=550.025n

* CHECK dout1_86 Vdout1_86ck109 = 0.9 time = 550
.meas tran vdout1_86ck109 FIND v(dout1_86) AT=550.025n

* CHECK dout1_87 Vdout1_87ck109 = 0 time = 550
.meas tran vdout1_87ck109 FIND v(dout1_87) AT=550.025n

* CHECK dout1_88 Vdout1_88ck109 = 0 time = 550
.meas tran vdout1_88ck109 FIND v(dout1_88) AT=550.025n

* CHECK dout1_89 Vdout1_89ck109 = 0 time = 550
.meas tran vdout1_89ck109 FIND v(dout1_89) AT=550.025n

* CHECK dout1_90 Vdout1_90ck109 = 0 time = 550
.meas tran vdout1_90ck109 FIND v(dout1_90) AT=550.025n

* CHECK dout1_91 Vdout1_91ck109 = 0 time = 550
.meas tran vdout1_91ck109 FIND v(dout1_91) AT=550.025n

* CHECK dout1_92 Vdout1_92ck109 = 0 time = 550
.meas tran vdout1_92ck109 FIND v(dout1_92) AT=550.025n

* CHECK dout1_93 Vdout1_93ck109 = 0 time = 550
.meas tran vdout1_93ck109 FIND v(dout1_93) AT=550.025n

* CHECK dout1_94 Vdout1_94ck109 = 0 time = 550
.meas tran vdout1_94ck109 FIND v(dout1_94) AT=550.025n

* CHECK dout1_95 Vdout1_95ck109 = 0.9 time = 550
.meas tran vdout1_95ck109 FIND v(dout1_95) AT=550.025n

* CHECK dout1_96 Vdout1_96ck109 = 0 time = 550
.meas tran vdout1_96ck109 FIND v(dout1_96) AT=550.025n

* CHECK dout1_97 Vdout1_97ck109 = 0.9 time = 550
.meas tran vdout1_97ck109 FIND v(dout1_97) AT=550.025n

* CHECK dout1_98 Vdout1_98ck109 = 0.9 time = 550
.meas tran vdout1_98ck109 FIND v(dout1_98) AT=550.025n

* CHECK dout1_99 Vdout1_99ck109 = 0 time = 550
.meas tran vdout1_99ck109 FIND v(dout1_99) AT=550.025n

* CHECK dout1_100 Vdout1_100ck109 = 0 time = 550
.meas tran vdout1_100ck109 FIND v(dout1_100) AT=550.025n

* CHECK dout1_101 Vdout1_101ck109 = 0 time = 550
.meas tran vdout1_101ck109 FIND v(dout1_101) AT=550.025n

* CHECK dout1_102 Vdout1_102ck109 = 0 time = 550
.meas tran vdout1_102ck109 FIND v(dout1_102) AT=550.025n

* CHECK dout1_103 Vdout1_103ck109 = 0 time = 550
.meas tran vdout1_103ck109 FIND v(dout1_103) AT=550.025n

* CHECK dout1_104 Vdout1_104ck109 = 0 time = 550
.meas tran vdout1_104ck109 FIND v(dout1_104) AT=550.025n

* CHECK dout1_105 Vdout1_105ck109 = 0.9 time = 550
.meas tran vdout1_105ck109 FIND v(dout1_105) AT=550.025n

* CHECK dout1_106 Vdout1_106ck109 = 0.9 time = 550
.meas tran vdout1_106ck109 FIND v(dout1_106) AT=550.025n

* CHECK dout1_107 Vdout1_107ck109 = 0 time = 550
.meas tran vdout1_107ck109 FIND v(dout1_107) AT=550.025n

* CHECK dout1_108 Vdout1_108ck109 = 0 time = 550
.meas tran vdout1_108ck109 FIND v(dout1_108) AT=550.025n

* CHECK dout1_109 Vdout1_109ck109 = 0 time = 550
.meas tran vdout1_109ck109 FIND v(dout1_109) AT=550.025n

* CHECK dout1_110 Vdout1_110ck109 = 0 time = 550
.meas tran vdout1_110ck109 FIND v(dout1_110) AT=550.025n

* CHECK dout1_111 Vdout1_111ck109 = 0 time = 550
.meas tran vdout1_111ck109 FIND v(dout1_111) AT=550.025n

* CHECK dout1_112 Vdout1_112ck109 = 0.9 time = 550
.meas tran vdout1_112ck109 FIND v(dout1_112) AT=550.025n

* CHECK dout1_113 Vdout1_113ck109 = 0.9 time = 550
.meas tran vdout1_113ck109 FIND v(dout1_113) AT=550.025n

* CHECK dout1_114 Vdout1_114ck109 = 0.9 time = 550
.meas tran vdout1_114ck109 FIND v(dout1_114) AT=550.025n

* CHECK dout1_115 Vdout1_115ck109 = 0.9 time = 550
.meas tran vdout1_115ck109 FIND v(dout1_115) AT=550.025n

* CHECK dout1_116 Vdout1_116ck109 = 0.9 time = 550
.meas tran vdout1_116ck109 FIND v(dout1_116) AT=550.025n

* CHECK dout1_117 Vdout1_117ck109 = 0.9 time = 550
.meas tran vdout1_117ck109 FIND v(dout1_117) AT=550.025n

* CHECK dout1_118 Vdout1_118ck109 = 0.9 time = 550
.meas tran vdout1_118ck109 FIND v(dout1_118) AT=550.025n

* CHECK dout1_119 Vdout1_119ck109 = 0.9 time = 550
.meas tran vdout1_119ck109 FIND v(dout1_119) AT=550.025n

* CHECK dout1_0 Vdout1_0ck114 = 0.9 time = 575
.meas tran vdout1_0ck114 FIND v(dout1_0) AT=575.025n

* CHECK dout1_1 Vdout1_1ck114 = 0 time = 575
.meas tran vdout1_1ck114 FIND v(dout1_1) AT=575.025n

* CHECK dout1_2 Vdout1_2ck114 = 0 time = 575
.meas tran vdout1_2ck114 FIND v(dout1_2) AT=575.025n

* CHECK dout1_3 Vdout1_3ck114 = 0.9 time = 575
.meas tran vdout1_3ck114 FIND v(dout1_3) AT=575.025n

* CHECK dout1_4 Vdout1_4ck114 = 0 time = 575
.meas tran vdout1_4ck114 FIND v(dout1_4) AT=575.025n

* CHECK dout1_5 Vdout1_5ck114 = 0.9 time = 575
.meas tran vdout1_5ck114 FIND v(dout1_5) AT=575.025n

* CHECK dout1_6 Vdout1_6ck114 = 0.9 time = 575
.meas tran vdout1_6ck114 FIND v(dout1_6) AT=575.025n

* CHECK dout1_7 Vdout1_7ck114 = 0 time = 575
.meas tran vdout1_7ck114 FIND v(dout1_7) AT=575.025n

* CHECK dout1_8 Vdout1_8ck114 = 0.9 time = 575
.meas tran vdout1_8ck114 FIND v(dout1_8) AT=575.025n

* CHECK dout1_9 Vdout1_9ck114 = 0 time = 575
.meas tran vdout1_9ck114 FIND v(dout1_9) AT=575.025n

* CHECK dout1_10 Vdout1_10ck114 = 0.9 time = 575
.meas tran vdout1_10ck114 FIND v(dout1_10) AT=575.025n

* CHECK dout1_11 Vdout1_11ck114 = 0.9 time = 575
.meas tran vdout1_11ck114 FIND v(dout1_11) AT=575.025n

* CHECK dout1_12 Vdout1_12ck114 = 0.9 time = 575
.meas tran vdout1_12ck114 FIND v(dout1_12) AT=575.025n

* CHECK dout1_13 Vdout1_13ck114 = 0.9 time = 575
.meas tran vdout1_13ck114 FIND v(dout1_13) AT=575.025n

* CHECK dout1_14 Vdout1_14ck114 = 0.9 time = 575
.meas tran vdout1_14ck114 FIND v(dout1_14) AT=575.025n

* CHECK dout1_15 Vdout1_15ck114 = 0.9 time = 575
.meas tran vdout1_15ck114 FIND v(dout1_15) AT=575.025n

* CHECK dout1_16 Vdout1_16ck114 = 0 time = 575
.meas tran vdout1_16ck114 FIND v(dout1_16) AT=575.025n

* CHECK dout1_17 Vdout1_17ck114 = 0 time = 575
.meas tran vdout1_17ck114 FIND v(dout1_17) AT=575.025n

* CHECK dout1_18 Vdout1_18ck114 = 0 time = 575
.meas tran vdout1_18ck114 FIND v(dout1_18) AT=575.025n

* CHECK dout1_19 Vdout1_19ck114 = 0.9 time = 575
.meas tran vdout1_19ck114 FIND v(dout1_19) AT=575.025n

* CHECK dout1_20 Vdout1_20ck114 = 0.9 time = 575
.meas tran vdout1_20ck114 FIND v(dout1_20) AT=575.025n

* CHECK dout1_21 Vdout1_21ck114 = 0.9 time = 575
.meas tran vdout1_21ck114 FIND v(dout1_21) AT=575.025n

* CHECK dout1_22 Vdout1_22ck114 = 0.9 time = 575
.meas tran vdout1_22ck114 FIND v(dout1_22) AT=575.025n

* CHECK dout1_23 Vdout1_23ck114 = 0 time = 575
.meas tran vdout1_23ck114 FIND v(dout1_23) AT=575.025n

* CHECK dout1_24 Vdout1_24ck114 = 0 time = 575
.meas tran vdout1_24ck114 FIND v(dout1_24) AT=575.025n

* CHECK dout1_25 Vdout1_25ck114 = 0.9 time = 575
.meas tran vdout1_25ck114 FIND v(dout1_25) AT=575.025n

* CHECK dout1_26 Vdout1_26ck114 = 0.9 time = 575
.meas tran vdout1_26ck114 FIND v(dout1_26) AT=575.025n

* CHECK dout1_27 Vdout1_27ck114 = 0.9 time = 575
.meas tran vdout1_27ck114 FIND v(dout1_27) AT=575.025n

* CHECK dout1_28 Vdout1_28ck114 = 0 time = 575
.meas tran vdout1_28ck114 FIND v(dout1_28) AT=575.025n

* CHECK dout1_29 Vdout1_29ck114 = 0 time = 575
.meas tran vdout1_29ck114 FIND v(dout1_29) AT=575.025n

* CHECK dout1_30 Vdout1_30ck114 = 0.9 time = 575
.meas tran vdout1_30ck114 FIND v(dout1_30) AT=575.025n

* CHECK dout1_31 Vdout1_31ck114 = 0.9 time = 575
.meas tran vdout1_31ck114 FIND v(dout1_31) AT=575.025n

* CHECK dout1_32 Vdout1_32ck114 = 0 time = 575
.meas tran vdout1_32ck114 FIND v(dout1_32) AT=575.025n

* CHECK dout1_33 Vdout1_33ck114 = 0 time = 575
.meas tran vdout1_33ck114 FIND v(dout1_33) AT=575.025n

* CHECK dout1_34 Vdout1_34ck114 = 0.9 time = 575
.meas tran vdout1_34ck114 FIND v(dout1_34) AT=575.025n

* CHECK dout1_35 Vdout1_35ck114 = 0 time = 575
.meas tran vdout1_35ck114 FIND v(dout1_35) AT=575.025n

* CHECK dout1_36 Vdout1_36ck114 = 0 time = 575
.meas tran vdout1_36ck114 FIND v(dout1_36) AT=575.025n

* CHECK dout1_37 Vdout1_37ck114 = 0 time = 575
.meas tran vdout1_37ck114 FIND v(dout1_37) AT=575.025n

* CHECK dout1_38 Vdout1_38ck114 = 0 time = 575
.meas tran vdout1_38ck114 FIND v(dout1_38) AT=575.025n

* CHECK dout1_39 Vdout1_39ck114 = 0.9 time = 575
.meas tran vdout1_39ck114 FIND v(dout1_39) AT=575.025n

* CHECK dout1_40 Vdout1_40ck114 = 0.9 time = 575
.meas tran vdout1_40ck114 FIND v(dout1_40) AT=575.025n

* CHECK dout1_41 Vdout1_41ck114 = 0.9 time = 575
.meas tran vdout1_41ck114 FIND v(dout1_41) AT=575.025n

* CHECK dout1_42 Vdout1_42ck114 = 0 time = 575
.meas tran vdout1_42ck114 FIND v(dout1_42) AT=575.025n

* CHECK dout1_43 Vdout1_43ck114 = 0 time = 575
.meas tran vdout1_43ck114 FIND v(dout1_43) AT=575.025n

* CHECK dout1_44 Vdout1_44ck114 = 0 time = 575
.meas tran vdout1_44ck114 FIND v(dout1_44) AT=575.025n

* CHECK dout1_45 Vdout1_45ck114 = 0.9 time = 575
.meas tran vdout1_45ck114 FIND v(dout1_45) AT=575.025n

* CHECK dout1_46 Vdout1_46ck114 = 0.9 time = 575
.meas tran vdout1_46ck114 FIND v(dout1_46) AT=575.025n

* CHECK dout1_47 Vdout1_47ck114 = 0.9 time = 575
.meas tran vdout1_47ck114 FIND v(dout1_47) AT=575.025n

* CHECK dout1_48 Vdout1_48ck114 = 0.9 time = 575
.meas tran vdout1_48ck114 FIND v(dout1_48) AT=575.025n

* CHECK dout1_49 Vdout1_49ck114 = 0.9 time = 575
.meas tran vdout1_49ck114 FIND v(dout1_49) AT=575.025n

* CHECK dout1_50 Vdout1_50ck114 = 0 time = 575
.meas tran vdout1_50ck114 FIND v(dout1_50) AT=575.025n

* CHECK dout1_51 Vdout1_51ck114 = 0.9 time = 575
.meas tran vdout1_51ck114 FIND v(dout1_51) AT=575.025n

* CHECK dout1_52 Vdout1_52ck114 = 0.9 time = 575
.meas tran vdout1_52ck114 FIND v(dout1_52) AT=575.025n

* CHECK dout1_53 Vdout1_53ck114 = 0.9 time = 575
.meas tran vdout1_53ck114 FIND v(dout1_53) AT=575.025n

* CHECK dout1_54 Vdout1_54ck114 = 0 time = 575
.meas tran vdout1_54ck114 FIND v(dout1_54) AT=575.025n

* CHECK dout1_55 Vdout1_55ck114 = 0.9 time = 575
.meas tran vdout1_55ck114 FIND v(dout1_55) AT=575.025n

* CHECK dout1_56 Vdout1_56ck114 = 0 time = 575
.meas tran vdout1_56ck114 FIND v(dout1_56) AT=575.025n

* CHECK dout1_57 Vdout1_57ck114 = 0.9 time = 575
.meas tran vdout1_57ck114 FIND v(dout1_57) AT=575.025n

* CHECK dout1_58 Vdout1_58ck114 = 0.9 time = 575
.meas tran vdout1_58ck114 FIND v(dout1_58) AT=575.025n

* CHECK dout1_59 Vdout1_59ck114 = 0.9 time = 575
.meas tran vdout1_59ck114 FIND v(dout1_59) AT=575.025n

* CHECK dout1_60 Vdout1_60ck114 = 0 time = 575
.meas tran vdout1_60ck114 FIND v(dout1_60) AT=575.025n

* CHECK dout1_61 Vdout1_61ck114 = 0 time = 575
.meas tran vdout1_61ck114 FIND v(dout1_61) AT=575.025n

* CHECK dout1_62 Vdout1_62ck114 = 0.9 time = 575
.meas tran vdout1_62ck114 FIND v(dout1_62) AT=575.025n

* CHECK dout1_63 Vdout1_63ck114 = 0 time = 575
.meas tran vdout1_63ck114 FIND v(dout1_63) AT=575.025n

* CHECK dout1_64 Vdout1_64ck114 = 0 time = 575
.meas tran vdout1_64ck114 FIND v(dout1_64) AT=575.025n

* CHECK dout1_65 Vdout1_65ck114 = 0.9 time = 575
.meas tran vdout1_65ck114 FIND v(dout1_65) AT=575.025n

* CHECK dout1_66 Vdout1_66ck114 = 0.9 time = 575
.meas tran vdout1_66ck114 FIND v(dout1_66) AT=575.025n

* CHECK dout1_67 Vdout1_67ck114 = 0 time = 575
.meas tran vdout1_67ck114 FIND v(dout1_67) AT=575.025n

* CHECK dout1_68 Vdout1_68ck114 = 0 time = 575
.meas tran vdout1_68ck114 FIND v(dout1_68) AT=575.025n

* CHECK dout1_69 Vdout1_69ck114 = 0 time = 575
.meas tran vdout1_69ck114 FIND v(dout1_69) AT=575.025n

* CHECK dout1_70 Vdout1_70ck114 = 0 time = 575
.meas tran vdout1_70ck114 FIND v(dout1_70) AT=575.025n

* CHECK dout1_71 Vdout1_71ck114 = 0 time = 575
.meas tran vdout1_71ck114 FIND v(dout1_71) AT=575.025n

* CHECK dout1_72 Vdout1_72ck114 = 0.9 time = 575
.meas tran vdout1_72ck114 FIND v(dout1_72) AT=575.025n

* CHECK dout1_73 Vdout1_73ck114 = 0.9 time = 575
.meas tran vdout1_73ck114 FIND v(dout1_73) AT=575.025n

* CHECK dout1_74 Vdout1_74ck114 = 0.9 time = 575
.meas tran vdout1_74ck114 FIND v(dout1_74) AT=575.025n

* CHECK dout1_75 Vdout1_75ck114 = 0 time = 575
.meas tran vdout1_75ck114 FIND v(dout1_75) AT=575.025n

* CHECK dout1_76 Vdout1_76ck114 = 0.9 time = 575
.meas tran vdout1_76ck114 FIND v(dout1_76) AT=575.025n

* CHECK dout1_77 Vdout1_77ck114 = 0 time = 575
.meas tran vdout1_77ck114 FIND v(dout1_77) AT=575.025n

* CHECK dout1_78 Vdout1_78ck114 = 0 time = 575
.meas tran vdout1_78ck114 FIND v(dout1_78) AT=575.025n

* CHECK dout1_79 Vdout1_79ck114 = 0 time = 575
.meas tran vdout1_79ck114 FIND v(dout1_79) AT=575.025n

* CHECK dout1_80 Vdout1_80ck114 = 0 time = 575
.meas tran vdout1_80ck114 FIND v(dout1_80) AT=575.025n

* CHECK dout1_81 Vdout1_81ck114 = 0 time = 575
.meas tran vdout1_81ck114 FIND v(dout1_81) AT=575.025n

* CHECK dout1_82 Vdout1_82ck114 = 0 time = 575
.meas tran vdout1_82ck114 FIND v(dout1_82) AT=575.025n

* CHECK dout1_83 Vdout1_83ck114 = 0.9 time = 575
.meas tran vdout1_83ck114 FIND v(dout1_83) AT=575.025n

* CHECK dout1_84 Vdout1_84ck114 = 0.9 time = 575
.meas tran vdout1_84ck114 FIND v(dout1_84) AT=575.025n

* CHECK dout1_85 Vdout1_85ck114 = 0 time = 575
.meas tran vdout1_85ck114 FIND v(dout1_85) AT=575.025n

* CHECK dout1_86 Vdout1_86ck114 = 0.9 time = 575
.meas tran vdout1_86ck114 FIND v(dout1_86) AT=575.025n

* CHECK dout1_87 Vdout1_87ck114 = 0 time = 575
.meas tran vdout1_87ck114 FIND v(dout1_87) AT=575.025n

* CHECK dout1_88 Vdout1_88ck114 = 0.9 time = 575
.meas tran vdout1_88ck114 FIND v(dout1_88) AT=575.025n

* CHECK dout1_89 Vdout1_89ck114 = 0 time = 575
.meas tran vdout1_89ck114 FIND v(dout1_89) AT=575.025n

* CHECK dout1_90 Vdout1_90ck114 = 0.9 time = 575
.meas tran vdout1_90ck114 FIND v(dout1_90) AT=575.025n

* CHECK dout1_91 Vdout1_91ck114 = 0 time = 575
.meas tran vdout1_91ck114 FIND v(dout1_91) AT=575.025n

* CHECK dout1_92 Vdout1_92ck114 = 0.9 time = 575
.meas tran vdout1_92ck114 FIND v(dout1_92) AT=575.025n

* CHECK dout1_93 Vdout1_93ck114 = 0 time = 575
.meas tran vdout1_93ck114 FIND v(dout1_93) AT=575.025n

* CHECK dout1_94 Vdout1_94ck114 = 0 time = 575
.meas tran vdout1_94ck114 FIND v(dout1_94) AT=575.025n

* CHECK dout1_95 Vdout1_95ck114 = 0 time = 575
.meas tran vdout1_95ck114 FIND v(dout1_95) AT=575.025n

* CHECK dout1_96 Vdout1_96ck114 = 0.9 time = 575
.meas tran vdout1_96ck114 FIND v(dout1_96) AT=575.025n

* CHECK dout1_97 Vdout1_97ck114 = 0.9 time = 575
.meas tran vdout1_97ck114 FIND v(dout1_97) AT=575.025n

* CHECK dout1_98 Vdout1_98ck114 = 0 time = 575
.meas tran vdout1_98ck114 FIND v(dout1_98) AT=575.025n

* CHECK dout1_99 Vdout1_99ck114 = 0 time = 575
.meas tran vdout1_99ck114 FIND v(dout1_99) AT=575.025n

* CHECK dout1_100 Vdout1_100ck114 = 0 time = 575
.meas tran vdout1_100ck114 FIND v(dout1_100) AT=575.025n

* CHECK dout1_101 Vdout1_101ck114 = 0.9 time = 575
.meas tran vdout1_101ck114 FIND v(dout1_101) AT=575.025n

* CHECK dout1_102 Vdout1_102ck114 = 0.9 time = 575
.meas tran vdout1_102ck114 FIND v(dout1_102) AT=575.025n

* CHECK dout1_103 Vdout1_103ck114 = 0.9 time = 575
.meas tran vdout1_103ck114 FIND v(dout1_103) AT=575.025n

* CHECK dout1_104 Vdout1_104ck114 = 0.9 time = 575
.meas tran vdout1_104ck114 FIND v(dout1_104) AT=575.025n

* CHECK dout1_105 Vdout1_105ck114 = 0 time = 575
.meas tran vdout1_105ck114 FIND v(dout1_105) AT=575.025n

* CHECK dout1_106 Vdout1_106ck114 = 0.9 time = 575
.meas tran vdout1_106ck114 FIND v(dout1_106) AT=575.025n

* CHECK dout1_107 Vdout1_107ck114 = 0.9 time = 575
.meas tran vdout1_107ck114 FIND v(dout1_107) AT=575.025n

* CHECK dout1_108 Vdout1_108ck114 = 0.9 time = 575
.meas tran vdout1_108ck114 FIND v(dout1_108) AT=575.025n

* CHECK dout1_109 Vdout1_109ck114 = 0.9 time = 575
.meas tran vdout1_109ck114 FIND v(dout1_109) AT=575.025n

* CHECK dout1_110 Vdout1_110ck114 = 0 time = 575
.meas tran vdout1_110ck114 FIND v(dout1_110) AT=575.025n

* CHECK dout1_111 Vdout1_111ck114 = 0 time = 575
.meas tran vdout1_111ck114 FIND v(dout1_111) AT=575.025n

* CHECK dout1_112 Vdout1_112ck114 = 0 time = 575
.meas tran vdout1_112ck114 FIND v(dout1_112) AT=575.025n

* CHECK dout1_113 Vdout1_113ck114 = 0 time = 575
.meas tran vdout1_113ck114 FIND v(dout1_113) AT=575.025n

* CHECK dout1_114 Vdout1_114ck114 = 0 time = 575
.meas tran vdout1_114ck114 FIND v(dout1_114) AT=575.025n

* CHECK dout1_115 Vdout1_115ck114 = 0 time = 575
.meas tran vdout1_115ck114 FIND v(dout1_115) AT=575.025n

* CHECK dout1_116 Vdout1_116ck114 = 0 time = 575
.meas tran vdout1_116ck114 FIND v(dout1_116) AT=575.025n

* CHECK dout1_117 Vdout1_117ck114 = 0 time = 575
.meas tran vdout1_117ck114 FIND v(dout1_117) AT=575.025n

* CHECK dout1_118 Vdout1_118ck114 = 0 time = 575
.meas tran vdout1_118ck114 FIND v(dout1_118) AT=575.025n

* CHECK dout1_119 Vdout1_119ck114 = 0 time = 575
.meas tran vdout1_119ck114 FIND v(dout1_119) AT=575.025n

* CHECK dout1_0 Vdout1_0ck116 = 0 time = 585
.meas tran vdout1_0ck116 FIND v(dout1_0) AT=585.025n

* CHECK dout1_1 Vdout1_1ck116 = 0.9 time = 585
.meas tran vdout1_1ck116 FIND v(dout1_1) AT=585.025n

* CHECK dout1_2 Vdout1_2ck116 = 0 time = 585
.meas tran vdout1_2ck116 FIND v(dout1_2) AT=585.025n

* CHECK dout1_3 Vdout1_3ck116 = 0 time = 585
.meas tran vdout1_3ck116 FIND v(dout1_3) AT=585.025n

* CHECK dout1_4 Vdout1_4ck116 = 0 time = 585
.meas tran vdout1_4ck116 FIND v(dout1_4) AT=585.025n

* CHECK dout1_5 Vdout1_5ck116 = 0.9 time = 585
.meas tran vdout1_5ck116 FIND v(dout1_5) AT=585.025n

* CHECK dout1_6 Vdout1_6ck116 = 0 time = 585
.meas tran vdout1_6ck116 FIND v(dout1_6) AT=585.025n

* CHECK dout1_7 Vdout1_7ck116 = 0.9 time = 585
.meas tran vdout1_7ck116 FIND v(dout1_7) AT=585.025n

* CHECK dout1_8 Vdout1_8ck116 = 0 time = 585
.meas tran vdout1_8ck116 FIND v(dout1_8) AT=585.025n

* CHECK dout1_9 Vdout1_9ck116 = 0.9 time = 585
.meas tran vdout1_9ck116 FIND v(dout1_9) AT=585.025n

* CHECK dout1_10 Vdout1_10ck116 = 0.9 time = 585
.meas tran vdout1_10ck116 FIND v(dout1_10) AT=585.025n

* CHECK dout1_11 Vdout1_11ck116 = 0.9 time = 585
.meas tran vdout1_11ck116 FIND v(dout1_11) AT=585.025n

* CHECK dout1_12 Vdout1_12ck116 = 0.9 time = 585
.meas tran vdout1_12ck116 FIND v(dout1_12) AT=585.025n

* CHECK dout1_13 Vdout1_13ck116 = 0 time = 585
.meas tran vdout1_13ck116 FIND v(dout1_13) AT=585.025n

* CHECK dout1_14 Vdout1_14ck116 = 0 time = 585
.meas tran vdout1_14ck116 FIND v(dout1_14) AT=585.025n

* CHECK dout1_15 Vdout1_15ck116 = 0 time = 585
.meas tran vdout1_15ck116 FIND v(dout1_15) AT=585.025n

* CHECK dout1_16 Vdout1_16ck116 = 0.9 time = 585
.meas tran vdout1_16ck116 FIND v(dout1_16) AT=585.025n

* CHECK dout1_17 Vdout1_17ck116 = 0 time = 585
.meas tran vdout1_17ck116 FIND v(dout1_17) AT=585.025n

* CHECK dout1_18 Vdout1_18ck116 = 0.9 time = 585
.meas tran vdout1_18ck116 FIND v(dout1_18) AT=585.025n

* CHECK dout1_19 Vdout1_19ck116 = 0.9 time = 585
.meas tran vdout1_19ck116 FIND v(dout1_19) AT=585.025n

* CHECK dout1_20 Vdout1_20ck116 = 0.9 time = 585
.meas tran vdout1_20ck116 FIND v(dout1_20) AT=585.025n

* CHECK dout1_21 Vdout1_21ck116 = 0.9 time = 585
.meas tran vdout1_21ck116 FIND v(dout1_21) AT=585.025n

* CHECK dout1_22 Vdout1_22ck116 = 0.9 time = 585
.meas tran vdout1_22ck116 FIND v(dout1_22) AT=585.025n

* CHECK dout1_23 Vdout1_23ck116 = 0 time = 585
.meas tran vdout1_23ck116 FIND v(dout1_23) AT=585.025n

* CHECK dout1_24 Vdout1_24ck116 = 0.9 time = 585
.meas tran vdout1_24ck116 FIND v(dout1_24) AT=585.025n

* CHECK dout1_25 Vdout1_25ck116 = 0.9 time = 585
.meas tran vdout1_25ck116 FIND v(dout1_25) AT=585.025n

* CHECK dout1_26 Vdout1_26ck116 = 0.9 time = 585
.meas tran vdout1_26ck116 FIND v(dout1_26) AT=585.025n

* CHECK dout1_27 Vdout1_27ck116 = 0.9 time = 585
.meas tran vdout1_27ck116 FIND v(dout1_27) AT=585.025n

* CHECK dout1_28 Vdout1_28ck116 = 0.9 time = 585
.meas tran vdout1_28ck116 FIND v(dout1_28) AT=585.025n

* CHECK dout1_29 Vdout1_29ck116 = 0 time = 585
.meas tran vdout1_29ck116 FIND v(dout1_29) AT=585.025n

* CHECK dout1_30 Vdout1_30ck116 = 0.9 time = 585
.meas tran vdout1_30ck116 FIND v(dout1_30) AT=585.025n

* CHECK dout1_31 Vdout1_31ck116 = 0 time = 585
.meas tran vdout1_31ck116 FIND v(dout1_31) AT=585.025n

* CHECK dout1_32 Vdout1_32ck116 = 0.9 time = 585
.meas tran vdout1_32ck116 FIND v(dout1_32) AT=585.025n

* CHECK dout1_33 Vdout1_33ck116 = 0 time = 585
.meas tran vdout1_33ck116 FIND v(dout1_33) AT=585.025n

* CHECK dout1_34 Vdout1_34ck116 = 0.9 time = 585
.meas tran vdout1_34ck116 FIND v(dout1_34) AT=585.025n

* CHECK dout1_35 Vdout1_35ck116 = 0 time = 585
.meas tran vdout1_35ck116 FIND v(dout1_35) AT=585.025n

* CHECK dout1_36 Vdout1_36ck116 = 0 time = 585
.meas tran vdout1_36ck116 FIND v(dout1_36) AT=585.025n

* CHECK dout1_37 Vdout1_37ck116 = 0 time = 585
.meas tran vdout1_37ck116 FIND v(dout1_37) AT=585.025n

* CHECK dout1_38 Vdout1_38ck116 = 0.9 time = 585
.meas tran vdout1_38ck116 FIND v(dout1_38) AT=585.025n

* CHECK dout1_39 Vdout1_39ck116 = 0.9 time = 585
.meas tran vdout1_39ck116 FIND v(dout1_39) AT=585.025n

* CHECK dout1_40 Vdout1_40ck116 = 0 time = 585
.meas tran vdout1_40ck116 FIND v(dout1_40) AT=585.025n

* CHECK dout1_41 Vdout1_41ck116 = 0.9 time = 585
.meas tran vdout1_41ck116 FIND v(dout1_41) AT=585.025n

* CHECK dout1_42 Vdout1_42ck116 = 0.9 time = 585
.meas tran vdout1_42ck116 FIND v(dout1_42) AT=585.025n

* CHECK dout1_43 Vdout1_43ck116 = 0.9 time = 585
.meas tran vdout1_43ck116 FIND v(dout1_43) AT=585.025n

* CHECK dout1_44 Vdout1_44ck116 = 0 time = 585
.meas tran vdout1_44ck116 FIND v(dout1_44) AT=585.025n

* CHECK dout1_45 Vdout1_45ck116 = 0.9 time = 585
.meas tran vdout1_45ck116 FIND v(dout1_45) AT=585.025n

* CHECK dout1_46 Vdout1_46ck116 = 0.9 time = 585
.meas tran vdout1_46ck116 FIND v(dout1_46) AT=585.025n

* CHECK dout1_47 Vdout1_47ck116 = 0 time = 585
.meas tran vdout1_47ck116 FIND v(dout1_47) AT=585.025n

* CHECK dout1_48 Vdout1_48ck116 = 0 time = 585
.meas tran vdout1_48ck116 FIND v(dout1_48) AT=585.025n

* CHECK dout1_49 Vdout1_49ck116 = 0.9 time = 585
.meas tran vdout1_49ck116 FIND v(dout1_49) AT=585.025n

* CHECK dout1_50 Vdout1_50ck116 = 0.9 time = 585
.meas tran vdout1_50ck116 FIND v(dout1_50) AT=585.025n

* CHECK dout1_51 Vdout1_51ck116 = 0.9 time = 585
.meas tran vdout1_51ck116 FIND v(dout1_51) AT=585.025n

* CHECK dout1_52 Vdout1_52ck116 = 0 time = 585
.meas tran vdout1_52ck116 FIND v(dout1_52) AT=585.025n

* CHECK dout1_53 Vdout1_53ck116 = 0.9 time = 585
.meas tran vdout1_53ck116 FIND v(dout1_53) AT=585.025n

* CHECK dout1_54 Vdout1_54ck116 = 0 time = 585
.meas tran vdout1_54ck116 FIND v(dout1_54) AT=585.025n

* CHECK dout1_55 Vdout1_55ck116 = 0.9 time = 585
.meas tran vdout1_55ck116 FIND v(dout1_55) AT=585.025n

* CHECK dout1_56 Vdout1_56ck116 = 0.9 time = 585
.meas tran vdout1_56ck116 FIND v(dout1_56) AT=585.025n

* CHECK dout1_57 Vdout1_57ck116 = 0.9 time = 585
.meas tran vdout1_57ck116 FIND v(dout1_57) AT=585.025n

* CHECK dout1_58 Vdout1_58ck116 = 0 time = 585
.meas tran vdout1_58ck116 FIND v(dout1_58) AT=585.025n

* CHECK dout1_59 Vdout1_59ck116 = 0.9 time = 585
.meas tran vdout1_59ck116 FIND v(dout1_59) AT=585.025n

* CHECK dout1_60 Vdout1_60ck116 = 0.9 time = 585
.meas tran vdout1_60ck116 FIND v(dout1_60) AT=585.025n

* CHECK dout1_61 Vdout1_61ck116 = 0 time = 585
.meas tran vdout1_61ck116 FIND v(dout1_61) AT=585.025n

* CHECK dout1_62 Vdout1_62ck116 = 0 time = 585
.meas tran vdout1_62ck116 FIND v(dout1_62) AT=585.025n

* CHECK dout1_63 Vdout1_63ck116 = 0 time = 585
.meas tran vdout1_63ck116 FIND v(dout1_63) AT=585.025n

* CHECK dout1_64 Vdout1_64ck116 = 0.9 time = 585
.meas tran vdout1_64ck116 FIND v(dout1_64) AT=585.025n

* CHECK dout1_65 Vdout1_65ck116 = 0 time = 585
.meas tran vdout1_65ck116 FIND v(dout1_65) AT=585.025n

* CHECK dout1_66 Vdout1_66ck116 = 0 time = 585
.meas tran vdout1_66ck116 FIND v(dout1_66) AT=585.025n

* CHECK dout1_67 Vdout1_67ck116 = 0.9 time = 585
.meas tran vdout1_67ck116 FIND v(dout1_67) AT=585.025n

* CHECK dout1_68 Vdout1_68ck116 = 0.9 time = 585
.meas tran vdout1_68ck116 FIND v(dout1_68) AT=585.025n

* CHECK dout1_69 Vdout1_69ck116 = 0 time = 585
.meas tran vdout1_69ck116 FIND v(dout1_69) AT=585.025n

* CHECK dout1_70 Vdout1_70ck116 = 0.9 time = 585
.meas tran vdout1_70ck116 FIND v(dout1_70) AT=585.025n

* CHECK dout1_71 Vdout1_71ck116 = 0 time = 585
.meas tran vdout1_71ck116 FIND v(dout1_71) AT=585.025n

* CHECK dout1_72 Vdout1_72ck116 = 0.9 time = 585
.meas tran vdout1_72ck116 FIND v(dout1_72) AT=585.025n

* CHECK dout1_73 Vdout1_73ck116 = 0.9 time = 585
.meas tran vdout1_73ck116 FIND v(dout1_73) AT=585.025n

* CHECK dout1_74 Vdout1_74ck116 = 0 time = 585
.meas tran vdout1_74ck116 FIND v(dout1_74) AT=585.025n

* CHECK dout1_75 Vdout1_75ck116 = 0.9 time = 585
.meas tran vdout1_75ck116 FIND v(dout1_75) AT=585.025n

* CHECK dout1_76 Vdout1_76ck116 = 0.9 time = 585
.meas tran vdout1_76ck116 FIND v(dout1_76) AT=585.025n

* CHECK dout1_77 Vdout1_77ck116 = 0 time = 585
.meas tran vdout1_77ck116 FIND v(dout1_77) AT=585.025n

* CHECK dout1_78 Vdout1_78ck116 = 0.9 time = 585
.meas tran vdout1_78ck116 FIND v(dout1_78) AT=585.025n

* CHECK dout1_79 Vdout1_79ck116 = 0 time = 585
.meas tran vdout1_79ck116 FIND v(dout1_79) AT=585.025n

* CHECK dout1_80 Vdout1_80ck116 = 0.9 time = 585
.meas tran vdout1_80ck116 FIND v(dout1_80) AT=585.025n

* CHECK dout1_81 Vdout1_81ck116 = 0 time = 585
.meas tran vdout1_81ck116 FIND v(dout1_81) AT=585.025n

* CHECK dout1_82 Vdout1_82ck116 = 0 time = 585
.meas tran vdout1_82ck116 FIND v(dout1_82) AT=585.025n

* CHECK dout1_83 Vdout1_83ck116 = 0.9 time = 585
.meas tran vdout1_83ck116 FIND v(dout1_83) AT=585.025n

* CHECK dout1_84 Vdout1_84ck116 = 0.9 time = 585
.meas tran vdout1_84ck116 FIND v(dout1_84) AT=585.025n

* CHECK dout1_85 Vdout1_85ck116 = 0 time = 585
.meas tran vdout1_85ck116 FIND v(dout1_85) AT=585.025n

* CHECK dout1_86 Vdout1_86ck116 = 0.9 time = 585
.meas tran vdout1_86ck116 FIND v(dout1_86) AT=585.025n

* CHECK dout1_87 Vdout1_87ck116 = 0 time = 585
.meas tran vdout1_87ck116 FIND v(dout1_87) AT=585.025n

* CHECK dout1_88 Vdout1_88ck116 = 0 time = 585
.meas tran vdout1_88ck116 FIND v(dout1_88) AT=585.025n

* CHECK dout1_89 Vdout1_89ck116 = 0.9 time = 585
.meas tran vdout1_89ck116 FIND v(dout1_89) AT=585.025n

* CHECK dout1_90 Vdout1_90ck116 = 0 time = 585
.meas tran vdout1_90ck116 FIND v(dout1_90) AT=585.025n

* CHECK dout1_91 Vdout1_91ck116 = 0 time = 585
.meas tran vdout1_91ck116 FIND v(dout1_91) AT=585.025n

* CHECK dout1_92 Vdout1_92ck116 = 0 time = 585
.meas tran vdout1_92ck116 FIND v(dout1_92) AT=585.025n

* CHECK dout1_93 Vdout1_93ck116 = 0.9 time = 585
.meas tran vdout1_93ck116 FIND v(dout1_93) AT=585.025n

* CHECK dout1_94 Vdout1_94ck116 = 0 time = 585
.meas tran vdout1_94ck116 FIND v(dout1_94) AT=585.025n

* CHECK dout1_95 Vdout1_95ck116 = 0.9 time = 585
.meas tran vdout1_95ck116 FIND v(dout1_95) AT=585.025n

* CHECK dout1_96 Vdout1_96ck116 = 0.9 time = 585
.meas tran vdout1_96ck116 FIND v(dout1_96) AT=585.025n

* CHECK dout1_97 Vdout1_97ck116 = 0.9 time = 585
.meas tran vdout1_97ck116 FIND v(dout1_97) AT=585.025n

* CHECK dout1_98 Vdout1_98ck116 = 0.9 time = 585
.meas tran vdout1_98ck116 FIND v(dout1_98) AT=585.025n

* CHECK dout1_99 Vdout1_99ck116 = 0.9 time = 585
.meas tran vdout1_99ck116 FIND v(dout1_99) AT=585.025n

* CHECK dout1_100 Vdout1_100ck116 = 0.9 time = 585
.meas tran vdout1_100ck116 FIND v(dout1_100) AT=585.025n

* CHECK dout1_101 Vdout1_101ck116 = 0 time = 585
.meas tran vdout1_101ck116 FIND v(dout1_101) AT=585.025n

* CHECK dout1_102 Vdout1_102ck116 = 0.9 time = 585
.meas tran vdout1_102ck116 FIND v(dout1_102) AT=585.025n

* CHECK dout1_103 Vdout1_103ck116 = 0.9 time = 585
.meas tran vdout1_103ck116 FIND v(dout1_103) AT=585.025n

* CHECK dout1_104 Vdout1_104ck116 = 0.9 time = 585
.meas tran vdout1_104ck116 FIND v(dout1_104) AT=585.025n

* CHECK dout1_105 Vdout1_105ck116 = 0 time = 585
.meas tran vdout1_105ck116 FIND v(dout1_105) AT=585.025n

* CHECK dout1_106 Vdout1_106ck116 = 0.9 time = 585
.meas tran vdout1_106ck116 FIND v(dout1_106) AT=585.025n

* CHECK dout1_107 Vdout1_107ck116 = 0.9 time = 585
.meas tran vdout1_107ck116 FIND v(dout1_107) AT=585.025n

* CHECK dout1_108 Vdout1_108ck116 = 0 time = 585
.meas tran vdout1_108ck116 FIND v(dout1_108) AT=585.025n

* CHECK dout1_109 Vdout1_109ck116 = 0 time = 585
.meas tran vdout1_109ck116 FIND v(dout1_109) AT=585.025n

* CHECK dout1_110 Vdout1_110ck116 = 0 time = 585
.meas tran vdout1_110ck116 FIND v(dout1_110) AT=585.025n

* CHECK dout1_111 Vdout1_111ck116 = 0.9 time = 585
.meas tran vdout1_111ck116 FIND v(dout1_111) AT=585.025n

* CHECK dout1_112 Vdout1_112ck116 = 0 time = 585
.meas tran vdout1_112ck116 FIND v(dout1_112) AT=585.025n

* CHECK dout1_113 Vdout1_113ck116 = 0 time = 585
.meas tran vdout1_113ck116 FIND v(dout1_113) AT=585.025n

* CHECK dout1_114 Vdout1_114ck116 = 0 time = 585
.meas tran vdout1_114ck116 FIND v(dout1_114) AT=585.025n

* CHECK dout1_115 Vdout1_115ck116 = 0.9 time = 585
.meas tran vdout1_115ck116 FIND v(dout1_115) AT=585.025n

* CHECK dout1_116 Vdout1_116ck116 = 0.9 time = 585
.meas tran vdout1_116ck116 FIND v(dout1_116) AT=585.025n

* CHECK dout1_117 Vdout1_117ck116 = 0.9 time = 585
.meas tran vdout1_117ck116 FIND v(dout1_117) AT=585.025n

* CHECK dout1_118 Vdout1_118ck116 = 0.9 time = 585
.meas tran vdout1_118ck116 FIND v(dout1_118) AT=585.025n

* CHECK dout1_119 Vdout1_119ck116 = 0.9 time = 585
.meas tran vdout1_119ck116 FIND v(dout1_119) AT=585.025n

* CHECK dout1_0 Vdout1_0ck118 = 0.9 time = 595
.meas tran vdout1_0ck118 FIND v(dout1_0) AT=595.025n

* CHECK dout1_1 Vdout1_1ck118 = 0 time = 595
.meas tran vdout1_1ck118 FIND v(dout1_1) AT=595.025n

* CHECK dout1_2 Vdout1_2ck118 = 0.9 time = 595
.meas tran vdout1_2ck118 FIND v(dout1_2) AT=595.025n

* CHECK dout1_3 Vdout1_3ck118 = 0.9 time = 595
.meas tran vdout1_3ck118 FIND v(dout1_3) AT=595.025n

* CHECK dout1_4 Vdout1_4ck118 = 0 time = 595
.meas tran vdout1_4ck118 FIND v(dout1_4) AT=595.025n

* CHECK dout1_5 Vdout1_5ck118 = 0.9 time = 595
.meas tran vdout1_5ck118 FIND v(dout1_5) AT=595.025n

* CHECK dout1_6 Vdout1_6ck118 = 0 time = 595
.meas tran vdout1_6ck118 FIND v(dout1_6) AT=595.025n

* CHECK dout1_7 Vdout1_7ck118 = 0.9 time = 595
.meas tran vdout1_7ck118 FIND v(dout1_7) AT=595.025n

* CHECK dout1_8 Vdout1_8ck118 = 0.9 time = 595
.meas tran vdout1_8ck118 FIND v(dout1_8) AT=595.025n

* CHECK dout1_9 Vdout1_9ck118 = 0.9 time = 595
.meas tran vdout1_9ck118 FIND v(dout1_9) AT=595.025n

* CHECK dout1_10 Vdout1_10ck118 = 0 time = 595
.meas tran vdout1_10ck118 FIND v(dout1_10) AT=595.025n

* CHECK dout1_11 Vdout1_11ck118 = 0.9 time = 595
.meas tran vdout1_11ck118 FIND v(dout1_11) AT=595.025n

* CHECK dout1_12 Vdout1_12ck118 = 0 time = 595
.meas tran vdout1_12ck118 FIND v(dout1_12) AT=595.025n

* CHECK dout1_13 Vdout1_13ck118 = 0.9 time = 595
.meas tran vdout1_13ck118 FIND v(dout1_13) AT=595.025n

* CHECK dout1_14 Vdout1_14ck118 = 0.9 time = 595
.meas tran vdout1_14ck118 FIND v(dout1_14) AT=595.025n

* CHECK dout1_15 Vdout1_15ck118 = 0.9 time = 595
.meas tran vdout1_15ck118 FIND v(dout1_15) AT=595.025n

* CHECK dout1_16 Vdout1_16ck118 = 0 time = 595
.meas tran vdout1_16ck118 FIND v(dout1_16) AT=595.025n

* CHECK dout1_17 Vdout1_17ck118 = 0.9 time = 595
.meas tran vdout1_17ck118 FIND v(dout1_17) AT=595.025n

* CHECK dout1_18 Vdout1_18ck118 = 0 time = 595
.meas tran vdout1_18ck118 FIND v(dout1_18) AT=595.025n

* CHECK dout1_19 Vdout1_19ck118 = 0 time = 595
.meas tran vdout1_19ck118 FIND v(dout1_19) AT=595.025n

* CHECK dout1_20 Vdout1_20ck118 = 0.9 time = 595
.meas tran vdout1_20ck118 FIND v(dout1_20) AT=595.025n

* CHECK dout1_21 Vdout1_21ck118 = 0 time = 595
.meas tran vdout1_21ck118 FIND v(dout1_21) AT=595.025n

* CHECK dout1_22 Vdout1_22ck118 = 0 time = 595
.meas tran vdout1_22ck118 FIND v(dout1_22) AT=595.025n

* CHECK dout1_23 Vdout1_23ck118 = 0 time = 595
.meas tran vdout1_23ck118 FIND v(dout1_23) AT=595.025n

* CHECK dout1_24 Vdout1_24ck118 = 0 time = 595
.meas tran vdout1_24ck118 FIND v(dout1_24) AT=595.025n

* CHECK dout1_25 Vdout1_25ck118 = 0.9 time = 595
.meas tran vdout1_25ck118 FIND v(dout1_25) AT=595.025n

* CHECK dout1_26 Vdout1_26ck118 = 0.9 time = 595
.meas tran vdout1_26ck118 FIND v(dout1_26) AT=595.025n

* CHECK dout1_27 Vdout1_27ck118 = 0 time = 595
.meas tran vdout1_27ck118 FIND v(dout1_27) AT=595.025n

* CHECK dout1_28 Vdout1_28ck118 = 0 time = 595
.meas tran vdout1_28ck118 FIND v(dout1_28) AT=595.025n

* CHECK dout1_29 Vdout1_29ck118 = 0 time = 595
.meas tran vdout1_29ck118 FIND v(dout1_29) AT=595.025n

* CHECK dout1_30 Vdout1_30ck118 = 0.9 time = 595
.meas tran vdout1_30ck118 FIND v(dout1_30) AT=595.025n

* CHECK dout1_31 Vdout1_31ck118 = 0.9 time = 595
.meas tran vdout1_31ck118 FIND v(dout1_31) AT=595.025n

* CHECK dout1_32 Vdout1_32ck118 = 0.9 time = 595
.meas tran vdout1_32ck118 FIND v(dout1_32) AT=595.025n

* CHECK dout1_33 Vdout1_33ck118 = 0.9 time = 595
.meas tran vdout1_33ck118 FIND v(dout1_33) AT=595.025n

* CHECK dout1_34 Vdout1_34ck118 = 0 time = 595
.meas tran vdout1_34ck118 FIND v(dout1_34) AT=595.025n

* CHECK dout1_35 Vdout1_35ck118 = 0.9 time = 595
.meas tran vdout1_35ck118 FIND v(dout1_35) AT=595.025n

* CHECK dout1_36 Vdout1_36ck118 = 0 time = 595
.meas tran vdout1_36ck118 FIND v(dout1_36) AT=595.025n

* CHECK dout1_37 Vdout1_37ck118 = 0 time = 595
.meas tran vdout1_37ck118 FIND v(dout1_37) AT=595.025n

* CHECK dout1_38 Vdout1_38ck118 = 0.9 time = 595
.meas tran vdout1_38ck118 FIND v(dout1_38) AT=595.025n

* CHECK dout1_39 Vdout1_39ck118 = 0.9 time = 595
.meas tran vdout1_39ck118 FIND v(dout1_39) AT=595.025n

* CHECK dout1_40 Vdout1_40ck118 = 0.9 time = 595
.meas tran vdout1_40ck118 FIND v(dout1_40) AT=595.025n

* CHECK dout1_41 Vdout1_41ck118 = 0.9 time = 595
.meas tran vdout1_41ck118 FIND v(dout1_41) AT=595.025n

* CHECK dout1_42 Vdout1_42ck118 = 0 time = 595
.meas tran vdout1_42ck118 FIND v(dout1_42) AT=595.025n

* CHECK dout1_43 Vdout1_43ck118 = 0.9 time = 595
.meas tran vdout1_43ck118 FIND v(dout1_43) AT=595.025n

* CHECK dout1_44 Vdout1_44ck118 = 0 time = 595
.meas tran vdout1_44ck118 FIND v(dout1_44) AT=595.025n

* CHECK dout1_45 Vdout1_45ck118 = 0.9 time = 595
.meas tran vdout1_45ck118 FIND v(dout1_45) AT=595.025n

* CHECK dout1_46 Vdout1_46ck118 = 0 time = 595
.meas tran vdout1_46ck118 FIND v(dout1_46) AT=595.025n

* CHECK dout1_47 Vdout1_47ck118 = 0 time = 595
.meas tran vdout1_47ck118 FIND v(dout1_47) AT=595.025n

* CHECK dout1_48 Vdout1_48ck118 = 0.9 time = 595
.meas tran vdout1_48ck118 FIND v(dout1_48) AT=595.025n

* CHECK dout1_49 Vdout1_49ck118 = 0.9 time = 595
.meas tran vdout1_49ck118 FIND v(dout1_49) AT=595.025n

* CHECK dout1_50 Vdout1_50ck118 = 0.9 time = 595
.meas tran vdout1_50ck118 FIND v(dout1_50) AT=595.025n

* CHECK dout1_51 Vdout1_51ck118 = 0 time = 595
.meas tran vdout1_51ck118 FIND v(dout1_51) AT=595.025n

* CHECK dout1_52 Vdout1_52ck118 = 0.9 time = 595
.meas tran vdout1_52ck118 FIND v(dout1_52) AT=595.025n

* CHECK dout1_53 Vdout1_53ck118 = 0.9 time = 595
.meas tran vdout1_53ck118 FIND v(dout1_53) AT=595.025n

* CHECK dout1_54 Vdout1_54ck118 = 0.9 time = 595
.meas tran vdout1_54ck118 FIND v(dout1_54) AT=595.025n

* CHECK dout1_55 Vdout1_55ck118 = 0 time = 595
.meas tran vdout1_55ck118 FIND v(dout1_55) AT=595.025n

* CHECK dout1_56 Vdout1_56ck118 = 0.9 time = 595
.meas tran vdout1_56ck118 FIND v(dout1_56) AT=595.025n

* CHECK dout1_57 Vdout1_57ck118 = 0.9 time = 595
.meas tran vdout1_57ck118 FIND v(dout1_57) AT=595.025n

* CHECK dout1_58 Vdout1_58ck118 = 0 time = 595
.meas tran vdout1_58ck118 FIND v(dout1_58) AT=595.025n

* CHECK dout1_59 Vdout1_59ck118 = 0 time = 595
.meas tran vdout1_59ck118 FIND v(dout1_59) AT=595.025n

* CHECK dout1_60 Vdout1_60ck118 = 0.9 time = 595
.meas tran vdout1_60ck118 FIND v(dout1_60) AT=595.025n

* CHECK dout1_61 Vdout1_61ck118 = 0.9 time = 595
.meas tran vdout1_61ck118 FIND v(dout1_61) AT=595.025n

* CHECK dout1_62 Vdout1_62ck118 = 0.9 time = 595
.meas tran vdout1_62ck118 FIND v(dout1_62) AT=595.025n

* CHECK dout1_63 Vdout1_63ck118 = 0 time = 595
.meas tran vdout1_63ck118 FIND v(dout1_63) AT=595.025n

* CHECK dout1_64 Vdout1_64ck118 = 0 time = 595
.meas tran vdout1_64ck118 FIND v(dout1_64) AT=595.025n

* CHECK dout1_65 Vdout1_65ck118 = 0 time = 595
.meas tran vdout1_65ck118 FIND v(dout1_65) AT=595.025n

* CHECK dout1_66 Vdout1_66ck118 = 0.9 time = 595
.meas tran vdout1_66ck118 FIND v(dout1_66) AT=595.025n

* CHECK dout1_67 Vdout1_67ck118 = 0.9 time = 595
.meas tran vdout1_67ck118 FIND v(dout1_67) AT=595.025n

* CHECK dout1_68 Vdout1_68ck118 = 0 time = 595
.meas tran vdout1_68ck118 FIND v(dout1_68) AT=595.025n

* CHECK dout1_69 Vdout1_69ck118 = 0.9 time = 595
.meas tran vdout1_69ck118 FIND v(dout1_69) AT=595.025n

* CHECK dout1_70 Vdout1_70ck118 = 0.9 time = 595
.meas tran vdout1_70ck118 FIND v(dout1_70) AT=595.025n

* CHECK dout1_71 Vdout1_71ck118 = 0.9 time = 595
.meas tran vdout1_71ck118 FIND v(dout1_71) AT=595.025n

* CHECK dout1_72 Vdout1_72ck118 = 0 time = 595
.meas tran vdout1_72ck118 FIND v(dout1_72) AT=595.025n

* CHECK dout1_73 Vdout1_73ck118 = 0.9 time = 595
.meas tran vdout1_73ck118 FIND v(dout1_73) AT=595.025n

* CHECK dout1_74 Vdout1_74ck118 = 0 time = 595
.meas tran vdout1_74ck118 FIND v(dout1_74) AT=595.025n

* CHECK dout1_75 Vdout1_75ck118 = 0 time = 595
.meas tran vdout1_75ck118 FIND v(dout1_75) AT=595.025n

* CHECK dout1_76 Vdout1_76ck118 = 0 time = 595
.meas tran vdout1_76ck118 FIND v(dout1_76) AT=595.025n

* CHECK dout1_77 Vdout1_77ck118 = 0 time = 595
.meas tran vdout1_77ck118 FIND v(dout1_77) AT=595.025n

* CHECK dout1_78 Vdout1_78ck118 = 0.9 time = 595
.meas tran vdout1_78ck118 FIND v(dout1_78) AT=595.025n

* CHECK dout1_79 Vdout1_79ck118 = 0 time = 595
.meas tran vdout1_79ck118 FIND v(dout1_79) AT=595.025n

* CHECK dout1_80 Vdout1_80ck118 = 0.9 time = 595
.meas tran vdout1_80ck118 FIND v(dout1_80) AT=595.025n

* CHECK dout1_81 Vdout1_81ck118 = 0 time = 595
.meas tran vdout1_81ck118 FIND v(dout1_81) AT=595.025n

* CHECK dout1_82 Vdout1_82ck118 = 0 time = 595
.meas tran vdout1_82ck118 FIND v(dout1_82) AT=595.025n

* CHECK dout1_83 Vdout1_83ck118 = 0.9 time = 595
.meas tran vdout1_83ck118 FIND v(dout1_83) AT=595.025n

* CHECK dout1_84 Vdout1_84ck118 = 0 time = 595
.meas tran vdout1_84ck118 FIND v(dout1_84) AT=595.025n

* CHECK dout1_85 Vdout1_85ck118 = 0 time = 595
.meas tran vdout1_85ck118 FIND v(dout1_85) AT=595.025n

* CHECK dout1_86 Vdout1_86ck118 = 0.9 time = 595
.meas tran vdout1_86ck118 FIND v(dout1_86) AT=595.025n

* CHECK dout1_87 Vdout1_87ck118 = 0 time = 595
.meas tran vdout1_87ck118 FIND v(dout1_87) AT=595.025n

* CHECK dout1_88 Vdout1_88ck118 = 0 time = 595
.meas tran vdout1_88ck118 FIND v(dout1_88) AT=595.025n

* CHECK dout1_89 Vdout1_89ck118 = 0.9 time = 595
.meas tran vdout1_89ck118 FIND v(dout1_89) AT=595.025n

* CHECK dout1_90 Vdout1_90ck118 = 0.9 time = 595
.meas tran vdout1_90ck118 FIND v(dout1_90) AT=595.025n

* CHECK dout1_91 Vdout1_91ck118 = 0 time = 595
.meas tran vdout1_91ck118 FIND v(dout1_91) AT=595.025n

* CHECK dout1_92 Vdout1_92ck118 = 0.9 time = 595
.meas tran vdout1_92ck118 FIND v(dout1_92) AT=595.025n

* CHECK dout1_93 Vdout1_93ck118 = 0.9 time = 595
.meas tran vdout1_93ck118 FIND v(dout1_93) AT=595.025n

* CHECK dout1_94 Vdout1_94ck118 = 0 time = 595
.meas tran vdout1_94ck118 FIND v(dout1_94) AT=595.025n

* CHECK dout1_95 Vdout1_95ck118 = 0 time = 595
.meas tran vdout1_95ck118 FIND v(dout1_95) AT=595.025n

* CHECK dout1_96 Vdout1_96ck118 = 0.9 time = 595
.meas tran vdout1_96ck118 FIND v(dout1_96) AT=595.025n

* CHECK dout1_97 Vdout1_97ck118 = 0.9 time = 595
.meas tran vdout1_97ck118 FIND v(dout1_97) AT=595.025n

* CHECK dout1_98 Vdout1_98ck118 = 0 time = 595
.meas tran vdout1_98ck118 FIND v(dout1_98) AT=595.025n

* CHECK dout1_99 Vdout1_99ck118 = 0 time = 595
.meas tran vdout1_99ck118 FIND v(dout1_99) AT=595.025n

* CHECK dout1_100 Vdout1_100ck118 = 0 time = 595
.meas tran vdout1_100ck118 FIND v(dout1_100) AT=595.025n

* CHECK dout1_101 Vdout1_101ck118 = 0 time = 595
.meas tran vdout1_101ck118 FIND v(dout1_101) AT=595.025n

* CHECK dout1_102 Vdout1_102ck118 = 0 time = 595
.meas tran vdout1_102ck118 FIND v(dout1_102) AT=595.025n

* CHECK dout1_103 Vdout1_103ck118 = 0.9 time = 595
.meas tran vdout1_103ck118 FIND v(dout1_103) AT=595.025n

* CHECK dout1_104 Vdout1_104ck118 = 0.9 time = 595
.meas tran vdout1_104ck118 FIND v(dout1_104) AT=595.025n

* CHECK dout1_105 Vdout1_105ck118 = 0.9 time = 595
.meas tran vdout1_105ck118 FIND v(dout1_105) AT=595.025n

* CHECK dout1_106 Vdout1_106ck118 = 0.9 time = 595
.meas tran vdout1_106ck118 FIND v(dout1_106) AT=595.025n

* CHECK dout1_107 Vdout1_107ck118 = 0 time = 595
.meas tran vdout1_107ck118 FIND v(dout1_107) AT=595.025n

* CHECK dout1_108 Vdout1_108ck118 = 0.9 time = 595
.meas tran vdout1_108ck118 FIND v(dout1_108) AT=595.025n

* CHECK dout1_109 Vdout1_109ck118 = 0.9 time = 595
.meas tran vdout1_109ck118 FIND v(dout1_109) AT=595.025n

* CHECK dout1_110 Vdout1_110ck118 = 0.9 time = 595
.meas tran vdout1_110ck118 FIND v(dout1_110) AT=595.025n

* CHECK dout1_111 Vdout1_111ck118 = 0.9 time = 595
.meas tran vdout1_111ck118 FIND v(dout1_111) AT=595.025n

* CHECK dout1_112 Vdout1_112ck118 = 0 time = 595
.meas tran vdout1_112ck118 FIND v(dout1_112) AT=595.025n

* CHECK dout1_113 Vdout1_113ck118 = 0 time = 595
.meas tran vdout1_113ck118 FIND v(dout1_113) AT=595.025n

* CHECK dout1_114 Vdout1_114ck118 = 0 time = 595
.meas tran vdout1_114ck118 FIND v(dout1_114) AT=595.025n

* CHECK dout1_115 Vdout1_115ck118 = 0.9 time = 595
.meas tran vdout1_115ck118 FIND v(dout1_115) AT=595.025n

* CHECK dout1_116 Vdout1_116ck118 = 0 time = 595
.meas tran vdout1_116ck118 FIND v(dout1_116) AT=595.025n

* CHECK dout1_117 Vdout1_117ck118 = 0.9 time = 595
.meas tran vdout1_117ck118 FIND v(dout1_117) AT=595.025n

* CHECK dout1_118 Vdout1_118ck118 = 0 time = 595
.meas tran vdout1_118ck118 FIND v(dout1_118) AT=595.025n

* CHECK dout1_119 Vdout1_119ck118 = 0.9 time = 595
.meas tran vdout1_119ck118 FIND v(dout1_119) AT=595.025n

* CHECK dout1_0 Vdout1_0ck127 = 0.9 time = 640
.meas tran vdout1_0ck127 FIND v(dout1_0) AT=640.025n

* CHECK dout1_1 Vdout1_1ck127 = 0.9 time = 640
.meas tran vdout1_1ck127 FIND v(dout1_1) AT=640.025n

* CHECK dout1_2 Vdout1_2ck127 = 0 time = 640
.meas tran vdout1_2ck127 FIND v(dout1_2) AT=640.025n

* CHECK dout1_3 Vdout1_3ck127 = 0 time = 640
.meas tran vdout1_3ck127 FIND v(dout1_3) AT=640.025n

* CHECK dout1_4 Vdout1_4ck127 = 0 time = 640
.meas tran vdout1_4ck127 FIND v(dout1_4) AT=640.025n

* CHECK dout1_5 Vdout1_5ck127 = 0 time = 640
.meas tran vdout1_5ck127 FIND v(dout1_5) AT=640.025n

* CHECK dout1_6 Vdout1_6ck127 = 0 time = 640
.meas tran vdout1_6ck127 FIND v(dout1_6) AT=640.025n

* CHECK dout1_7 Vdout1_7ck127 = 0 time = 640
.meas tran vdout1_7ck127 FIND v(dout1_7) AT=640.025n

* CHECK dout1_8 Vdout1_8ck127 = 0 time = 640
.meas tran vdout1_8ck127 FIND v(dout1_8) AT=640.025n

* CHECK dout1_9 Vdout1_9ck127 = 0 time = 640
.meas tran vdout1_9ck127 FIND v(dout1_9) AT=640.025n

* CHECK dout1_10 Vdout1_10ck127 = 0.9 time = 640
.meas tran vdout1_10ck127 FIND v(dout1_10) AT=640.025n

* CHECK dout1_11 Vdout1_11ck127 = 0 time = 640
.meas tran vdout1_11ck127 FIND v(dout1_11) AT=640.025n

* CHECK dout1_12 Vdout1_12ck127 = 0 time = 640
.meas tran vdout1_12ck127 FIND v(dout1_12) AT=640.025n

* CHECK dout1_13 Vdout1_13ck127 = 0 time = 640
.meas tran vdout1_13ck127 FIND v(dout1_13) AT=640.025n

* CHECK dout1_14 Vdout1_14ck127 = 0.9 time = 640
.meas tran vdout1_14ck127 FIND v(dout1_14) AT=640.025n

* CHECK dout1_15 Vdout1_15ck127 = 0 time = 640
.meas tran vdout1_15ck127 FIND v(dout1_15) AT=640.025n

* CHECK dout1_16 Vdout1_16ck127 = 0.9 time = 640
.meas tran vdout1_16ck127 FIND v(dout1_16) AT=640.025n

* CHECK dout1_17 Vdout1_17ck127 = 0.9 time = 640
.meas tran vdout1_17ck127 FIND v(dout1_17) AT=640.025n

* CHECK dout1_18 Vdout1_18ck127 = 0.9 time = 640
.meas tran vdout1_18ck127 FIND v(dout1_18) AT=640.025n

* CHECK dout1_19 Vdout1_19ck127 = 0.9 time = 640
.meas tran vdout1_19ck127 FIND v(dout1_19) AT=640.025n

* CHECK dout1_20 Vdout1_20ck127 = 0 time = 640
.meas tran vdout1_20ck127 FIND v(dout1_20) AT=640.025n

* CHECK dout1_21 Vdout1_21ck127 = 0.9 time = 640
.meas tran vdout1_21ck127 FIND v(dout1_21) AT=640.025n

* CHECK dout1_22 Vdout1_22ck127 = 0 time = 640
.meas tran vdout1_22ck127 FIND v(dout1_22) AT=640.025n

* CHECK dout1_23 Vdout1_23ck127 = 0.9 time = 640
.meas tran vdout1_23ck127 FIND v(dout1_23) AT=640.025n

* CHECK dout1_24 Vdout1_24ck127 = 0 time = 640
.meas tran vdout1_24ck127 FIND v(dout1_24) AT=640.025n

* CHECK dout1_25 Vdout1_25ck127 = 0 time = 640
.meas tran vdout1_25ck127 FIND v(dout1_25) AT=640.025n

* CHECK dout1_26 Vdout1_26ck127 = 0 time = 640
.meas tran vdout1_26ck127 FIND v(dout1_26) AT=640.025n

* CHECK dout1_27 Vdout1_27ck127 = 0.9 time = 640
.meas tran vdout1_27ck127 FIND v(dout1_27) AT=640.025n

* CHECK dout1_28 Vdout1_28ck127 = 0.9 time = 640
.meas tran vdout1_28ck127 FIND v(dout1_28) AT=640.025n

* CHECK dout1_29 Vdout1_29ck127 = 0 time = 640
.meas tran vdout1_29ck127 FIND v(dout1_29) AT=640.025n

* CHECK dout1_30 Vdout1_30ck127 = 0 time = 640
.meas tran vdout1_30ck127 FIND v(dout1_30) AT=640.025n

* CHECK dout1_31 Vdout1_31ck127 = 0 time = 640
.meas tran vdout1_31ck127 FIND v(dout1_31) AT=640.025n

* CHECK dout1_32 Vdout1_32ck127 = 0.9 time = 640
.meas tran vdout1_32ck127 FIND v(dout1_32) AT=640.025n

* CHECK dout1_33 Vdout1_33ck127 = 0 time = 640
.meas tran vdout1_33ck127 FIND v(dout1_33) AT=640.025n

* CHECK dout1_34 Vdout1_34ck127 = 0.9 time = 640
.meas tran vdout1_34ck127 FIND v(dout1_34) AT=640.025n

* CHECK dout1_35 Vdout1_35ck127 = 0.9 time = 640
.meas tran vdout1_35ck127 FIND v(dout1_35) AT=640.025n

* CHECK dout1_36 Vdout1_36ck127 = 0 time = 640
.meas tran vdout1_36ck127 FIND v(dout1_36) AT=640.025n

* CHECK dout1_37 Vdout1_37ck127 = 0.9 time = 640
.meas tran vdout1_37ck127 FIND v(dout1_37) AT=640.025n

* CHECK dout1_38 Vdout1_38ck127 = 0.9 time = 640
.meas tran vdout1_38ck127 FIND v(dout1_38) AT=640.025n

* CHECK dout1_39 Vdout1_39ck127 = 0 time = 640
.meas tran vdout1_39ck127 FIND v(dout1_39) AT=640.025n

* CHECK dout1_40 Vdout1_40ck127 = 0.9 time = 640
.meas tran vdout1_40ck127 FIND v(dout1_40) AT=640.025n

* CHECK dout1_41 Vdout1_41ck127 = 0 time = 640
.meas tran vdout1_41ck127 FIND v(dout1_41) AT=640.025n

* CHECK dout1_42 Vdout1_42ck127 = 0.9 time = 640
.meas tran vdout1_42ck127 FIND v(dout1_42) AT=640.025n

* CHECK dout1_43 Vdout1_43ck127 = 0.9 time = 640
.meas tran vdout1_43ck127 FIND v(dout1_43) AT=640.025n

* CHECK dout1_44 Vdout1_44ck127 = 0 time = 640
.meas tran vdout1_44ck127 FIND v(dout1_44) AT=640.025n

* CHECK dout1_45 Vdout1_45ck127 = 0.9 time = 640
.meas tran vdout1_45ck127 FIND v(dout1_45) AT=640.025n

* CHECK dout1_46 Vdout1_46ck127 = 0.9 time = 640
.meas tran vdout1_46ck127 FIND v(dout1_46) AT=640.025n

* CHECK dout1_47 Vdout1_47ck127 = 0 time = 640
.meas tran vdout1_47ck127 FIND v(dout1_47) AT=640.025n

* CHECK dout1_48 Vdout1_48ck127 = 0.9 time = 640
.meas tran vdout1_48ck127 FIND v(dout1_48) AT=640.025n

* CHECK dout1_49 Vdout1_49ck127 = 0 time = 640
.meas tran vdout1_49ck127 FIND v(dout1_49) AT=640.025n

* CHECK dout1_50 Vdout1_50ck127 = 0 time = 640
.meas tran vdout1_50ck127 FIND v(dout1_50) AT=640.025n

* CHECK dout1_51 Vdout1_51ck127 = 0 time = 640
.meas tran vdout1_51ck127 FIND v(dout1_51) AT=640.025n

* CHECK dout1_52 Vdout1_52ck127 = 0.9 time = 640
.meas tran vdout1_52ck127 FIND v(dout1_52) AT=640.025n

* CHECK dout1_53 Vdout1_53ck127 = 0 time = 640
.meas tran vdout1_53ck127 FIND v(dout1_53) AT=640.025n

* CHECK dout1_54 Vdout1_54ck127 = 0 time = 640
.meas tran vdout1_54ck127 FIND v(dout1_54) AT=640.025n

* CHECK dout1_55 Vdout1_55ck127 = 0.9 time = 640
.meas tran vdout1_55ck127 FIND v(dout1_55) AT=640.025n

* CHECK dout1_56 Vdout1_56ck127 = 0.9 time = 640
.meas tran vdout1_56ck127 FIND v(dout1_56) AT=640.025n

* CHECK dout1_57 Vdout1_57ck127 = 0 time = 640
.meas tran vdout1_57ck127 FIND v(dout1_57) AT=640.025n

* CHECK dout1_58 Vdout1_58ck127 = 0 time = 640
.meas tran vdout1_58ck127 FIND v(dout1_58) AT=640.025n

* CHECK dout1_59 Vdout1_59ck127 = 0 time = 640
.meas tran vdout1_59ck127 FIND v(dout1_59) AT=640.025n

* CHECK dout1_60 Vdout1_60ck127 = 0.9 time = 640
.meas tran vdout1_60ck127 FIND v(dout1_60) AT=640.025n

* CHECK dout1_61 Vdout1_61ck127 = 0 time = 640
.meas tran vdout1_61ck127 FIND v(dout1_61) AT=640.025n

* CHECK dout1_62 Vdout1_62ck127 = 0.9 time = 640
.meas tran vdout1_62ck127 FIND v(dout1_62) AT=640.025n

* CHECK dout1_63 Vdout1_63ck127 = 0.9 time = 640
.meas tran vdout1_63ck127 FIND v(dout1_63) AT=640.025n

* CHECK dout1_64 Vdout1_64ck127 = 0 time = 640
.meas tran vdout1_64ck127 FIND v(dout1_64) AT=640.025n

* CHECK dout1_65 Vdout1_65ck127 = 0 time = 640
.meas tran vdout1_65ck127 FIND v(dout1_65) AT=640.025n

* CHECK dout1_66 Vdout1_66ck127 = 0.9 time = 640
.meas tran vdout1_66ck127 FIND v(dout1_66) AT=640.025n

* CHECK dout1_67 Vdout1_67ck127 = 0.9 time = 640
.meas tran vdout1_67ck127 FIND v(dout1_67) AT=640.025n

* CHECK dout1_68 Vdout1_68ck127 = 0.9 time = 640
.meas tran vdout1_68ck127 FIND v(dout1_68) AT=640.025n

* CHECK dout1_69 Vdout1_69ck127 = 0 time = 640
.meas tran vdout1_69ck127 FIND v(dout1_69) AT=640.025n

* CHECK dout1_70 Vdout1_70ck127 = 0.9 time = 640
.meas tran vdout1_70ck127 FIND v(dout1_70) AT=640.025n

* CHECK dout1_71 Vdout1_71ck127 = 0.9 time = 640
.meas tran vdout1_71ck127 FIND v(dout1_71) AT=640.025n

* CHECK dout1_72 Vdout1_72ck127 = 0.9 time = 640
.meas tran vdout1_72ck127 FIND v(dout1_72) AT=640.025n

* CHECK dout1_73 Vdout1_73ck127 = 0 time = 640
.meas tran vdout1_73ck127 FIND v(dout1_73) AT=640.025n

* CHECK dout1_74 Vdout1_74ck127 = 0 time = 640
.meas tran vdout1_74ck127 FIND v(dout1_74) AT=640.025n

* CHECK dout1_75 Vdout1_75ck127 = 0 time = 640
.meas tran vdout1_75ck127 FIND v(dout1_75) AT=640.025n

* CHECK dout1_76 Vdout1_76ck127 = 0 time = 640
.meas tran vdout1_76ck127 FIND v(dout1_76) AT=640.025n

* CHECK dout1_77 Vdout1_77ck127 = 0 time = 640
.meas tran vdout1_77ck127 FIND v(dout1_77) AT=640.025n

* CHECK dout1_78 Vdout1_78ck127 = 0 time = 640
.meas tran vdout1_78ck127 FIND v(dout1_78) AT=640.025n

* CHECK dout1_79 Vdout1_79ck127 = 0.9 time = 640
.meas tran vdout1_79ck127 FIND v(dout1_79) AT=640.025n

* CHECK dout1_80 Vdout1_80ck127 = 0 time = 640
.meas tran vdout1_80ck127 FIND v(dout1_80) AT=640.025n

* CHECK dout1_81 Vdout1_81ck127 = 0.9 time = 640
.meas tran vdout1_81ck127 FIND v(dout1_81) AT=640.025n

* CHECK dout1_82 Vdout1_82ck127 = 0.9 time = 640
.meas tran vdout1_82ck127 FIND v(dout1_82) AT=640.025n

* CHECK dout1_83 Vdout1_83ck127 = 0 time = 640
.meas tran vdout1_83ck127 FIND v(dout1_83) AT=640.025n

* CHECK dout1_84 Vdout1_84ck127 = 0.9 time = 640
.meas tran vdout1_84ck127 FIND v(dout1_84) AT=640.025n

* CHECK dout1_85 Vdout1_85ck127 = 0.9 time = 640
.meas tran vdout1_85ck127 FIND v(dout1_85) AT=640.025n

* CHECK dout1_86 Vdout1_86ck127 = 0 time = 640
.meas tran vdout1_86ck127 FIND v(dout1_86) AT=640.025n

* CHECK dout1_87 Vdout1_87ck127 = 0 time = 640
.meas tran vdout1_87ck127 FIND v(dout1_87) AT=640.025n

* CHECK dout1_88 Vdout1_88ck127 = 0 time = 640
.meas tran vdout1_88ck127 FIND v(dout1_88) AT=640.025n

* CHECK dout1_89 Vdout1_89ck127 = 0.9 time = 640
.meas tran vdout1_89ck127 FIND v(dout1_89) AT=640.025n

* CHECK dout1_90 Vdout1_90ck127 = 0 time = 640
.meas tran vdout1_90ck127 FIND v(dout1_90) AT=640.025n

* CHECK dout1_91 Vdout1_91ck127 = 0 time = 640
.meas tran vdout1_91ck127 FIND v(dout1_91) AT=640.025n

* CHECK dout1_92 Vdout1_92ck127 = 0 time = 640
.meas tran vdout1_92ck127 FIND v(dout1_92) AT=640.025n

* CHECK dout1_93 Vdout1_93ck127 = 0.9 time = 640
.meas tran vdout1_93ck127 FIND v(dout1_93) AT=640.025n

* CHECK dout1_94 Vdout1_94ck127 = 0 time = 640
.meas tran vdout1_94ck127 FIND v(dout1_94) AT=640.025n

* CHECK dout1_95 Vdout1_95ck127 = 0.9 time = 640
.meas tran vdout1_95ck127 FIND v(dout1_95) AT=640.025n

* CHECK dout1_96 Vdout1_96ck127 = 0.9 time = 640
.meas tran vdout1_96ck127 FIND v(dout1_96) AT=640.025n

* CHECK dout1_97 Vdout1_97ck127 = 0.9 time = 640
.meas tran vdout1_97ck127 FIND v(dout1_97) AT=640.025n

* CHECK dout1_98 Vdout1_98ck127 = 0 time = 640
.meas tran vdout1_98ck127 FIND v(dout1_98) AT=640.025n

* CHECK dout1_99 Vdout1_99ck127 = 0 time = 640
.meas tran vdout1_99ck127 FIND v(dout1_99) AT=640.025n

* CHECK dout1_100 Vdout1_100ck127 = 0.9 time = 640
.meas tran vdout1_100ck127 FIND v(dout1_100) AT=640.025n

* CHECK dout1_101 Vdout1_101ck127 = 0 time = 640
.meas tran vdout1_101ck127 FIND v(dout1_101) AT=640.025n

* CHECK dout1_102 Vdout1_102ck127 = 0 time = 640
.meas tran vdout1_102ck127 FIND v(dout1_102) AT=640.025n

* CHECK dout1_103 Vdout1_103ck127 = 0.9 time = 640
.meas tran vdout1_103ck127 FIND v(dout1_103) AT=640.025n

* CHECK dout1_104 Vdout1_104ck127 = 0.9 time = 640
.meas tran vdout1_104ck127 FIND v(dout1_104) AT=640.025n

* CHECK dout1_105 Vdout1_105ck127 = 0.9 time = 640
.meas tran vdout1_105ck127 FIND v(dout1_105) AT=640.025n

* CHECK dout1_106 Vdout1_106ck127 = 0.9 time = 640
.meas tran vdout1_106ck127 FIND v(dout1_106) AT=640.025n

* CHECK dout1_107 Vdout1_107ck127 = 0 time = 640
.meas tran vdout1_107ck127 FIND v(dout1_107) AT=640.025n

* CHECK dout1_108 Vdout1_108ck127 = 0 time = 640
.meas tran vdout1_108ck127 FIND v(dout1_108) AT=640.025n

* CHECK dout1_109 Vdout1_109ck127 = 0 time = 640
.meas tran vdout1_109ck127 FIND v(dout1_109) AT=640.025n

* CHECK dout1_110 Vdout1_110ck127 = 0.9 time = 640
.meas tran vdout1_110ck127 FIND v(dout1_110) AT=640.025n

* CHECK dout1_111 Vdout1_111ck127 = 0.9 time = 640
.meas tran vdout1_111ck127 FIND v(dout1_111) AT=640.025n

* CHECK dout1_112 Vdout1_112ck127 = 0 time = 640
.meas tran vdout1_112ck127 FIND v(dout1_112) AT=640.025n

* CHECK dout1_113 Vdout1_113ck127 = 0.9 time = 640
.meas tran vdout1_113ck127 FIND v(dout1_113) AT=640.025n

* CHECK dout1_114 Vdout1_114ck127 = 0 time = 640
.meas tran vdout1_114ck127 FIND v(dout1_114) AT=640.025n

* CHECK dout1_115 Vdout1_115ck127 = 0.9 time = 640
.meas tran vdout1_115ck127 FIND v(dout1_115) AT=640.025n

* CHECK dout1_116 Vdout1_116ck127 = 0 time = 640
.meas tran vdout1_116ck127 FIND v(dout1_116) AT=640.025n

* CHECK dout1_117 Vdout1_117ck127 = 0.9 time = 640
.meas tran vdout1_117ck127 FIND v(dout1_117) AT=640.025n

* CHECK dout1_118 Vdout1_118ck127 = 0.9 time = 640
.meas tran vdout1_118ck127 FIND v(dout1_118) AT=640.025n

* CHECK dout1_119 Vdout1_119ck127 = 0 time = 640
.meas tran vdout1_119ck127 FIND v(dout1_119) AT=640.025n

* CHECK dout1_0 Vdout1_0ck128 = 0.9 time = 645
.meas tran vdout1_0ck128 FIND v(dout1_0) AT=645.025n

* CHECK dout1_1 Vdout1_1ck128 = 0.9 time = 645
.meas tran vdout1_1ck128 FIND v(dout1_1) AT=645.025n

* CHECK dout1_2 Vdout1_2ck128 = 0 time = 645
.meas tran vdout1_2ck128 FIND v(dout1_2) AT=645.025n

* CHECK dout1_3 Vdout1_3ck128 = 0 time = 645
.meas tran vdout1_3ck128 FIND v(dout1_3) AT=645.025n

* CHECK dout1_4 Vdout1_4ck128 = 0 time = 645
.meas tran vdout1_4ck128 FIND v(dout1_4) AT=645.025n

* CHECK dout1_5 Vdout1_5ck128 = 0 time = 645
.meas tran vdout1_5ck128 FIND v(dout1_5) AT=645.025n

* CHECK dout1_6 Vdout1_6ck128 = 0 time = 645
.meas tran vdout1_6ck128 FIND v(dout1_6) AT=645.025n

* CHECK dout1_7 Vdout1_7ck128 = 0 time = 645
.meas tran vdout1_7ck128 FIND v(dout1_7) AT=645.025n

* CHECK dout1_8 Vdout1_8ck128 = 0 time = 645
.meas tran vdout1_8ck128 FIND v(dout1_8) AT=645.025n

* CHECK dout1_9 Vdout1_9ck128 = 0 time = 645
.meas tran vdout1_9ck128 FIND v(dout1_9) AT=645.025n

* CHECK dout1_10 Vdout1_10ck128 = 0.9 time = 645
.meas tran vdout1_10ck128 FIND v(dout1_10) AT=645.025n

* CHECK dout1_11 Vdout1_11ck128 = 0 time = 645
.meas tran vdout1_11ck128 FIND v(dout1_11) AT=645.025n

* CHECK dout1_12 Vdout1_12ck128 = 0 time = 645
.meas tran vdout1_12ck128 FIND v(dout1_12) AT=645.025n

* CHECK dout1_13 Vdout1_13ck128 = 0 time = 645
.meas tran vdout1_13ck128 FIND v(dout1_13) AT=645.025n

* CHECK dout1_14 Vdout1_14ck128 = 0.9 time = 645
.meas tran vdout1_14ck128 FIND v(dout1_14) AT=645.025n

* CHECK dout1_15 Vdout1_15ck128 = 0 time = 645
.meas tran vdout1_15ck128 FIND v(dout1_15) AT=645.025n

* CHECK dout1_16 Vdout1_16ck128 = 0.9 time = 645
.meas tran vdout1_16ck128 FIND v(dout1_16) AT=645.025n

* CHECK dout1_17 Vdout1_17ck128 = 0.9 time = 645
.meas tran vdout1_17ck128 FIND v(dout1_17) AT=645.025n

* CHECK dout1_18 Vdout1_18ck128 = 0.9 time = 645
.meas tran vdout1_18ck128 FIND v(dout1_18) AT=645.025n

* CHECK dout1_19 Vdout1_19ck128 = 0.9 time = 645
.meas tran vdout1_19ck128 FIND v(dout1_19) AT=645.025n

* CHECK dout1_20 Vdout1_20ck128 = 0 time = 645
.meas tran vdout1_20ck128 FIND v(dout1_20) AT=645.025n

* CHECK dout1_21 Vdout1_21ck128 = 0.9 time = 645
.meas tran vdout1_21ck128 FIND v(dout1_21) AT=645.025n

* CHECK dout1_22 Vdout1_22ck128 = 0 time = 645
.meas tran vdout1_22ck128 FIND v(dout1_22) AT=645.025n

* CHECK dout1_23 Vdout1_23ck128 = 0.9 time = 645
.meas tran vdout1_23ck128 FIND v(dout1_23) AT=645.025n

* CHECK dout1_24 Vdout1_24ck128 = 0 time = 645
.meas tran vdout1_24ck128 FIND v(dout1_24) AT=645.025n

* CHECK dout1_25 Vdout1_25ck128 = 0 time = 645
.meas tran vdout1_25ck128 FIND v(dout1_25) AT=645.025n

* CHECK dout1_26 Vdout1_26ck128 = 0 time = 645
.meas tran vdout1_26ck128 FIND v(dout1_26) AT=645.025n

* CHECK dout1_27 Vdout1_27ck128 = 0.9 time = 645
.meas tran vdout1_27ck128 FIND v(dout1_27) AT=645.025n

* CHECK dout1_28 Vdout1_28ck128 = 0.9 time = 645
.meas tran vdout1_28ck128 FIND v(dout1_28) AT=645.025n

* CHECK dout1_29 Vdout1_29ck128 = 0 time = 645
.meas tran vdout1_29ck128 FIND v(dout1_29) AT=645.025n

* CHECK dout1_30 Vdout1_30ck128 = 0 time = 645
.meas tran vdout1_30ck128 FIND v(dout1_30) AT=645.025n

* CHECK dout1_31 Vdout1_31ck128 = 0 time = 645
.meas tran vdout1_31ck128 FIND v(dout1_31) AT=645.025n

* CHECK dout1_32 Vdout1_32ck128 = 0.9 time = 645
.meas tran vdout1_32ck128 FIND v(dout1_32) AT=645.025n

* CHECK dout1_33 Vdout1_33ck128 = 0 time = 645
.meas tran vdout1_33ck128 FIND v(dout1_33) AT=645.025n

* CHECK dout1_34 Vdout1_34ck128 = 0.9 time = 645
.meas tran vdout1_34ck128 FIND v(dout1_34) AT=645.025n

* CHECK dout1_35 Vdout1_35ck128 = 0.9 time = 645
.meas tran vdout1_35ck128 FIND v(dout1_35) AT=645.025n

* CHECK dout1_36 Vdout1_36ck128 = 0 time = 645
.meas tran vdout1_36ck128 FIND v(dout1_36) AT=645.025n

* CHECK dout1_37 Vdout1_37ck128 = 0.9 time = 645
.meas tran vdout1_37ck128 FIND v(dout1_37) AT=645.025n

* CHECK dout1_38 Vdout1_38ck128 = 0.9 time = 645
.meas tran vdout1_38ck128 FIND v(dout1_38) AT=645.025n

* CHECK dout1_39 Vdout1_39ck128 = 0 time = 645
.meas tran vdout1_39ck128 FIND v(dout1_39) AT=645.025n

* CHECK dout1_40 Vdout1_40ck128 = 0.9 time = 645
.meas tran vdout1_40ck128 FIND v(dout1_40) AT=645.025n

* CHECK dout1_41 Vdout1_41ck128 = 0 time = 645
.meas tran vdout1_41ck128 FIND v(dout1_41) AT=645.025n

* CHECK dout1_42 Vdout1_42ck128 = 0.9 time = 645
.meas tran vdout1_42ck128 FIND v(dout1_42) AT=645.025n

* CHECK dout1_43 Vdout1_43ck128 = 0.9 time = 645
.meas tran vdout1_43ck128 FIND v(dout1_43) AT=645.025n

* CHECK dout1_44 Vdout1_44ck128 = 0 time = 645
.meas tran vdout1_44ck128 FIND v(dout1_44) AT=645.025n

* CHECK dout1_45 Vdout1_45ck128 = 0.9 time = 645
.meas tran vdout1_45ck128 FIND v(dout1_45) AT=645.025n

* CHECK dout1_46 Vdout1_46ck128 = 0.9 time = 645
.meas tran vdout1_46ck128 FIND v(dout1_46) AT=645.025n

* CHECK dout1_47 Vdout1_47ck128 = 0 time = 645
.meas tran vdout1_47ck128 FIND v(dout1_47) AT=645.025n

* CHECK dout1_48 Vdout1_48ck128 = 0.9 time = 645
.meas tran vdout1_48ck128 FIND v(dout1_48) AT=645.025n

* CHECK dout1_49 Vdout1_49ck128 = 0 time = 645
.meas tran vdout1_49ck128 FIND v(dout1_49) AT=645.025n

* CHECK dout1_50 Vdout1_50ck128 = 0 time = 645
.meas tran vdout1_50ck128 FIND v(dout1_50) AT=645.025n

* CHECK dout1_51 Vdout1_51ck128 = 0 time = 645
.meas tran vdout1_51ck128 FIND v(dout1_51) AT=645.025n

* CHECK dout1_52 Vdout1_52ck128 = 0.9 time = 645
.meas tran vdout1_52ck128 FIND v(dout1_52) AT=645.025n

* CHECK dout1_53 Vdout1_53ck128 = 0 time = 645
.meas tran vdout1_53ck128 FIND v(dout1_53) AT=645.025n

* CHECK dout1_54 Vdout1_54ck128 = 0 time = 645
.meas tran vdout1_54ck128 FIND v(dout1_54) AT=645.025n

* CHECK dout1_55 Vdout1_55ck128 = 0.9 time = 645
.meas tran vdout1_55ck128 FIND v(dout1_55) AT=645.025n

* CHECK dout1_56 Vdout1_56ck128 = 0.9 time = 645
.meas tran vdout1_56ck128 FIND v(dout1_56) AT=645.025n

* CHECK dout1_57 Vdout1_57ck128 = 0 time = 645
.meas tran vdout1_57ck128 FIND v(dout1_57) AT=645.025n

* CHECK dout1_58 Vdout1_58ck128 = 0 time = 645
.meas tran vdout1_58ck128 FIND v(dout1_58) AT=645.025n

* CHECK dout1_59 Vdout1_59ck128 = 0 time = 645
.meas tran vdout1_59ck128 FIND v(dout1_59) AT=645.025n

* CHECK dout1_60 Vdout1_60ck128 = 0.9 time = 645
.meas tran vdout1_60ck128 FIND v(dout1_60) AT=645.025n

* CHECK dout1_61 Vdout1_61ck128 = 0 time = 645
.meas tran vdout1_61ck128 FIND v(dout1_61) AT=645.025n

* CHECK dout1_62 Vdout1_62ck128 = 0.9 time = 645
.meas tran vdout1_62ck128 FIND v(dout1_62) AT=645.025n

* CHECK dout1_63 Vdout1_63ck128 = 0.9 time = 645
.meas tran vdout1_63ck128 FIND v(dout1_63) AT=645.025n

* CHECK dout1_64 Vdout1_64ck128 = 0 time = 645
.meas tran vdout1_64ck128 FIND v(dout1_64) AT=645.025n

* CHECK dout1_65 Vdout1_65ck128 = 0 time = 645
.meas tran vdout1_65ck128 FIND v(dout1_65) AT=645.025n

* CHECK dout1_66 Vdout1_66ck128 = 0.9 time = 645
.meas tran vdout1_66ck128 FIND v(dout1_66) AT=645.025n

* CHECK dout1_67 Vdout1_67ck128 = 0.9 time = 645
.meas tran vdout1_67ck128 FIND v(dout1_67) AT=645.025n

* CHECK dout1_68 Vdout1_68ck128 = 0.9 time = 645
.meas tran vdout1_68ck128 FIND v(dout1_68) AT=645.025n

* CHECK dout1_69 Vdout1_69ck128 = 0 time = 645
.meas tran vdout1_69ck128 FIND v(dout1_69) AT=645.025n

* CHECK dout1_70 Vdout1_70ck128 = 0.9 time = 645
.meas tran vdout1_70ck128 FIND v(dout1_70) AT=645.025n

* CHECK dout1_71 Vdout1_71ck128 = 0.9 time = 645
.meas tran vdout1_71ck128 FIND v(dout1_71) AT=645.025n

* CHECK dout1_72 Vdout1_72ck128 = 0.9 time = 645
.meas tran vdout1_72ck128 FIND v(dout1_72) AT=645.025n

* CHECK dout1_73 Vdout1_73ck128 = 0 time = 645
.meas tran vdout1_73ck128 FIND v(dout1_73) AT=645.025n

* CHECK dout1_74 Vdout1_74ck128 = 0 time = 645
.meas tran vdout1_74ck128 FIND v(dout1_74) AT=645.025n

* CHECK dout1_75 Vdout1_75ck128 = 0 time = 645
.meas tran vdout1_75ck128 FIND v(dout1_75) AT=645.025n

* CHECK dout1_76 Vdout1_76ck128 = 0 time = 645
.meas tran vdout1_76ck128 FIND v(dout1_76) AT=645.025n

* CHECK dout1_77 Vdout1_77ck128 = 0 time = 645
.meas tran vdout1_77ck128 FIND v(dout1_77) AT=645.025n

* CHECK dout1_78 Vdout1_78ck128 = 0 time = 645
.meas tran vdout1_78ck128 FIND v(dout1_78) AT=645.025n

* CHECK dout1_79 Vdout1_79ck128 = 0.9 time = 645
.meas tran vdout1_79ck128 FIND v(dout1_79) AT=645.025n

* CHECK dout1_80 Vdout1_80ck128 = 0 time = 645
.meas tran vdout1_80ck128 FIND v(dout1_80) AT=645.025n

* CHECK dout1_81 Vdout1_81ck128 = 0.9 time = 645
.meas tran vdout1_81ck128 FIND v(dout1_81) AT=645.025n

* CHECK dout1_82 Vdout1_82ck128 = 0.9 time = 645
.meas tran vdout1_82ck128 FIND v(dout1_82) AT=645.025n

* CHECK dout1_83 Vdout1_83ck128 = 0 time = 645
.meas tran vdout1_83ck128 FIND v(dout1_83) AT=645.025n

* CHECK dout1_84 Vdout1_84ck128 = 0.9 time = 645
.meas tran vdout1_84ck128 FIND v(dout1_84) AT=645.025n

* CHECK dout1_85 Vdout1_85ck128 = 0.9 time = 645
.meas tran vdout1_85ck128 FIND v(dout1_85) AT=645.025n

* CHECK dout1_86 Vdout1_86ck128 = 0 time = 645
.meas tran vdout1_86ck128 FIND v(dout1_86) AT=645.025n

* CHECK dout1_87 Vdout1_87ck128 = 0 time = 645
.meas tran vdout1_87ck128 FIND v(dout1_87) AT=645.025n

* CHECK dout1_88 Vdout1_88ck128 = 0 time = 645
.meas tran vdout1_88ck128 FIND v(dout1_88) AT=645.025n

* CHECK dout1_89 Vdout1_89ck128 = 0.9 time = 645
.meas tran vdout1_89ck128 FIND v(dout1_89) AT=645.025n

* CHECK dout1_90 Vdout1_90ck128 = 0 time = 645
.meas tran vdout1_90ck128 FIND v(dout1_90) AT=645.025n

* CHECK dout1_91 Vdout1_91ck128 = 0 time = 645
.meas tran vdout1_91ck128 FIND v(dout1_91) AT=645.025n

* CHECK dout1_92 Vdout1_92ck128 = 0 time = 645
.meas tran vdout1_92ck128 FIND v(dout1_92) AT=645.025n

* CHECK dout1_93 Vdout1_93ck128 = 0.9 time = 645
.meas tran vdout1_93ck128 FIND v(dout1_93) AT=645.025n

* CHECK dout1_94 Vdout1_94ck128 = 0 time = 645
.meas tran vdout1_94ck128 FIND v(dout1_94) AT=645.025n

* CHECK dout1_95 Vdout1_95ck128 = 0.9 time = 645
.meas tran vdout1_95ck128 FIND v(dout1_95) AT=645.025n

* CHECK dout1_96 Vdout1_96ck128 = 0.9 time = 645
.meas tran vdout1_96ck128 FIND v(dout1_96) AT=645.025n

* CHECK dout1_97 Vdout1_97ck128 = 0.9 time = 645
.meas tran vdout1_97ck128 FIND v(dout1_97) AT=645.025n

* CHECK dout1_98 Vdout1_98ck128 = 0 time = 645
.meas tran vdout1_98ck128 FIND v(dout1_98) AT=645.025n

* CHECK dout1_99 Vdout1_99ck128 = 0 time = 645
.meas tran vdout1_99ck128 FIND v(dout1_99) AT=645.025n

* CHECK dout1_100 Vdout1_100ck128 = 0.9 time = 645
.meas tran vdout1_100ck128 FIND v(dout1_100) AT=645.025n

* CHECK dout1_101 Vdout1_101ck128 = 0 time = 645
.meas tran vdout1_101ck128 FIND v(dout1_101) AT=645.025n

* CHECK dout1_102 Vdout1_102ck128 = 0 time = 645
.meas tran vdout1_102ck128 FIND v(dout1_102) AT=645.025n

* CHECK dout1_103 Vdout1_103ck128 = 0.9 time = 645
.meas tran vdout1_103ck128 FIND v(dout1_103) AT=645.025n

* CHECK dout1_104 Vdout1_104ck128 = 0.9 time = 645
.meas tran vdout1_104ck128 FIND v(dout1_104) AT=645.025n

* CHECK dout1_105 Vdout1_105ck128 = 0.9 time = 645
.meas tran vdout1_105ck128 FIND v(dout1_105) AT=645.025n

* CHECK dout1_106 Vdout1_106ck128 = 0.9 time = 645
.meas tran vdout1_106ck128 FIND v(dout1_106) AT=645.025n

* CHECK dout1_107 Vdout1_107ck128 = 0 time = 645
.meas tran vdout1_107ck128 FIND v(dout1_107) AT=645.025n

* CHECK dout1_108 Vdout1_108ck128 = 0 time = 645
.meas tran vdout1_108ck128 FIND v(dout1_108) AT=645.025n

* CHECK dout1_109 Vdout1_109ck128 = 0 time = 645
.meas tran vdout1_109ck128 FIND v(dout1_109) AT=645.025n

* CHECK dout1_110 Vdout1_110ck128 = 0.9 time = 645
.meas tran vdout1_110ck128 FIND v(dout1_110) AT=645.025n

* CHECK dout1_111 Vdout1_111ck128 = 0.9 time = 645
.meas tran vdout1_111ck128 FIND v(dout1_111) AT=645.025n

* CHECK dout1_112 Vdout1_112ck128 = 0 time = 645
.meas tran vdout1_112ck128 FIND v(dout1_112) AT=645.025n

* CHECK dout1_113 Vdout1_113ck128 = 0.9 time = 645
.meas tran vdout1_113ck128 FIND v(dout1_113) AT=645.025n

* CHECK dout1_114 Vdout1_114ck128 = 0 time = 645
.meas tran vdout1_114ck128 FIND v(dout1_114) AT=645.025n

* CHECK dout1_115 Vdout1_115ck128 = 0.9 time = 645
.meas tran vdout1_115ck128 FIND v(dout1_115) AT=645.025n

* CHECK dout1_116 Vdout1_116ck128 = 0 time = 645
.meas tran vdout1_116ck128 FIND v(dout1_116) AT=645.025n

* CHECK dout1_117 Vdout1_117ck128 = 0.9 time = 645
.meas tran vdout1_117ck128 FIND v(dout1_117) AT=645.025n

* CHECK dout1_118 Vdout1_118ck128 = 0.9 time = 645
.meas tran vdout1_118ck128 FIND v(dout1_118) AT=645.025n

* CHECK dout1_119 Vdout1_119ck128 = 0 time = 645
.meas tran vdout1_119ck128 FIND v(dout1_119) AT=645.025n

* CHECK dout1_0 Vdout1_0ck131 = 0 time = 660
.meas tran vdout1_0ck131 FIND v(dout1_0) AT=660.025n

* CHECK dout1_1 Vdout1_1ck131 = 0.9 time = 660
.meas tran vdout1_1ck131 FIND v(dout1_1) AT=660.025n

* CHECK dout1_2 Vdout1_2ck131 = 0 time = 660
.meas tran vdout1_2ck131 FIND v(dout1_2) AT=660.025n

* CHECK dout1_3 Vdout1_3ck131 = 0 time = 660
.meas tran vdout1_3ck131 FIND v(dout1_3) AT=660.025n

* CHECK dout1_4 Vdout1_4ck131 = 0.9 time = 660
.meas tran vdout1_4ck131 FIND v(dout1_4) AT=660.025n

* CHECK dout1_5 Vdout1_5ck131 = 0.9 time = 660
.meas tran vdout1_5ck131 FIND v(dout1_5) AT=660.025n

* CHECK dout1_6 Vdout1_6ck131 = 0 time = 660
.meas tran vdout1_6ck131 FIND v(dout1_6) AT=660.025n

* CHECK dout1_7 Vdout1_7ck131 = 0.9 time = 660
.meas tran vdout1_7ck131 FIND v(dout1_7) AT=660.025n

* CHECK dout1_8 Vdout1_8ck131 = 0.9 time = 660
.meas tran vdout1_8ck131 FIND v(dout1_8) AT=660.025n

* CHECK dout1_9 Vdout1_9ck131 = 0 time = 660
.meas tran vdout1_9ck131 FIND v(dout1_9) AT=660.025n

* CHECK dout1_10 Vdout1_10ck131 = 0.9 time = 660
.meas tran vdout1_10ck131 FIND v(dout1_10) AT=660.025n

* CHECK dout1_11 Vdout1_11ck131 = 0.9 time = 660
.meas tran vdout1_11ck131 FIND v(dout1_11) AT=660.025n

* CHECK dout1_12 Vdout1_12ck131 = 0.9 time = 660
.meas tran vdout1_12ck131 FIND v(dout1_12) AT=660.025n

* CHECK dout1_13 Vdout1_13ck131 = 0.9 time = 660
.meas tran vdout1_13ck131 FIND v(dout1_13) AT=660.025n

* CHECK dout1_14 Vdout1_14ck131 = 0.9 time = 660
.meas tran vdout1_14ck131 FIND v(dout1_14) AT=660.025n

* CHECK dout1_15 Vdout1_15ck131 = 0.9 time = 660
.meas tran vdout1_15ck131 FIND v(dout1_15) AT=660.025n

* CHECK dout1_16 Vdout1_16ck131 = 0 time = 660
.meas tran vdout1_16ck131 FIND v(dout1_16) AT=660.025n

* CHECK dout1_17 Vdout1_17ck131 = 0.9 time = 660
.meas tran vdout1_17ck131 FIND v(dout1_17) AT=660.025n

* CHECK dout1_18 Vdout1_18ck131 = 0 time = 660
.meas tran vdout1_18ck131 FIND v(dout1_18) AT=660.025n

* CHECK dout1_19 Vdout1_19ck131 = 0 time = 660
.meas tran vdout1_19ck131 FIND v(dout1_19) AT=660.025n

* CHECK dout1_20 Vdout1_20ck131 = 0 time = 660
.meas tran vdout1_20ck131 FIND v(dout1_20) AT=660.025n

* CHECK dout1_21 Vdout1_21ck131 = 0.9 time = 660
.meas tran vdout1_21ck131 FIND v(dout1_21) AT=660.025n

* CHECK dout1_22 Vdout1_22ck131 = 0.9 time = 660
.meas tran vdout1_22ck131 FIND v(dout1_22) AT=660.025n

* CHECK dout1_23 Vdout1_23ck131 = 0 time = 660
.meas tran vdout1_23ck131 FIND v(dout1_23) AT=660.025n

* CHECK dout1_24 Vdout1_24ck131 = 0.9 time = 660
.meas tran vdout1_24ck131 FIND v(dout1_24) AT=660.025n

* CHECK dout1_25 Vdout1_25ck131 = 0 time = 660
.meas tran vdout1_25ck131 FIND v(dout1_25) AT=660.025n

* CHECK dout1_26 Vdout1_26ck131 = 0 time = 660
.meas tran vdout1_26ck131 FIND v(dout1_26) AT=660.025n

* CHECK dout1_27 Vdout1_27ck131 = 0.9 time = 660
.meas tran vdout1_27ck131 FIND v(dout1_27) AT=660.025n

* CHECK dout1_28 Vdout1_28ck131 = 0.9 time = 660
.meas tran vdout1_28ck131 FIND v(dout1_28) AT=660.025n

* CHECK dout1_29 Vdout1_29ck131 = 0.9 time = 660
.meas tran vdout1_29ck131 FIND v(dout1_29) AT=660.025n

* CHECK dout1_30 Vdout1_30ck131 = 0 time = 660
.meas tran vdout1_30ck131 FIND v(dout1_30) AT=660.025n

* CHECK dout1_31 Vdout1_31ck131 = 0 time = 660
.meas tran vdout1_31ck131 FIND v(dout1_31) AT=660.025n

* CHECK dout1_32 Vdout1_32ck131 = 0.9 time = 660
.meas tran vdout1_32ck131 FIND v(dout1_32) AT=660.025n

* CHECK dout1_33 Vdout1_33ck131 = 0 time = 660
.meas tran vdout1_33ck131 FIND v(dout1_33) AT=660.025n

* CHECK dout1_34 Vdout1_34ck131 = 0.9 time = 660
.meas tran vdout1_34ck131 FIND v(dout1_34) AT=660.025n

* CHECK dout1_35 Vdout1_35ck131 = 0.9 time = 660
.meas tran vdout1_35ck131 FIND v(dout1_35) AT=660.025n

* CHECK dout1_36 Vdout1_36ck131 = 0.9 time = 660
.meas tran vdout1_36ck131 FIND v(dout1_36) AT=660.025n

* CHECK dout1_37 Vdout1_37ck131 = 0 time = 660
.meas tran vdout1_37ck131 FIND v(dout1_37) AT=660.025n

* CHECK dout1_38 Vdout1_38ck131 = 0 time = 660
.meas tran vdout1_38ck131 FIND v(dout1_38) AT=660.025n

* CHECK dout1_39 Vdout1_39ck131 = 0 time = 660
.meas tran vdout1_39ck131 FIND v(dout1_39) AT=660.025n

* CHECK dout1_40 Vdout1_40ck131 = 0.9 time = 660
.meas tran vdout1_40ck131 FIND v(dout1_40) AT=660.025n

* CHECK dout1_41 Vdout1_41ck131 = 0 time = 660
.meas tran vdout1_41ck131 FIND v(dout1_41) AT=660.025n

* CHECK dout1_42 Vdout1_42ck131 = 0 time = 660
.meas tran vdout1_42ck131 FIND v(dout1_42) AT=660.025n

* CHECK dout1_43 Vdout1_43ck131 = 0 time = 660
.meas tran vdout1_43ck131 FIND v(dout1_43) AT=660.025n

* CHECK dout1_44 Vdout1_44ck131 = 0.9 time = 660
.meas tran vdout1_44ck131 FIND v(dout1_44) AT=660.025n

* CHECK dout1_45 Vdout1_45ck131 = 0 time = 660
.meas tran vdout1_45ck131 FIND v(dout1_45) AT=660.025n

* CHECK dout1_46 Vdout1_46ck131 = 0.9 time = 660
.meas tran vdout1_46ck131 FIND v(dout1_46) AT=660.025n

* CHECK dout1_47 Vdout1_47ck131 = 0.9 time = 660
.meas tran vdout1_47ck131 FIND v(dout1_47) AT=660.025n

* CHECK dout1_48 Vdout1_48ck131 = 0 time = 660
.meas tran vdout1_48ck131 FIND v(dout1_48) AT=660.025n

* CHECK dout1_49 Vdout1_49ck131 = 0.9 time = 660
.meas tran vdout1_49ck131 FIND v(dout1_49) AT=660.025n

* CHECK dout1_50 Vdout1_50ck131 = 0.9 time = 660
.meas tran vdout1_50ck131 FIND v(dout1_50) AT=660.025n

* CHECK dout1_51 Vdout1_51ck131 = 0.9 time = 660
.meas tran vdout1_51ck131 FIND v(dout1_51) AT=660.025n

* CHECK dout1_52 Vdout1_52ck131 = 0.9 time = 660
.meas tran vdout1_52ck131 FIND v(dout1_52) AT=660.025n

* CHECK dout1_53 Vdout1_53ck131 = 0 time = 660
.meas tran vdout1_53ck131 FIND v(dout1_53) AT=660.025n

* CHECK dout1_54 Vdout1_54ck131 = 0.9 time = 660
.meas tran vdout1_54ck131 FIND v(dout1_54) AT=660.025n

* CHECK dout1_55 Vdout1_55ck131 = 0.9 time = 660
.meas tran vdout1_55ck131 FIND v(dout1_55) AT=660.025n

* CHECK dout1_56 Vdout1_56ck131 = 0 time = 660
.meas tran vdout1_56ck131 FIND v(dout1_56) AT=660.025n

* CHECK dout1_57 Vdout1_57ck131 = 0 time = 660
.meas tran vdout1_57ck131 FIND v(dout1_57) AT=660.025n

* CHECK dout1_58 Vdout1_58ck131 = 0 time = 660
.meas tran vdout1_58ck131 FIND v(dout1_58) AT=660.025n

* CHECK dout1_59 Vdout1_59ck131 = 0.9 time = 660
.meas tran vdout1_59ck131 FIND v(dout1_59) AT=660.025n

* CHECK dout1_60 Vdout1_60ck131 = 0 time = 660
.meas tran vdout1_60ck131 FIND v(dout1_60) AT=660.025n

* CHECK dout1_61 Vdout1_61ck131 = 0.9 time = 660
.meas tran vdout1_61ck131 FIND v(dout1_61) AT=660.025n

* CHECK dout1_62 Vdout1_62ck131 = 0.9 time = 660
.meas tran vdout1_62ck131 FIND v(dout1_62) AT=660.025n

* CHECK dout1_63 Vdout1_63ck131 = 0 time = 660
.meas tran vdout1_63ck131 FIND v(dout1_63) AT=660.025n

* CHECK dout1_64 Vdout1_64ck131 = 0 time = 660
.meas tran vdout1_64ck131 FIND v(dout1_64) AT=660.025n

* CHECK dout1_65 Vdout1_65ck131 = 0 time = 660
.meas tran vdout1_65ck131 FIND v(dout1_65) AT=660.025n

* CHECK dout1_66 Vdout1_66ck131 = 0 time = 660
.meas tran vdout1_66ck131 FIND v(dout1_66) AT=660.025n

* CHECK dout1_67 Vdout1_67ck131 = 0 time = 660
.meas tran vdout1_67ck131 FIND v(dout1_67) AT=660.025n

* CHECK dout1_68 Vdout1_68ck131 = 0 time = 660
.meas tran vdout1_68ck131 FIND v(dout1_68) AT=660.025n

* CHECK dout1_69 Vdout1_69ck131 = 0.9 time = 660
.meas tran vdout1_69ck131 FIND v(dout1_69) AT=660.025n

* CHECK dout1_70 Vdout1_70ck131 = 0 time = 660
.meas tran vdout1_70ck131 FIND v(dout1_70) AT=660.025n

* CHECK dout1_71 Vdout1_71ck131 = 0 time = 660
.meas tran vdout1_71ck131 FIND v(dout1_71) AT=660.025n

* CHECK dout1_72 Vdout1_72ck131 = 0 time = 660
.meas tran vdout1_72ck131 FIND v(dout1_72) AT=660.025n

* CHECK dout1_73 Vdout1_73ck131 = 0 time = 660
.meas tran vdout1_73ck131 FIND v(dout1_73) AT=660.025n

* CHECK dout1_74 Vdout1_74ck131 = 0.9 time = 660
.meas tran vdout1_74ck131 FIND v(dout1_74) AT=660.025n

* CHECK dout1_75 Vdout1_75ck131 = 0.9 time = 660
.meas tran vdout1_75ck131 FIND v(dout1_75) AT=660.025n

* CHECK dout1_76 Vdout1_76ck131 = 0.9 time = 660
.meas tran vdout1_76ck131 FIND v(dout1_76) AT=660.025n

* CHECK dout1_77 Vdout1_77ck131 = 0 time = 660
.meas tran vdout1_77ck131 FIND v(dout1_77) AT=660.025n

* CHECK dout1_78 Vdout1_78ck131 = 0 time = 660
.meas tran vdout1_78ck131 FIND v(dout1_78) AT=660.025n

* CHECK dout1_79 Vdout1_79ck131 = 0.9 time = 660
.meas tran vdout1_79ck131 FIND v(dout1_79) AT=660.025n

* CHECK dout1_80 Vdout1_80ck131 = 0.9 time = 660
.meas tran vdout1_80ck131 FIND v(dout1_80) AT=660.025n

* CHECK dout1_81 Vdout1_81ck131 = 0.9 time = 660
.meas tran vdout1_81ck131 FIND v(dout1_81) AT=660.025n

* CHECK dout1_82 Vdout1_82ck131 = 0 time = 660
.meas tran vdout1_82ck131 FIND v(dout1_82) AT=660.025n

* CHECK dout1_83 Vdout1_83ck131 = 0 time = 660
.meas tran vdout1_83ck131 FIND v(dout1_83) AT=660.025n

* CHECK dout1_84 Vdout1_84ck131 = 0.9 time = 660
.meas tran vdout1_84ck131 FIND v(dout1_84) AT=660.025n

* CHECK dout1_85 Vdout1_85ck131 = 0 time = 660
.meas tran vdout1_85ck131 FIND v(dout1_85) AT=660.025n

* CHECK dout1_86 Vdout1_86ck131 = 0.9 time = 660
.meas tran vdout1_86ck131 FIND v(dout1_86) AT=660.025n

* CHECK dout1_87 Vdout1_87ck131 = 0 time = 660
.meas tran vdout1_87ck131 FIND v(dout1_87) AT=660.025n

* CHECK dout1_88 Vdout1_88ck131 = 0.9 time = 660
.meas tran vdout1_88ck131 FIND v(dout1_88) AT=660.025n

* CHECK dout1_89 Vdout1_89ck131 = 0.9 time = 660
.meas tran vdout1_89ck131 FIND v(dout1_89) AT=660.025n

* CHECK dout1_90 Vdout1_90ck131 = 0.9 time = 660
.meas tran vdout1_90ck131 FIND v(dout1_90) AT=660.025n

* CHECK dout1_91 Vdout1_91ck131 = 0 time = 660
.meas tran vdout1_91ck131 FIND v(dout1_91) AT=660.025n

* CHECK dout1_92 Vdout1_92ck131 = 0 time = 660
.meas tran vdout1_92ck131 FIND v(dout1_92) AT=660.025n

* CHECK dout1_93 Vdout1_93ck131 = 0 time = 660
.meas tran vdout1_93ck131 FIND v(dout1_93) AT=660.025n

* CHECK dout1_94 Vdout1_94ck131 = 0.9 time = 660
.meas tran vdout1_94ck131 FIND v(dout1_94) AT=660.025n

* CHECK dout1_95 Vdout1_95ck131 = 0 time = 660
.meas tran vdout1_95ck131 FIND v(dout1_95) AT=660.025n

* CHECK dout1_96 Vdout1_96ck131 = 0.9 time = 660
.meas tran vdout1_96ck131 FIND v(dout1_96) AT=660.025n

* CHECK dout1_97 Vdout1_97ck131 = 0 time = 660
.meas tran vdout1_97ck131 FIND v(dout1_97) AT=660.025n

* CHECK dout1_98 Vdout1_98ck131 = 0.9 time = 660
.meas tran vdout1_98ck131 FIND v(dout1_98) AT=660.025n

* CHECK dout1_99 Vdout1_99ck131 = 0 time = 660
.meas tran vdout1_99ck131 FIND v(dout1_99) AT=660.025n

* CHECK dout1_100 Vdout1_100ck131 = 0 time = 660
.meas tran vdout1_100ck131 FIND v(dout1_100) AT=660.025n

* CHECK dout1_101 Vdout1_101ck131 = 0.9 time = 660
.meas tran vdout1_101ck131 FIND v(dout1_101) AT=660.025n

* CHECK dout1_102 Vdout1_102ck131 = 0.9 time = 660
.meas tran vdout1_102ck131 FIND v(dout1_102) AT=660.025n

* CHECK dout1_103 Vdout1_103ck131 = 0.9 time = 660
.meas tran vdout1_103ck131 FIND v(dout1_103) AT=660.025n

* CHECK dout1_104 Vdout1_104ck131 = 0 time = 660
.meas tran vdout1_104ck131 FIND v(dout1_104) AT=660.025n

* CHECK dout1_105 Vdout1_105ck131 = 0 time = 660
.meas tran vdout1_105ck131 FIND v(dout1_105) AT=660.025n

* CHECK dout1_106 Vdout1_106ck131 = 0.9 time = 660
.meas tran vdout1_106ck131 FIND v(dout1_106) AT=660.025n

* CHECK dout1_107 Vdout1_107ck131 = 0.9 time = 660
.meas tran vdout1_107ck131 FIND v(dout1_107) AT=660.025n

* CHECK dout1_108 Vdout1_108ck131 = 0.9 time = 660
.meas tran vdout1_108ck131 FIND v(dout1_108) AT=660.025n

* CHECK dout1_109 Vdout1_109ck131 = 0 time = 660
.meas tran vdout1_109ck131 FIND v(dout1_109) AT=660.025n

* CHECK dout1_110 Vdout1_110ck131 = 0.9 time = 660
.meas tran vdout1_110ck131 FIND v(dout1_110) AT=660.025n

* CHECK dout1_111 Vdout1_111ck131 = 0.9 time = 660
.meas tran vdout1_111ck131 FIND v(dout1_111) AT=660.025n

* CHECK dout1_112 Vdout1_112ck131 = 0.9 time = 660
.meas tran vdout1_112ck131 FIND v(dout1_112) AT=660.025n

* CHECK dout1_113 Vdout1_113ck131 = 0 time = 660
.meas tran vdout1_113ck131 FIND v(dout1_113) AT=660.025n

* CHECK dout1_114 Vdout1_114ck131 = 0.9 time = 660
.meas tran vdout1_114ck131 FIND v(dout1_114) AT=660.025n

* CHECK dout1_115 Vdout1_115ck131 = 0 time = 660
.meas tran vdout1_115ck131 FIND v(dout1_115) AT=660.025n

* CHECK dout1_116 Vdout1_116ck131 = 0.9 time = 660
.meas tran vdout1_116ck131 FIND v(dout1_116) AT=660.025n

* CHECK dout1_117 Vdout1_117ck131 = 0.9 time = 660
.meas tran vdout1_117ck131 FIND v(dout1_117) AT=660.025n

* CHECK dout1_118 Vdout1_118ck131 = 0.9 time = 660
.meas tran vdout1_118ck131 FIND v(dout1_118) AT=660.025n

* CHECK dout1_119 Vdout1_119ck131 = 0 time = 660
.meas tran vdout1_119ck131 FIND v(dout1_119) AT=660.025n

* CHECK dout1_0 Vdout1_0ck135 = 0 time = 680
.meas tran vdout1_0ck135 FIND v(dout1_0) AT=680.025n

* CHECK dout1_1 Vdout1_1ck135 = 0.9 time = 680
.meas tran vdout1_1ck135 FIND v(dout1_1) AT=680.025n

* CHECK dout1_2 Vdout1_2ck135 = 0.9 time = 680
.meas tran vdout1_2ck135 FIND v(dout1_2) AT=680.025n

* CHECK dout1_3 Vdout1_3ck135 = 0.9 time = 680
.meas tran vdout1_3ck135 FIND v(dout1_3) AT=680.025n

* CHECK dout1_4 Vdout1_4ck135 = 0 time = 680
.meas tran vdout1_4ck135 FIND v(dout1_4) AT=680.025n

* CHECK dout1_5 Vdout1_5ck135 = 0.9 time = 680
.meas tran vdout1_5ck135 FIND v(dout1_5) AT=680.025n

* CHECK dout1_6 Vdout1_6ck135 = 0 time = 680
.meas tran vdout1_6ck135 FIND v(dout1_6) AT=680.025n

* CHECK dout1_7 Vdout1_7ck135 = 0 time = 680
.meas tran vdout1_7ck135 FIND v(dout1_7) AT=680.025n

* CHECK dout1_8 Vdout1_8ck135 = 0.9 time = 680
.meas tran vdout1_8ck135 FIND v(dout1_8) AT=680.025n

* CHECK dout1_9 Vdout1_9ck135 = 0.9 time = 680
.meas tran vdout1_9ck135 FIND v(dout1_9) AT=680.025n

* CHECK dout1_10 Vdout1_10ck135 = 0.9 time = 680
.meas tran vdout1_10ck135 FIND v(dout1_10) AT=680.025n

* CHECK dout1_11 Vdout1_11ck135 = 0.9 time = 680
.meas tran vdout1_11ck135 FIND v(dout1_11) AT=680.025n

* CHECK dout1_12 Vdout1_12ck135 = 0.9 time = 680
.meas tran vdout1_12ck135 FIND v(dout1_12) AT=680.025n

* CHECK dout1_13 Vdout1_13ck135 = 0.9 time = 680
.meas tran vdout1_13ck135 FIND v(dout1_13) AT=680.025n

* CHECK dout1_14 Vdout1_14ck135 = 0 time = 680
.meas tran vdout1_14ck135 FIND v(dout1_14) AT=680.025n

* CHECK dout1_15 Vdout1_15ck135 = 0.9 time = 680
.meas tran vdout1_15ck135 FIND v(dout1_15) AT=680.025n

* CHECK dout1_16 Vdout1_16ck135 = 0.9 time = 680
.meas tran vdout1_16ck135 FIND v(dout1_16) AT=680.025n

* CHECK dout1_17 Vdout1_17ck135 = 0.9 time = 680
.meas tran vdout1_17ck135 FIND v(dout1_17) AT=680.025n

* CHECK dout1_18 Vdout1_18ck135 = 0 time = 680
.meas tran vdout1_18ck135 FIND v(dout1_18) AT=680.025n

* CHECK dout1_19 Vdout1_19ck135 = 0.9 time = 680
.meas tran vdout1_19ck135 FIND v(dout1_19) AT=680.025n

* CHECK dout1_20 Vdout1_20ck135 = 0 time = 680
.meas tran vdout1_20ck135 FIND v(dout1_20) AT=680.025n

* CHECK dout1_21 Vdout1_21ck135 = 0 time = 680
.meas tran vdout1_21ck135 FIND v(dout1_21) AT=680.025n

* CHECK dout1_22 Vdout1_22ck135 = 0.9 time = 680
.meas tran vdout1_22ck135 FIND v(dout1_22) AT=680.025n

* CHECK dout1_23 Vdout1_23ck135 = 0 time = 680
.meas tran vdout1_23ck135 FIND v(dout1_23) AT=680.025n

* CHECK dout1_24 Vdout1_24ck135 = 0 time = 680
.meas tran vdout1_24ck135 FIND v(dout1_24) AT=680.025n

* CHECK dout1_25 Vdout1_25ck135 = 0.9 time = 680
.meas tran vdout1_25ck135 FIND v(dout1_25) AT=680.025n

* CHECK dout1_26 Vdout1_26ck135 = 0 time = 680
.meas tran vdout1_26ck135 FIND v(dout1_26) AT=680.025n

* CHECK dout1_27 Vdout1_27ck135 = 0.9 time = 680
.meas tran vdout1_27ck135 FIND v(dout1_27) AT=680.025n

* CHECK dout1_28 Vdout1_28ck135 = 0.9 time = 680
.meas tran vdout1_28ck135 FIND v(dout1_28) AT=680.025n

* CHECK dout1_29 Vdout1_29ck135 = 0 time = 680
.meas tran vdout1_29ck135 FIND v(dout1_29) AT=680.025n

* CHECK dout1_30 Vdout1_30ck135 = 0.9 time = 680
.meas tran vdout1_30ck135 FIND v(dout1_30) AT=680.025n

* CHECK dout1_31 Vdout1_31ck135 = 0.9 time = 680
.meas tran vdout1_31ck135 FIND v(dout1_31) AT=680.025n

* CHECK dout1_32 Vdout1_32ck135 = 0.9 time = 680
.meas tran vdout1_32ck135 FIND v(dout1_32) AT=680.025n

* CHECK dout1_33 Vdout1_33ck135 = 0 time = 680
.meas tran vdout1_33ck135 FIND v(dout1_33) AT=680.025n

* CHECK dout1_34 Vdout1_34ck135 = 0 time = 680
.meas tran vdout1_34ck135 FIND v(dout1_34) AT=680.025n

* CHECK dout1_35 Vdout1_35ck135 = 0 time = 680
.meas tran vdout1_35ck135 FIND v(dout1_35) AT=680.025n

* CHECK dout1_36 Vdout1_36ck135 = 0.9 time = 680
.meas tran vdout1_36ck135 FIND v(dout1_36) AT=680.025n

* CHECK dout1_37 Vdout1_37ck135 = 0 time = 680
.meas tran vdout1_37ck135 FIND v(dout1_37) AT=680.025n

* CHECK dout1_38 Vdout1_38ck135 = 0 time = 680
.meas tran vdout1_38ck135 FIND v(dout1_38) AT=680.025n

* CHECK dout1_39 Vdout1_39ck135 = 0.9 time = 680
.meas tran vdout1_39ck135 FIND v(dout1_39) AT=680.025n

* CHECK dout1_40 Vdout1_40ck135 = 0 time = 680
.meas tran vdout1_40ck135 FIND v(dout1_40) AT=680.025n

* CHECK dout1_41 Vdout1_41ck135 = 0 time = 680
.meas tran vdout1_41ck135 FIND v(dout1_41) AT=680.025n

* CHECK dout1_42 Vdout1_42ck135 = 0 time = 680
.meas tran vdout1_42ck135 FIND v(dout1_42) AT=680.025n

* CHECK dout1_43 Vdout1_43ck135 = 0.9 time = 680
.meas tran vdout1_43ck135 FIND v(dout1_43) AT=680.025n

* CHECK dout1_44 Vdout1_44ck135 = 0.9 time = 680
.meas tran vdout1_44ck135 FIND v(dout1_44) AT=680.025n

* CHECK dout1_45 Vdout1_45ck135 = 0 time = 680
.meas tran vdout1_45ck135 FIND v(dout1_45) AT=680.025n

* CHECK dout1_46 Vdout1_46ck135 = 0 time = 680
.meas tran vdout1_46ck135 FIND v(dout1_46) AT=680.025n

* CHECK dout1_47 Vdout1_47ck135 = 0.9 time = 680
.meas tran vdout1_47ck135 FIND v(dout1_47) AT=680.025n

* CHECK dout1_48 Vdout1_48ck135 = 0.9 time = 680
.meas tran vdout1_48ck135 FIND v(dout1_48) AT=680.025n

* CHECK dout1_49 Vdout1_49ck135 = 0.9 time = 680
.meas tran vdout1_49ck135 FIND v(dout1_49) AT=680.025n

* CHECK dout1_50 Vdout1_50ck135 = 0 time = 680
.meas tran vdout1_50ck135 FIND v(dout1_50) AT=680.025n

* CHECK dout1_51 Vdout1_51ck135 = 0 time = 680
.meas tran vdout1_51ck135 FIND v(dout1_51) AT=680.025n

* CHECK dout1_52 Vdout1_52ck135 = 0 time = 680
.meas tran vdout1_52ck135 FIND v(dout1_52) AT=680.025n

* CHECK dout1_53 Vdout1_53ck135 = 0.9 time = 680
.meas tran vdout1_53ck135 FIND v(dout1_53) AT=680.025n

* CHECK dout1_54 Vdout1_54ck135 = 0.9 time = 680
.meas tran vdout1_54ck135 FIND v(dout1_54) AT=680.025n

* CHECK dout1_55 Vdout1_55ck135 = 0 time = 680
.meas tran vdout1_55ck135 FIND v(dout1_55) AT=680.025n

* CHECK dout1_56 Vdout1_56ck135 = 0.9 time = 680
.meas tran vdout1_56ck135 FIND v(dout1_56) AT=680.025n

* CHECK dout1_57 Vdout1_57ck135 = 0 time = 680
.meas tran vdout1_57ck135 FIND v(dout1_57) AT=680.025n

* CHECK dout1_58 Vdout1_58ck135 = 0 time = 680
.meas tran vdout1_58ck135 FIND v(dout1_58) AT=680.025n

* CHECK dout1_59 Vdout1_59ck135 = 0.9 time = 680
.meas tran vdout1_59ck135 FIND v(dout1_59) AT=680.025n

* CHECK dout1_60 Vdout1_60ck135 = 0 time = 680
.meas tran vdout1_60ck135 FIND v(dout1_60) AT=680.025n

* CHECK dout1_61 Vdout1_61ck135 = 0.9 time = 680
.meas tran vdout1_61ck135 FIND v(dout1_61) AT=680.025n

* CHECK dout1_62 Vdout1_62ck135 = 0.9 time = 680
.meas tran vdout1_62ck135 FIND v(dout1_62) AT=680.025n

* CHECK dout1_63 Vdout1_63ck135 = 0.9 time = 680
.meas tran vdout1_63ck135 FIND v(dout1_63) AT=680.025n

* CHECK dout1_64 Vdout1_64ck135 = 0 time = 680
.meas tran vdout1_64ck135 FIND v(dout1_64) AT=680.025n

* CHECK dout1_65 Vdout1_65ck135 = 0 time = 680
.meas tran vdout1_65ck135 FIND v(dout1_65) AT=680.025n

* CHECK dout1_66 Vdout1_66ck135 = 0.9 time = 680
.meas tran vdout1_66ck135 FIND v(dout1_66) AT=680.025n

* CHECK dout1_67 Vdout1_67ck135 = 0 time = 680
.meas tran vdout1_67ck135 FIND v(dout1_67) AT=680.025n

* CHECK dout1_68 Vdout1_68ck135 = 0.9 time = 680
.meas tran vdout1_68ck135 FIND v(dout1_68) AT=680.025n

* CHECK dout1_69 Vdout1_69ck135 = 0.9 time = 680
.meas tran vdout1_69ck135 FIND v(dout1_69) AT=680.025n

* CHECK dout1_70 Vdout1_70ck135 = 0 time = 680
.meas tran vdout1_70ck135 FIND v(dout1_70) AT=680.025n

* CHECK dout1_71 Vdout1_71ck135 = 0 time = 680
.meas tran vdout1_71ck135 FIND v(dout1_71) AT=680.025n

* CHECK dout1_72 Vdout1_72ck135 = 0 time = 680
.meas tran vdout1_72ck135 FIND v(dout1_72) AT=680.025n

* CHECK dout1_73 Vdout1_73ck135 = 0 time = 680
.meas tran vdout1_73ck135 FIND v(dout1_73) AT=680.025n

* CHECK dout1_74 Vdout1_74ck135 = 0.9 time = 680
.meas tran vdout1_74ck135 FIND v(dout1_74) AT=680.025n

* CHECK dout1_75 Vdout1_75ck135 = 0 time = 680
.meas tran vdout1_75ck135 FIND v(dout1_75) AT=680.025n

* CHECK dout1_76 Vdout1_76ck135 = 0 time = 680
.meas tran vdout1_76ck135 FIND v(dout1_76) AT=680.025n

* CHECK dout1_77 Vdout1_77ck135 = 0.9 time = 680
.meas tran vdout1_77ck135 FIND v(dout1_77) AT=680.025n

* CHECK dout1_78 Vdout1_78ck135 = 0 time = 680
.meas tran vdout1_78ck135 FIND v(dout1_78) AT=680.025n

* CHECK dout1_79 Vdout1_79ck135 = 0 time = 680
.meas tran vdout1_79ck135 FIND v(dout1_79) AT=680.025n

* CHECK dout1_80 Vdout1_80ck135 = 0.9 time = 680
.meas tran vdout1_80ck135 FIND v(dout1_80) AT=680.025n

* CHECK dout1_81 Vdout1_81ck135 = 0 time = 680
.meas tran vdout1_81ck135 FIND v(dout1_81) AT=680.025n

* CHECK dout1_82 Vdout1_82ck135 = 0.9 time = 680
.meas tran vdout1_82ck135 FIND v(dout1_82) AT=680.025n

* CHECK dout1_83 Vdout1_83ck135 = 0 time = 680
.meas tran vdout1_83ck135 FIND v(dout1_83) AT=680.025n

* CHECK dout1_84 Vdout1_84ck135 = 0.9 time = 680
.meas tran vdout1_84ck135 FIND v(dout1_84) AT=680.025n

* CHECK dout1_85 Vdout1_85ck135 = 0 time = 680
.meas tran vdout1_85ck135 FIND v(dout1_85) AT=680.025n

* CHECK dout1_86 Vdout1_86ck135 = 0 time = 680
.meas tran vdout1_86ck135 FIND v(dout1_86) AT=680.025n

* CHECK dout1_87 Vdout1_87ck135 = 0 time = 680
.meas tran vdout1_87ck135 FIND v(dout1_87) AT=680.025n

* CHECK dout1_88 Vdout1_88ck135 = 0.9 time = 680
.meas tran vdout1_88ck135 FIND v(dout1_88) AT=680.025n

* CHECK dout1_89 Vdout1_89ck135 = 0.9 time = 680
.meas tran vdout1_89ck135 FIND v(dout1_89) AT=680.025n

* CHECK dout1_90 Vdout1_90ck135 = 0.9 time = 680
.meas tran vdout1_90ck135 FIND v(dout1_90) AT=680.025n

* CHECK dout1_91 Vdout1_91ck135 = 0 time = 680
.meas tran vdout1_91ck135 FIND v(dout1_91) AT=680.025n

* CHECK dout1_92 Vdout1_92ck135 = 0 time = 680
.meas tran vdout1_92ck135 FIND v(dout1_92) AT=680.025n

* CHECK dout1_93 Vdout1_93ck135 = 0 time = 680
.meas tran vdout1_93ck135 FIND v(dout1_93) AT=680.025n

* CHECK dout1_94 Vdout1_94ck135 = 0.9 time = 680
.meas tran vdout1_94ck135 FIND v(dout1_94) AT=680.025n

* CHECK dout1_95 Vdout1_95ck135 = 0 time = 680
.meas tran vdout1_95ck135 FIND v(dout1_95) AT=680.025n

* CHECK dout1_96 Vdout1_96ck135 = 0.9 time = 680
.meas tran vdout1_96ck135 FIND v(dout1_96) AT=680.025n

* CHECK dout1_97 Vdout1_97ck135 = 0 time = 680
.meas tran vdout1_97ck135 FIND v(dout1_97) AT=680.025n

* CHECK dout1_98 Vdout1_98ck135 = 0.9 time = 680
.meas tran vdout1_98ck135 FIND v(dout1_98) AT=680.025n

* CHECK dout1_99 Vdout1_99ck135 = 0 time = 680
.meas tran vdout1_99ck135 FIND v(dout1_99) AT=680.025n

* CHECK dout1_100 Vdout1_100ck135 = 0.9 time = 680
.meas tran vdout1_100ck135 FIND v(dout1_100) AT=680.025n

* CHECK dout1_101 Vdout1_101ck135 = 0.9 time = 680
.meas tran vdout1_101ck135 FIND v(dout1_101) AT=680.025n

* CHECK dout1_102 Vdout1_102ck135 = 0.9 time = 680
.meas tran vdout1_102ck135 FIND v(dout1_102) AT=680.025n

* CHECK dout1_103 Vdout1_103ck135 = 0 time = 680
.meas tran vdout1_103ck135 FIND v(dout1_103) AT=680.025n

* CHECK dout1_104 Vdout1_104ck135 = 0.9 time = 680
.meas tran vdout1_104ck135 FIND v(dout1_104) AT=680.025n

* CHECK dout1_105 Vdout1_105ck135 = 0 time = 680
.meas tran vdout1_105ck135 FIND v(dout1_105) AT=680.025n

* CHECK dout1_106 Vdout1_106ck135 = 0.9 time = 680
.meas tran vdout1_106ck135 FIND v(dout1_106) AT=680.025n

* CHECK dout1_107 Vdout1_107ck135 = 0 time = 680
.meas tran vdout1_107ck135 FIND v(dout1_107) AT=680.025n

* CHECK dout1_108 Vdout1_108ck135 = 0 time = 680
.meas tran vdout1_108ck135 FIND v(dout1_108) AT=680.025n

* CHECK dout1_109 Vdout1_109ck135 = 0 time = 680
.meas tran vdout1_109ck135 FIND v(dout1_109) AT=680.025n

* CHECK dout1_110 Vdout1_110ck135 = 0 time = 680
.meas tran vdout1_110ck135 FIND v(dout1_110) AT=680.025n

* CHECK dout1_111 Vdout1_111ck135 = 0.9 time = 680
.meas tran vdout1_111ck135 FIND v(dout1_111) AT=680.025n

* CHECK dout1_112 Vdout1_112ck135 = 0.9 time = 680
.meas tran vdout1_112ck135 FIND v(dout1_112) AT=680.025n

* CHECK dout1_113 Vdout1_113ck135 = 0.9 time = 680
.meas tran vdout1_113ck135 FIND v(dout1_113) AT=680.025n

* CHECK dout1_114 Vdout1_114ck135 = 0.9 time = 680
.meas tran vdout1_114ck135 FIND v(dout1_114) AT=680.025n

* CHECK dout1_115 Vdout1_115ck135 = 0.9 time = 680
.meas tran vdout1_115ck135 FIND v(dout1_115) AT=680.025n

* CHECK dout1_116 Vdout1_116ck135 = 0.9 time = 680
.meas tran vdout1_116ck135 FIND v(dout1_116) AT=680.025n

* CHECK dout1_117 Vdout1_117ck135 = 0 time = 680
.meas tran vdout1_117ck135 FIND v(dout1_117) AT=680.025n

* CHECK dout1_118 Vdout1_118ck135 = 0.9 time = 680
.meas tran vdout1_118ck135 FIND v(dout1_118) AT=680.025n

* CHECK dout1_119 Vdout1_119ck135 = 0.9 time = 680
.meas tran vdout1_119ck135 FIND v(dout1_119) AT=680.025n

* CHECK dout1_0 Vdout1_0ck136 = 0.9 time = 685
.meas tran vdout1_0ck136 FIND v(dout1_0) AT=685.025n

* CHECK dout1_1 Vdout1_1ck136 = 0 time = 685
.meas tran vdout1_1ck136 FIND v(dout1_1) AT=685.025n

* CHECK dout1_2 Vdout1_2ck136 = 0.9 time = 685
.meas tran vdout1_2ck136 FIND v(dout1_2) AT=685.025n

* CHECK dout1_3 Vdout1_3ck136 = 0 time = 685
.meas tran vdout1_3ck136 FIND v(dout1_3) AT=685.025n

* CHECK dout1_4 Vdout1_4ck136 = 0 time = 685
.meas tran vdout1_4ck136 FIND v(dout1_4) AT=685.025n

* CHECK dout1_5 Vdout1_5ck136 = 0 time = 685
.meas tran vdout1_5ck136 FIND v(dout1_5) AT=685.025n

* CHECK dout1_6 Vdout1_6ck136 = 0 time = 685
.meas tran vdout1_6ck136 FIND v(dout1_6) AT=685.025n

* CHECK dout1_7 Vdout1_7ck136 = 0 time = 685
.meas tran vdout1_7ck136 FIND v(dout1_7) AT=685.025n

* CHECK dout1_8 Vdout1_8ck136 = 0.9 time = 685
.meas tran vdout1_8ck136 FIND v(dout1_8) AT=685.025n

* CHECK dout1_9 Vdout1_9ck136 = 0 time = 685
.meas tran vdout1_9ck136 FIND v(dout1_9) AT=685.025n

* CHECK dout1_10 Vdout1_10ck136 = 0 time = 685
.meas tran vdout1_10ck136 FIND v(dout1_10) AT=685.025n

* CHECK dout1_11 Vdout1_11ck136 = 0.9 time = 685
.meas tran vdout1_11ck136 FIND v(dout1_11) AT=685.025n

* CHECK dout1_12 Vdout1_12ck136 = 0 time = 685
.meas tran vdout1_12ck136 FIND v(dout1_12) AT=685.025n

* CHECK dout1_13 Vdout1_13ck136 = 0.9 time = 685
.meas tran vdout1_13ck136 FIND v(dout1_13) AT=685.025n

* CHECK dout1_14 Vdout1_14ck136 = 0.9 time = 685
.meas tran vdout1_14ck136 FIND v(dout1_14) AT=685.025n

* CHECK dout1_15 Vdout1_15ck136 = 0 time = 685
.meas tran vdout1_15ck136 FIND v(dout1_15) AT=685.025n

* CHECK dout1_16 Vdout1_16ck136 = 0 time = 685
.meas tran vdout1_16ck136 FIND v(dout1_16) AT=685.025n

* CHECK dout1_17 Vdout1_17ck136 = 0 time = 685
.meas tran vdout1_17ck136 FIND v(dout1_17) AT=685.025n

* CHECK dout1_18 Vdout1_18ck136 = 0.9 time = 685
.meas tran vdout1_18ck136 FIND v(dout1_18) AT=685.025n

* CHECK dout1_19 Vdout1_19ck136 = 0 time = 685
.meas tran vdout1_19ck136 FIND v(dout1_19) AT=685.025n

* CHECK dout1_20 Vdout1_20ck136 = 0 time = 685
.meas tran vdout1_20ck136 FIND v(dout1_20) AT=685.025n

* CHECK dout1_21 Vdout1_21ck136 = 0 time = 685
.meas tran vdout1_21ck136 FIND v(dout1_21) AT=685.025n

* CHECK dout1_22 Vdout1_22ck136 = 0.9 time = 685
.meas tran vdout1_22ck136 FIND v(dout1_22) AT=685.025n

* CHECK dout1_23 Vdout1_23ck136 = 0.9 time = 685
.meas tran vdout1_23ck136 FIND v(dout1_23) AT=685.025n

* CHECK dout1_24 Vdout1_24ck136 = 0.9 time = 685
.meas tran vdout1_24ck136 FIND v(dout1_24) AT=685.025n

* CHECK dout1_25 Vdout1_25ck136 = 0 time = 685
.meas tran vdout1_25ck136 FIND v(dout1_25) AT=685.025n

* CHECK dout1_26 Vdout1_26ck136 = 0.9 time = 685
.meas tran vdout1_26ck136 FIND v(dout1_26) AT=685.025n

* CHECK dout1_27 Vdout1_27ck136 = 0 time = 685
.meas tran vdout1_27ck136 FIND v(dout1_27) AT=685.025n

* CHECK dout1_28 Vdout1_28ck136 = 0 time = 685
.meas tran vdout1_28ck136 FIND v(dout1_28) AT=685.025n

* CHECK dout1_29 Vdout1_29ck136 = 0 time = 685
.meas tran vdout1_29ck136 FIND v(dout1_29) AT=685.025n

* CHECK dout1_30 Vdout1_30ck136 = 0.9 time = 685
.meas tran vdout1_30ck136 FIND v(dout1_30) AT=685.025n

* CHECK dout1_31 Vdout1_31ck136 = 0.9 time = 685
.meas tran vdout1_31ck136 FIND v(dout1_31) AT=685.025n

* CHECK dout1_32 Vdout1_32ck136 = 0 time = 685
.meas tran vdout1_32ck136 FIND v(dout1_32) AT=685.025n

* CHECK dout1_33 Vdout1_33ck136 = 0 time = 685
.meas tran vdout1_33ck136 FIND v(dout1_33) AT=685.025n

* CHECK dout1_34 Vdout1_34ck136 = 0 time = 685
.meas tran vdout1_34ck136 FIND v(dout1_34) AT=685.025n

* CHECK dout1_35 Vdout1_35ck136 = 0 time = 685
.meas tran vdout1_35ck136 FIND v(dout1_35) AT=685.025n

* CHECK dout1_36 Vdout1_36ck136 = 0 time = 685
.meas tran vdout1_36ck136 FIND v(dout1_36) AT=685.025n

* CHECK dout1_37 Vdout1_37ck136 = 0 time = 685
.meas tran vdout1_37ck136 FIND v(dout1_37) AT=685.025n

* CHECK dout1_38 Vdout1_38ck136 = 0 time = 685
.meas tran vdout1_38ck136 FIND v(dout1_38) AT=685.025n

* CHECK dout1_39 Vdout1_39ck136 = 0 time = 685
.meas tran vdout1_39ck136 FIND v(dout1_39) AT=685.025n

* CHECK dout1_40 Vdout1_40ck136 = 0 time = 685
.meas tran vdout1_40ck136 FIND v(dout1_40) AT=685.025n

* CHECK dout1_41 Vdout1_41ck136 = 0 time = 685
.meas tran vdout1_41ck136 FIND v(dout1_41) AT=685.025n

* CHECK dout1_42 Vdout1_42ck136 = 0 time = 685
.meas tran vdout1_42ck136 FIND v(dout1_42) AT=685.025n

* CHECK dout1_43 Vdout1_43ck136 = 0 time = 685
.meas tran vdout1_43ck136 FIND v(dout1_43) AT=685.025n

* CHECK dout1_44 Vdout1_44ck136 = 0.9 time = 685
.meas tran vdout1_44ck136 FIND v(dout1_44) AT=685.025n

* CHECK dout1_45 Vdout1_45ck136 = 0 time = 685
.meas tran vdout1_45ck136 FIND v(dout1_45) AT=685.025n

* CHECK dout1_46 Vdout1_46ck136 = 0 time = 685
.meas tran vdout1_46ck136 FIND v(dout1_46) AT=685.025n

* CHECK dout1_47 Vdout1_47ck136 = 0 time = 685
.meas tran vdout1_47ck136 FIND v(dout1_47) AT=685.025n

* CHECK dout1_48 Vdout1_48ck136 = 0 time = 685
.meas tran vdout1_48ck136 FIND v(dout1_48) AT=685.025n

* CHECK dout1_49 Vdout1_49ck136 = 0 time = 685
.meas tran vdout1_49ck136 FIND v(dout1_49) AT=685.025n

* CHECK dout1_50 Vdout1_50ck136 = 0.9 time = 685
.meas tran vdout1_50ck136 FIND v(dout1_50) AT=685.025n

* CHECK dout1_51 Vdout1_51ck136 = 0.9 time = 685
.meas tran vdout1_51ck136 FIND v(dout1_51) AT=685.025n

* CHECK dout1_52 Vdout1_52ck136 = 0.9 time = 685
.meas tran vdout1_52ck136 FIND v(dout1_52) AT=685.025n

* CHECK dout1_53 Vdout1_53ck136 = 0 time = 685
.meas tran vdout1_53ck136 FIND v(dout1_53) AT=685.025n

* CHECK dout1_54 Vdout1_54ck136 = 0.9 time = 685
.meas tran vdout1_54ck136 FIND v(dout1_54) AT=685.025n

* CHECK dout1_55 Vdout1_55ck136 = 0.9 time = 685
.meas tran vdout1_55ck136 FIND v(dout1_55) AT=685.025n

* CHECK dout1_56 Vdout1_56ck136 = 0.9 time = 685
.meas tran vdout1_56ck136 FIND v(dout1_56) AT=685.025n

* CHECK dout1_57 Vdout1_57ck136 = 0 time = 685
.meas tran vdout1_57ck136 FIND v(dout1_57) AT=685.025n

* CHECK dout1_58 Vdout1_58ck136 = 0 time = 685
.meas tran vdout1_58ck136 FIND v(dout1_58) AT=685.025n

* CHECK dout1_59 Vdout1_59ck136 = 0 time = 685
.meas tran vdout1_59ck136 FIND v(dout1_59) AT=685.025n

* CHECK dout1_60 Vdout1_60ck136 = 0.9 time = 685
.meas tran vdout1_60ck136 FIND v(dout1_60) AT=685.025n

* CHECK dout1_61 Vdout1_61ck136 = 0.9 time = 685
.meas tran vdout1_61ck136 FIND v(dout1_61) AT=685.025n

* CHECK dout1_62 Vdout1_62ck136 = 0 time = 685
.meas tran vdout1_62ck136 FIND v(dout1_62) AT=685.025n

* CHECK dout1_63 Vdout1_63ck136 = 0.9 time = 685
.meas tran vdout1_63ck136 FIND v(dout1_63) AT=685.025n

* CHECK dout1_64 Vdout1_64ck136 = 0 time = 685
.meas tran vdout1_64ck136 FIND v(dout1_64) AT=685.025n

* CHECK dout1_65 Vdout1_65ck136 = 0.9 time = 685
.meas tran vdout1_65ck136 FIND v(dout1_65) AT=685.025n

* CHECK dout1_66 Vdout1_66ck136 = 0.9 time = 685
.meas tran vdout1_66ck136 FIND v(dout1_66) AT=685.025n

* CHECK dout1_67 Vdout1_67ck136 = 0.9 time = 685
.meas tran vdout1_67ck136 FIND v(dout1_67) AT=685.025n

* CHECK dout1_68 Vdout1_68ck136 = 0.9 time = 685
.meas tran vdout1_68ck136 FIND v(dout1_68) AT=685.025n

* CHECK dout1_69 Vdout1_69ck136 = 0.9 time = 685
.meas tran vdout1_69ck136 FIND v(dout1_69) AT=685.025n

* CHECK dout1_70 Vdout1_70ck136 = 0.9 time = 685
.meas tran vdout1_70ck136 FIND v(dout1_70) AT=685.025n

* CHECK dout1_71 Vdout1_71ck136 = 0.9 time = 685
.meas tran vdout1_71ck136 FIND v(dout1_71) AT=685.025n

* CHECK dout1_72 Vdout1_72ck136 = 0.9 time = 685
.meas tran vdout1_72ck136 FIND v(dout1_72) AT=685.025n

* CHECK dout1_73 Vdout1_73ck136 = 0 time = 685
.meas tran vdout1_73ck136 FIND v(dout1_73) AT=685.025n

* CHECK dout1_74 Vdout1_74ck136 = 0 time = 685
.meas tran vdout1_74ck136 FIND v(dout1_74) AT=685.025n

* CHECK dout1_75 Vdout1_75ck136 = 0 time = 685
.meas tran vdout1_75ck136 FIND v(dout1_75) AT=685.025n

* CHECK dout1_76 Vdout1_76ck136 = 0.9 time = 685
.meas tran vdout1_76ck136 FIND v(dout1_76) AT=685.025n

* CHECK dout1_77 Vdout1_77ck136 = 0.9 time = 685
.meas tran vdout1_77ck136 FIND v(dout1_77) AT=685.025n

* CHECK dout1_78 Vdout1_78ck136 = 0.9 time = 685
.meas tran vdout1_78ck136 FIND v(dout1_78) AT=685.025n

* CHECK dout1_79 Vdout1_79ck136 = 0.9 time = 685
.meas tran vdout1_79ck136 FIND v(dout1_79) AT=685.025n

* CHECK dout1_80 Vdout1_80ck136 = 0.9 time = 685
.meas tran vdout1_80ck136 FIND v(dout1_80) AT=685.025n

* CHECK dout1_81 Vdout1_81ck136 = 0 time = 685
.meas tran vdout1_81ck136 FIND v(dout1_81) AT=685.025n

* CHECK dout1_82 Vdout1_82ck136 = 0 time = 685
.meas tran vdout1_82ck136 FIND v(dout1_82) AT=685.025n

* CHECK dout1_83 Vdout1_83ck136 = 0 time = 685
.meas tran vdout1_83ck136 FIND v(dout1_83) AT=685.025n

* CHECK dout1_84 Vdout1_84ck136 = 0.9 time = 685
.meas tran vdout1_84ck136 FIND v(dout1_84) AT=685.025n

* CHECK dout1_85 Vdout1_85ck136 = 0.9 time = 685
.meas tran vdout1_85ck136 FIND v(dout1_85) AT=685.025n

* CHECK dout1_86 Vdout1_86ck136 = 0.9 time = 685
.meas tran vdout1_86ck136 FIND v(dout1_86) AT=685.025n

* CHECK dout1_87 Vdout1_87ck136 = 0.9 time = 685
.meas tran vdout1_87ck136 FIND v(dout1_87) AT=685.025n

* CHECK dout1_88 Vdout1_88ck136 = 0 time = 685
.meas tran vdout1_88ck136 FIND v(dout1_88) AT=685.025n

* CHECK dout1_89 Vdout1_89ck136 = 0.9 time = 685
.meas tran vdout1_89ck136 FIND v(dout1_89) AT=685.025n

* CHECK dout1_90 Vdout1_90ck136 = 0 time = 685
.meas tran vdout1_90ck136 FIND v(dout1_90) AT=685.025n

* CHECK dout1_91 Vdout1_91ck136 = 0 time = 685
.meas tran vdout1_91ck136 FIND v(dout1_91) AT=685.025n

* CHECK dout1_92 Vdout1_92ck136 = 0 time = 685
.meas tran vdout1_92ck136 FIND v(dout1_92) AT=685.025n

* CHECK dout1_93 Vdout1_93ck136 = 0 time = 685
.meas tran vdout1_93ck136 FIND v(dout1_93) AT=685.025n

* CHECK dout1_94 Vdout1_94ck136 = 0 time = 685
.meas tran vdout1_94ck136 FIND v(dout1_94) AT=685.025n

* CHECK dout1_95 Vdout1_95ck136 = 0.9 time = 685
.meas tran vdout1_95ck136 FIND v(dout1_95) AT=685.025n

* CHECK dout1_96 Vdout1_96ck136 = 0.9 time = 685
.meas tran vdout1_96ck136 FIND v(dout1_96) AT=685.025n

* CHECK dout1_97 Vdout1_97ck136 = 0.9 time = 685
.meas tran vdout1_97ck136 FIND v(dout1_97) AT=685.025n

* CHECK dout1_98 Vdout1_98ck136 = 0.9 time = 685
.meas tran vdout1_98ck136 FIND v(dout1_98) AT=685.025n

* CHECK dout1_99 Vdout1_99ck136 = 0 time = 685
.meas tran vdout1_99ck136 FIND v(dout1_99) AT=685.025n

* CHECK dout1_100 Vdout1_100ck136 = 0 time = 685
.meas tran vdout1_100ck136 FIND v(dout1_100) AT=685.025n

* CHECK dout1_101 Vdout1_101ck136 = 0.9 time = 685
.meas tran vdout1_101ck136 FIND v(dout1_101) AT=685.025n

* CHECK dout1_102 Vdout1_102ck136 = 0.9 time = 685
.meas tran vdout1_102ck136 FIND v(dout1_102) AT=685.025n

* CHECK dout1_103 Vdout1_103ck136 = 0 time = 685
.meas tran vdout1_103ck136 FIND v(dout1_103) AT=685.025n

* CHECK dout1_104 Vdout1_104ck136 = 0 time = 685
.meas tran vdout1_104ck136 FIND v(dout1_104) AT=685.025n

* CHECK dout1_105 Vdout1_105ck136 = 0.9 time = 685
.meas tran vdout1_105ck136 FIND v(dout1_105) AT=685.025n

* CHECK dout1_106 Vdout1_106ck136 = 0 time = 685
.meas tran vdout1_106ck136 FIND v(dout1_106) AT=685.025n

* CHECK dout1_107 Vdout1_107ck136 = 0 time = 685
.meas tran vdout1_107ck136 FIND v(dout1_107) AT=685.025n

* CHECK dout1_108 Vdout1_108ck136 = 0 time = 685
.meas tran vdout1_108ck136 FIND v(dout1_108) AT=685.025n

* CHECK dout1_109 Vdout1_109ck136 = 0.9 time = 685
.meas tran vdout1_109ck136 FIND v(dout1_109) AT=685.025n

* CHECK dout1_110 Vdout1_110ck136 = 0 time = 685
.meas tran vdout1_110ck136 FIND v(dout1_110) AT=685.025n

* CHECK dout1_111 Vdout1_111ck136 = 0.9 time = 685
.meas tran vdout1_111ck136 FIND v(dout1_111) AT=685.025n

* CHECK dout1_112 Vdout1_112ck136 = 0.9 time = 685
.meas tran vdout1_112ck136 FIND v(dout1_112) AT=685.025n

* CHECK dout1_113 Vdout1_113ck136 = 0 time = 685
.meas tran vdout1_113ck136 FIND v(dout1_113) AT=685.025n

* CHECK dout1_114 Vdout1_114ck136 = 0.9 time = 685
.meas tran vdout1_114ck136 FIND v(dout1_114) AT=685.025n

* CHECK dout1_115 Vdout1_115ck136 = 0 time = 685
.meas tran vdout1_115ck136 FIND v(dout1_115) AT=685.025n

* CHECK dout1_116 Vdout1_116ck136 = 0 time = 685
.meas tran vdout1_116ck136 FIND v(dout1_116) AT=685.025n

* CHECK dout1_117 Vdout1_117ck136 = 0 time = 685
.meas tran vdout1_117ck136 FIND v(dout1_117) AT=685.025n

* CHECK dout1_118 Vdout1_118ck136 = 0.9 time = 685
.meas tran vdout1_118ck136 FIND v(dout1_118) AT=685.025n

* CHECK dout1_119 Vdout1_119ck136 = 0 time = 685
.meas tran vdout1_119ck136 FIND v(dout1_119) AT=685.025n

* CHECK dout1_0 Vdout1_0ck138 = 0.9 time = 695
.meas tran vdout1_0ck138 FIND v(dout1_0) AT=695.025n

* CHECK dout1_1 Vdout1_1ck138 = 0 time = 695
.meas tran vdout1_1ck138 FIND v(dout1_1) AT=695.025n

* CHECK dout1_2 Vdout1_2ck138 = 0.9 time = 695
.meas tran vdout1_2ck138 FIND v(dout1_2) AT=695.025n

* CHECK dout1_3 Vdout1_3ck138 = 0 time = 695
.meas tran vdout1_3ck138 FIND v(dout1_3) AT=695.025n

* CHECK dout1_4 Vdout1_4ck138 = 0 time = 695
.meas tran vdout1_4ck138 FIND v(dout1_4) AT=695.025n

* CHECK dout1_5 Vdout1_5ck138 = 0 time = 695
.meas tran vdout1_5ck138 FIND v(dout1_5) AT=695.025n

* CHECK dout1_6 Vdout1_6ck138 = 0 time = 695
.meas tran vdout1_6ck138 FIND v(dout1_6) AT=695.025n

* CHECK dout1_7 Vdout1_7ck138 = 0 time = 695
.meas tran vdout1_7ck138 FIND v(dout1_7) AT=695.025n

* CHECK dout1_8 Vdout1_8ck138 = 0.9 time = 695
.meas tran vdout1_8ck138 FIND v(dout1_8) AT=695.025n

* CHECK dout1_9 Vdout1_9ck138 = 0 time = 695
.meas tran vdout1_9ck138 FIND v(dout1_9) AT=695.025n

* CHECK dout1_10 Vdout1_10ck138 = 0 time = 695
.meas tran vdout1_10ck138 FIND v(dout1_10) AT=695.025n

* CHECK dout1_11 Vdout1_11ck138 = 0.9 time = 695
.meas tran vdout1_11ck138 FIND v(dout1_11) AT=695.025n

* CHECK dout1_12 Vdout1_12ck138 = 0 time = 695
.meas tran vdout1_12ck138 FIND v(dout1_12) AT=695.025n

* CHECK dout1_13 Vdout1_13ck138 = 0.9 time = 695
.meas tran vdout1_13ck138 FIND v(dout1_13) AT=695.025n

* CHECK dout1_14 Vdout1_14ck138 = 0.9 time = 695
.meas tran vdout1_14ck138 FIND v(dout1_14) AT=695.025n

* CHECK dout1_15 Vdout1_15ck138 = 0 time = 695
.meas tran vdout1_15ck138 FIND v(dout1_15) AT=695.025n

* CHECK dout1_16 Vdout1_16ck138 = 0 time = 695
.meas tran vdout1_16ck138 FIND v(dout1_16) AT=695.025n

* CHECK dout1_17 Vdout1_17ck138 = 0 time = 695
.meas tran vdout1_17ck138 FIND v(dout1_17) AT=695.025n

* CHECK dout1_18 Vdout1_18ck138 = 0.9 time = 695
.meas tran vdout1_18ck138 FIND v(dout1_18) AT=695.025n

* CHECK dout1_19 Vdout1_19ck138 = 0 time = 695
.meas tran vdout1_19ck138 FIND v(dout1_19) AT=695.025n

* CHECK dout1_20 Vdout1_20ck138 = 0 time = 695
.meas tran vdout1_20ck138 FIND v(dout1_20) AT=695.025n

* CHECK dout1_21 Vdout1_21ck138 = 0 time = 695
.meas tran vdout1_21ck138 FIND v(dout1_21) AT=695.025n

* CHECK dout1_22 Vdout1_22ck138 = 0.9 time = 695
.meas tran vdout1_22ck138 FIND v(dout1_22) AT=695.025n

* CHECK dout1_23 Vdout1_23ck138 = 0.9 time = 695
.meas tran vdout1_23ck138 FIND v(dout1_23) AT=695.025n

* CHECK dout1_24 Vdout1_24ck138 = 0.9 time = 695
.meas tran vdout1_24ck138 FIND v(dout1_24) AT=695.025n

* CHECK dout1_25 Vdout1_25ck138 = 0 time = 695
.meas tran vdout1_25ck138 FIND v(dout1_25) AT=695.025n

* CHECK dout1_26 Vdout1_26ck138 = 0.9 time = 695
.meas tran vdout1_26ck138 FIND v(dout1_26) AT=695.025n

* CHECK dout1_27 Vdout1_27ck138 = 0 time = 695
.meas tran vdout1_27ck138 FIND v(dout1_27) AT=695.025n

* CHECK dout1_28 Vdout1_28ck138 = 0 time = 695
.meas tran vdout1_28ck138 FIND v(dout1_28) AT=695.025n

* CHECK dout1_29 Vdout1_29ck138 = 0 time = 695
.meas tran vdout1_29ck138 FIND v(dout1_29) AT=695.025n

* CHECK dout1_30 Vdout1_30ck138 = 0.9 time = 695
.meas tran vdout1_30ck138 FIND v(dout1_30) AT=695.025n

* CHECK dout1_31 Vdout1_31ck138 = 0.9 time = 695
.meas tran vdout1_31ck138 FIND v(dout1_31) AT=695.025n

* CHECK dout1_32 Vdout1_32ck138 = 0 time = 695
.meas tran vdout1_32ck138 FIND v(dout1_32) AT=695.025n

* CHECK dout1_33 Vdout1_33ck138 = 0 time = 695
.meas tran vdout1_33ck138 FIND v(dout1_33) AT=695.025n

* CHECK dout1_34 Vdout1_34ck138 = 0 time = 695
.meas tran vdout1_34ck138 FIND v(dout1_34) AT=695.025n

* CHECK dout1_35 Vdout1_35ck138 = 0 time = 695
.meas tran vdout1_35ck138 FIND v(dout1_35) AT=695.025n

* CHECK dout1_36 Vdout1_36ck138 = 0 time = 695
.meas tran vdout1_36ck138 FIND v(dout1_36) AT=695.025n

* CHECK dout1_37 Vdout1_37ck138 = 0 time = 695
.meas tran vdout1_37ck138 FIND v(dout1_37) AT=695.025n

* CHECK dout1_38 Vdout1_38ck138 = 0 time = 695
.meas tran vdout1_38ck138 FIND v(dout1_38) AT=695.025n

* CHECK dout1_39 Vdout1_39ck138 = 0 time = 695
.meas tran vdout1_39ck138 FIND v(dout1_39) AT=695.025n

* CHECK dout1_40 Vdout1_40ck138 = 0 time = 695
.meas tran vdout1_40ck138 FIND v(dout1_40) AT=695.025n

* CHECK dout1_41 Vdout1_41ck138 = 0 time = 695
.meas tran vdout1_41ck138 FIND v(dout1_41) AT=695.025n

* CHECK dout1_42 Vdout1_42ck138 = 0 time = 695
.meas tran vdout1_42ck138 FIND v(dout1_42) AT=695.025n

* CHECK dout1_43 Vdout1_43ck138 = 0 time = 695
.meas tran vdout1_43ck138 FIND v(dout1_43) AT=695.025n

* CHECK dout1_44 Vdout1_44ck138 = 0.9 time = 695
.meas tran vdout1_44ck138 FIND v(dout1_44) AT=695.025n

* CHECK dout1_45 Vdout1_45ck138 = 0 time = 695
.meas tran vdout1_45ck138 FIND v(dout1_45) AT=695.025n

* CHECK dout1_46 Vdout1_46ck138 = 0 time = 695
.meas tran vdout1_46ck138 FIND v(dout1_46) AT=695.025n

* CHECK dout1_47 Vdout1_47ck138 = 0 time = 695
.meas tran vdout1_47ck138 FIND v(dout1_47) AT=695.025n

* CHECK dout1_48 Vdout1_48ck138 = 0 time = 695
.meas tran vdout1_48ck138 FIND v(dout1_48) AT=695.025n

* CHECK dout1_49 Vdout1_49ck138 = 0 time = 695
.meas tran vdout1_49ck138 FIND v(dout1_49) AT=695.025n

* CHECK dout1_50 Vdout1_50ck138 = 0.9 time = 695
.meas tran vdout1_50ck138 FIND v(dout1_50) AT=695.025n

* CHECK dout1_51 Vdout1_51ck138 = 0.9 time = 695
.meas tran vdout1_51ck138 FIND v(dout1_51) AT=695.025n

* CHECK dout1_52 Vdout1_52ck138 = 0.9 time = 695
.meas tran vdout1_52ck138 FIND v(dout1_52) AT=695.025n

* CHECK dout1_53 Vdout1_53ck138 = 0 time = 695
.meas tran vdout1_53ck138 FIND v(dout1_53) AT=695.025n

* CHECK dout1_54 Vdout1_54ck138 = 0.9 time = 695
.meas tran vdout1_54ck138 FIND v(dout1_54) AT=695.025n

* CHECK dout1_55 Vdout1_55ck138 = 0.9 time = 695
.meas tran vdout1_55ck138 FIND v(dout1_55) AT=695.025n

* CHECK dout1_56 Vdout1_56ck138 = 0.9 time = 695
.meas tran vdout1_56ck138 FIND v(dout1_56) AT=695.025n

* CHECK dout1_57 Vdout1_57ck138 = 0 time = 695
.meas tran vdout1_57ck138 FIND v(dout1_57) AT=695.025n

* CHECK dout1_58 Vdout1_58ck138 = 0 time = 695
.meas tran vdout1_58ck138 FIND v(dout1_58) AT=695.025n

* CHECK dout1_59 Vdout1_59ck138 = 0 time = 695
.meas tran vdout1_59ck138 FIND v(dout1_59) AT=695.025n

* CHECK dout1_60 Vdout1_60ck138 = 0.9 time = 695
.meas tran vdout1_60ck138 FIND v(dout1_60) AT=695.025n

* CHECK dout1_61 Vdout1_61ck138 = 0.9 time = 695
.meas tran vdout1_61ck138 FIND v(dout1_61) AT=695.025n

* CHECK dout1_62 Vdout1_62ck138 = 0 time = 695
.meas tran vdout1_62ck138 FIND v(dout1_62) AT=695.025n

* CHECK dout1_63 Vdout1_63ck138 = 0.9 time = 695
.meas tran vdout1_63ck138 FIND v(dout1_63) AT=695.025n

* CHECK dout1_64 Vdout1_64ck138 = 0 time = 695
.meas tran vdout1_64ck138 FIND v(dout1_64) AT=695.025n

* CHECK dout1_65 Vdout1_65ck138 = 0.9 time = 695
.meas tran vdout1_65ck138 FIND v(dout1_65) AT=695.025n

* CHECK dout1_66 Vdout1_66ck138 = 0.9 time = 695
.meas tran vdout1_66ck138 FIND v(dout1_66) AT=695.025n

* CHECK dout1_67 Vdout1_67ck138 = 0.9 time = 695
.meas tran vdout1_67ck138 FIND v(dout1_67) AT=695.025n

* CHECK dout1_68 Vdout1_68ck138 = 0.9 time = 695
.meas tran vdout1_68ck138 FIND v(dout1_68) AT=695.025n

* CHECK dout1_69 Vdout1_69ck138 = 0.9 time = 695
.meas tran vdout1_69ck138 FIND v(dout1_69) AT=695.025n

* CHECK dout1_70 Vdout1_70ck138 = 0.9 time = 695
.meas tran vdout1_70ck138 FIND v(dout1_70) AT=695.025n

* CHECK dout1_71 Vdout1_71ck138 = 0.9 time = 695
.meas tran vdout1_71ck138 FIND v(dout1_71) AT=695.025n

* CHECK dout1_72 Vdout1_72ck138 = 0.9 time = 695
.meas tran vdout1_72ck138 FIND v(dout1_72) AT=695.025n

* CHECK dout1_73 Vdout1_73ck138 = 0 time = 695
.meas tran vdout1_73ck138 FIND v(dout1_73) AT=695.025n

* CHECK dout1_74 Vdout1_74ck138 = 0 time = 695
.meas tran vdout1_74ck138 FIND v(dout1_74) AT=695.025n

* CHECK dout1_75 Vdout1_75ck138 = 0 time = 695
.meas tran vdout1_75ck138 FIND v(dout1_75) AT=695.025n

* CHECK dout1_76 Vdout1_76ck138 = 0.9 time = 695
.meas tran vdout1_76ck138 FIND v(dout1_76) AT=695.025n

* CHECK dout1_77 Vdout1_77ck138 = 0.9 time = 695
.meas tran vdout1_77ck138 FIND v(dout1_77) AT=695.025n

* CHECK dout1_78 Vdout1_78ck138 = 0.9 time = 695
.meas tran vdout1_78ck138 FIND v(dout1_78) AT=695.025n

* CHECK dout1_79 Vdout1_79ck138 = 0.9 time = 695
.meas tran vdout1_79ck138 FIND v(dout1_79) AT=695.025n

* CHECK dout1_80 Vdout1_80ck138 = 0.9 time = 695
.meas tran vdout1_80ck138 FIND v(dout1_80) AT=695.025n

* CHECK dout1_81 Vdout1_81ck138 = 0 time = 695
.meas tran vdout1_81ck138 FIND v(dout1_81) AT=695.025n

* CHECK dout1_82 Vdout1_82ck138 = 0 time = 695
.meas tran vdout1_82ck138 FIND v(dout1_82) AT=695.025n

* CHECK dout1_83 Vdout1_83ck138 = 0 time = 695
.meas tran vdout1_83ck138 FIND v(dout1_83) AT=695.025n

* CHECK dout1_84 Vdout1_84ck138 = 0.9 time = 695
.meas tran vdout1_84ck138 FIND v(dout1_84) AT=695.025n

* CHECK dout1_85 Vdout1_85ck138 = 0.9 time = 695
.meas tran vdout1_85ck138 FIND v(dout1_85) AT=695.025n

* CHECK dout1_86 Vdout1_86ck138 = 0.9 time = 695
.meas tran vdout1_86ck138 FIND v(dout1_86) AT=695.025n

* CHECK dout1_87 Vdout1_87ck138 = 0.9 time = 695
.meas tran vdout1_87ck138 FIND v(dout1_87) AT=695.025n

* CHECK dout1_88 Vdout1_88ck138 = 0 time = 695
.meas tran vdout1_88ck138 FIND v(dout1_88) AT=695.025n

* CHECK dout1_89 Vdout1_89ck138 = 0.9 time = 695
.meas tran vdout1_89ck138 FIND v(dout1_89) AT=695.025n

* CHECK dout1_90 Vdout1_90ck138 = 0 time = 695
.meas tran vdout1_90ck138 FIND v(dout1_90) AT=695.025n

* CHECK dout1_91 Vdout1_91ck138 = 0 time = 695
.meas tran vdout1_91ck138 FIND v(dout1_91) AT=695.025n

* CHECK dout1_92 Vdout1_92ck138 = 0 time = 695
.meas tran vdout1_92ck138 FIND v(dout1_92) AT=695.025n

* CHECK dout1_93 Vdout1_93ck138 = 0 time = 695
.meas tran vdout1_93ck138 FIND v(dout1_93) AT=695.025n

* CHECK dout1_94 Vdout1_94ck138 = 0 time = 695
.meas tran vdout1_94ck138 FIND v(dout1_94) AT=695.025n

* CHECK dout1_95 Vdout1_95ck138 = 0.9 time = 695
.meas tran vdout1_95ck138 FIND v(dout1_95) AT=695.025n

* CHECK dout1_96 Vdout1_96ck138 = 0.9 time = 695
.meas tran vdout1_96ck138 FIND v(dout1_96) AT=695.025n

* CHECK dout1_97 Vdout1_97ck138 = 0.9 time = 695
.meas tran vdout1_97ck138 FIND v(dout1_97) AT=695.025n

* CHECK dout1_98 Vdout1_98ck138 = 0.9 time = 695
.meas tran vdout1_98ck138 FIND v(dout1_98) AT=695.025n

* CHECK dout1_99 Vdout1_99ck138 = 0 time = 695
.meas tran vdout1_99ck138 FIND v(dout1_99) AT=695.025n

* CHECK dout1_100 Vdout1_100ck138 = 0 time = 695
.meas tran vdout1_100ck138 FIND v(dout1_100) AT=695.025n

* CHECK dout1_101 Vdout1_101ck138 = 0.9 time = 695
.meas tran vdout1_101ck138 FIND v(dout1_101) AT=695.025n

* CHECK dout1_102 Vdout1_102ck138 = 0.9 time = 695
.meas tran vdout1_102ck138 FIND v(dout1_102) AT=695.025n

* CHECK dout1_103 Vdout1_103ck138 = 0 time = 695
.meas tran vdout1_103ck138 FIND v(dout1_103) AT=695.025n

* CHECK dout1_104 Vdout1_104ck138 = 0 time = 695
.meas tran vdout1_104ck138 FIND v(dout1_104) AT=695.025n

* CHECK dout1_105 Vdout1_105ck138 = 0.9 time = 695
.meas tran vdout1_105ck138 FIND v(dout1_105) AT=695.025n

* CHECK dout1_106 Vdout1_106ck138 = 0 time = 695
.meas tran vdout1_106ck138 FIND v(dout1_106) AT=695.025n

* CHECK dout1_107 Vdout1_107ck138 = 0 time = 695
.meas tran vdout1_107ck138 FIND v(dout1_107) AT=695.025n

* CHECK dout1_108 Vdout1_108ck138 = 0 time = 695
.meas tran vdout1_108ck138 FIND v(dout1_108) AT=695.025n

* CHECK dout1_109 Vdout1_109ck138 = 0.9 time = 695
.meas tran vdout1_109ck138 FIND v(dout1_109) AT=695.025n

* CHECK dout1_110 Vdout1_110ck138 = 0 time = 695
.meas tran vdout1_110ck138 FIND v(dout1_110) AT=695.025n

* CHECK dout1_111 Vdout1_111ck138 = 0.9 time = 695
.meas tran vdout1_111ck138 FIND v(dout1_111) AT=695.025n

* CHECK dout1_112 Vdout1_112ck138 = 0.9 time = 695
.meas tran vdout1_112ck138 FIND v(dout1_112) AT=695.025n

* CHECK dout1_113 Vdout1_113ck138 = 0 time = 695
.meas tran vdout1_113ck138 FIND v(dout1_113) AT=695.025n

* CHECK dout1_114 Vdout1_114ck138 = 0.9 time = 695
.meas tran vdout1_114ck138 FIND v(dout1_114) AT=695.025n

* CHECK dout1_115 Vdout1_115ck138 = 0 time = 695
.meas tran vdout1_115ck138 FIND v(dout1_115) AT=695.025n

* CHECK dout1_116 Vdout1_116ck138 = 0 time = 695
.meas tran vdout1_116ck138 FIND v(dout1_116) AT=695.025n

* CHECK dout1_117 Vdout1_117ck138 = 0 time = 695
.meas tran vdout1_117ck138 FIND v(dout1_117) AT=695.025n

* CHECK dout1_118 Vdout1_118ck138 = 0.9 time = 695
.meas tran vdout1_118ck138 FIND v(dout1_118) AT=695.025n

* CHECK dout1_119 Vdout1_119ck138 = 0 time = 695
.meas tran vdout1_119ck138 FIND v(dout1_119) AT=695.025n

* CHECK dout1_0 Vdout1_0ck140 = 0 time = 705
.meas tran vdout1_0ck140 FIND v(dout1_0) AT=705.025n

* CHECK dout1_1 Vdout1_1ck140 = 0 time = 705
.meas tran vdout1_1ck140 FIND v(dout1_1) AT=705.025n

* CHECK dout1_2 Vdout1_2ck140 = 0 time = 705
.meas tran vdout1_2ck140 FIND v(dout1_2) AT=705.025n

* CHECK dout1_3 Vdout1_3ck140 = 0.9 time = 705
.meas tran vdout1_3ck140 FIND v(dout1_3) AT=705.025n

* CHECK dout1_4 Vdout1_4ck140 = 0.9 time = 705
.meas tran vdout1_4ck140 FIND v(dout1_4) AT=705.025n

* CHECK dout1_5 Vdout1_5ck140 = 0 time = 705
.meas tran vdout1_5ck140 FIND v(dout1_5) AT=705.025n

* CHECK dout1_6 Vdout1_6ck140 = 0 time = 705
.meas tran vdout1_6ck140 FIND v(dout1_6) AT=705.025n

* CHECK dout1_7 Vdout1_7ck140 = 0.9 time = 705
.meas tran vdout1_7ck140 FIND v(dout1_7) AT=705.025n

* CHECK dout1_8 Vdout1_8ck140 = 0.9 time = 705
.meas tran vdout1_8ck140 FIND v(dout1_8) AT=705.025n

* CHECK dout1_9 Vdout1_9ck140 = 0.9 time = 705
.meas tran vdout1_9ck140 FIND v(dout1_9) AT=705.025n

* CHECK dout1_10 Vdout1_10ck140 = 0 time = 705
.meas tran vdout1_10ck140 FIND v(dout1_10) AT=705.025n

* CHECK dout1_11 Vdout1_11ck140 = 0 time = 705
.meas tran vdout1_11ck140 FIND v(dout1_11) AT=705.025n

* CHECK dout1_12 Vdout1_12ck140 = 0 time = 705
.meas tran vdout1_12ck140 FIND v(dout1_12) AT=705.025n

* CHECK dout1_13 Vdout1_13ck140 = 0 time = 705
.meas tran vdout1_13ck140 FIND v(dout1_13) AT=705.025n

* CHECK dout1_14 Vdout1_14ck140 = 0.9 time = 705
.meas tran vdout1_14ck140 FIND v(dout1_14) AT=705.025n

* CHECK dout1_15 Vdout1_15ck140 = 0.9 time = 705
.meas tran vdout1_15ck140 FIND v(dout1_15) AT=705.025n

* CHECK dout1_16 Vdout1_16ck140 = 0 time = 705
.meas tran vdout1_16ck140 FIND v(dout1_16) AT=705.025n

* CHECK dout1_17 Vdout1_17ck140 = 0.9 time = 705
.meas tran vdout1_17ck140 FIND v(dout1_17) AT=705.025n

* CHECK dout1_18 Vdout1_18ck140 = 0.9 time = 705
.meas tran vdout1_18ck140 FIND v(dout1_18) AT=705.025n

* CHECK dout1_19 Vdout1_19ck140 = 0 time = 705
.meas tran vdout1_19ck140 FIND v(dout1_19) AT=705.025n

* CHECK dout1_20 Vdout1_20ck140 = 0.9 time = 705
.meas tran vdout1_20ck140 FIND v(dout1_20) AT=705.025n

* CHECK dout1_21 Vdout1_21ck140 = 0 time = 705
.meas tran vdout1_21ck140 FIND v(dout1_21) AT=705.025n

* CHECK dout1_22 Vdout1_22ck140 = 0.9 time = 705
.meas tran vdout1_22ck140 FIND v(dout1_22) AT=705.025n

* CHECK dout1_23 Vdout1_23ck140 = 0 time = 705
.meas tran vdout1_23ck140 FIND v(dout1_23) AT=705.025n

* CHECK dout1_24 Vdout1_24ck140 = 0 time = 705
.meas tran vdout1_24ck140 FIND v(dout1_24) AT=705.025n

* CHECK dout1_25 Vdout1_25ck140 = 0.9 time = 705
.meas tran vdout1_25ck140 FIND v(dout1_25) AT=705.025n

* CHECK dout1_26 Vdout1_26ck140 = 0 time = 705
.meas tran vdout1_26ck140 FIND v(dout1_26) AT=705.025n

* CHECK dout1_27 Vdout1_27ck140 = 0 time = 705
.meas tran vdout1_27ck140 FIND v(dout1_27) AT=705.025n

* CHECK dout1_28 Vdout1_28ck140 = 0.9 time = 705
.meas tran vdout1_28ck140 FIND v(dout1_28) AT=705.025n

* CHECK dout1_29 Vdout1_29ck140 = 0.9 time = 705
.meas tran vdout1_29ck140 FIND v(dout1_29) AT=705.025n

* CHECK dout1_30 Vdout1_30ck140 = 0 time = 705
.meas tran vdout1_30ck140 FIND v(dout1_30) AT=705.025n

* CHECK dout1_31 Vdout1_31ck140 = 0.9 time = 705
.meas tran vdout1_31ck140 FIND v(dout1_31) AT=705.025n

* CHECK dout1_32 Vdout1_32ck140 = 0.9 time = 705
.meas tran vdout1_32ck140 FIND v(dout1_32) AT=705.025n

* CHECK dout1_33 Vdout1_33ck140 = 0.9 time = 705
.meas tran vdout1_33ck140 FIND v(dout1_33) AT=705.025n

* CHECK dout1_34 Vdout1_34ck140 = 0 time = 705
.meas tran vdout1_34ck140 FIND v(dout1_34) AT=705.025n

* CHECK dout1_35 Vdout1_35ck140 = 0.9 time = 705
.meas tran vdout1_35ck140 FIND v(dout1_35) AT=705.025n

* CHECK dout1_36 Vdout1_36ck140 = 0.9 time = 705
.meas tran vdout1_36ck140 FIND v(dout1_36) AT=705.025n

* CHECK dout1_37 Vdout1_37ck140 = 0.9 time = 705
.meas tran vdout1_37ck140 FIND v(dout1_37) AT=705.025n

* CHECK dout1_38 Vdout1_38ck140 = 0.9 time = 705
.meas tran vdout1_38ck140 FIND v(dout1_38) AT=705.025n

* CHECK dout1_39 Vdout1_39ck140 = 0 time = 705
.meas tran vdout1_39ck140 FIND v(dout1_39) AT=705.025n

* CHECK dout1_40 Vdout1_40ck140 = 0.9 time = 705
.meas tran vdout1_40ck140 FIND v(dout1_40) AT=705.025n

* CHECK dout1_41 Vdout1_41ck140 = 0 time = 705
.meas tran vdout1_41ck140 FIND v(dout1_41) AT=705.025n

* CHECK dout1_42 Vdout1_42ck140 = 0.9 time = 705
.meas tran vdout1_42ck140 FIND v(dout1_42) AT=705.025n

* CHECK dout1_43 Vdout1_43ck140 = 0 time = 705
.meas tran vdout1_43ck140 FIND v(dout1_43) AT=705.025n

* CHECK dout1_44 Vdout1_44ck140 = 0 time = 705
.meas tran vdout1_44ck140 FIND v(dout1_44) AT=705.025n

* CHECK dout1_45 Vdout1_45ck140 = 0 time = 705
.meas tran vdout1_45ck140 FIND v(dout1_45) AT=705.025n

* CHECK dout1_46 Vdout1_46ck140 = 0.9 time = 705
.meas tran vdout1_46ck140 FIND v(dout1_46) AT=705.025n

* CHECK dout1_47 Vdout1_47ck140 = 0.9 time = 705
.meas tran vdout1_47ck140 FIND v(dout1_47) AT=705.025n

* CHECK dout1_48 Vdout1_48ck140 = 0.9 time = 705
.meas tran vdout1_48ck140 FIND v(dout1_48) AT=705.025n

* CHECK dout1_49 Vdout1_49ck140 = 0.9 time = 705
.meas tran vdout1_49ck140 FIND v(dout1_49) AT=705.025n

* CHECK dout1_50 Vdout1_50ck140 = 0 time = 705
.meas tran vdout1_50ck140 FIND v(dout1_50) AT=705.025n

* CHECK dout1_51 Vdout1_51ck140 = 0 time = 705
.meas tran vdout1_51ck140 FIND v(dout1_51) AT=705.025n

* CHECK dout1_52 Vdout1_52ck140 = 0.9 time = 705
.meas tran vdout1_52ck140 FIND v(dout1_52) AT=705.025n

* CHECK dout1_53 Vdout1_53ck140 = 0 time = 705
.meas tran vdout1_53ck140 FIND v(dout1_53) AT=705.025n

* CHECK dout1_54 Vdout1_54ck140 = 0 time = 705
.meas tran vdout1_54ck140 FIND v(dout1_54) AT=705.025n

* CHECK dout1_55 Vdout1_55ck140 = 0 time = 705
.meas tran vdout1_55ck140 FIND v(dout1_55) AT=705.025n

* CHECK dout1_56 Vdout1_56ck140 = 0.9 time = 705
.meas tran vdout1_56ck140 FIND v(dout1_56) AT=705.025n

* CHECK dout1_57 Vdout1_57ck140 = 0 time = 705
.meas tran vdout1_57ck140 FIND v(dout1_57) AT=705.025n

* CHECK dout1_58 Vdout1_58ck140 = 0 time = 705
.meas tran vdout1_58ck140 FIND v(dout1_58) AT=705.025n

* CHECK dout1_59 Vdout1_59ck140 = 0.9 time = 705
.meas tran vdout1_59ck140 FIND v(dout1_59) AT=705.025n

* CHECK dout1_60 Vdout1_60ck140 = 0 time = 705
.meas tran vdout1_60ck140 FIND v(dout1_60) AT=705.025n

* CHECK dout1_61 Vdout1_61ck140 = 0 time = 705
.meas tran vdout1_61ck140 FIND v(dout1_61) AT=705.025n

* CHECK dout1_62 Vdout1_62ck140 = 0 time = 705
.meas tran vdout1_62ck140 FIND v(dout1_62) AT=705.025n

* CHECK dout1_63 Vdout1_63ck140 = 0 time = 705
.meas tran vdout1_63ck140 FIND v(dout1_63) AT=705.025n

* CHECK dout1_64 Vdout1_64ck140 = 0 time = 705
.meas tran vdout1_64ck140 FIND v(dout1_64) AT=705.025n

* CHECK dout1_65 Vdout1_65ck140 = 0 time = 705
.meas tran vdout1_65ck140 FIND v(dout1_65) AT=705.025n

* CHECK dout1_66 Vdout1_66ck140 = 0.9 time = 705
.meas tran vdout1_66ck140 FIND v(dout1_66) AT=705.025n

* CHECK dout1_67 Vdout1_67ck140 = 0.9 time = 705
.meas tran vdout1_67ck140 FIND v(dout1_67) AT=705.025n

* CHECK dout1_68 Vdout1_68ck140 = 0 time = 705
.meas tran vdout1_68ck140 FIND v(dout1_68) AT=705.025n

* CHECK dout1_69 Vdout1_69ck140 = 0 time = 705
.meas tran vdout1_69ck140 FIND v(dout1_69) AT=705.025n

* CHECK dout1_70 Vdout1_70ck140 = 0 time = 705
.meas tran vdout1_70ck140 FIND v(dout1_70) AT=705.025n

* CHECK dout1_71 Vdout1_71ck140 = 0.9 time = 705
.meas tran vdout1_71ck140 FIND v(dout1_71) AT=705.025n

* CHECK dout1_72 Vdout1_72ck140 = 0 time = 705
.meas tran vdout1_72ck140 FIND v(dout1_72) AT=705.025n

* CHECK dout1_73 Vdout1_73ck140 = 0.9 time = 705
.meas tran vdout1_73ck140 FIND v(dout1_73) AT=705.025n

* CHECK dout1_74 Vdout1_74ck140 = 0.9 time = 705
.meas tran vdout1_74ck140 FIND v(dout1_74) AT=705.025n

* CHECK dout1_75 Vdout1_75ck140 = 0 time = 705
.meas tran vdout1_75ck140 FIND v(dout1_75) AT=705.025n

* CHECK dout1_76 Vdout1_76ck140 = 0 time = 705
.meas tran vdout1_76ck140 FIND v(dout1_76) AT=705.025n

* CHECK dout1_77 Vdout1_77ck140 = 0 time = 705
.meas tran vdout1_77ck140 FIND v(dout1_77) AT=705.025n

* CHECK dout1_78 Vdout1_78ck140 = 0 time = 705
.meas tran vdout1_78ck140 FIND v(dout1_78) AT=705.025n

* CHECK dout1_79 Vdout1_79ck140 = 0 time = 705
.meas tran vdout1_79ck140 FIND v(dout1_79) AT=705.025n

* CHECK dout1_80 Vdout1_80ck140 = 0.9 time = 705
.meas tran vdout1_80ck140 FIND v(dout1_80) AT=705.025n

* CHECK dout1_81 Vdout1_81ck140 = 0 time = 705
.meas tran vdout1_81ck140 FIND v(dout1_81) AT=705.025n

* CHECK dout1_82 Vdout1_82ck140 = 0 time = 705
.meas tran vdout1_82ck140 FIND v(dout1_82) AT=705.025n

* CHECK dout1_83 Vdout1_83ck140 = 0 time = 705
.meas tran vdout1_83ck140 FIND v(dout1_83) AT=705.025n

* CHECK dout1_84 Vdout1_84ck140 = 0 time = 705
.meas tran vdout1_84ck140 FIND v(dout1_84) AT=705.025n

* CHECK dout1_85 Vdout1_85ck140 = 0 time = 705
.meas tran vdout1_85ck140 FIND v(dout1_85) AT=705.025n

* CHECK dout1_86 Vdout1_86ck140 = 0 time = 705
.meas tran vdout1_86ck140 FIND v(dout1_86) AT=705.025n

* CHECK dout1_87 Vdout1_87ck140 = 0 time = 705
.meas tran vdout1_87ck140 FIND v(dout1_87) AT=705.025n

* CHECK dout1_88 Vdout1_88ck140 = 0 time = 705
.meas tran vdout1_88ck140 FIND v(dout1_88) AT=705.025n

* CHECK dout1_89 Vdout1_89ck140 = 0.9 time = 705
.meas tran vdout1_89ck140 FIND v(dout1_89) AT=705.025n

* CHECK dout1_90 Vdout1_90ck140 = 0.9 time = 705
.meas tran vdout1_90ck140 FIND v(dout1_90) AT=705.025n

* CHECK dout1_91 Vdout1_91ck140 = 0.9 time = 705
.meas tran vdout1_91ck140 FIND v(dout1_91) AT=705.025n

* CHECK dout1_92 Vdout1_92ck140 = 0 time = 705
.meas tran vdout1_92ck140 FIND v(dout1_92) AT=705.025n

* CHECK dout1_93 Vdout1_93ck140 = 0 time = 705
.meas tran vdout1_93ck140 FIND v(dout1_93) AT=705.025n

* CHECK dout1_94 Vdout1_94ck140 = 0.9 time = 705
.meas tran vdout1_94ck140 FIND v(dout1_94) AT=705.025n

* CHECK dout1_95 Vdout1_95ck140 = 0 time = 705
.meas tran vdout1_95ck140 FIND v(dout1_95) AT=705.025n

* CHECK dout1_96 Vdout1_96ck140 = 0.9 time = 705
.meas tran vdout1_96ck140 FIND v(dout1_96) AT=705.025n

* CHECK dout1_97 Vdout1_97ck140 = 0 time = 705
.meas tran vdout1_97ck140 FIND v(dout1_97) AT=705.025n

* CHECK dout1_98 Vdout1_98ck140 = 0 time = 705
.meas tran vdout1_98ck140 FIND v(dout1_98) AT=705.025n

* CHECK dout1_99 Vdout1_99ck140 = 0.9 time = 705
.meas tran vdout1_99ck140 FIND v(dout1_99) AT=705.025n

* CHECK dout1_100 Vdout1_100ck140 = 0.9 time = 705
.meas tran vdout1_100ck140 FIND v(dout1_100) AT=705.025n

* CHECK dout1_101 Vdout1_101ck140 = 0 time = 705
.meas tran vdout1_101ck140 FIND v(dout1_101) AT=705.025n

* CHECK dout1_102 Vdout1_102ck140 = 0 time = 705
.meas tran vdout1_102ck140 FIND v(dout1_102) AT=705.025n

* CHECK dout1_103 Vdout1_103ck140 = 0.9 time = 705
.meas tran vdout1_103ck140 FIND v(dout1_103) AT=705.025n

* CHECK dout1_104 Vdout1_104ck140 = 0 time = 705
.meas tran vdout1_104ck140 FIND v(dout1_104) AT=705.025n

* CHECK dout1_105 Vdout1_105ck140 = 0 time = 705
.meas tran vdout1_105ck140 FIND v(dout1_105) AT=705.025n

* CHECK dout1_106 Vdout1_106ck140 = 0.9 time = 705
.meas tran vdout1_106ck140 FIND v(dout1_106) AT=705.025n

* CHECK dout1_107 Vdout1_107ck140 = 0.9 time = 705
.meas tran vdout1_107ck140 FIND v(dout1_107) AT=705.025n

* CHECK dout1_108 Vdout1_108ck140 = 0.9 time = 705
.meas tran vdout1_108ck140 FIND v(dout1_108) AT=705.025n

* CHECK dout1_109 Vdout1_109ck140 = 0.9 time = 705
.meas tran vdout1_109ck140 FIND v(dout1_109) AT=705.025n

* CHECK dout1_110 Vdout1_110ck140 = 0.9 time = 705
.meas tran vdout1_110ck140 FIND v(dout1_110) AT=705.025n

* CHECK dout1_111 Vdout1_111ck140 = 0 time = 705
.meas tran vdout1_111ck140 FIND v(dout1_111) AT=705.025n

* CHECK dout1_112 Vdout1_112ck140 = 0 time = 705
.meas tran vdout1_112ck140 FIND v(dout1_112) AT=705.025n

* CHECK dout1_113 Vdout1_113ck140 = 0.9 time = 705
.meas tran vdout1_113ck140 FIND v(dout1_113) AT=705.025n

* CHECK dout1_114 Vdout1_114ck140 = 0.9 time = 705
.meas tran vdout1_114ck140 FIND v(dout1_114) AT=705.025n

* CHECK dout1_115 Vdout1_115ck140 = 0 time = 705
.meas tran vdout1_115ck140 FIND v(dout1_115) AT=705.025n

* CHECK dout1_116 Vdout1_116ck140 = 0.9 time = 705
.meas tran vdout1_116ck140 FIND v(dout1_116) AT=705.025n

* CHECK dout1_117 Vdout1_117ck140 = 0 time = 705
.meas tran vdout1_117ck140 FIND v(dout1_117) AT=705.025n

* CHECK dout1_118 Vdout1_118ck140 = 0 time = 705
.meas tran vdout1_118ck140 FIND v(dout1_118) AT=705.025n

* CHECK dout1_119 Vdout1_119ck140 = 0.9 time = 705
.meas tran vdout1_119ck140 FIND v(dout1_119) AT=705.025n

* CHECK dout1_0 Vdout1_0ck142 = 0 time = 715
.meas tran vdout1_0ck142 FIND v(dout1_0) AT=715.025n

* CHECK dout1_1 Vdout1_1ck142 = 0.9 time = 715
.meas tran vdout1_1ck142 FIND v(dout1_1) AT=715.025n

* CHECK dout1_2 Vdout1_2ck142 = 0 time = 715
.meas tran vdout1_2ck142 FIND v(dout1_2) AT=715.025n

* CHECK dout1_3 Vdout1_3ck142 = 0 time = 715
.meas tran vdout1_3ck142 FIND v(dout1_3) AT=715.025n

* CHECK dout1_4 Vdout1_4ck142 = 0.9 time = 715
.meas tran vdout1_4ck142 FIND v(dout1_4) AT=715.025n

* CHECK dout1_5 Vdout1_5ck142 = 0.9 time = 715
.meas tran vdout1_5ck142 FIND v(dout1_5) AT=715.025n

* CHECK dout1_6 Vdout1_6ck142 = 0.9 time = 715
.meas tran vdout1_6ck142 FIND v(dout1_6) AT=715.025n

* CHECK dout1_7 Vdout1_7ck142 = 0 time = 715
.meas tran vdout1_7ck142 FIND v(dout1_7) AT=715.025n

* CHECK dout1_8 Vdout1_8ck142 = 0.9 time = 715
.meas tran vdout1_8ck142 FIND v(dout1_8) AT=715.025n

* CHECK dout1_9 Vdout1_9ck142 = 0 time = 715
.meas tran vdout1_9ck142 FIND v(dout1_9) AT=715.025n

* CHECK dout1_10 Vdout1_10ck142 = 0.9 time = 715
.meas tran vdout1_10ck142 FIND v(dout1_10) AT=715.025n

* CHECK dout1_11 Vdout1_11ck142 = 0 time = 715
.meas tran vdout1_11ck142 FIND v(dout1_11) AT=715.025n

* CHECK dout1_12 Vdout1_12ck142 = 0 time = 715
.meas tran vdout1_12ck142 FIND v(dout1_12) AT=715.025n

* CHECK dout1_13 Vdout1_13ck142 = 0.9 time = 715
.meas tran vdout1_13ck142 FIND v(dout1_13) AT=715.025n

* CHECK dout1_14 Vdout1_14ck142 = 0.9 time = 715
.meas tran vdout1_14ck142 FIND v(dout1_14) AT=715.025n

* CHECK dout1_15 Vdout1_15ck142 = 0.9 time = 715
.meas tran vdout1_15ck142 FIND v(dout1_15) AT=715.025n

* CHECK dout1_16 Vdout1_16ck142 = 0 time = 715
.meas tran vdout1_16ck142 FIND v(dout1_16) AT=715.025n

* CHECK dout1_17 Vdout1_17ck142 = 0 time = 715
.meas tran vdout1_17ck142 FIND v(dout1_17) AT=715.025n

* CHECK dout1_18 Vdout1_18ck142 = 0 time = 715
.meas tran vdout1_18ck142 FIND v(dout1_18) AT=715.025n

* CHECK dout1_19 Vdout1_19ck142 = 0 time = 715
.meas tran vdout1_19ck142 FIND v(dout1_19) AT=715.025n

* CHECK dout1_20 Vdout1_20ck142 = 0.9 time = 715
.meas tran vdout1_20ck142 FIND v(dout1_20) AT=715.025n

* CHECK dout1_21 Vdout1_21ck142 = 0.9 time = 715
.meas tran vdout1_21ck142 FIND v(dout1_21) AT=715.025n

* CHECK dout1_22 Vdout1_22ck142 = 0.9 time = 715
.meas tran vdout1_22ck142 FIND v(dout1_22) AT=715.025n

* CHECK dout1_23 Vdout1_23ck142 = 0.9 time = 715
.meas tran vdout1_23ck142 FIND v(dout1_23) AT=715.025n

* CHECK dout1_24 Vdout1_24ck142 = 0 time = 715
.meas tran vdout1_24ck142 FIND v(dout1_24) AT=715.025n

* CHECK dout1_25 Vdout1_25ck142 = 0 time = 715
.meas tran vdout1_25ck142 FIND v(dout1_25) AT=715.025n

* CHECK dout1_26 Vdout1_26ck142 = 0.9 time = 715
.meas tran vdout1_26ck142 FIND v(dout1_26) AT=715.025n

* CHECK dout1_27 Vdout1_27ck142 = 0.9 time = 715
.meas tran vdout1_27ck142 FIND v(dout1_27) AT=715.025n

* CHECK dout1_28 Vdout1_28ck142 = 0.9 time = 715
.meas tran vdout1_28ck142 FIND v(dout1_28) AT=715.025n

* CHECK dout1_29 Vdout1_29ck142 = 0 time = 715
.meas tran vdout1_29ck142 FIND v(dout1_29) AT=715.025n

* CHECK dout1_30 Vdout1_30ck142 = 0 time = 715
.meas tran vdout1_30ck142 FIND v(dout1_30) AT=715.025n

* CHECK dout1_31 Vdout1_31ck142 = 0.9 time = 715
.meas tran vdout1_31ck142 FIND v(dout1_31) AT=715.025n

* CHECK dout1_32 Vdout1_32ck142 = 0 time = 715
.meas tran vdout1_32ck142 FIND v(dout1_32) AT=715.025n

* CHECK dout1_33 Vdout1_33ck142 = 0 time = 715
.meas tran vdout1_33ck142 FIND v(dout1_33) AT=715.025n

* CHECK dout1_34 Vdout1_34ck142 = 0.9 time = 715
.meas tran vdout1_34ck142 FIND v(dout1_34) AT=715.025n

* CHECK dout1_35 Vdout1_35ck142 = 0.9 time = 715
.meas tran vdout1_35ck142 FIND v(dout1_35) AT=715.025n

* CHECK dout1_36 Vdout1_36ck142 = 0.9 time = 715
.meas tran vdout1_36ck142 FIND v(dout1_36) AT=715.025n

* CHECK dout1_37 Vdout1_37ck142 = 0 time = 715
.meas tran vdout1_37ck142 FIND v(dout1_37) AT=715.025n

* CHECK dout1_38 Vdout1_38ck142 = 0.9 time = 715
.meas tran vdout1_38ck142 FIND v(dout1_38) AT=715.025n

* CHECK dout1_39 Vdout1_39ck142 = 0 time = 715
.meas tran vdout1_39ck142 FIND v(dout1_39) AT=715.025n

* CHECK dout1_40 Vdout1_40ck142 = 0 time = 715
.meas tran vdout1_40ck142 FIND v(dout1_40) AT=715.025n

* CHECK dout1_41 Vdout1_41ck142 = 0 time = 715
.meas tran vdout1_41ck142 FIND v(dout1_41) AT=715.025n

* CHECK dout1_42 Vdout1_42ck142 = 0 time = 715
.meas tran vdout1_42ck142 FIND v(dout1_42) AT=715.025n

* CHECK dout1_43 Vdout1_43ck142 = 0.9 time = 715
.meas tran vdout1_43ck142 FIND v(dout1_43) AT=715.025n

* CHECK dout1_44 Vdout1_44ck142 = 0.9 time = 715
.meas tran vdout1_44ck142 FIND v(dout1_44) AT=715.025n

* CHECK dout1_45 Vdout1_45ck142 = 0.9 time = 715
.meas tran vdout1_45ck142 FIND v(dout1_45) AT=715.025n

* CHECK dout1_46 Vdout1_46ck142 = 0 time = 715
.meas tran vdout1_46ck142 FIND v(dout1_46) AT=715.025n

* CHECK dout1_47 Vdout1_47ck142 = 0 time = 715
.meas tran vdout1_47ck142 FIND v(dout1_47) AT=715.025n

* CHECK dout1_48 Vdout1_48ck142 = 0 time = 715
.meas tran vdout1_48ck142 FIND v(dout1_48) AT=715.025n

* CHECK dout1_49 Vdout1_49ck142 = 0.9 time = 715
.meas tran vdout1_49ck142 FIND v(dout1_49) AT=715.025n

* CHECK dout1_50 Vdout1_50ck142 = 0 time = 715
.meas tran vdout1_50ck142 FIND v(dout1_50) AT=715.025n

* CHECK dout1_51 Vdout1_51ck142 = 0.9 time = 715
.meas tran vdout1_51ck142 FIND v(dout1_51) AT=715.025n

* CHECK dout1_52 Vdout1_52ck142 = 0 time = 715
.meas tran vdout1_52ck142 FIND v(dout1_52) AT=715.025n

* CHECK dout1_53 Vdout1_53ck142 = 0 time = 715
.meas tran vdout1_53ck142 FIND v(dout1_53) AT=715.025n

* CHECK dout1_54 Vdout1_54ck142 = 0.9 time = 715
.meas tran vdout1_54ck142 FIND v(dout1_54) AT=715.025n

* CHECK dout1_55 Vdout1_55ck142 = 0 time = 715
.meas tran vdout1_55ck142 FIND v(dout1_55) AT=715.025n

* CHECK dout1_56 Vdout1_56ck142 = 0 time = 715
.meas tran vdout1_56ck142 FIND v(dout1_56) AT=715.025n

* CHECK dout1_57 Vdout1_57ck142 = 0 time = 715
.meas tran vdout1_57ck142 FIND v(dout1_57) AT=715.025n

* CHECK dout1_58 Vdout1_58ck142 = 0 time = 715
.meas tran vdout1_58ck142 FIND v(dout1_58) AT=715.025n

* CHECK dout1_59 Vdout1_59ck142 = 0 time = 715
.meas tran vdout1_59ck142 FIND v(dout1_59) AT=715.025n

* CHECK dout1_60 Vdout1_60ck142 = 0.9 time = 715
.meas tran vdout1_60ck142 FIND v(dout1_60) AT=715.025n

* CHECK dout1_61 Vdout1_61ck142 = 0.9 time = 715
.meas tran vdout1_61ck142 FIND v(dout1_61) AT=715.025n

* CHECK dout1_62 Vdout1_62ck142 = 0 time = 715
.meas tran vdout1_62ck142 FIND v(dout1_62) AT=715.025n

* CHECK dout1_63 Vdout1_63ck142 = 0 time = 715
.meas tran vdout1_63ck142 FIND v(dout1_63) AT=715.025n

* CHECK dout1_64 Vdout1_64ck142 = 0 time = 715
.meas tran vdout1_64ck142 FIND v(dout1_64) AT=715.025n

* CHECK dout1_65 Vdout1_65ck142 = 0.9 time = 715
.meas tran vdout1_65ck142 FIND v(dout1_65) AT=715.025n

* CHECK dout1_66 Vdout1_66ck142 = 0 time = 715
.meas tran vdout1_66ck142 FIND v(dout1_66) AT=715.025n

* CHECK dout1_67 Vdout1_67ck142 = 0 time = 715
.meas tran vdout1_67ck142 FIND v(dout1_67) AT=715.025n

* CHECK dout1_68 Vdout1_68ck142 = 0 time = 715
.meas tran vdout1_68ck142 FIND v(dout1_68) AT=715.025n

* CHECK dout1_69 Vdout1_69ck142 = 0 time = 715
.meas tran vdout1_69ck142 FIND v(dout1_69) AT=715.025n

* CHECK dout1_70 Vdout1_70ck142 = 0.9 time = 715
.meas tran vdout1_70ck142 FIND v(dout1_70) AT=715.025n

* CHECK dout1_71 Vdout1_71ck142 = 0.9 time = 715
.meas tran vdout1_71ck142 FIND v(dout1_71) AT=715.025n

* CHECK dout1_72 Vdout1_72ck142 = 0 time = 715
.meas tran vdout1_72ck142 FIND v(dout1_72) AT=715.025n

* CHECK dout1_73 Vdout1_73ck142 = 0.9 time = 715
.meas tran vdout1_73ck142 FIND v(dout1_73) AT=715.025n

* CHECK dout1_74 Vdout1_74ck142 = 0 time = 715
.meas tran vdout1_74ck142 FIND v(dout1_74) AT=715.025n

* CHECK dout1_75 Vdout1_75ck142 = 0.9 time = 715
.meas tran vdout1_75ck142 FIND v(dout1_75) AT=715.025n

* CHECK dout1_76 Vdout1_76ck142 = 0.9 time = 715
.meas tran vdout1_76ck142 FIND v(dout1_76) AT=715.025n

* CHECK dout1_77 Vdout1_77ck142 = 0.9 time = 715
.meas tran vdout1_77ck142 FIND v(dout1_77) AT=715.025n

* CHECK dout1_78 Vdout1_78ck142 = 0 time = 715
.meas tran vdout1_78ck142 FIND v(dout1_78) AT=715.025n

* CHECK dout1_79 Vdout1_79ck142 = 0 time = 715
.meas tran vdout1_79ck142 FIND v(dout1_79) AT=715.025n

* CHECK dout1_80 Vdout1_80ck142 = 0.9 time = 715
.meas tran vdout1_80ck142 FIND v(dout1_80) AT=715.025n

* CHECK dout1_81 Vdout1_81ck142 = 0 time = 715
.meas tran vdout1_81ck142 FIND v(dout1_81) AT=715.025n

* CHECK dout1_82 Vdout1_82ck142 = 0 time = 715
.meas tran vdout1_82ck142 FIND v(dout1_82) AT=715.025n

* CHECK dout1_83 Vdout1_83ck142 = 0 time = 715
.meas tran vdout1_83ck142 FIND v(dout1_83) AT=715.025n

* CHECK dout1_84 Vdout1_84ck142 = 0.9 time = 715
.meas tran vdout1_84ck142 FIND v(dout1_84) AT=715.025n

* CHECK dout1_85 Vdout1_85ck142 = 0.9 time = 715
.meas tran vdout1_85ck142 FIND v(dout1_85) AT=715.025n

* CHECK dout1_86 Vdout1_86ck142 = 0 time = 715
.meas tran vdout1_86ck142 FIND v(dout1_86) AT=715.025n

* CHECK dout1_87 Vdout1_87ck142 = 0.9 time = 715
.meas tran vdout1_87ck142 FIND v(dout1_87) AT=715.025n

* CHECK dout1_88 Vdout1_88ck142 = 0 time = 715
.meas tran vdout1_88ck142 FIND v(dout1_88) AT=715.025n

* CHECK dout1_89 Vdout1_89ck142 = 0.9 time = 715
.meas tran vdout1_89ck142 FIND v(dout1_89) AT=715.025n

* CHECK dout1_90 Vdout1_90ck142 = 0.9 time = 715
.meas tran vdout1_90ck142 FIND v(dout1_90) AT=715.025n

* CHECK dout1_91 Vdout1_91ck142 = 0 time = 715
.meas tran vdout1_91ck142 FIND v(dout1_91) AT=715.025n

* CHECK dout1_92 Vdout1_92ck142 = 0.9 time = 715
.meas tran vdout1_92ck142 FIND v(dout1_92) AT=715.025n

* CHECK dout1_93 Vdout1_93ck142 = 0.9 time = 715
.meas tran vdout1_93ck142 FIND v(dout1_93) AT=715.025n

* CHECK dout1_94 Vdout1_94ck142 = 0 time = 715
.meas tran vdout1_94ck142 FIND v(dout1_94) AT=715.025n

* CHECK dout1_95 Vdout1_95ck142 = 0 time = 715
.meas tran vdout1_95ck142 FIND v(dout1_95) AT=715.025n

* CHECK dout1_96 Vdout1_96ck142 = 0.9 time = 715
.meas tran vdout1_96ck142 FIND v(dout1_96) AT=715.025n

* CHECK dout1_97 Vdout1_97ck142 = 0.9 time = 715
.meas tran vdout1_97ck142 FIND v(dout1_97) AT=715.025n

* CHECK dout1_98 Vdout1_98ck142 = 0.9 time = 715
.meas tran vdout1_98ck142 FIND v(dout1_98) AT=715.025n

* CHECK dout1_99 Vdout1_99ck142 = 0 time = 715
.meas tran vdout1_99ck142 FIND v(dout1_99) AT=715.025n

* CHECK dout1_100 Vdout1_100ck142 = 0.9 time = 715
.meas tran vdout1_100ck142 FIND v(dout1_100) AT=715.025n

* CHECK dout1_101 Vdout1_101ck142 = 0 time = 715
.meas tran vdout1_101ck142 FIND v(dout1_101) AT=715.025n

* CHECK dout1_102 Vdout1_102ck142 = 0.9 time = 715
.meas tran vdout1_102ck142 FIND v(dout1_102) AT=715.025n

* CHECK dout1_103 Vdout1_103ck142 = 0 time = 715
.meas tran vdout1_103ck142 FIND v(dout1_103) AT=715.025n

* CHECK dout1_104 Vdout1_104ck142 = 0.9 time = 715
.meas tran vdout1_104ck142 FIND v(dout1_104) AT=715.025n

* CHECK dout1_105 Vdout1_105ck142 = 0 time = 715
.meas tran vdout1_105ck142 FIND v(dout1_105) AT=715.025n

* CHECK dout1_106 Vdout1_106ck142 = 0.9 time = 715
.meas tran vdout1_106ck142 FIND v(dout1_106) AT=715.025n

* CHECK dout1_107 Vdout1_107ck142 = 0.9 time = 715
.meas tran vdout1_107ck142 FIND v(dout1_107) AT=715.025n

* CHECK dout1_108 Vdout1_108ck142 = 0.9 time = 715
.meas tran vdout1_108ck142 FIND v(dout1_108) AT=715.025n

* CHECK dout1_109 Vdout1_109ck142 = 0 time = 715
.meas tran vdout1_109ck142 FIND v(dout1_109) AT=715.025n

* CHECK dout1_110 Vdout1_110ck142 = 0 time = 715
.meas tran vdout1_110ck142 FIND v(dout1_110) AT=715.025n

* CHECK dout1_111 Vdout1_111ck142 = 0 time = 715
.meas tran vdout1_111ck142 FIND v(dout1_111) AT=715.025n

* CHECK dout1_112 Vdout1_112ck142 = 0.9 time = 715
.meas tran vdout1_112ck142 FIND v(dout1_112) AT=715.025n

* CHECK dout1_113 Vdout1_113ck142 = 0 time = 715
.meas tran vdout1_113ck142 FIND v(dout1_113) AT=715.025n

* CHECK dout1_114 Vdout1_114ck142 = 0.9 time = 715
.meas tran vdout1_114ck142 FIND v(dout1_114) AT=715.025n

* CHECK dout1_115 Vdout1_115ck142 = 0 time = 715
.meas tran vdout1_115ck142 FIND v(dout1_115) AT=715.025n

* CHECK dout1_116 Vdout1_116ck142 = 0.9 time = 715
.meas tran vdout1_116ck142 FIND v(dout1_116) AT=715.025n

* CHECK dout1_117 Vdout1_117ck142 = 0.9 time = 715
.meas tran vdout1_117ck142 FIND v(dout1_117) AT=715.025n

* CHECK dout1_118 Vdout1_118ck142 = 0 time = 715
.meas tran vdout1_118ck142 FIND v(dout1_118) AT=715.025n

* CHECK dout1_119 Vdout1_119ck142 = 0.9 time = 715
.meas tran vdout1_119ck142 FIND v(dout1_119) AT=715.025n

* CHECK dout1_0 Vdout1_0ck143 = 0.9 time = 720
.meas tran vdout1_0ck143 FIND v(dout1_0) AT=720.025n

* CHECK dout1_1 Vdout1_1ck143 = 0 time = 720
.meas tran vdout1_1ck143 FIND v(dout1_1) AT=720.025n

* CHECK dout1_2 Vdout1_2ck143 = 0 time = 720
.meas tran vdout1_2ck143 FIND v(dout1_2) AT=720.025n

* CHECK dout1_3 Vdout1_3ck143 = 0 time = 720
.meas tran vdout1_3ck143 FIND v(dout1_3) AT=720.025n

* CHECK dout1_4 Vdout1_4ck143 = 0 time = 720
.meas tran vdout1_4ck143 FIND v(dout1_4) AT=720.025n

* CHECK dout1_5 Vdout1_5ck143 = 0.9 time = 720
.meas tran vdout1_5ck143 FIND v(dout1_5) AT=720.025n

* CHECK dout1_6 Vdout1_6ck143 = 0.9 time = 720
.meas tran vdout1_6ck143 FIND v(dout1_6) AT=720.025n

* CHECK dout1_7 Vdout1_7ck143 = 0.9 time = 720
.meas tran vdout1_7ck143 FIND v(dout1_7) AT=720.025n

* CHECK dout1_8 Vdout1_8ck143 = 0 time = 720
.meas tran vdout1_8ck143 FIND v(dout1_8) AT=720.025n

* CHECK dout1_9 Vdout1_9ck143 = 0.9 time = 720
.meas tran vdout1_9ck143 FIND v(dout1_9) AT=720.025n

* CHECK dout1_10 Vdout1_10ck143 = 0.9 time = 720
.meas tran vdout1_10ck143 FIND v(dout1_10) AT=720.025n

* CHECK dout1_11 Vdout1_11ck143 = 0.9 time = 720
.meas tran vdout1_11ck143 FIND v(dout1_11) AT=720.025n

* CHECK dout1_12 Vdout1_12ck143 = 0.9 time = 720
.meas tran vdout1_12ck143 FIND v(dout1_12) AT=720.025n

* CHECK dout1_13 Vdout1_13ck143 = 0 time = 720
.meas tran vdout1_13ck143 FIND v(dout1_13) AT=720.025n

* CHECK dout1_14 Vdout1_14ck143 = 0.9 time = 720
.meas tran vdout1_14ck143 FIND v(dout1_14) AT=720.025n

* CHECK dout1_15 Vdout1_15ck143 = 0 time = 720
.meas tran vdout1_15ck143 FIND v(dout1_15) AT=720.025n

* CHECK dout1_16 Vdout1_16ck143 = 0.9 time = 720
.meas tran vdout1_16ck143 FIND v(dout1_16) AT=720.025n

* CHECK dout1_17 Vdout1_17ck143 = 0 time = 720
.meas tran vdout1_17ck143 FIND v(dout1_17) AT=720.025n

* CHECK dout1_18 Vdout1_18ck143 = 0.9 time = 720
.meas tran vdout1_18ck143 FIND v(dout1_18) AT=720.025n

* CHECK dout1_19 Vdout1_19ck143 = 0.9 time = 720
.meas tran vdout1_19ck143 FIND v(dout1_19) AT=720.025n

* CHECK dout1_20 Vdout1_20ck143 = 0.9 time = 720
.meas tran vdout1_20ck143 FIND v(dout1_20) AT=720.025n

* CHECK dout1_21 Vdout1_21ck143 = 0 time = 720
.meas tran vdout1_21ck143 FIND v(dout1_21) AT=720.025n

* CHECK dout1_22 Vdout1_22ck143 = 0 time = 720
.meas tran vdout1_22ck143 FIND v(dout1_22) AT=720.025n

* CHECK dout1_23 Vdout1_23ck143 = 0.9 time = 720
.meas tran vdout1_23ck143 FIND v(dout1_23) AT=720.025n

* CHECK dout1_24 Vdout1_24ck143 = 0 time = 720
.meas tran vdout1_24ck143 FIND v(dout1_24) AT=720.025n

* CHECK dout1_25 Vdout1_25ck143 = 0.9 time = 720
.meas tran vdout1_25ck143 FIND v(dout1_25) AT=720.025n

* CHECK dout1_26 Vdout1_26ck143 = 0 time = 720
.meas tran vdout1_26ck143 FIND v(dout1_26) AT=720.025n

* CHECK dout1_27 Vdout1_27ck143 = 0.9 time = 720
.meas tran vdout1_27ck143 FIND v(dout1_27) AT=720.025n

* CHECK dout1_28 Vdout1_28ck143 = 0 time = 720
.meas tran vdout1_28ck143 FIND v(dout1_28) AT=720.025n

* CHECK dout1_29 Vdout1_29ck143 = 0 time = 720
.meas tran vdout1_29ck143 FIND v(dout1_29) AT=720.025n

* CHECK dout1_30 Vdout1_30ck143 = 0.9 time = 720
.meas tran vdout1_30ck143 FIND v(dout1_30) AT=720.025n

* CHECK dout1_31 Vdout1_31ck143 = 0.9 time = 720
.meas tran vdout1_31ck143 FIND v(dout1_31) AT=720.025n

* CHECK dout1_32 Vdout1_32ck143 = 0 time = 720
.meas tran vdout1_32ck143 FIND v(dout1_32) AT=720.025n

* CHECK dout1_33 Vdout1_33ck143 = 0.9 time = 720
.meas tran vdout1_33ck143 FIND v(dout1_33) AT=720.025n

* CHECK dout1_34 Vdout1_34ck143 = 0.9 time = 720
.meas tran vdout1_34ck143 FIND v(dout1_34) AT=720.025n

* CHECK dout1_35 Vdout1_35ck143 = 0 time = 720
.meas tran vdout1_35ck143 FIND v(dout1_35) AT=720.025n

* CHECK dout1_36 Vdout1_36ck143 = 0 time = 720
.meas tran vdout1_36ck143 FIND v(dout1_36) AT=720.025n

* CHECK dout1_37 Vdout1_37ck143 = 0.9 time = 720
.meas tran vdout1_37ck143 FIND v(dout1_37) AT=720.025n

* CHECK dout1_38 Vdout1_38ck143 = 0 time = 720
.meas tran vdout1_38ck143 FIND v(dout1_38) AT=720.025n

* CHECK dout1_39 Vdout1_39ck143 = 0.9 time = 720
.meas tran vdout1_39ck143 FIND v(dout1_39) AT=720.025n

* CHECK dout1_40 Vdout1_40ck143 = 0 time = 720
.meas tran vdout1_40ck143 FIND v(dout1_40) AT=720.025n

* CHECK dout1_41 Vdout1_41ck143 = 0 time = 720
.meas tran vdout1_41ck143 FIND v(dout1_41) AT=720.025n

* CHECK dout1_42 Vdout1_42ck143 = 0 time = 720
.meas tran vdout1_42ck143 FIND v(dout1_42) AT=720.025n

* CHECK dout1_43 Vdout1_43ck143 = 0 time = 720
.meas tran vdout1_43ck143 FIND v(dout1_43) AT=720.025n

* CHECK dout1_44 Vdout1_44ck143 = 0 time = 720
.meas tran vdout1_44ck143 FIND v(dout1_44) AT=720.025n

* CHECK dout1_45 Vdout1_45ck143 = 0.9 time = 720
.meas tran vdout1_45ck143 FIND v(dout1_45) AT=720.025n

* CHECK dout1_46 Vdout1_46ck143 = 0 time = 720
.meas tran vdout1_46ck143 FIND v(dout1_46) AT=720.025n

* CHECK dout1_47 Vdout1_47ck143 = 0 time = 720
.meas tran vdout1_47ck143 FIND v(dout1_47) AT=720.025n

* CHECK dout1_48 Vdout1_48ck143 = 0.9 time = 720
.meas tran vdout1_48ck143 FIND v(dout1_48) AT=720.025n

* CHECK dout1_49 Vdout1_49ck143 = 0 time = 720
.meas tran vdout1_49ck143 FIND v(dout1_49) AT=720.025n

* CHECK dout1_50 Vdout1_50ck143 = 0.9 time = 720
.meas tran vdout1_50ck143 FIND v(dout1_50) AT=720.025n

* CHECK dout1_51 Vdout1_51ck143 = 0 time = 720
.meas tran vdout1_51ck143 FIND v(dout1_51) AT=720.025n

* CHECK dout1_52 Vdout1_52ck143 = 0 time = 720
.meas tran vdout1_52ck143 FIND v(dout1_52) AT=720.025n

* CHECK dout1_53 Vdout1_53ck143 = 0.9 time = 720
.meas tran vdout1_53ck143 FIND v(dout1_53) AT=720.025n

* CHECK dout1_54 Vdout1_54ck143 = 0 time = 720
.meas tran vdout1_54ck143 FIND v(dout1_54) AT=720.025n

* CHECK dout1_55 Vdout1_55ck143 = 0.9 time = 720
.meas tran vdout1_55ck143 FIND v(dout1_55) AT=720.025n

* CHECK dout1_56 Vdout1_56ck143 = 0 time = 720
.meas tran vdout1_56ck143 FIND v(dout1_56) AT=720.025n

* CHECK dout1_57 Vdout1_57ck143 = 0.9 time = 720
.meas tran vdout1_57ck143 FIND v(dout1_57) AT=720.025n

* CHECK dout1_58 Vdout1_58ck143 = 0 time = 720
.meas tran vdout1_58ck143 FIND v(dout1_58) AT=720.025n

* CHECK dout1_59 Vdout1_59ck143 = 0 time = 720
.meas tran vdout1_59ck143 FIND v(dout1_59) AT=720.025n

* CHECK dout1_60 Vdout1_60ck143 = 0.9 time = 720
.meas tran vdout1_60ck143 FIND v(dout1_60) AT=720.025n

* CHECK dout1_61 Vdout1_61ck143 = 0 time = 720
.meas tran vdout1_61ck143 FIND v(dout1_61) AT=720.025n

* CHECK dout1_62 Vdout1_62ck143 = 0 time = 720
.meas tran vdout1_62ck143 FIND v(dout1_62) AT=720.025n

* CHECK dout1_63 Vdout1_63ck143 = 0.9 time = 720
.meas tran vdout1_63ck143 FIND v(dout1_63) AT=720.025n

* CHECK dout1_64 Vdout1_64ck143 = 0 time = 720
.meas tran vdout1_64ck143 FIND v(dout1_64) AT=720.025n

* CHECK dout1_65 Vdout1_65ck143 = 0 time = 720
.meas tran vdout1_65ck143 FIND v(dout1_65) AT=720.025n

* CHECK dout1_66 Vdout1_66ck143 = 0 time = 720
.meas tran vdout1_66ck143 FIND v(dout1_66) AT=720.025n

* CHECK dout1_67 Vdout1_67ck143 = 0.9 time = 720
.meas tran vdout1_67ck143 FIND v(dout1_67) AT=720.025n

* CHECK dout1_68 Vdout1_68ck143 = 0 time = 720
.meas tran vdout1_68ck143 FIND v(dout1_68) AT=720.025n

* CHECK dout1_69 Vdout1_69ck143 = 0 time = 720
.meas tran vdout1_69ck143 FIND v(dout1_69) AT=720.025n

* CHECK dout1_70 Vdout1_70ck143 = 0 time = 720
.meas tran vdout1_70ck143 FIND v(dout1_70) AT=720.025n

* CHECK dout1_71 Vdout1_71ck143 = 0.9 time = 720
.meas tran vdout1_71ck143 FIND v(dout1_71) AT=720.025n

* CHECK dout1_72 Vdout1_72ck143 = 0 time = 720
.meas tran vdout1_72ck143 FIND v(dout1_72) AT=720.025n

* CHECK dout1_73 Vdout1_73ck143 = 0.9 time = 720
.meas tran vdout1_73ck143 FIND v(dout1_73) AT=720.025n

* CHECK dout1_74 Vdout1_74ck143 = 0 time = 720
.meas tran vdout1_74ck143 FIND v(dout1_74) AT=720.025n

* CHECK dout1_75 Vdout1_75ck143 = 0 time = 720
.meas tran vdout1_75ck143 FIND v(dout1_75) AT=720.025n

* CHECK dout1_76 Vdout1_76ck143 = 0 time = 720
.meas tran vdout1_76ck143 FIND v(dout1_76) AT=720.025n

* CHECK dout1_77 Vdout1_77ck143 = 0 time = 720
.meas tran vdout1_77ck143 FIND v(dout1_77) AT=720.025n

* CHECK dout1_78 Vdout1_78ck143 = 0 time = 720
.meas tran vdout1_78ck143 FIND v(dout1_78) AT=720.025n

* CHECK dout1_79 Vdout1_79ck143 = 0.9 time = 720
.meas tran vdout1_79ck143 FIND v(dout1_79) AT=720.025n

* CHECK dout1_80 Vdout1_80ck143 = 0 time = 720
.meas tran vdout1_80ck143 FIND v(dout1_80) AT=720.025n

* CHECK dout1_81 Vdout1_81ck143 = 0 time = 720
.meas tran vdout1_81ck143 FIND v(dout1_81) AT=720.025n

* CHECK dout1_82 Vdout1_82ck143 = 0.9 time = 720
.meas tran vdout1_82ck143 FIND v(dout1_82) AT=720.025n

* CHECK dout1_83 Vdout1_83ck143 = 0 time = 720
.meas tran vdout1_83ck143 FIND v(dout1_83) AT=720.025n

* CHECK dout1_84 Vdout1_84ck143 = 0.9 time = 720
.meas tran vdout1_84ck143 FIND v(dout1_84) AT=720.025n

* CHECK dout1_85 Vdout1_85ck143 = 0.9 time = 720
.meas tran vdout1_85ck143 FIND v(dout1_85) AT=720.025n

* CHECK dout1_86 Vdout1_86ck143 = 0 time = 720
.meas tran vdout1_86ck143 FIND v(dout1_86) AT=720.025n

* CHECK dout1_87 Vdout1_87ck143 = 0.9 time = 720
.meas tran vdout1_87ck143 FIND v(dout1_87) AT=720.025n

* CHECK dout1_88 Vdout1_88ck143 = 0.9 time = 720
.meas tran vdout1_88ck143 FIND v(dout1_88) AT=720.025n

* CHECK dout1_89 Vdout1_89ck143 = 0.9 time = 720
.meas tran vdout1_89ck143 FIND v(dout1_89) AT=720.025n

* CHECK dout1_90 Vdout1_90ck143 = 0 time = 720
.meas tran vdout1_90ck143 FIND v(dout1_90) AT=720.025n

* CHECK dout1_91 Vdout1_91ck143 = 0.9 time = 720
.meas tran vdout1_91ck143 FIND v(dout1_91) AT=720.025n

* CHECK dout1_92 Vdout1_92ck143 = 0.9 time = 720
.meas tran vdout1_92ck143 FIND v(dout1_92) AT=720.025n

* CHECK dout1_93 Vdout1_93ck143 = 0 time = 720
.meas tran vdout1_93ck143 FIND v(dout1_93) AT=720.025n

* CHECK dout1_94 Vdout1_94ck143 = 0 time = 720
.meas tran vdout1_94ck143 FIND v(dout1_94) AT=720.025n

* CHECK dout1_95 Vdout1_95ck143 = 0.9 time = 720
.meas tran vdout1_95ck143 FIND v(dout1_95) AT=720.025n

* CHECK dout1_96 Vdout1_96ck143 = 0.9 time = 720
.meas tran vdout1_96ck143 FIND v(dout1_96) AT=720.025n

* CHECK dout1_97 Vdout1_97ck143 = 0.9 time = 720
.meas tran vdout1_97ck143 FIND v(dout1_97) AT=720.025n

* CHECK dout1_98 Vdout1_98ck143 = 0.9 time = 720
.meas tran vdout1_98ck143 FIND v(dout1_98) AT=720.025n

* CHECK dout1_99 Vdout1_99ck143 = 0 time = 720
.meas tran vdout1_99ck143 FIND v(dout1_99) AT=720.025n

* CHECK dout1_100 Vdout1_100ck143 = 0 time = 720
.meas tran vdout1_100ck143 FIND v(dout1_100) AT=720.025n

* CHECK dout1_101 Vdout1_101ck143 = 0.9 time = 720
.meas tran vdout1_101ck143 FIND v(dout1_101) AT=720.025n

* CHECK dout1_102 Vdout1_102ck143 = 0 time = 720
.meas tran vdout1_102ck143 FIND v(dout1_102) AT=720.025n

* CHECK dout1_103 Vdout1_103ck143 = 0.9 time = 720
.meas tran vdout1_103ck143 FIND v(dout1_103) AT=720.025n

* CHECK dout1_104 Vdout1_104ck143 = 0.9 time = 720
.meas tran vdout1_104ck143 FIND v(dout1_104) AT=720.025n

* CHECK dout1_105 Vdout1_105ck143 = 0 time = 720
.meas tran vdout1_105ck143 FIND v(dout1_105) AT=720.025n

* CHECK dout1_106 Vdout1_106ck143 = 0 time = 720
.meas tran vdout1_106ck143 FIND v(dout1_106) AT=720.025n

* CHECK dout1_107 Vdout1_107ck143 = 0.9 time = 720
.meas tran vdout1_107ck143 FIND v(dout1_107) AT=720.025n

* CHECK dout1_108 Vdout1_108ck143 = 0 time = 720
.meas tran vdout1_108ck143 FIND v(dout1_108) AT=720.025n

* CHECK dout1_109 Vdout1_109ck143 = 0 time = 720
.meas tran vdout1_109ck143 FIND v(dout1_109) AT=720.025n

* CHECK dout1_110 Vdout1_110ck143 = 0 time = 720
.meas tran vdout1_110ck143 FIND v(dout1_110) AT=720.025n

* CHECK dout1_111 Vdout1_111ck143 = 0 time = 720
.meas tran vdout1_111ck143 FIND v(dout1_111) AT=720.025n

* CHECK dout1_112 Vdout1_112ck143 = 0 time = 720
.meas tran vdout1_112ck143 FIND v(dout1_112) AT=720.025n

* CHECK dout1_113 Vdout1_113ck143 = 0 time = 720
.meas tran vdout1_113ck143 FIND v(dout1_113) AT=720.025n

* CHECK dout1_114 Vdout1_114ck143 = 0.9 time = 720
.meas tran vdout1_114ck143 FIND v(dout1_114) AT=720.025n

* CHECK dout1_115 Vdout1_115ck143 = 0 time = 720
.meas tran vdout1_115ck143 FIND v(dout1_115) AT=720.025n

* CHECK dout1_116 Vdout1_116ck143 = 0 time = 720
.meas tran vdout1_116ck143 FIND v(dout1_116) AT=720.025n

* CHECK dout1_117 Vdout1_117ck143 = 0 time = 720
.meas tran vdout1_117ck143 FIND v(dout1_117) AT=720.025n

* CHECK dout1_118 Vdout1_118ck143 = 0.9 time = 720
.meas tran vdout1_118ck143 FIND v(dout1_118) AT=720.025n

* CHECK dout1_119 Vdout1_119ck143 = 0 time = 720
.meas tran vdout1_119ck143 FIND v(dout1_119) AT=720.025n

* CHECK dout1_0 Vdout1_0ck146 = 0.9 time = 735
.meas tran vdout1_0ck146 FIND v(dout1_0) AT=735.025n

* CHECK dout1_1 Vdout1_1ck146 = 0 time = 735
.meas tran vdout1_1ck146 FIND v(dout1_1) AT=735.025n

* CHECK dout1_2 Vdout1_2ck146 = 0 time = 735
.meas tran vdout1_2ck146 FIND v(dout1_2) AT=735.025n

* CHECK dout1_3 Vdout1_3ck146 = 0 time = 735
.meas tran vdout1_3ck146 FIND v(dout1_3) AT=735.025n

* CHECK dout1_4 Vdout1_4ck146 = 0 time = 735
.meas tran vdout1_4ck146 FIND v(dout1_4) AT=735.025n

* CHECK dout1_5 Vdout1_5ck146 = 0.9 time = 735
.meas tran vdout1_5ck146 FIND v(dout1_5) AT=735.025n

* CHECK dout1_6 Vdout1_6ck146 = 0.9 time = 735
.meas tran vdout1_6ck146 FIND v(dout1_6) AT=735.025n

* CHECK dout1_7 Vdout1_7ck146 = 0.9 time = 735
.meas tran vdout1_7ck146 FIND v(dout1_7) AT=735.025n

* CHECK dout1_8 Vdout1_8ck146 = 0 time = 735
.meas tran vdout1_8ck146 FIND v(dout1_8) AT=735.025n

* CHECK dout1_9 Vdout1_9ck146 = 0.9 time = 735
.meas tran vdout1_9ck146 FIND v(dout1_9) AT=735.025n

* CHECK dout1_10 Vdout1_10ck146 = 0.9 time = 735
.meas tran vdout1_10ck146 FIND v(dout1_10) AT=735.025n

* CHECK dout1_11 Vdout1_11ck146 = 0.9 time = 735
.meas tran vdout1_11ck146 FIND v(dout1_11) AT=735.025n

* CHECK dout1_12 Vdout1_12ck146 = 0.9 time = 735
.meas tran vdout1_12ck146 FIND v(dout1_12) AT=735.025n

* CHECK dout1_13 Vdout1_13ck146 = 0 time = 735
.meas tran vdout1_13ck146 FIND v(dout1_13) AT=735.025n

* CHECK dout1_14 Vdout1_14ck146 = 0.9 time = 735
.meas tran vdout1_14ck146 FIND v(dout1_14) AT=735.025n

* CHECK dout1_15 Vdout1_15ck146 = 0 time = 735
.meas tran vdout1_15ck146 FIND v(dout1_15) AT=735.025n

* CHECK dout1_16 Vdout1_16ck146 = 0.9 time = 735
.meas tran vdout1_16ck146 FIND v(dout1_16) AT=735.025n

* CHECK dout1_17 Vdout1_17ck146 = 0 time = 735
.meas tran vdout1_17ck146 FIND v(dout1_17) AT=735.025n

* CHECK dout1_18 Vdout1_18ck146 = 0.9 time = 735
.meas tran vdout1_18ck146 FIND v(dout1_18) AT=735.025n

* CHECK dout1_19 Vdout1_19ck146 = 0.9 time = 735
.meas tran vdout1_19ck146 FIND v(dout1_19) AT=735.025n

* CHECK dout1_20 Vdout1_20ck146 = 0.9 time = 735
.meas tran vdout1_20ck146 FIND v(dout1_20) AT=735.025n

* CHECK dout1_21 Vdout1_21ck146 = 0 time = 735
.meas tran vdout1_21ck146 FIND v(dout1_21) AT=735.025n

* CHECK dout1_22 Vdout1_22ck146 = 0 time = 735
.meas tran vdout1_22ck146 FIND v(dout1_22) AT=735.025n

* CHECK dout1_23 Vdout1_23ck146 = 0.9 time = 735
.meas tran vdout1_23ck146 FIND v(dout1_23) AT=735.025n

* CHECK dout1_24 Vdout1_24ck146 = 0 time = 735
.meas tran vdout1_24ck146 FIND v(dout1_24) AT=735.025n

* CHECK dout1_25 Vdout1_25ck146 = 0.9 time = 735
.meas tran vdout1_25ck146 FIND v(dout1_25) AT=735.025n

* CHECK dout1_26 Vdout1_26ck146 = 0 time = 735
.meas tran vdout1_26ck146 FIND v(dout1_26) AT=735.025n

* CHECK dout1_27 Vdout1_27ck146 = 0.9 time = 735
.meas tran vdout1_27ck146 FIND v(dout1_27) AT=735.025n

* CHECK dout1_28 Vdout1_28ck146 = 0 time = 735
.meas tran vdout1_28ck146 FIND v(dout1_28) AT=735.025n

* CHECK dout1_29 Vdout1_29ck146 = 0 time = 735
.meas tran vdout1_29ck146 FIND v(dout1_29) AT=735.025n

* CHECK dout1_30 Vdout1_30ck146 = 0.9 time = 735
.meas tran vdout1_30ck146 FIND v(dout1_30) AT=735.025n

* CHECK dout1_31 Vdout1_31ck146 = 0.9 time = 735
.meas tran vdout1_31ck146 FIND v(dout1_31) AT=735.025n

* CHECK dout1_32 Vdout1_32ck146 = 0 time = 735
.meas tran vdout1_32ck146 FIND v(dout1_32) AT=735.025n

* CHECK dout1_33 Vdout1_33ck146 = 0.9 time = 735
.meas tran vdout1_33ck146 FIND v(dout1_33) AT=735.025n

* CHECK dout1_34 Vdout1_34ck146 = 0.9 time = 735
.meas tran vdout1_34ck146 FIND v(dout1_34) AT=735.025n

* CHECK dout1_35 Vdout1_35ck146 = 0 time = 735
.meas tran vdout1_35ck146 FIND v(dout1_35) AT=735.025n

* CHECK dout1_36 Vdout1_36ck146 = 0 time = 735
.meas tran vdout1_36ck146 FIND v(dout1_36) AT=735.025n

* CHECK dout1_37 Vdout1_37ck146 = 0.9 time = 735
.meas tran vdout1_37ck146 FIND v(dout1_37) AT=735.025n

* CHECK dout1_38 Vdout1_38ck146 = 0 time = 735
.meas tran vdout1_38ck146 FIND v(dout1_38) AT=735.025n

* CHECK dout1_39 Vdout1_39ck146 = 0.9 time = 735
.meas tran vdout1_39ck146 FIND v(dout1_39) AT=735.025n

* CHECK dout1_40 Vdout1_40ck146 = 0 time = 735
.meas tran vdout1_40ck146 FIND v(dout1_40) AT=735.025n

* CHECK dout1_41 Vdout1_41ck146 = 0 time = 735
.meas tran vdout1_41ck146 FIND v(dout1_41) AT=735.025n

* CHECK dout1_42 Vdout1_42ck146 = 0 time = 735
.meas tran vdout1_42ck146 FIND v(dout1_42) AT=735.025n

* CHECK dout1_43 Vdout1_43ck146 = 0 time = 735
.meas tran vdout1_43ck146 FIND v(dout1_43) AT=735.025n

* CHECK dout1_44 Vdout1_44ck146 = 0 time = 735
.meas tran vdout1_44ck146 FIND v(dout1_44) AT=735.025n

* CHECK dout1_45 Vdout1_45ck146 = 0.9 time = 735
.meas tran vdout1_45ck146 FIND v(dout1_45) AT=735.025n

* CHECK dout1_46 Vdout1_46ck146 = 0 time = 735
.meas tran vdout1_46ck146 FIND v(dout1_46) AT=735.025n

* CHECK dout1_47 Vdout1_47ck146 = 0 time = 735
.meas tran vdout1_47ck146 FIND v(dout1_47) AT=735.025n

* CHECK dout1_48 Vdout1_48ck146 = 0.9 time = 735
.meas tran vdout1_48ck146 FIND v(dout1_48) AT=735.025n

* CHECK dout1_49 Vdout1_49ck146 = 0 time = 735
.meas tran vdout1_49ck146 FIND v(dout1_49) AT=735.025n

* CHECK dout1_50 Vdout1_50ck146 = 0.9 time = 735
.meas tran vdout1_50ck146 FIND v(dout1_50) AT=735.025n

* CHECK dout1_51 Vdout1_51ck146 = 0 time = 735
.meas tran vdout1_51ck146 FIND v(dout1_51) AT=735.025n

* CHECK dout1_52 Vdout1_52ck146 = 0 time = 735
.meas tran vdout1_52ck146 FIND v(dout1_52) AT=735.025n

* CHECK dout1_53 Vdout1_53ck146 = 0.9 time = 735
.meas tran vdout1_53ck146 FIND v(dout1_53) AT=735.025n

* CHECK dout1_54 Vdout1_54ck146 = 0 time = 735
.meas tran vdout1_54ck146 FIND v(dout1_54) AT=735.025n

* CHECK dout1_55 Vdout1_55ck146 = 0.9 time = 735
.meas tran vdout1_55ck146 FIND v(dout1_55) AT=735.025n

* CHECK dout1_56 Vdout1_56ck146 = 0 time = 735
.meas tran vdout1_56ck146 FIND v(dout1_56) AT=735.025n

* CHECK dout1_57 Vdout1_57ck146 = 0.9 time = 735
.meas tran vdout1_57ck146 FIND v(dout1_57) AT=735.025n

* CHECK dout1_58 Vdout1_58ck146 = 0 time = 735
.meas tran vdout1_58ck146 FIND v(dout1_58) AT=735.025n

* CHECK dout1_59 Vdout1_59ck146 = 0 time = 735
.meas tran vdout1_59ck146 FIND v(dout1_59) AT=735.025n

* CHECK dout1_60 Vdout1_60ck146 = 0.9 time = 735
.meas tran vdout1_60ck146 FIND v(dout1_60) AT=735.025n

* CHECK dout1_61 Vdout1_61ck146 = 0 time = 735
.meas tran vdout1_61ck146 FIND v(dout1_61) AT=735.025n

* CHECK dout1_62 Vdout1_62ck146 = 0 time = 735
.meas tran vdout1_62ck146 FIND v(dout1_62) AT=735.025n

* CHECK dout1_63 Vdout1_63ck146 = 0.9 time = 735
.meas tran vdout1_63ck146 FIND v(dout1_63) AT=735.025n

* CHECK dout1_64 Vdout1_64ck146 = 0 time = 735
.meas tran vdout1_64ck146 FIND v(dout1_64) AT=735.025n

* CHECK dout1_65 Vdout1_65ck146 = 0 time = 735
.meas tran vdout1_65ck146 FIND v(dout1_65) AT=735.025n

* CHECK dout1_66 Vdout1_66ck146 = 0 time = 735
.meas tran vdout1_66ck146 FIND v(dout1_66) AT=735.025n

* CHECK dout1_67 Vdout1_67ck146 = 0.9 time = 735
.meas tran vdout1_67ck146 FIND v(dout1_67) AT=735.025n

* CHECK dout1_68 Vdout1_68ck146 = 0 time = 735
.meas tran vdout1_68ck146 FIND v(dout1_68) AT=735.025n

* CHECK dout1_69 Vdout1_69ck146 = 0 time = 735
.meas tran vdout1_69ck146 FIND v(dout1_69) AT=735.025n

* CHECK dout1_70 Vdout1_70ck146 = 0 time = 735
.meas tran vdout1_70ck146 FIND v(dout1_70) AT=735.025n

* CHECK dout1_71 Vdout1_71ck146 = 0.9 time = 735
.meas tran vdout1_71ck146 FIND v(dout1_71) AT=735.025n

* CHECK dout1_72 Vdout1_72ck146 = 0 time = 735
.meas tran vdout1_72ck146 FIND v(dout1_72) AT=735.025n

* CHECK dout1_73 Vdout1_73ck146 = 0.9 time = 735
.meas tran vdout1_73ck146 FIND v(dout1_73) AT=735.025n

* CHECK dout1_74 Vdout1_74ck146 = 0 time = 735
.meas tran vdout1_74ck146 FIND v(dout1_74) AT=735.025n

* CHECK dout1_75 Vdout1_75ck146 = 0 time = 735
.meas tran vdout1_75ck146 FIND v(dout1_75) AT=735.025n

* CHECK dout1_76 Vdout1_76ck146 = 0 time = 735
.meas tran vdout1_76ck146 FIND v(dout1_76) AT=735.025n

* CHECK dout1_77 Vdout1_77ck146 = 0 time = 735
.meas tran vdout1_77ck146 FIND v(dout1_77) AT=735.025n

* CHECK dout1_78 Vdout1_78ck146 = 0 time = 735
.meas tran vdout1_78ck146 FIND v(dout1_78) AT=735.025n

* CHECK dout1_79 Vdout1_79ck146 = 0.9 time = 735
.meas tran vdout1_79ck146 FIND v(dout1_79) AT=735.025n

* CHECK dout1_80 Vdout1_80ck146 = 0 time = 735
.meas tran vdout1_80ck146 FIND v(dout1_80) AT=735.025n

* CHECK dout1_81 Vdout1_81ck146 = 0 time = 735
.meas tran vdout1_81ck146 FIND v(dout1_81) AT=735.025n

* CHECK dout1_82 Vdout1_82ck146 = 0.9 time = 735
.meas tran vdout1_82ck146 FIND v(dout1_82) AT=735.025n

* CHECK dout1_83 Vdout1_83ck146 = 0 time = 735
.meas tran vdout1_83ck146 FIND v(dout1_83) AT=735.025n

* CHECK dout1_84 Vdout1_84ck146 = 0.9 time = 735
.meas tran vdout1_84ck146 FIND v(dout1_84) AT=735.025n

* CHECK dout1_85 Vdout1_85ck146 = 0.9 time = 735
.meas tran vdout1_85ck146 FIND v(dout1_85) AT=735.025n

* CHECK dout1_86 Vdout1_86ck146 = 0 time = 735
.meas tran vdout1_86ck146 FIND v(dout1_86) AT=735.025n

* CHECK dout1_87 Vdout1_87ck146 = 0.9 time = 735
.meas tran vdout1_87ck146 FIND v(dout1_87) AT=735.025n

* CHECK dout1_88 Vdout1_88ck146 = 0.9 time = 735
.meas tran vdout1_88ck146 FIND v(dout1_88) AT=735.025n

* CHECK dout1_89 Vdout1_89ck146 = 0.9 time = 735
.meas tran vdout1_89ck146 FIND v(dout1_89) AT=735.025n

* CHECK dout1_90 Vdout1_90ck146 = 0 time = 735
.meas tran vdout1_90ck146 FIND v(dout1_90) AT=735.025n

* CHECK dout1_91 Vdout1_91ck146 = 0.9 time = 735
.meas tran vdout1_91ck146 FIND v(dout1_91) AT=735.025n

* CHECK dout1_92 Vdout1_92ck146 = 0.9 time = 735
.meas tran vdout1_92ck146 FIND v(dout1_92) AT=735.025n

* CHECK dout1_93 Vdout1_93ck146 = 0 time = 735
.meas tran vdout1_93ck146 FIND v(dout1_93) AT=735.025n

* CHECK dout1_94 Vdout1_94ck146 = 0 time = 735
.meas tran vdout1_94ck146 FIND v(dout1_94) AT=735.025n

* CHECK dout1_95 Vdout1_95ck146 = 0.9 time = 735
.meas tran vdout1_95ck146 FIND v(dout1_95) AT=735.025n

* CHECK dout1_96 Vdout1_96ck146 = 0.9 time = 735
.meas tran vdout1_96ck146 FIND v(dout1_96) AT=735.025n

* CHECK dout1_97 Vdout1_97ck146 = 0.9 time = 735
.meas tran vdout1_97ck146 FIND v(dout1_97) AT=735.025n

* CHECK dout1_98 Vdout1_98ck146 = 0.9 time = 735
.meas tran vdout1_98ck146 FIND v(dout1_98) AT=735.025n

* CHECK dout1_99 Vdout1_99ck146 = 0 time = 735
.meas tran vdout1_99ck146 FIND v(dout1_99) AT=735.025n

* CHECK dout1_100 Vdout1_100ck146 = 0 time = 735
.meas tran vdout1_100ck146 FIND v(dout1_100) AT=735.025n

* CHECK dout1_101 Vdout1_101ck146 = 0.9 time = 735
.meas tran vdout1_101ck146 FIND v(dout1_101) AT=735.025n

* CHECK dout1_102 Vdout1_102ck146 = 0 time = 735
.meas tran vdout1_102ck146 FIND v(dout1_102) AT=735.025n

* CHECK dout1_103 Vdout1_103ck146 = 0.9 time = 735
.meas tran vdout1_103ck146 FIND v(dout1_103) AT=735.025n

* CHECK dout1_104 Vdout1_104ck146 = 0.9 time = 735
.meas tran vdout1_104ck146 FIND v(dout1_104) AT=735.025n

* CHECK dout1_105 Vdout1_105ck146 = 0 time = 735
.meas tran vdout1_105ck146 FIND v(dout1_105) AT=735.025n

* CHECK dout1_106 Vdout1_106ck146 = 0 time = 735
.meas tran vdout1_106ck146 FIND v(dout1_106) AT=735.025n

* CHECK dout1_107 Vdout1_107ck146 = 0.9 time = 735
.meas tran vdout1_107ck146 FIND v(dout1_107) AT=735.025n

* CHECK dout1_108 Vdout1_108ck146 = 0 time = 735
.meas tran vdout1_108ck146 FIND v(dout1_108) AT=735.025n

* CHECK dout1_109 Vdout1_109ck146 = 0 time = 735
.meas tran vdout1_109ck146 FIND v(dout1_109) AT=735.025n

* CHECK dout1_110 Vdout1_110ck146 = 0 time = 735
.meas tran vdout1_110ck146 FIND v(dout1_110) AT=735.025n

* CHECK dout1_111 Vdout1_111ck146 = 0 time = 735
.meas tran vdout1_111ck146 FIND v(dout1_111) AT=735.025n

* CHECK dout1_112 Vdout1_112ck146 = 0 time = 735
.meas tran vdout1_112ck146 FIND v(dout1_112) AT=735.025n

* CHECK dout1_113 Vdout1_113ck146 = 0 time = 735
.meas tran vdout1_113ck146 FIND v(dout1_113) AT=735.025n

* CHECK dout1_114 Vdout1_114ck146 = 0.9 time = 735
.meas tran vdout1_114ck146 FIND v(dout1_114) AT=735.025n

* CHECK dout1_115 Vdout1_115ck146 = 0 time = 735
.meas tran vdout1_115ck146 FIND v(dout1_115) AT=735.025n

* CHECK dout1_116 Vdout1_116ck146 = 0 time = 735
.meas tran vdout1_116ck146 FIND v(dout1_116) AT=735.025n

* CHECK dout1_117 Vdout1_117ck146 = 0 time = 735
.meas tran vdout1_117ck146 FIND v(dout1_117) AT=735.025n

* CHECK dout1_118 Vdout1_118ck146 = 0.9 time = 735
.meas tran vdout1_118ck146 FIND v(dout1_118) AT=735.025n

* CHECK dout1_119 Vdout1_119ck146 = 0 time = 735
.meas tran vdout1_119ck146 FIND v(dout1_119) AT=735.025n

* CHECK dout1_0 Vdout1_0ck150 = 0.9 time = 755
.meas tran vdout1_0ck150 FIND v(dout1_0) AT=755.025n

* CHECK dout1_1 Vdout1_1ck150 = 0 time = 755
.meas tran vdout1_1ck150 FIND v(dout1_1) AT=755.025n

* CHECK dout1_2 Vdout1_2ck150 = 0 time = 755
.meas tran vdout1_2ck150 FIND v(dout1_2) AT=755.025n

* CHECK dout1_3 Vdout1_3ck150 = 0.9 time = 755
.meas tran vdout1_3ck150 FIND v(dout1_3) AT=755.025n

* CHECK dout1_4 Vdout1_4ck150 = 0.9 time = 755
.meas tran vdout1_4ck150 FIND v(dout1_4) AT=755.025n

* CHECK dout1_5 Vdout1_5ck150 = 0 time = 755
.meas tran vdout1_5ck150 FIND v(dout1_5) AT=755.025n

* CHECK dout1_6 Vdout1_6ck150 = 0 time = 755
.meas tran vdout1_6ck150 FIND v(dout1_6) AT=755.025n

* CHECK dout1_7 Vdout1_7ck150 = 0 time = 755
.meas tran vdout1_7ck150 FIND v(dout1_7) AT=755.025n

* CHECK dout1_8 Vdout1_8ck150 = 0.9 time = 755
.meas tran vdout1_8ck150 FIND v(dout1_8) AT=755.025n

* CHECK dout1_9 Vdout1_9ck150 = 0.9 time = 755
.meas tran vdout1_9ck150 FIND v(dout1_9) AT=755.025n

* CHECK dout1_10 Vdout1_10ck150 = 0 time = 755
.meas tran vdout1_10ck150 FIND v(dout1_10) AT=755.025n

* CHECK dout1_11 Vdout1_11ck150 = 0.9 time = 755
.meas tran vdout1_11ck150 FIND v(dout1_11) AT=755.025n

* CHECK dout1_12 Vdout1_12ck150 = 0 time = 755
.meas tran vdout1_12ck150 FIND v(dout1_12) AT=755.025n

* CHECK dout1_13 Vdout1_13ck150 = 0.9 time = 755
.meas tran vdout1_13ck150 FIND v(dout1_13) AT=755.025n

* CHECK dout1_14 Vdout1_14ck150 = 0.9 time = 755
.meas tran vdout1_14ck150 FIND v(dout1_14) AT=755.025n

* CHECK dout1_15 Vdout1_15ck150 = 0.9 time = 755
.meas tran vdout1_15ck150 FIND v(dout1_15) AT=755.025n

* CHECK dout1_16 Vdout1_16ck150 = 0 time = 755
.meas tran vdout1_16ck150 FIND v(dout1_16) AT=755.025n

* CHECK dout1_17 Vdout1_17ck150 = 0 time = 755
.meas tran vdout1_17ck150 FIND v(dout1_17) AT=755.025n

* CHECK dout1_18 Vdout1_18ck150 = 0 time = 755
.meas tran vdout1_18ck150 FIND v(dout1_18) AT=755.025n

* CHECK dout1_19 Vdout1_19ck150 = 0.9 time = 755
.meas tran vdout1_19ck150 FIND v(dout1_19) AT=755.025n

* CHECK dout1_20 Vdout1_20ck150 = 0 time = 755
.meas tran vdout1_20ck150 FIND v(dout1_20) AT=755.025n

* CHECK dout1_21 Vdout1_21ck150 = 0 time = 755
.meas tran vdout1_21ck150 FIND v(dout1_21) AT=755.025n

* CHECK dout1_22 Vdout1_22ck150 = 0.9 time = 755
.meas tran vdout1_22ck150 FIND v(dout1_22) AT=755.025n

* CHECK dout1_23 Vdout1_23ck150 = 0.9 time = 755
.meas tran vdout1_23ck150 FIND v(dout1_23) AT=755.025n

* CHECK dout1_24 Vdout1_24ck150 = 0 time = 755
.meas tran vdout1_24ck150 FIND v(dout1_24) AT=755.025n

* CHECK dout1_25 Vdout1_25ck150 = 0.9 time = 755
.meas tran vdout1_25ck150 FIND v(dout1_25) AT=755.025n

* CHECK dout1_26 Vdout1_26ck150 = 0 time = 755
.meas tran vdout1_26ck150 FIND v(dout1_26) AT=755.025n

* CHECK dout1_27 Vdout1_27ck150 = 0.9 time = 755
.meas tran vdout1_27ck150 FIND v(dout1_27) AT=755.025n

* CHECK dout1_28 Vdout1_28ck150 = 0.9 time = 755
.meas tran vdout1_28ck150 FIND v(dout1_28) AT=755.025n

* CHECK dout1_29 Vdout1_29ck150 = 0.9 time = 755
.meas tran vdout1_29ck150 FIND v(dout1_29) AT=755.025n

* CHECK dout1_30 Vdout1_30ck150 = 0 time = 755
.meas tran vdout1_30ck150 FIND v(dout1_30) AT=755.025n

* CHECK dout1_31 Vdout1_31ck150 = 0.9 time = 755
.meas tran vdout1_31ck150 FIND v(dout1_31) AT=755.025n

* CHECK dout1_32 Vdout1_32ck150 = 0 time = 755
.meas tran vdout1_32ck150 FIND v(dout1_32) AT=755.025n

* CHECK dout1_33 Vdout1_33ck150 = 0.9 time = 755
.meas tran vdout1_33ck150 FIND v(dout1_33) AT=755.025n

* CHECK dout1_34 Vdout1_34ck150 = 0 time = 755
.meas tran vdout1_34ck150 FIND v(dout1_34) AT=755.025n

* CHECK dout1_35 Vdout1_35ck150 = 0.9 time = 755
.meas tran vdout1_35ck150 FIND v(dout1_35) AT=755.025n

* CHECK dout1_36 Vdout1_36ck150 = 0 time = 755
.meas tran vdout1_36ck150 FIND v(dout1_36) AT=755.025n

* CHECK dout1_37 Vdout1_37ck150 = 0 time = 755
.meas tran vdout1_37ck150 FIND v(dout1_37) AT=755.025n

* CHECK dout1_38 Vdout1_38ck150 = 0 time = 755
.meas tran vdout1_38ck150 FIND v(dout1_38) AT=755.025n

* CHECK dout1_39 Vdout1_39ck150 = 0 time = 755
.meas tran vdout1_39ck150 FIND v(dout1_39) AT=755.025n

* CHECK dout1_40 Vdout1_40ck150 = 0.9 time = 755
.meas tran vdout1_40ck150 FIND v(dout1_40) AT=755.025n

* CHECK dout1_41 Vdout1_41ck150 = 0.9 time = 755
.meas tran vdout1_41ck150 FIND v(dout1_41) AT=755.025n

* CHECK dout1_42 Vdout1_42ck150 = 0.9 time = 755
.meas tran vdout1_42ck150 FIND v(dout1_42) AT=755.025n

* CHECK dout1_43 Vdout1_43ck150 = 0 time = 755
.meas tran vdout1_43ck150 FIND v(dout1_43) AT=755.025n

* CHECK dout1_44 Vdout1_44ck150 = 0 time = 755
.meas tran vdout1_44ck150 FIND v(dout1_44) AT=755.025n

* CHECK dout1_45 Vdout1_45ck150 = 0.9 time = 755
.meas tran vdout1_45ck150 FIND v(dout1_45) AT=755.025n

* CHECK dout1_46 Vdout1_46ck150 = 0 time = 755
.meas tran vdout1_46ck150 FIND v(dout1_46) AT=755.025n

* CHECK dout1_47 Vdout1_47ck150 = 0.9 time = 755
.meas tran vdout1_47ck150 FIND v(dout1_47) AT=755.025n

* CHECK dout1_48 Vdout1_48ck150 = 0.9 time = 755
.meas tran vdout1_48ck150 FIND v(dout1_48) AT=755.025n

* CHECK dout1_49 Vdout1_49ck150 = 0.9 time = 755
.meas tran vdout1_49ck150 FIND v(dout1_49) AT=755.025n

* CHECK dout1_50 Vdout1_50ck150 = 0 time = 755
.meas tran vdout1_50ck150 FIND v(dout1_50) AT=755.025n

* CHECK dout1_51 Vdout1_51ck150 = 0 time = 755
.meas tran vdout1_51ck150 FIND v(dout1_51) AT=755.025n

* CHECK dout1_52 Vdout1_52ck150 = 0 time = 755
.meas tran vdout1_52ck150 FIND v(dout1_52) AT=755.025n

* CHECK dout1_53 Vdout1_53ck150 = 0 time = 755
.meas tran vdout1_53ck150 FIND v(dout1_53) AT=755.025n

* CHECK dout1_54 Vdout1_54ck150 = 0.9 time = 755
.meas tran vdout1_54ck150 FIND v(dout1_54) AT=755.025n

* CHECK dout1_55 Vdout1_55ck150 = 0 time = 755
.meas tran vdout1_55ck150 FIND v(dout1_55) AT=755.025n

* CHECK dout1_56 Vdout1_56ck150 = 0 time = 755
.meas tran vdout1_56ck150 FIND v(dout1_56) AT=755.025n

* CHECK dout1_57 Vdout1_57ck150 = 0 time = 755
.meas tran vdout1_57ck150 FIND v(dout1_57) AT=755.025n

* CHECK dout1_58 Vdout1_58ck150 = 0.9 time = 755
.meas tran vdout1_58ck150 FIND v(dout1_58) AT=755.025n

* CHECK dout1_59 Vdout1_59ck150 = 0.9 time = 755
.meas tran vdout1_59ck150 FIND v(dout1_59) AT=755.025n

* CHECK dout1_60 Vdout1_60ck150 = 0.9 time = 755
.meas tran vdout1_60ck150 FIND v(dout1_60) AT=755.025n

* CHECK dout1_61 Vdout1_61ck150 = 0 time = 755
.meas tran vdout1_61ck150 FIND v(dout1_61) AT=755.025n

* CHECK dout1_62 Vdout1_62ck150 = 0 time = 755
.meas tran vdout1_62ck150 FIND v(dout1_62) AT=755.025n

* CHECK dout1_63 Vdout1_63ck150 = 0.9 time = 755
.meas tran vdout1_63ck150 FIND v(dout1_63) AT=755.025n

* CHECK dout1_64 Vdout1_64ck150 = 0 time = 755
.meas tran vdout1_64ck150 FIND v(dout1_64) AT=755.025n

* CHECK dout1_65 Vdout1_65ck150 = 0.9 time = 755
.meas tran vdout1_65ck150 FIND v(dout1_65) AT=755.025n

* CHECK dout1_66 Vdout1_66ck150 = 0 time = 755
.meas tran vdout1_66ck150 FIND v(dout1_66) AT=755.025n

* CHECK dout1_67 Vdout1_67ck150 = 0 time = 755
.meas tran vdout1_67ck150 FIND v(dout1_67) AT=755.025n

* CHECK dout1_68 Vdout1_68ck150 = 0 time = 755
.meas tran vdout1_68ck150 FIND v(dout1_68) AT=755.025n

* CHECK dout1_69 Vdout1_69ck150 = 0 time = 755
.meas tran vdout1_69ck150 FIND v(dout1_69) AT=755.025n

* CHECK dout1_70 Vdout1_70ck150 = 0 time = 755
.meas tran vdout1_70ck150 FIND v(dout1_70) AT=755.025n

* CHECK dout1_71 Vdout1_71ck150 = 0 time = 755
.meas tran vdout1_71ck150 FIND v(dout1_71) AT=755.025n

* CHECK dout1_72 Vdout1_72ck150 = 0 time = 755
.meas tran vdout1_72ck150 FIND v(dout1_72) AT=755.025n

* CHECK dout1_73 Vdout1_73ck150 = 0 time = 755
.meas tran vdout1_73ck150 FIND v(dout1_73) AT=755.025n

* CHECK dout1_74 Vdout1_74ck150 = 0.9 time = 755
.meas tran vdout1_74ck150 FIND v(dout1_74) AT=755.025n

* CHECK dout1_75 Vdout1_75ck150 = 0.9 time = 755
.meas tran vdout1_75ck150 FIND v(dout1_75) AT=755.025n

* CHECK dout1_76 Vdout1_76ck150 = 0 time = 755
.meas tran vdout1_76ck150 FIND v(dout1_76) AT=755.025n

* CHECK dout1_77 Vdout1_77ck150 = 0 time = 755
.meas tran vdout1_77ck150 FIND v(dout1_77) AT=755.025n

* CHECK dout1_78 Vdout1_78ck150 = 0 time = 755
.meas tran vdout1_78ck150 FIND v(dout1_78) AT=755.025n

* CHECK dout1_79 Vdout1_79ck150 = 0.9 time = 755
.meas tran vdout1_79ck150 FIND v(dout1_79) AT=755.025n

* CHECK dout1_80 Vdout1_80ck150 = 0 time = 755
.meas tran vdout1_80ck150 FIND v(dout1_80) AT=755.025n

* CHECK dout1_81 Vdout1_81ck150 = 0 time = 755
.meas tran vdout1_81ck150 FIND v(dout1_81) AT=755.025n

* CHECK dout1_82 Vdout1_82ck150 = 0.9 time = 755
.meas tran vdout1_82ck150 FIND v(dout1_82) AT=755.025n

* CHECK dout1_83 Vdout1_83ck150 = 0 time = 755
.meas tran vdout1_83ck150 FIND v(dout1_83) AT=755.025n

* CHECK dout1_84 Vdout1_84ck150 = 0.9 time = 755
.meas tran vdout1_84ck150 FIND v(dout1_84) AT=755.025n

* CHECK dout1_85 Vdout1_85ck150 = 0.9 time = 755
.meas tran vdout1_85ck150 FIND v(dout1_85) AT=755.025n

* CHECK dout1_86 Vdout1_86ck150 = 0 time = 755
.meas tran vdout1_86ck150 FIND v(dout1_86) AT=755.025n

* CHECK dout1_87 Vdout1_87ck150 = 0 time = 755
.meas tran vdout1_87ck150 FIND v(dout1_87) AT=755.025n

* CHECK dout1_88 Vdout1_88ck150 = 0 time = 755
.meas tran vdout1_88ck150 FIND v(dout1_88) AT=755.025n

* CHECK dout1_89 Vdout1_89ck150 = 0.9 time = 755
.meas tran vdout1_89ck150 FIND v(dout1_89) AT=755.025n

* CHECK dout1_90 Vdout1_90ck150 = 0 time = 755
.meas tran vdout1_90ck150 FIND v(dout1_90) AT=755.025n

* CHECK dout1_91 Vdout1_91ck150 = 0.9 time = 755
.meas tran vdout1_91ck150 FIND v(dout1_91) AT=755.025n

* CHECK dout1_92 Vdout1_92ck150 = 0 time = 755
.meas tran vdout1_92ck150 FIND v(dout1_92) AT=755.025n

* CHECK dout1_93 Vdout1_93ck150 = 0.9 time = 755
.meas tran vdout1_93ck150 FIND v(dout1_93) AT=755.025n

* CHECK dout1_94 Vdout1_94ck150 = 0.9 time = 755
.meas tran vdout1_94ck150 FIND v(dout1_94) AT=755.025n

* CHECK dout1_95 Vdout1_95ck150 = 0.9 time = 755
.meas tran vdout1_95ck150 FIND v(dout1_95) AT=755.025n

* CHECK dout1_96 Vdout1_96ck150 = 0.9 time = 755
.meas tran vdout1_96ck150 FIND v(dout1_96) AT=755.025n

* CHECK dout1_97 Vdout1_97ck150 = 0.9 time = 755
.meas tran vdout1_97ck150 FIND v(dout1_97) AT=755.025n

* CHECK dout1_98 Vdout1_98ck150 = 0 time = 755
.meas tran vdout1_98ck150 FIND v(dout1_98) AT=755.025n

* CHECK dout1_99 Vdout1_99ck150 = 0.9 time = 755
.meas tran vdout1_99ck150 FIND v(dout1_99) AT=755.025n

* CHECK dout1_100 Vdout1_100ck150 = 0 time = 755
.meas tran vdout1_100ck150 FIND v(dout1_100) AT=755.025n

* CHECK dout1_101 Vdout1_101ck150 = 0.9 time = 755
.meas tran vdout1_101ck150 FIND v(dout1_101) AT=755.025n

* CHECK dout1_102 Vdout1_102ck150 = 0.9 time = 755
.meas tran vdout1_102ck150 FIND v(dout1_102) AT=755.025n

* CHECK dout1_103 Vdout1_103ck150 = 0.9 time = 755
.meas tran vdout1_103ck150 FIND v(dout1_103) AT=755.025n

* CHECK dout1_104 Vdout1_104ck150 = 0.9 time = 755
.meas tran vdout1_104ck150 FIND v(dout1_104) AT=755.025n

* CHECK dout1_105 Vdout1_105ck150 = 0 time = 755
.meas tran vdout1_105ck150 FIND v(dout1_105) AT=755.025n

* CHECK dout1_106 Vdout1_106ck150 = 0.9 time = 755
.meas tran vdout1_106ck150 FIND v(dout1_106) AT=755.025n

* CHECK dout1_107 Vdout1_107ck150 = 0 time = 755
.meas tran vdout1_107ck150 FIND v(dout1_107) AT=755.025n

* CHECK dout1_108 Vdout1_108ck150 = 0 time = 755
.meas tran vdout1_108ck150 FIND v(dout1_108) AT=755.025n

* CHECK dout1_109 Vdout1_109ck150 = 0 time = 755
.meas tran vdout1_109ck150 FIND v(dout1_109) AT=755.025n

* CHECK dout1_110 Vdout1_110ck150 = 0 time = 755
.meas tran vdout1_110ck150 FIND v(dout1_110) AT=755.025n

* CHECK dout1_111 Vdout1_111ck150 = 0 time = 755
.meas tran vdout1_111ck150 FIND v(dout1_111) AT=755.025n

* CHECK dout1_112 Vdout1_112ck150 = 0.9 time = 755
.meas tran vdout1_112ck150 FIND v(dout1_112) AT=755.025n

* CHECK dout1_113 Vdout1_113ck150 = 0.9 time = 755
.meas tran vdout1_113ck150 FIND v(dout1_113) AT=755.025n

* CHECK dout1_114 Vdout1_114ck150 = 0.9 time = 755
.meas tran vdout1_114ck150 FIND v(dout1_114) AT=755.025n

* CHECK dout1_115 Vdout1_115ck150 = 0.9 time = 755
.meas tran vdout1_115ck150 FIND v(dout1_115) AT=755.025n

* CHECK dout1_116 Vdout1_116ck150 = 0.9 time = 755
.meas tran vdout1_116ck150 FIND v(dout1_116) AT=755.025n

* CHECK dout1_117 Vdout1_117ck150 = 0.9 time = 755
.meas tran vdout1_117ck150 FIND v(dout1_117) AT=755.025n

* CHECK dout1_118 Vdout1_118ck150 = 0.9 time = 755
.meas tran vdout1_118ck150 FIND v(dout1_118) AT=755.025n

* CHECK dout1_119 Vdout1_119ck150 = 0.9 time = 755
.meas tran vdout1_119ck150 FIND v(dout1_119) AT=755.025n

* CHECK dout1_0 Vdout1_0ck151 = 0.9 time = 760
.meas tran vdout1_0ck151 FIND v(dout1_0) AT=760.025n

* CHECK dout1_1 Vdout1_1ck151 = 0 time = 760
.meas tran vdout1_1ck151 FIND v(dout1_1) AT=760.025n

* CHECK dout1_2 Vdout1_2ck151 = 0 time = 760
.meas tran vdout1_2ck151 FIND v(dout1_2) AT=760.025n

* CHECK dout1_3 Vdout1_3ck151 = 0.9 time = 760
.meas tran vdout1_3ck151 FIND v(dout1_3) AT=760.025n

* CHECK dout1_4 Vdout1_4ck151 = 0.9 time = 760
.meas tran vdout1_4ck151 FIND v(dout1_4) AT=760.025n

* CHECK dout1_5 Vdout1_5ck151 = 0 time = 760
.meas tran vdout1_5ck151 FIND v(dout1_5) AT=760.025n

* CHECK dout1_6 Vdout1_6ck151 = 0 time = 760
.meas tran vdout1_6ck151 FIND v(dout1_6) AT=760.025n

* CHECK dout1_7 Vdout1_7ck151 = 0 time = 760
.meas tran vdout1_7ck151 FIND v(dout1_7) AT=760.025n

* CHECK dout1_8 Vdout1_8ck151 = 0.9 time = 760
.meas tran vdout1_8ck151 FIND v(dout1_8) AT=760.025n

* CHECK dout1_9 Vdout1_9ck151 = 0.9 time = 760
.meas tran vdout1_9ck151 FIND v(dout1_9) AT=760.025n

* CHECK dout1_10 Vdout1_10ck151 = 0 time = 760
.meas tran vdout1_10ck151 FIND v(dout1_10) AT=760.025n

* CHECK dout1_11 Vdout1_11ck151 = 0.9 time = 760
.meas tran vdout1_11ck151 FIND v(dout1_11) AT=760.025n

* CHECK dout1_12 Vdout1_12ck151 = 0 time = 760
.meas tran vdout1_12ck151 FIND v(dout1_12) AT=760.025n

* CHECK dout1_13 Vdout1_13ck151 = 0.9 time = 760
.meas tran vdout1_13ck151 FIND v(dout1_13) AT=760.025n

* CHECK dout1_14 Vdout1_14ck151 = 0.9 time = 760
.meas tran vdout1_14ck151 FIND v(dout1_14) AT=760.025n

* CHECK dout1_15 Vdout1_15ck151 = 0.9 time = 760
.meas tran vdout1_15ck151 FIND v(dout1_15) AT=760.025n

* CHECK dout1_16 Vdout1_16ck151 = 0 time = 760
.meas tran vdout1_16ck151 FIND v(dout1_16) AT=760.025n

* CHECK dout1_17 Vdout1_17ck151 = 0 time = 760
.meas tran vdout1_17ck151 FIND v(dout1_17) AT=760.025n

* CHECK dout1_18 Vdout1_18ck151 = 0 time = 760
.meas tran vdout1_18ck151 FIND v(dout1_18) AT=760.025n

* CHECK dout1_19 Vdout1_19ck151 = 0.9 time = 760
.meas tran vdout1_19ck151 FIND v(dout1_19) AT=760.025n

* CHECK dout1_20 Vdout1_20ck151 = 0 time = 760
.meas tran vdout1_20ck151 FIND v(dout1_20) AT=760.025n

* CHECK dout1_21 Vdout1_21ck151 = 0 time = 760
.meas tran vdout1_21ck151 FIND v(dout1_21) AT=760.025n

* CHECK dout1_22 Vdout1_22ck151 = 0.9 time = 760
.meas tran vdout1_22ck151 FIND v(dout1_22) AT=760.025n

* CHECK dout1_23 Vdout1_23ck151 = 0.9 time = 760
.meas tran vdout1_23ck151 FIND v(dout1_23) AT=760.025n

* CHECK dout1_24 Vdout1_24ck151 = 0 time = 760
.meas tran vdout1_24ck151 FIND v(dout1_24) AT=760.025n

* CHECK dout1_25 Vdout1_25ck151 = 0.9 time = 760
.meas tran vdout1_25ck151 FIND v(dout1_25) AT=760.025n

* CHECK dout1_26 Vdout1_26ck151 = 0 time = 760
.meas tran vdout1_26ck151 FIND v(dout1_26) AT=760.025n

* CHECK dout1_27 Vdout1_27ck151 = 0.9 time = 760
.meas tran vdout1_27ck151 FIND v(dout1_27) AT=760.025n

* CHECK dout1_28 Vdout1_28ck151 = 0.9 time = 760
.meas tran vdout1_28ck151 FIND v(dout1_28) AT=760.025n

* CHECK dout1_29 Vdout1_29ck151 = 0.9 time = 760
.meas tran vdout1_29ck151 FIND v(dout1_29) AT=760.025n

* CHECK dout1_30 Vdout1_30ck151 = 0 time = 760
.meas tran vdout1_30ck151 FIND v(dout1_30) AT=760.025n

* CHECK dout1_31 Vdout1_31ck151 = 0.9 time = 760
.meas tran vdout1_31ck151 FIND v(dout1_31) AT=760.025n

* CHECK dout1_32 Vdout1_32ck151 = 0 time = 760
.meas tran vdout1_32ck151 FIND v(dout1_32) AT=760.025n

* CHECK dout1_33 Vdout1_33ck151 = 0.9 time = 760
.meas tran vdout1_33ck151 FIND v(dout1_33) AT=760.025n

* CHECK dout1_34 Vdout1_34ck151 = 0 time = 760
.meas tran vdout1_34ck151 FIND v(dout1_34) AT=760.025n

* CHECK dout1_35 Vdout1_35ck151 = 0.9 time = 760
.meas tran vdout1_35ck151 FIND v(dout1_35) AT=760.025n

* CHECK dout1_36 Vdout1_36ck151 = 0 time = 760
.meas tran vdout1_36ck151 FIND v(dout1_36) AT=760.025n

* CHECK dout1_37 Vdout1_37ck151 = 0 time = 760
.meas tran vdout1_37ck151 FIND v(dout1_37) AT=760.025n

* CHECK dout1_38 Vdout1_38ck151 = 0 time = 760
.meas tran vdout1_38ck151 FIND v(dout1_38) AT=760.025n

* CHECK dout1_39 Vdout1_39ck151 = 0 time = 760
.meas tran vdout1_39ck151 FIND v(dout1_39) AT=760.025n

* CHECK dout1_40 Vdout1_40ck151 = 0.9 time = 760
.meas tran vdout1_40ck151 FIND v(dout1_40) AT=760.025n

* CHECK dout1_41 Vdout1_41ck151 = 0.9 time = 760
.meas tran vdout1_41ck151 FIND v(dout1_41) AT=760.025n

* CHECK dout1_42 Vdout1_42ck151 = 0.9 time = 760
.meas tran vdout1_42ck151 FIND v(dout1_42) AT=760.025n

* CHECK dout1_43 Vdout1_43ck151 = 0 time = 760
.meas tran vdout1_43ck151 FIND v(dout1_43) AT=760.025n

* CHECK dout1_44 Vdout1_44ck151 = 0 time = 760
.meas tran vdout1_44ck151 FIND v(dout1_44) AT=760.025n

* CHECK dout1_45 Vdout1_45ck151 = 0.9 time = 760
.meas tran vdout1_45ck151 FIND v(dout1_45) AT=760.025n

* CHECK dout1_46 Vdout1_46ck151 = 0 time = 760
.meas tran vdout1_46ck151 FIND v(dout1_46) AT=760.025n

* CHECK dout1_47 Vdout1_47ck151 = 0.9 time = 760
.meas tran vdout1_47ck151 FIND v(dout1_47) AT=760.025n

* CHECK dout1_48 Vdout1_48ck151 = 0.9 time = 760
.meas tran vdout1_48ck151 FIND v(dout1_48) AT=760.025n

* CHECK dout1_49 Vdout1_49ck151 = 0.9 time = 760
.meas tran vdout1_49ck151 FIND v(dout1_49) AT=760.025n

* CHECK dout1_50 Vdout1_50ck151 = 0 time = 760
.meas tran vdout1_50ck151 FIND v(dout1_50) AT=760.025n

* CHECK dout1_51 Vdout1_51ck151 = 0 time = 760
.meas tran vdout1_51ck151 FIND v(dout1_51) AT=760.025n

* CHECK dout1_52 Vdout1_52ck151 = 0 time = 760
.meas tran vdout1_52ck151 FIND v(dout1_52) AT=760.025n

* CHECK dout1_53 Vdout1_53ck151 = 0 time = 760
.meas tran vdout1_53ck151 FIND v(dout1_53) AT=760.025n

* CHECK dout1_54 Vdout1_54ck151 = 0.9 time = 760
.meas tran vdout1_54ck151 FIND v(dout1_54) AT=760.025n

* CHECK dout1_55 Vdout1_55ck151 = 0 time = 760
.meas tran vdout1_55ck151 FIND v(dout1_55) AT=760.025n

* CHECK dout1_56 Vdout1_56ck151 = 0 time = 760
.meas tran vdout1_56ck151 FIND v(dout1_56) AT=760.025n

* CHECK dout1_57 Vdout1_57ck151 = 0 time = 760
.meas tran vdout1_57ck151 FIND v(dout1_57) AT=760.025n

* CHECK dout1_58 Vdout1_58ck151 = 0.9 time = 760
.meas tran vdout1_58ck151 FIND v(dout1_58) AT=760.025n

* CHECK dout1_59 Vdout1_59ck151 = 0.9 time = 760
.meas tran vdout1_59ck151 FIND v(dout1_59) AT=760.025n

* CHECK dout1_60 Vdout1_60ck151 = 0.9 time = 760
.meas tran vdout1_60ck151 FIND v(dout1_60) AT=760.025n

* CHECK dout1_61 Vdout1_61ck151 = 0 time = 760
.meas tran vdout1_61ck151 FIND v(dout1_61) AT=760.025n

* CHECK dout1_62 Vdout1_62ck151 = 0 time = 760
.meas tran vdout1_62ck151 FIND v(dout1_62) AT=760.025n

* CHECK dout1_63 Vdout1_63ck151 = 0.9 time = 760
.meas tran vdout1_63ck151 FIND v(dout1_63) AT=760.025n

* CHECK dout1_64 Vdout1_64ck151 = 0 time = 760
.meas tran vdout1_64ck151 FIND v(dout1_64) AT=760.025n

* CHECK dout1_65 Vdout1_65ck151 = 0.9 time = 760
.meas tran vdout1_65ck151 FIND v(dout1_65) AT=760.025n

* CHECK dout1_66 Vdout1_66ck151 = 0 time = 760
.meas tran vdout1_66ck151 FIND v(dout1_66) AT=760.025n

* CHECK dout1_67 Vdout1_67ck151 = 0 time = 760
.meas tran vdout1_67ck151 FIND v(dout1_67) AT=760.025n

* CHECK dout1_68 Vdout1_68ck151 = 0 time = 760
.meas tran vdout1_68ck151 FIND v(dout1_68) AT=760.025n

* CHECK dout1_69 Vdout1_69ck151 = 0 time = 760
.meas tran vdout1_69ck151 FIND v(dout1_69) AT=760.025n

* CHECK dout1_70 Vdout1_70ck151 = 0 time = 760
.meas tran vdout1_70ck151 FIND v(dout1_70) AT=760.025n

* CHECK dout1_71 Vdout1_71ck151 = 0 time = 760
.meas tran vdout1_71ck151 FIND v(dout1_71) AT=760.025n

* CHECK dout1_72 Vdout1_72ck151 = 0 time = 760
.meas tran vdout1_72ck151 FIND v(dout1_72) AT=760.025n

* CHECK dout1_73 Vdout1_73ck151 = 0 time = 760
.meas tran vdout1_73ck151 FIND v(dout1_73) AT=760.025n

* CHECK dout1_74 Vdout1_74ck151 = 0.9 time = 760
.meas tran vdout1_74ck151 FIND v(dout1_74) AT=760.025n

* CHECK dout1_75 Vdout1_75ck151 = 0.9 time = 760
.meas tran vdout1_75ck151 FIND v(dout1_75) AT=760.025n

* CHECK dout1_76 Vdout1_76ck151 = 0 time = 760
.meas tran vdout1_76ck151 FIND v(dout1_76) AT=760.025n

* CHECK dout1_77 Vdout1_77ck151 = 0 time = 760
.meas tran vdout1_77ck151 FIND v(dout1_77) AT=760.025n

* CHECK dout1_78 Vdout1_78ck151 = 0 time = 760
.meas tran vdout1_78ck151 FIND v(dout1_78) AT=760.025n

* CHECK dout1_79 Vdout1_79ck151 = 0.9 time = 760
.meas tran vdout1_79ck151 FIND v(dout1_79) AT=760.025n

* CHECK dout1_80 Vdout1_80ck151 = 0 time = 760
.meas tran vdout1_80ck151 FIND v(dout1_80) AT=760.025n

* CHECK dout1_81 Vdout1_81ck151 = 0 time = 760
.meas tran vdout1_81ck151 FIND v(dout1_81) AT=760.025n

* CHECK dout1_82 Vdout1_82ck151 = 0.9 time = 760
.meas tran vdout1_82ck151 FIND v(dout1_82) AT=760.025n

* CHECK dout1_83 Vdout1_83ck151 = 0 time = 760
.meas tran vdout1_83ck151 FIND v(dout1_83) AT=760.025n

* CHECK dout1_84 Vdout1_84ck151 = 0.9 time = 760
.meas tran vdout1_84ck151 FIND v(dout1_84) AT=760.025n

* CHECK dout1_85 Vdout1_85ck151 = 0.9 time = 760
.meas tran vdout1_85ck151 FIND v(dout1_85) AT=760.025n

* CHECK dout1_86 Vdout1_86ck151 = 0 time = 760
.meas tran vdout1_86ck151 FIND v(dout1_86) AT=760.025n

* CHECK dout1_87 Vdout1_87ck151 = 0 time = 760
.meas tran vdout1_87ck151 FIND v(dout1_87) AT=760.025n

* CHECK dout1_88 Vdout1_88ck151 = 0 time = 760
.meas tran vdout1_88ck151 FIND v(dout1_88) AT=760.025n

* CHECK dout1_89 Vdout1_89ck151 = 0.9 time = 760
.meas tran vdout1_89ck151 FIND v(dout1_89) AT=760.025n

* CHECK dout1_90 Vdout1_90ck151 = 0 time = 760
.meas tran vdout1_90ck151 FIND v(dout1_90) AT=760.025n

* CHECK dout1_91 Vdout1_91ck151 = 0.9 time = 760
.meas tran vdout1_91ck151 FIND v(dout1_91) AT=760.025n

* CHECK dout1_92 Vdout1_92ck151 = 0 time = 760
.meas tran vdout1_92ck151 FIND v(dout1_92) AT=760.025n

* CHECK dout1_93 Vdout1_93ck151 = 0.9 time = 760
.meas tran vdout1_93ck151 FIND v(dout1_93) AT=760.025n

* CHECK dout1_94 Vdout1_94ck151 = 0.9 time = 760
.meas tran vdout1_94ck151 FIND v(dout1_94) AT=760.025n

* CHECK dout1_95 Vdout1_95ck151 = 0.9 time = 760
.meas tran vdout1_95ck151 FIND v(dout1_95) AT=760.025n

* CHECK dout1_96 Vdout1_96ck151 = 0.9 time = 760
.meas tran vdout1_96ck151 FIND v(dout1_96) AT=760.025n

* CHECK dout1_97 Vdout1_97ck151 = 0.9 time = 760
.meas tran vdout1_97ck151 FIND v(dout1_97) AT=760.025n

* CHECK dout1_98 Vdout1_98ck151 = 0 time = 760
.meas tran vdout1_98ck151 FIND v(dout1_98) AT=760.025n

* CHECK dout1_99 Vdout1_99ck151 = 0.9 time = 760
.meas tran vdout1_99ck151 FIND v(dout1_99) AT=760.025n

* CHECK dout1_100 Vdout1_100ck151 = 0 time = 760
.meas tran vdout1_100ck151 FIND v(dout1_100) AT=760.025n

* CHECK dout1_101 Vdout1_101ck151 = 0.9 time = 760
.meas tran vdout1_101ck151 FIND v(dout1_101) AT=760.025n

* CHECK dout1_102 Vdout1_102ck151 = 0.9 time = 760
.meas tran vdout1_102ck151 FIND v(dout1_102) AT=760.025n

* CHECK dout1_103 Vdout1_103ck151 = 0.9 time = 760
.meas tran vdout1_103ck151 FIND v(dout1_103) AT=760.025n

* CHECK dout1_104 Vdout1_104ck151 = 0.9 time = 760
.meas tran vdout1_104ck151 FIND v(dout1_104) AT=760.025n

* CHECK dout1_105 Vdout1_105ck151 = 0 time = 760
.meas tran vdout1_105ck151 FIND v(dout1_105) AT=760.025n

* CHECK dout1_106 Vdout1_106ck151 = 0.9 time = 760
.meas tran vdout1_106ck151 FIND v(dout1_106) AT=760.025n

* CHECK dout1_107 Vdout1_107ck151 = 0 time = 760
.meas tran vdout1_107ck151 FIND v(dout1_107) AT=760.025n

* CHECK dout1_108 Vdout1_108ck151 = 0 time = 760
.meas tran vdout1_108ck151 FIND v(dout1_108) AT=760.025n

* CHECK dout1_109 Vdout1_109ck151 = 0 time = 760
.meas tran vdout1_109ck151 FIND v(dout1_109) AT=760.025n

* CHECK dout1_110 Vdout1_110ck151 = 0 time = 760
.meas tran vdout1_110ck151 FIND v(dout1_110) AT=760.025n

* CHECK dout1_111 Vdout1_111ck151 = 0 time = 760
.meas tran vdout1_111ck151 FIND v(dout1_111) AT=760.025n

* CHECK dout1_112 Vdout1_112ck151 = 0.9 time = 760
.meas tran vdout1_112ck151 FIND v(dout1_112) AT=760.025n

* CHECK dout1_113 Vdout1_113ck151 = 0.9 time = 760
.meas tran vdout1_113ck151 FIND v(dout1_113) AT=760.025n

* CHECK dout1_114 Vdout1_114ck151 = 0.9 time = 760
.meas tran vdout1_114ck151 FIND v(dout1_114) AT=760.025n

* CHECK dout1_115 Vdout1_115ck151 = 0.9 time = 760
.meas tran vdout1_115ck151 FIND v(dout1_115) AT=760.025n

* CHECK dout1_116 Vdout1_116ck151 = 0.9 time = 760
.meas tran vdout1_116ck151 FIND v(dout1_116) AT=760.025n

* CHECK dout1_117 Vdout1_117ck151 = 0.9 time = 760
.meas tran vdout1_117ck151 FIND v(dout1_117) AT=760.025n

* CHECK dout1_118 Vdout1_118ck151 = 0.9 time = 760
.meas tran vdout1_118ck151 FIND v(dout1_118) AT=760.025n

* CHECK dout1_119 Vdout1_119ck151 = 0.9 time = 760
.meas tran vdout1_119ck151 FIND v(dout1_119) AT=760.025n

* CHECK dout1_0 Vdout1_0ck154 = 0.9 time = 775
.meas tran vdout1_0ck154 FIND v(dout1_0) AT=775.025n

* CHECK dout1_1 Vdout1_1ck154 = 0.9 time = 775
.meas tran vdout1_1ck154 FIND v(dout1_1) AT=775.025n

* CHECK dout1_2 Vdout1_2ck154 = 0.9 time = 775
.meas tran vdout1_2ck154 FIND v(dout1_2) AT=775.025n

* CHECK dout1_3 Vdout1_3ck154 = 0.9 time = 775
.meas tran vdout1_3ck154 FIND v(dout1_3) AT=775.025n

* CHECK dout1_4 Vdout1_4ck154 = 0 time = 775
.meas tran vdout1_4ck154 FIND v(dout1_4) AT=775.025n

* CHECK dout1_5 Vdout1_5ck154 = 0.9 time = 775
.meas tran vdout1_5ck154 FIND v(dout1_5) AT=775.025n

* CHECK dout1_6 Vdout1_6ck154 = 0.9 time = 775
.meas tran vdout1_6ck154 FIND v(dout1_6) AT=775.025n

* CHECK dout1_7 Vdout1_7ck154 = 0 time = 775
.meas tran vdout1_7ck154 FIND v(dout1_7) AT=775.025n

* CHECK dout1_8 Vdout1_8ck154 = 0.9 time = 775
.meas tran vdout1_8ck154 FIND v(dout1_8) AT=775.025n

* CHECK dout1_9 Vdout1_9ck154 = 0 time = 775
.meas tran vdout1_9ck154 FIND v(dout1_9) AT=775.025n

* CHECK dout1_10 Vdout1_10ck154 = 0 time = 775
.meas tran vdout1_10ck154 FIND v(dout1_10) AT=775.025n

* CHECK dout1_11 Vdout1_11ck154 = 0 time = 775
.meas tran vdout1_11ck154 FIND v(dout1_11) AT=775.025n

* CHECK dout1_12 Vdout1_12ck154 = 0 time = 775
.meas tran vdout1_12ck154 FIND v(dout1_12) AT=775.025n

* CHECK dout1_13 Vdout1_13ck154 = 0.9 time = 775
.meas tran vdout1_13ck154 FIND v(dout1_13) AT=775.025n

* CHECK dout1_14 Vdout1_14ck154 = 0.9 time = 775
.meas tran vdout1_14ck154 FIND v(dout1_14) AT=775.025n

* CHECK dout1_15 Vdout1_15ck154 = 0.9 time = 775
.meas tran vdout1_15ck154 FIND v(dout1_15) AT=775.025n

* CHECK dout1_16 Vdout1_16ck154 = 0.9 time = 775
.meas tran vdout1_16ck154 FIND v(dout1_16) AT=775.025n

* CHECK dout1_17 Vdout1_17ck154 = 0 time = 775
.meas tran vdout1_17ck154 FIND v(dout1_17) AT=775.025n

* CHECK dout1_18 Vdout1_18ck154 = 0 time = 775
.meas tran vdout1_18ck154 FIND v(dout1_18) AT=775.025n

* CHECK dout1_19 Vdout1_19ck154 = 0.9 time = 775
.meas tran vdout1_19ck154 FIND v(dout1_19) AT=775.025n

* CHECK dout1_20 Vdout1_20ck154 = 0 time = 775
.meas tran vdout1_20ck154 FIND v(dout1_20) AT=775.025n

* CHECK dout1_21 Vdout1_21ck154 = 0.9 time = 775
.meas tran vdout1_21ck154 FIND v(dout1_21) AT=775.025n

* CHECK dout1_22 Vdout1_22ck154 = 0.9 time = 775
.meas tran vdout1_22ck154 FIND v(dout1_22) AT=775.025n

* CHECK dout1_23 Vdout1_23ck154 = 0 time = 775
.meas tran vdout1_23ck154 FIND v(dout1_23) AT=775.025n

* CHECK dout1_24 Vdout1_24ck154 = 0 time = 775
.meas tran vdout1_24ck154 FIND v(dout1_24) AT=775.025n

* CHECK dout1_25 Vdout1_25ck154 = 0 time = 775
.meas tran vdout1_25ck154 FIND v(dout1_25) AT=775.025n

* CHECK dout1_26 Vdout1_26ck154 = 0.9 time = 775
.meas tran vdout1_26ck154 FIND v(dout1_26) AT=775.025n

* CHECK dout1_27 Vdout1_27ck154 = 0 time = 775
.meas tran vdout1_27ck154 FIND v(dout1_27) AT=775.025n

* CHECK dout1_28 Vdout1_28ck154 = 0.9 time = 775
.meas tran vdout1_28ck154 FIND v(dout1_28) AT=775.025n

* CHECK dout1_29 Vdout1_29ck154 = 0 time = 775
.meas tran vdout1_29ck154 FIND v(dout1_29) AT=775.025n

* CHECK dout1_30 Vdout1_30ck154 = 0 time = 775
.meas tran vdout1_30ck154 FIND v(dout1_30) AT=775.025n

* CHECK dout1_31 Vdout1_31ck154 = 0.9 time = 775
.meas tran vdout1_31ck154 FIND v(dout1_31) AT=775.025n

* CHECK dout1_32 Vdout1_32ck154 = 0 time = 775
.meas tran vdout1_32ck154 FIND v(dout1_32) AT=775.025n

* CHECK dout1_33 Vdout1_33ck154 = 0 time = 775
.meas tran vdout1_33ck154 FIND v(dout1_33) AT=775.025n

* CHECK dout1_34 Vdout1_34ck154 = 0 time = 775
.meas tran vdout1_34ck154 FIND v(dout1_34) AT=775.025n

* CHECK dout1_35 Vdout1_35ck154 = 0.9 time = 775
.meas tran vdout1_35ck154 FIND v(dout1_35) AT=775.025n

* CHECK dout1_36 Vdout1_36ck154 = 0.9 time = 775
.meas tran vdout1_36ck154 FIND v(dout1_36) AT=775.025n

* CHECK dout1_37 Vdout1_37ck154 = 0.9 time = 775
.meas tran vdout1_37ck154 FIND v(dout1_37) AT=775.025n

* CHECK dout1_38 Vdout1_38ck154 = 0.9 time = 775
.meas tran vdout1_38ck154 FIND v(dout1_38) AT=775.025n

* CHECK dout1_39 Vdout1_39ck154 = 0 time = 775
.meas tran vdout1_39ck154 FIND v(dout1_39) AT=775.025n

* CHECK dout1_40 Vdout1_40ck154 = 0 time = 775
.meas tran vdout1_40ck154 FIND v(dout1_40) AT=775.025n

* CHECK dout1_41 Vdout1_41ck154 = 0 time = 775
.meas tran vdout1_41ck154 FIND v(dout1_41) AT=775.025n

* CHECK dout1_42 Vdout1_42ck154 = 0 time = 775
.meas tran vdout1_42ck154 FIND v(dout1_42) AT=775.025n

* CHECK dout1_43 Vdout1_43ck154 = 0 time = 775
.meas tran vdout1_43ck154 FIND v(dout1_43) AT=775.025n

* CHECK dout1_44 Vdout1_44ck154 = 0 time = 775
.meas tran vdout1_44ck154 FIND v(dout1_44) AT=775.025n

* CHECK dout1_45 Vdout1_45ck154 = 0 time = 775
.meas tran vdout1_45ck154 FIND v(dout1_45) AT=775.025n

* CHECK dout1_46 Vdout1_46ck154 = 0 time = 775
.meas tran vdout1_46ck154 FIND v(dout1_46) AT=775.025n

* CHECK dout1_47 Vdout1_47ck154 = 0 time = 775
.meas tran vdout1_47ck154 FIND v(dout1_47) AT=775.025n

* CHECK dout1_48 Vdout1_48ck154 = 0.9 time = 775
.meas tran vdout1_48ck154 FIND v(dout1_48) AT=775.025n

* CHECK dout1_49 Vdout1_49ck154 = 0.9 time = 775
.meas tran vdout1_49ck154 FIND v(dout1_49) AT=775.025n

* CHECK dout1_50 Vdout1_50ck154 = 0 time = 775
.meas tran vdout1_50ck154 FIND v(dout1_50) AT=775.025n

* CHECK dout1_51 Vdout1_51ck154 = 0.9 time = 775
.meas tran vdout1_51ck154 FIND v(dout1_51) AT=775.025n

* CHECK dout1_52 Vdout1_52ck154 = 0.9 time = 775
.meas tran vdout1_52ck154 FIND v(dout1_52) AT=775.025n

* CHECK dout1_53 Vdout1_53ck154 = 0 time = 775
.meas tran vdout1_53ck154 FIND v(dout1_53) AT=775.025n

* CHECK dout1_54 Vdout1_54ck154 = 0.9 time = 775
.meas tran vdout1_54ck154 FIND v(dout1_54) AT=775.025n

* CHECK dout1_55 Vdout1_55ck154 = 0.9 time = 775
.meas tran vdout1_55ck154 FIND v(dout1_55) AT=775.025n

* CHECK dout1_56 Vdout1_56ck154 = 0.9 time = 775
.meas tran vdout1_56ck154 FIND v(dout1_56) AT=775.025n

* CHECK dout1_57 Vdout1_57ck154 = 0.9 time = 775
.meas tran vdout1_57ck154 FIND v(dout1_57) AT=775.025n

* CHECK dout1_58 Vdout1_58ck154 = 0 time = 775
.meas tran vdout1_58ck154 FIND v(dout1_58) AT=775.025n

* CHECK dout1_59 Vdout1_59ck154 = 0.9 time = 775
.meas tran vdout1_59ck154 FIND v(dout1_59) AT=775.025n

* CHECK dout1_60 Vdout1_60ck154 = 0 time = 775
.meas tran vdout1_60ck154 FIND v(dout1_60) AT=775.025n

* CHECK dout1_61 Vdout1_61ck154 = 0 time = 775
.meas tran vdout1_61ck154 FIND v(dout1_61) AT=775.025n

* CHECK dout1_62 Vdout1_62ck154 = 0 time = 775
.meas tran vdout1_62ck154 FIND v(dout1_62) AT=775.025n

* CHECK dout1_63 Vdout1_63ck154 = 0.9 time = 775
.meas tran vdout1_63ck154 FIND v(dout1_63) AT=775.025n

* CHECK dout1_64 Vdout1_64ck154 = 0.9 time = 775
.meas tran vdout1_64ck154 FIND v(dout1_64) AT=775.025n

* CHECK dout1_65 Vdout1_65ck154 = 0 time = 775
.meas tran vdout1_65ck154 FIND v(dout1_65) AT=775.025n

* CHECK dout1_66 Vdout1_66ck154 = 0.9 time = 775
.meas tran vdout1_66ck154 FIND v(dout1_66) AT=775.025n

* CHECK dout1_67 Vdout1_67ck154 = 0.9 time = 775
.meas tran vdout1_67ck154 FIND v(dout1_67) AT=775.025n

* CHECK dout1_68 Vdout1_68ck154 = 0.9 time = 775
.meas tran vdout1_68ck154 FIND v(dout1_68) AT=775.025n

* CHECK dout1_69 Vdout1_69ck154 = 0.9 time = 775
.meas tran vdout1_69ck154 FIND v(dout1_69) AT=775.025n

* CHECK dout1_70 Vdout1_70ck154 = 0 time = 775
.meas tran vdout1_70ck154 FIND v(dout1_70) AT=775.025n

* CHECK dout1_71 Vdout1_71ck154 = 0.9 time = 775
.meas tran vdout1_71ck154 FIND v(dout1_71) AT=775.025n

* CHECK dout1_72 Vdout1_72ck154 = 0.9 time = 775
.meas tran vdout1_72ck154 FIND v(dout1_72) AT=775.025n

* CHECK dout1_73 Vdout1_73ck154 = 0 time = 775
.meas tran vdout1_73ck154 FIND v(dout1_73) AT=775.025n

* CHECK dout1_74 Vdout1_74ck154 = 0 time = 775
.meas tran vdout1_74ck154 FIND v(dout1_74) AT=775.025n

* CHECK dout1_75 Vdout1_75ck154 = 0.9 time = 775
.meas tran vdout1_75ck154 FIND v(dout1_75) AT=775.025n

* CHECK dout1_76 Vdout1_76ck154 = 0.9 time = 775
.meas tran vdout1_76ck154 FIND v(dout1_76) AT=775.025n

* CHECK dout1_77 Vdout1_77ck154 = 0.9 time = 775
.meas tran vdout1_77ck154 FIND v(dout1_77) AT=775.025n

* CHECK dout1_78 Vdout1_78ck154 = 0 time = 775
.meas tran vdout1_78ck154 FIND v(dout1_78) AT=775.025n

* CHECK dout1_79 Vdout1_79ck154 = 0 time = 775
.meas tran vdout1_79ck154 FIND v(dout1_79) AT=775.025n

* CHECK dout1_80 Vdout1_80ck154 = 0.9 time = 775
.meas tran vdout1_80ck154 FIND v(dout1_80) AT=775.025n

* CHECK dout1_81 Vdout1_81ck154 = 0.9 time = 775
.meas tran vdout1_81ck154 FIND v(dout1_81) AT=775.025n

* CHECK dout1_82 Vdout1_82ck154 = 0.9 time = 775
.meas tran vdout1_82ck154 FIND v(dout1_82) AT=775.025n

* CHECK dout1_83 Vdout1_83ck154 = 0.9 time = 775
.meas tran vdout1_83ck154 FIND v(dout1_83) AT=775.025n

* CHECK dout1_84 Vdout1_84ck154 = 0 time = 775
.meas tran vdout1_84ck154 FIND v(dout1_84) AT=775.025n

* CHECK dout1_85 Vdout1_85ck154 = 0 time = 775
.meas tran vdout1_85ck154 FIND v(dout1_85) AT=775.025n

* CHECK dout1_86 Vdout1_86ck154 = 0.9 time = 775
.meas tran vdout1_86ck154 FIND v(dout1_86) AT=775.025n

* CHECK dout1_87 Vdout1_87ck154 = 0.9 time = 775
.meas tran vdout1_87ck154 FIND v(dout1_87) AT=775.025n

* CHECK dout1_88 Vdout1_88ck154 = 0 time = 775
.meas tran vdout1_88ck154 FIND v(dout1_88) AT=775.025n

* CHECK dout1_89 Vdout1_89ck154 = 0.9 time = 775
.meas tran vdout1_89ck154 FIND v(dout1_89) AT=775.025n

* CHECK dout1_90 Vdout1_90ck154 = 0.9 time = 775
.meas tran vdout1_90ck154 FIND v(dout1_90) AT=775.025n

* CHECK dout1_91 Vdout1_91ck154 = 0 time = 775
.meas tran vdout1_91ck154 FIND v(dout1_91) AT=775.025n

* CHECK dout1_92 Vdout1_92ck154 = 0.9 time = 775
.meas tran vdout1_92ck154 FIND v(dout1_92) AT=775.025n

* CHECK dout1_93 Vdout1_93ck154 = 0 time = 775
.meas tran vdout1_93ck154 FIND v(dout1_93) AT=775.025n

* CHECK dout1_94 Vdout1_94ck154 = 0.9 time = 775
.meas tran vdout1_94ck154 FIND v(dout1_94) AT=775.025n

* CHECK dout1_95 Vdout1_95ck154 = 0.9 time = 775
.meas tran vdout1_95ck154 FIND v(dout1_95) AT=775.025n

* CHECK dout1_96 Vdout1_96ck154 = 0 time = 775
.meas tran vdout1_96ck154 FIND v(dout1_96) AT=775.025n

* CHECK dout1_97 Vdout1_97ck154 = 0 time = 775
.meas tran vdout1_97ck154 FIND v(dout1_97) AT=775.025n

* CHECK dout1_98 Vdout1_98ck154 = 0 time = 775
.meas tran vdout1_98ck154 FIND v(dout1_98) AT=775.025n

* CHECK dout1_99 Vdout1_99ck154 = 0.9 time = 775
.meas tran vdout1_99ck154 FIND v(dout1_99) AT=775.025n

* CHECK dout1_100 Vdout1_100ck154 = 0 time = 775
.meas tran vdout1_100ck154 FIND v(dout1_100) AT=775.025n

* CHECK dout1_101 Vdout1_101ck154 = 0.9 time = 775
.meas tran vdout1_101ck154 FIND v(dout1_101) AT=775.025n

* CHECK dout1_102 Vdout1_102ck154 = 0 time = 775
.meas tran vdout1_102ck154 FIND v(dout1_102) AT=775.025n

* CHECK dout1_103 Vdout1_103ck154 = 0 time = 775
.meas tran vdout1_103ck154 FIND v(dout1_103) AT=775.025n

* CHECK dout1_104 Vdout1_104ck154 = 0 time = 775
.meas tran vdout1_104ck154 FIND v(dout1_104) AT=775.025n

* CHECK dout1_105 Vdout1_105ck154 = 0 time = 775
.meas tran vdout1_105ck154 FIND v(dout1_105) AT=775.025n

* CHECK dout1_106 Vdout1_106ck154 = 0 time = 775
.meas tran vdout1_106ck154 FIND v(dout1_106) AT=775.025n

* CHECK dout1_107 Vdout1_107ck154 = 0.9 time = 775
.meas tran vdout1_107ck154 FIND v(dout1_107) AT=775.025n

* CHECK dout1_108 Vdout1_108ck154 = 0.9 time = 775
.meas tran vdout1_108ck154 FIND v(dout1_108) AT=775.025n

* CHECK dout1_109 Vdout1_109ck154 = 0.9 time = 775
.meas tran vdout1_109ck154 FIND v(dout1_109) AT=775.025n

* CHECK dout1_110 Vdout1_110ck154 = 0 time = 775
.meas tran vdout1_110ck154 FIND v(dout1_110) AT=775.025n

* CHECK dout1_111 Vdout1_111ck154 = 0.9 time = 775
.meas tran vdout1_111ck154 FIND v(dout1_111) AT=775.025n

* CHECK dout1_112 Vdout1_112ck154 = 0 time = 775
.meas tran vdout1_112ck154 FIND v(dout1_112) AT=775.025n

* CHECK dout1_113 Vdout1_113ck154 = 0.9 time = 775
.meas tran vdout1_113ck154 FIND v(dout1_113) AT=775.025n

* CHECK dout1_114 Vdout1_114ck154 = 0.9 time = 775
.meas tran vdout1_114ck154 FIND v(dout1_114) AT=775.025n

* CHECK dout1_115 Vdout1_115ck154 = 0 time = 775
.meas tran vdout1_115ck154 FIND v(dout1_115) AT=775.025n

* CHECK dout1_116 Vdout1_116ck154 = 0 time = 775
.meas tran vdout1_116ck154 FIND v(dout1_116) AT=775.025n

* CHECK dout1_117 Vdout1_117ck154 = 0.9 time = 775
.meas tran vdout1_117ck154 FIND v(dout1_117) AT=775.025n

* CHECK dout1_118 Vdout1_118ck154 = 0 time = 775
.meas tran vdout1_118ck154 FIND v(dout1_118) AT=775.025n

* CHECK dout1_119 Vdout1_119ck154 = 0 time = 775
.meas tran vdout1_119ck154 FIND v(dout1_119) AT=775.025n

* CHECK dout1_0 Vdout1_0ck157 = 0.9 time = 790
.meas tran vdout1_0ck157 FIND v(dout1_0) AT=790.025n

* CHECK dout1_1 Vdout1_1ck157 = 0 time = 790
.meas tran vdout1_1ck157 FIND v(dout1_1) AT=790.025n

* CHECK dout1_2 Vdout1_2ck157 = 0 time = 790
.meas tran vdout1_2ck157 FIND v(dout1_2) AT=790.025n

* CHECK dout1_3 Vdout1_3ck157 = 0.9 time = 790
.meas tran vdout1_3ck157 FIND v(dout1_3) AT=790.025n

* CHECK dout1_4 Vdout1_4ck157 = 0.9 time = 790
.meas tran vdout1_4ck157 FIND v(dout1_4) AT=790.025n

* CHECK dout1_5 Vdout1_5ck157 = 0 time = 790
.meas tran vdout1_5ck157 FIND v(dout1_5) AT=790.025n

* CHECK dout1_6 Vdout1_6ck157 = 0 time = 790
.meas tran vdout1_6ck157 FIND v(dout1_6) AT=790.025n

* CHECK dout1_7 Vdout1_7ck157 = 0 time = 790
.meas tran vdout1_7ck157 FIND v(dout1_7) AT=790.025n

* CHECK dout1_8 Vdout1_8ck157 = 0.9 time = 790
.meas tran vdout1_8ck157 FIND v(dout1_8) AT=790.025n

* CHECK dout1_9 Vdout1_9ck157 = 0.9 time = 790
.meas tran vdout1_9ck157 FIND v(dout1_9) AT=790.025n

* CHECK dout1_10 Vdout1_10ck157 = 0 time = 790
.meas tran vdout1_10ck157 FIND v(dout1_10) AT=790.025n

* CHECK dout1_11 Vdout1_11ck157 = 0.9 time = 790
.meas tran vdout1_11ck157 FIND v(dout1_11) AT=790.025n

* CHECK dout1_12 Vdout1_12ck157 = 0 time = 790
.meas tran vdout1_12ck157 FIND v(dout1_12) AT=790.025n

* CHECK dout1_13 Vdout1_13ck157 = 0.9 time = 790
.meas tran vdout1_13ck157 FIND v(dout1_13) AT=790.025n

* CHECK dout1_14 Vdout1_14ck157 = 0.9 time = 790
.meas tran vdout1_14ck157 FIND v(dout1_14) AT=790.025n

* CHECK dout1_15 Vdout1_15ck157 = 0.9 time = 790
.meas tran vdout1_15ck157 FIND v(dout1_15) AT=790.025n

* CHECK dout1_16 Vdout1_16ck157 = 0 time = 790
.meas tran vdout1_16ck157 FIND v(dout1_16) AT=790.025n

* CHECK dout1_17 Vdout1_17ck157 = 0 time = 790
.meas tran vdout1_17ck157 FIND v(dout1_17) AT=790.025n

* CHECK dout1_18 Vdout1_18ck157 = 0 time = 790
.meas tran vdout1_18ck157 FIND v(dout1_18) AT=790.025n

* CHECK dout1_19 Vdout1_19ck157 = 0.9 time = 790
.meas tran vdout1_19ck157 FIND v(dout1_19) AT=790.025n

* CHECK dout1_20 Vdout1_20ck157 = 0 time = 790
.meas tran vdout1_20ck157 FIND v(dout1_20) AT=790.025n

* CHECK dout1_21 Vdout1_21ck157 = 0 time = 790
.meas tran vdout1_21ck157 FIND v(dout1_21) AT=790.025n

* CHECK dout1_22 Vdout1_22ck157 = 0.9 time = 790
.meas tran vdout1_22ck157 FIND v(dout1_22) AT=790.025n

* CHECK dout1_23 Vdout1_23ck157 = 0.9 time = 790
.meas tran vdout1_23ck157 FIND v(dout1_23) AT=790.025n

* CHECK dout1_24 Vdout1_24ck157 = 0 time = 790
.meas tran vdout1_24ck157 FIND v(dout1_24) AT=790.025n

* CHECK dout1_25 Vdout1_25ck157 = 0.9 time = 790
.meas tran vdout1_25ck157 FIND v(dout1_25) AT=790.025n

* CHECK dout1_26 Vdout1_26ck157 = 0 time = 790
.meas tran vdout1_26ck157 FIND v(dout1_26) AT=790.025n

* CHECK dout1_27 Vdout1_27ck157 = 0.9 time = 790
.meas tran vdout1_27ck157 FIND v(dout1_27) AT=790.025n

* CHECK dout1_28 Vdout1_28ck157 = 0.9 time = 790
.meas tran vdout1_28ck157 FIND v(dout1_28) AT=790.025n

* CHECK dout1_29 Vdout1_29ck157 = 0.9 time = 790
.meas tran vdout1_29ck157 FIND v(dout1_29) AT=790.025n

* CHECK dout1_30 Vdout1_30ck157 = 0 time = 790
.meas tran vdout1_30ck157 FIND v(dout1_30) AT=790.025n

* CHECK dout1_31 Vdout1_31ck157 = 0.9 time = 790
.meas tran vdout1_31ck157 FIND v(dout1_31) AT=790.025n

* CHECK dout1_32 Vdout1_32ck157 = 0 time = 790
.meas tran vdout1_32ck157 FIND v(dout1_32) AT=790.025n

* CHECK dout1_33 Vdout1_33ck157 = 0.9 time = 790
.meas tran vdout1_33ck157 FIND v(dout1_33) AT=790.025n

* CHECK dout1_34 Vdout1_34ck157 = 0 time = 790
.meas tran vdout1_34ck157 FIND v(dout1_34) AT=790.025n

* CHECK dout1_35 Vdout1_35ck157 = 0.9 time = 790
.meas tran vdout1_35ck157 FIND v(dout1_35) AT=790.025n

* CHECK dout1_36 Vdout1_36ck157 = 0 time = 790
.meas tran vdout1_36ck157 FIND v(dout1_36) AT=790.025n

* CHECK dout1_37 Vdout1_37ck157 = 0 time = 790
.meas tran vdout1_37ck157 FIND v(dout1_37) AT=790.025n

* CHECK dout1_38 Vdout1_38ck157 = 0 time = 790
.meas tran vdout1_38ck157 FIND v(dout1_38) AT=790.025n

* CHECK dout1_39 Vdout1_39ck157 = 0 time = 790
.meas tran vdout1_39ck157 FIND v(dout1_39) AT=790.025n

* CHECK dout1_40 Vdout1_40ck157 = 0.9 time = 790
.meas tran vdout1_40ck157 FIND v(dout1_40) AT=790.025n

* CHECK dout1_41 Vdout1_41ck157 = 0.9 time = 790
.meas tran vdout1_41ck157 FIND v(dout1_41) AT=790.025n

* CHECK dout1_42 Vdout1_42ck157 = 0.9 time = 790
.meas tran vdout1_42ck157 FIND v(dout1_42) AT=790.025n

* CHECK dout1_43 Vdout1_43ck157 = 0 time = 790
.meas tran vdout1_43ck157 FIND v(dout1_43) AT=790.025n

* CHECK dout1_44 Vdout1_44ck157 = 0 time = 790
.meas tran vdout1_44ck157 FIND v(dout1_44) AT=790.025n

* CHECK dout1_45 Vdout1_45ck157 = 0.9 time = 790
.meas tran vdout1_45ck157 FIND v(dout1_45) AT=790.025n

* CHECK dout1_46 Vdout1_46ck157 = 0 time = 790
.meas tran vdout1_46ck157 FIND v(dout1_46) AT=790.025n

* CHECK dout1_47 Vdout1_47ck157 = 0.9 time = 790
.meas tran vdout1_47ck157 FIND v(dout1_47) AT=790.025n

* CHECK dout1_48 Vdout1_48ck157 = 0.9 time = 790
.meas tran vdout1_48ck157 FIND v(dout1_48) AT=790.025n

* CHECK dout1_49 Vdout1_49ck157 = 0.9 time = 790
.meas tran vdout1_49ck157 FIND v(dout1_49) AT=790.025n

* CHECK dout1_50 Vdout1_50ck157 = 0 time = 790
.meas tran vdout1_50ck157 FIND v(dout1_50) AT=790.025n

* CHECK dout1_51 Vdout1_51ck157 = 0 time = 790
.meas tran vdout1_51ck157 FIND v(dout1_51) AT=790.025n

* CHECK dout1_52 Vdout1_52ck157 = 0 time = 790
.meas tran vdout1_52ck157 FIND v(dout1_52) AT=790.025n

* CHECK dout1_53 Vdout1_53ck157 = 0 time = 790
.meas tran vdout1_53ck157 FIND v(dout1_53) AT=790.025n

* CHECK dout1_54 Vdout1_54ck157 = 0.9 time = 790
.meas tran vdout1_54ck157 FIND v(dout1_54) AT=790.025n

* CHECK dout1_55 Vdout1_55ck157 = 0 time = 790
.meas tran vdout1_55ck157 FIND v(dout1_55) AT=790.025n

* CHECK dout1_56 Vdout1_56ck157 = 0 time = 790
.meas tran vdout1_56ck157 FIND v(dout1_56) AT=790.025n

* CHECK dout1_57 Vdout1_57ck157 = 0 time = 790
.meas tran vdout1_57ck157 FIND v(dout1_57) AT=790.025n

* CHECK dout1_58 Vdout1_58ck157 = 0.9 time = 790
.meas tran vdout1_58ck157 FIND v(dout1_58) AT=790.025n

* CHECK dout1_59 Vdout1_59ck157 = 0.9 time = 790
.meas tran vdout1_59ck157 FIND v(dout1_59) AT=790.025n

* CHECK dout1_60 Vdout1_60ck157 = 0.9 time = 790
.meas tran vdout1_60ck157 FIND v(dout1_60) AT=790.025n

* CHECK dout1_61 Vdout1_61ck157 = 0 time = 790
.meas tran vdout1_61ck157 FIND v(dout1_61) AT=790.025n

* CHECK dout1_62 Vdout1_62ck157 = 0 time = 790
.meas tran vdout1_62ck157 FIND v(dout1_62) AT=790.025n

* CHECK dout1_63 Vdout1_63ck157 = 0.9 time = 790
.meas tran vdout1_63ck157 FIND v(dout1_63) AT=790.025n

* CHECK dout1_64 Vdout1_64ck157 = 0 time = 790
.meas tran vdout1_64ck157 FIND v(dout1_64) AT=790.025n

* CHECK dout1_65 Vdout1_65ck157 = 0.9 time = 790
.meas tran vdout1_65ck157 FIND v(dout1_65) AT=790.025n

* CHECK dout1_66 Vdout1_66ck157 = 0 time = 790
.meas tran vdout1_66ck157 FIND v(dout1_66) AT=790.025n

* CHECK dout1_67 Vdout1_67ck157 = 0 time = 790
.meas tran vdout1_67ck157 FIND v(dout1_67) AT=790.025n

* CHECK dout1_68 Vdout1_68ck157 = 0 time = 790
.meas tran vdout1_68ck157 FIND v(dout1_68) AT=790.025n

* CHECK dout1_69 Vdout1_69ck157 = 0 time = 790
.meas tran vdout1_69ck157 FIND v(dout1_69) AT=790.025n

* CHECK dout1_70 Vdout1_70ck157 = 0 time = 790
.meas tran vdout1_70ck157 FIND v(dout1_70) AT=790.025n

* CHECK dout1_71 Vdout1_71ck157 = 0 time = 790
.meas tran vdout1_71ck157 FIND v(dout1_71) AT=790.025n

* CHECK dout1_72 Vdout1_72ck157 = 0 time = 790
.meas tran vdout1_72ck157 FIND v(dout1_72) AT=790.025n

* CHECK dout1_73 Vdout1_73ck157 = 0 time = 790
.meas tran vdout1_73ck157 FIND v(dout1_73) AT=790.025n

* CHECK dout1_74 Vdout1_74ck157 = 0.9 time = 790
.meas tran vdout1_74ck157 FIND v(dout1_74) AT=790.025n

* CHECK dout1_75 Vdout1_75ck157 = 0.9 time = 790
.meas tran vdout1_75ck157 FIND v(dout1_75) AT=790.025n

* CHECK dout1_76 Vdout1_76ck157 = 0 time = 790
.meas tran vdout1_76ck157 FIND v(dout1_76) AT=790.025n

* CHECK dout1_77 Vdout1_77ck157 = 0 time = 790
.meas tran vdout1_77ck157 FIND v(dout1_77) AT=790.025n

* CHECK dout1_78 Vdout1_78ck157 = 0 time = 790
.meas tran vdout1_78ck157 FIND v(dout1_78) AT=790.025n

* CHECK dout1_79 Vdout1_79ck157 = 0.9 time = 790
.meas tran vdout1_79ck157 FIND v(dout1_79) AT=790.025n

* CHECK dout1_80 Vdout1_80ck157 = 0 time = 790
.meas tran vdout1_80ck157 FIND v(dout1_80) AT=790.025n

* CHECK dout1_81 Vdout1_81ck157 = 0 time = 790
.meas tran vdout1_81ck157 FIND v(dout1_81) AT=790.025n

* CHECK dout1_82 Vdout1_82ck157 = 0.9 time = 790
.meas tran vdout1_82ck157 FIND v(dout1_82) AT=790.025n

* CHECK dout1_83 Vdout1_83ck157 = 0 time = 790
.meas tran vdout1_83ck157 FIND v(dout1_83) AT=790.025n

* CHECK dout1_84 Vdout1_84ck157 = 0.9 time = 790
.meas tran vdout1_84ck157 FIND v(dout1_84) AT=790.025n

* CHECK dout1_85 Vdout1_85ck157 = 0.9 time = 790
.meas tran vdout1_85ck157 FIND v(dout1_85) AT=790.025n

* CHECK dout1_86 Vdout1_86ck157 = 0 time = 790
.meas tran vdout1_86ck157 FIND v(dout1_86) AT=790.025n

* CHECK dout1_87 Vdout1_87ck157 = 0 time = 790
.meas tran vdout1_87ck157 FIND v(dout1_87) AT=790.025n

* CHECK dout1_88 Vdout1_88ck157 = 0 time = 790
.meas tran vdout1_88ck157 FIND v(dout1_88) AT=790.025n

* CHECK dout1_89 Vdout1_89ck157 = 0.9 time = 790
.meas tran vdout1_89ck157 FIND v(dout1_89) AT=790.025n

* CHECK dout1_90 Vdout1_90ck157 = 0 time = 790
.meas tran vdout1_90ck157 FIND v(dout1_90) AT=790.025n

* CHECK dout1_91 Vdout1_91ck157 = 0.9 time = 790
.meas tran vdout1_91ck157 FIND v(dout1_91) AT=790.025n

* CHECK dout1_92 Vdout1_92ck157 = 0 time = 790
.meas tran vdout1_92ck157 FIND v(dout1_92) AT=790.025n

* CHECK dout1_93 Vdout1_93ck157 = 0.9 time = 790
.meas tran vdout1_93ck157 FIND v(dout1_93) AT=790.025n

* CHECK dout1_94 Vdout1_94ck157 = 0.9 time = 790
.meas tran vdout1_94ck157 FIND v(dout1_94) AT=790.025n

* CHECK dout1_95 Vdout1_95ck157 = 0.9 time = 790
.meas tran vdout1_95ck157 FIND v(dout1_95) AT=790.025n

* CHECK dout1_96 Vdout1_96ck157 = 0.9 time = 790
.meas tran vdout1_96ck157 FIND v(dout1_96) AT=790.025n

* CHECK dout1_97 Vdout1_97ck157 = 0.9 time = 790
.meas tran vdout1_97ck157 FIND v(dout1_97) AT=790.025n

* CHECK dout1_98 Vdout1_98ck157 = 0 time = 790
.meas tran vdout1_98ck157 FIND v(dout1_98) AT=790.025n

* CHECK dout1_99 Vdout1_99ck157 = 0.9 time = 790
.meas tran vdout1_99ck157 FIND v(dout1_99) AT=790.025n

* CHECK dout1_100 Vdout1_100ck157 = 0 time = 790
.meas tran vdout1_100ck157 FIND v(dout1_100) AT=790.025n

* CHECK dout1_101 Vdout1_101ck157 = 0.9 time = 790
.meas tran vdout1_101ck157 FIND v(dout1_101) AT=790.025n

* CHECK dout1_102 Vdout1_102ck157 = 0.9 time = 790
.meas tran vdout1_102ck157 FIND v(dout1_102) AT=790.025n

* CHECK dout1_103 Vdout1_103ck157 = 0.9 time = 790
.meas tran vdout1_103ck157 FIND v(dout1_103) AT=790.025n

* CHECK dout1_104 Vdout1_104ck157 = 0.9 time = 790
.meas tran vdout1_104ck157 FIND v(dout1_104) AT=790.025n

* CHECK dout1_105 Vdout1_105ck157 = 0 time = 790
.meas tran vdout1_105ck157 FIND v(dout1_105) AT=790.025n

* CHECK dout1_106 Vdout1_106ck157 = 0.9 time = 790
.meas tran vdout1_106ck157 FIND v(dout1_106) AT=790.025n

* CHECK dout1_107 Vdout1_107ck157 = 0 time = 790
.meas tran vdout1_107ck157 FIND v(dout1_107) AT=790.025n

* CHECK dout1_108 Vdout1_108ck157 = 0 time = 790
.meas tran vdout1_108ck157 FIND v(dout1_108) AT=790.025n

* CHECK dout1_109 Vdout1_109ck157 = 0 time = 790
.meas tran vdout1_109ck157 FIND v(dout1_109) AT=790.025n

* CHECK dout1_110 Vdout1_110ck157 = 0 time = 790
.meas tran vdout1_110ck157 FIND v(dout1_110) AT=790.025n

* CHECK dout1_111 Vdout1_111ck157 = 0 time = 790
.meas tran vdout1_111ck157 FIND v(dout1_111) AT=790.025n

* CHECK dout1_112 Vdout1_112ck157 = 0.9 time = 790
.meas tran vdout1_112ck157 FIND v(dout1_112) AT=790.025n

* CHECK dout1_113 Vdout1_113ck157 = 0.9 time = 790
.meas tran vdout1_113ck157 FIND v(dout1_113) AT=790.025n

* CHECK dout1_114 Vdout1_114ck157 = 0.9 time = 790
.meas tran vdout1_114ck157 FIND v(dout1_114) AT=790.025n

* CHECK dout1_115 Vdout1_115ck157 = 0.9 time = 790
.meas tran vdout1_115ck157 FIND v(dout1_115) AT=790.025n

* CHECK dout1_116 Vdout1_116ck157 = 0.9 time = 790
.meas tran vdout1_116ck157 FIND v(dout1_116) AT=790.025n

* CHECK dout1_117 Vdout1_117ck157 = 0.9 time = 790
.meas tran vdout1_117ck157 FIND v(dout1_117) AT=790.025n

* CHECK dout1_118 Vdout1_118ck157 = 0.9 time = 790
.meas tran vdout1_118ck157 FIND v(dout1_118) AT=790.025n

* CHECK dout1_119 Vdout1_119ck157 = 0.9 time = 790
.meas tran vdout1_119ck157 FIND v(dout1_119) AT=790.025n

* CHECK dout1_0 Vdout1_0ck159 = 0.9 time = 800
.meas tran vdout1_0ck159 FIND v(dout1_0) AT=800.025n

* CHECK dout1_1 Vdout1_1ck159 = 0.9 time = 800
.meas tran vdout1_1ck159 FIND v(dout1_1) AT=800.025n

* CHECK dout1_2 Vdout1_2ck159 = 0 time = 800
.meas tran vdout1_2ck159 FIND v(dout1_2) AT=800.025n

* CHECK dout1_3 Vdout1_3ck159 = 0.9 time = 800
.meas tran vdout1_3ck159 FIND v(dout1_3) AT=800.025n

* CHECK dout1_4 Vdout1_4ck159 = 0 time = 800
.meas tran vdout1_4ck159 FIND v(dout1_4) AT=800.025n

* CHECK dout1_5 Vdout1_5ck159 = 0 time = 800
.meas tran vdout1_5ck159 FIND v(dout1_5) AT=800.025n

* CHECK dout1_6 Vdout1_6ck159 = 0.9 time = 800
.meas tran vdout1_6ck159 FIND v(dout1_6) AT=800.025n

* CHECK dout1_7 Vdout1_7ck159 = 0 time = 800
.meas tran vdout1_7ck159 FIND v(dout1_7) AT=800.025n

* CHECK dout1_8 Vdout1_8ck159 = 0 time = 800
.meas tran vdout1_8ck159 FIND v(dout1_8) AT=800.025n

* CHECK dout1_9 Vdout1_9ck159 = 0 time = 800
.meas tran vdout1_9ck159 FIND v(dout1_9) AT=800.025n

* CHECK dout1_10 Vdout1_10ck159 = 0.9 time = 800
.meas tran vdout1_10ck159 FIND v(dout1_10) AT=800.025n

* CHECK dout1_11 Vdout1_11ck159 = 0 time = 800
.meas tran vdout1_11ck159 FIND v(dout1_11) AT=800.025n

* CHECK dout1_12 Vdout1_12ck159 = 0.9 time = 800
.meas tran vdout1_12ck159 FIND v(dout1_12) AT=800.025n

* CHECK dout1_13 Vdout1_13ck159 = 0 time = 800
.meas tran vdout1_13ck159 FIND v(dout1_13) AT=800.025n

* CHECK dout1_14 Vdout1_14ck159 = 0 time = 800
.meas tran vdout1_14ck159 FIND v(dout1_14) AT=800.025n

* CHECK dout1_15 Vdout1_15ck159 = 0.9 time = 800
.meas tran vdout1_15ck159 FIND v(dout1_15) AT=800.025n

* CHECK dout1_16 Vdout1_16ck159 = 0.9 time = 800
.meas tran vdout1_16ck159 FIND v(dout1_16) AT=800.025n

* CHECK dout1_17 Vdout1_17ck159 = 0.9 time = 800
.meas tran vdout1_17ck159 FIND v(dout1_17) AT=800.025n

* CHECK dout1_18 Vdout1_18ck159 = 0.9 time = 800
.meas tran vdout1_18ck159 FIND v(dout1_18) AT=800.025n

* CHECK dout1_19 Vdout1_19ck159 = 0.9 time = 800
.meas tran vdout1_19ck159 FIND v(dout1_19) AT=800.025n

* CHECK dout1_20 Vdout1_20ck159 = 0.9 time = 800
.meas tran vdout1_20ck159 FIND v(dout1_20) AT=800.025n

* CHECK dout1_21 Vdout1_21ck159 = 0.9 time = 800
.meas tran vdout1_21ck159 FIND v(dout1_21) AT=800.025n

* CHECK dout1_22 Vdout1_22ck159 = 0 time = 800
.meas tran vdout1_22ck159 FIND v(dout1_22) AT=800.025n

* CHECK dout1_23 Vdout1_23ck159 = 0.9 time = 800
.meas tran vdout1_23ck159 FIND v(dout1_23) AT=800.025n

* CHECK dout1_24 Vdout1_24ck159 = 0 time = 800
.meas tran vdout1_24ck159 FIND v(dout1_24) AT=800.025n

* CHECK dout1_25 Vdout1_25ck159 = 0.9 time = 800
.meas tran vdout1_25ck159 FIND v(dout1_25) AT=800.025n

* CHECK dout1_26 Vdout1_26ck159 = 0.9 time = 800
.meas tran vdout1_26ck159 FIND v(dout1_26) AT=800.025n

* CHECK dout1_27 Vdout1_27ck159 = 0 time = 800
.meas tran vdout1_27ck159 FIND v(dout1_27) AT=800.025n

* CHECK dout1_28 Vdout1_28ck159 = 0.9 time = 800
.meas tran vdout1_28ck159 FIND v(dout1_28) AT=800.025n

* CHECK dout1_29 Vdout1_29ck159 = 0 time = 800
.meas tran vdout1_29ck159 FIND v(dout1_29) AT=800.025n

* CHECK dout1_30 Vdout1_30ck159 = 0.9 time = 800
.meas tran vdout1_30ck159 FIND v(dout1_30) AT=800.025n

* CHECK dout1_31 Vdout1_31ck159 = 0.9 time = 800
.meas tran vdout1_31ck159 FIND v(dout1_31) AT=800.025n

* CHECK dout1_32 Vdout1_32ck159 = 0.9 time = 800
.meas tran vdout1_32ck159 FIND v(dout1_32) AT=800.025n

* CHECK dout1_33 Vdout1_33ck159 = 0.9 time = 800
.meas tran vdout1_33ck159 FIND v(dout1_33) AT=800.025n

* CHECK dout1_34 Vdout1_34ck159 = 0 time = 800
.meas tran vdout1_34ck159 FIND v(dout1_34) AT=800.025n

* CHECK dout1_35 Vdout1_35ck159 = 0.9 time = 800
.meas tran vdout1_35ck159 FIND v(dout1_35) AT=800.025n

* CHECK dout1_36 Vdout1_36ck159 = 0 time = 800
.meas tran vdout1_36ck159 FIND v(dout1_36) AT=800.025n

* CHECK dout1_37 Vdout1_37ck159 = 0 time = 800
.meas tran vdout1_37ck159 FIND v(dout1_37) AT=800.025n

* CHECK dout1_38 Vdout1_38ck159 = 0 time = 800
.meas tran vdout1_38ck159 FIND v(dout1_38) AT=800.025n

* CHECK dout1_39 Vdout1_39ck159 = 0.9 time = 800
.meas tran vdout1_39ck159 FIND v(dout1_39) AT=800.025n

* CHECK dout1_40 Vdout1_40ck159 = 0 time = 800
.meas tran vdout1_40ck159 FIND v(dout1_40) AT=800.025n

* CHECK dout1_41 Vdout1_41ck159 = 0.9 time = 800
.meas tran vdout1_41ck159 FIND v(dout1_41) AT=800.025n

* CHECK dout1_42 Vdout1_42ck159 = 0 time = 800
.meas tran vdout1_42ck159 FIND v(dout1_42) AT=800.025n

* CHECK dout1_43 Vdout1_43ck159 = 0 time = 800
.meas tran vdout1_43ck159 FIND v(dout1_43) AT=800.025n

* CHECK dout1_44 Vdout1_44ck159 = 0 time = 800
.meas tran vdout1_44ck159 FIND v(dout1_44) AT=800.025n

* CHECK dout1_45 Vdout1_45ck159 = 0.9 time = 800
.meas tran vdout1_45ck159 FIND v(dout1_45) AT=800.025n

* CHECK dout1_46 Vdout1_46ck159 = 0 time = 800
.meas tran vdout1_46ck159 FIND v(dout1_46) AT=800.025n

* CHECK dout1_47 Vdout1_47ck159 = 0 time = 800
.meas tran vdout1_47ck159 FIND v(dout1_47) AT=800.025n

* CHECK dout1_48 Vdout1_48ck159 = 0 time = 800
.meas tran vdout1_48ck159 FIND v(dout1_48) AT=800.025n

* CHECK dout1_49 Vdout1_49ck159 = 0 time = 800
.meas tran vdout1_49ck159 FIND v(dout1_49) AT=800.025n

* CHECK dout1_50 Vdout1_50ck159 = 0 time = 800
.meas tran vdout1_50ck159 FIND v(dout1_50) AT=800.025n

* CHECK dout1_51 Vdout1_51ck159 = 0 time = 800
.meas tran vdout1_51ck159 FIND v(dout1_51) AT=800.025n

* CHECK dout1_52 Vdout1_52ck159 = 0 time = 800
.meas tran vdout1_52ck159 FIND v(dout1_52) AT=800.025n

* CHECK dout1_53 Vdout1_53ck159 = 0 time = 800
.meas tran vdout1_53ck159 FIND v(dout1_53) AT=800.025n

* CHECK dout1_54 Vdout1_54ck159 = 0 time = 800
.meas tran vdout1_54ck159 FIND v(dout1_54) AT=800.025n

* CHECK dout1_55 Vdout1_55ck159 = 0.9 time = 800
.meas tran vdout1_55ck159 FIND v(dout1_55) AT=800.025n

* CHECK dout1_56 Vdout1_56ck159 = 0 time = 800
.meas tran vdout1_56ck159 FIND v(dout1_56) AT=800.025n

* CHECK dout1_57 Vdout1_57ck159 = 0 time = 800
.meas tran vdout1_57ck159 FIND v(dout1_57) AT=800.025n

* CHECK dout1_58 Vdout1_58ck159 = 0 time = 800
.meas tran vdout1_58ck159 FIND v(dout1_58) AT=800.025n

* CHECK dout1_59 Vdout1_59ck159 = 0 time = 800
.meas tran vdout1_59ck159 FIND v(dout1_59) AT=800.025n

* CHECK dout1_60 Vdout1_60ck159 = 0 time = 800
.meas tran vdout1_60ck159 FIND v(dout1_60) AT=800.025n

* CHECK dout1_61 Vdout1_61ck159 = 0.9 time = 800
.meas tran vdout1_61ck159 FIND v(dout1_61) AT=800.025n

* CHECK dout1_62 Vdout1_62ck159 = 0.9 time = 800
.meas tran vdout1_62ck159 FIND v(dout1_62) AT=800.025n

* CHECK dout1_63 Vdout1_63ck159 = 0 time = 800
.meas tran vdout1_63ck159 FIND v(dout1_63) AT=800.025n

* CHECK dout1_64 Vdout1_64ck159 = 0 time = 800
.meas tran vdout1_64ck159 FIND v(dout1_64) AT=800.025n

* CHECK dout1_65 Vdout1_65ck159 = 0 time = 800
.meas tran vdout1_65ck159 FIND v(dout1_65) AT=800.025n

* CHECK dout1_66 Vdout1_66ck159 = 0 time = 800
.meas tran vdout1_66ck159 FIND v(dout1_66) AT=800.025n

* CHECK dout1_67 Vdout1_67ck159 = 0 time = 800
.meas tran vdout1_67ck159 FIND v(dout1_67) AT=800.025n

* CHECK dout1_68 Vdout1_68ck159 = 0 time = 800
.meas tran vdout1_68ck159 FIND v(dout1_68) AT=800.025n

* CHECK dout1_69 Vdout1_69ck159 = 0.9 time = 800
.meas tran vdout1_69ck159 FIND v(dout1_69) AT=800.025n

* CHECK dout1_70 Vdout1_70ck159 = 0 time = 800
.meas tran vdout1_70ck159 FIND v(dout1_70) AT=800.025n

* CHECK dout1_71 Vdout1_71ck159 = 0 time = 800
.meas tran vdout1_71ck159 FIND v(dout1_71) AT=800.025n

* CHECK dout1_72 Vdout1_72ck159 = 0 time = 800
.meas tran vdout1_72ck159 FIND v(dout1_72) AT=800.025n

* CHECK dout1_73 Vdout1_73ck159 = 0.9 time = 800
.meas tran vdout1_73ck159 FIND v(dout1_73) AT=800.025n

* CHECK dout1_74 Vdout1_74ck159 = 0.9 time = 800
.meas tran vdout1_74ck159 FIND v(dout1_74) AT=800.025n

* CHECK dout1_75 Vdout1_75ck159 = 0.9 time = 800
.meas tran vdout1_75ck159 FIND v(dout1_75) AT=800.025n

* CHECK dout1_76 Vdout1_76ck159 = 0 time = 800
.meas tran vdout1_76ck159 FIND v(dout1_76) AT=800.025n

* CHECK dout1_77 Vdout1_77ck159 = 0.9 time = 800
.meas tran vdout1_77ck159 FIND v(dout1_77) AT=800.025n

* CHECK dout1_78 Vdout1_78ck159 = 0.9 time = 800
.meas tran vdout1_78ck159 FIND v(dout1_78) AT=800.025n

* CHECK dout1_79 Vdout1_79ck159 = 0.9 time = 800
.meas tran vdout1_79ck159 FIND v(dout1_79) AT=800.025n

* CHECK dout1_80 Vdout1_80ck159 = 0.9 time = 800
.meas tran vdout1_80ck159 FIND v(dout1_80) AT=800.025n

* CHECK dout1_81 Vdout1_81ck159 = 0.9 time = 800
.meas tran vdout1_81ck159 FIND v(dout1_81) AT=800.025n

* CHECK dout1_82 Vdout1_82ck159 = 0 time = 800
.meas tran vdout1_82ck159 FIND v(dout1_82) AT=800.025n

* CHECK dout1_83 Vdout1_83ck159 = 0 time = 800
.meas tran vdout1_83ck159 FIND v(dout1_83) AT=800.025n

* CHECK dout1_84 Vdout1_84ck159 = 0.9 time = 800
.meas tran vdout1_84ck159 FIND v(dout1_84) AT=800.025n

* CHECK dout1_85 Vdout1_85ck159 = 0 time = 800
.meas tran vdout1_85ck159 FIND v(dout1_85) AT=800.025n

* CHECK dout1_86 Vdout1_86ck159 = 0 time = 800
.meas tran vdout1_86ck159 FIND v(dout1_86) AT=800.025n

* CHECK dout1_87 Vdout1_87ck159 = 0.9 time = 800
.meas tran vdout1_87ck159 FIND v(dout1_87) AT=800.025n

* CHECK dout1_88 Vdout1_88ck159 = 0.9 time = 800
.meas tran vdout1_88ck159 FIND v(dout1_88) AT=800.025n

* CHECK dout1_89 Vdout1_89ck159 = 0.9 time = 800
.meas tran vdout1_89ck159 FIND v(dout1_89) AT=800.025n

* CHECK dout1_90 Vdout1_90ck159 = 0.9 time = 800
.meas tran vdout1_90ck159 FIND v(dout1_90) AT=800.025n

* CHECK dout1_91 Vdout1_91ck159 = 0.9 time = 800
.meas tran vdout1_91ck159 FIND v(dout1_91) AT=800.025n

* CHECK dout1_92 Vdout1_92ck159 = 0.9 time = 800
.meas tran vdout1_92ck159 FIND v(dout1_92) AT=800.025n

* CHECK dout1_93 Vdout1_93ck159 = 0 time = 800
.meas tran vdout1_93ck159 FIND v(dout1_93) AT=800.025n

* CHECK dout1_94 Vdout1_94ck159 = 0 time = 800
.meas tran vdout1_94ck159 FIND v(dout1_94) AT=800.025n

* CHECK dout1_95 Vdout1_95ck159 = 0 time = 800
.meas tran vdout1_95ck159 FIND v(dout1_95) AT=800.025n

* CHECK dout1_96 Vdout1_96ck159 = 0.9 time = 800
.meas tran vdout1_96ck159 FIND v(dout1_96) AT=800.025n

* CHECK dout1_97 Vdout1_97ck159 = 0 time = 800
.meas tran vdout1_97ck159 FIND v(dout1_97) AT=800.025n

* CHECK dout1_98 Vdout1_98ck159 = 0 time = 800
.meas tran vdout1_98ck159 FIND v(dout1_98) AT=800.025n

* CHECK dout1_99 Vdout1_99ck159 = 0 time = 800
.meas tran vdout1_99ck159 FIND v(dout1_99) AT=800.025n

* CHECK dout1_100 Vdout1_100ck159 = 0 time = 800
.meas tran vdout1_100ck159 FIND v(dout1_100) AT=800.025n

* CHECK dout1_101 Vdout1_101ck159 = 0.9 time = 800
.meas tran vdout1_101ck159 FIND v(dout1_101) AT=800.025n

* CHECK dout1_102 Vdout1_102ck159 = 0.9 time = 800
.meas tran vdout1_102ck159 FIND v(dout1_102) AT=800.025n

* CHECK dout1_103 Vdout1_103ck159 = 0.9 time = 800
.meas tran vdout1_103ck159 FIND v(dout1_103) AT=800.025n

* CHECK dout1_104 Vdout1_104ck159 = 0 time = 800
.meas tran vdout1_104ck159 FIND v(dout1_104) AT=800.025n

* CHECK dout1_105 Vdout1_105ck159 = 0.9 time = 800
.meas tran vdout1_105ck159 FIND v(dout1_105) AT=800.025n

* CHECK dout1_106 Vdout1_106ck159 = 0.9 time = 800
.meas tran vdout1_106ck159 FIND v(dout1_106) AT=800.025n

* CHECK dout1_107 Vdout1_107ck159 = 0 time = 800
.meas tran vdout1_107ck159 FIND v(dout1_107) AT=800.025n

* CHECK dout1_108 Vdout1_108ck159 = 0 time = 800
.meas tran vdout1_108ck159 FIND v(dout1_108) AT=800.025n

* CHECK dout1_109 Vdout1_109ck159 = 0 time = 800
.meas tran vdout1_109ck159 FIND v(dout1_109) AT=800.025n

* CHECK dout1_110 Vdout1_110ck159 = 0 time = 800
.meas tran vdout1_110ck159 FIND v(dout1_110) AT=800.025n

* CHECK dout1_111 Vdout1_111ck159 = 0.9 time = 800
.meas tran vdout1_111ck159 FIND v(dout1_111) AT=800.025n

* CHECK dout1_112 Vdout1_112ck159 = 0 time = 800
.meas tran vdout1_112ck159 FIND v(dout1_112) AT=800.025n

* CHECK dout1_113 Vdout1_113ck159 = 0.9 time = 800
.meas tran vdout1_113ck159 FIND v(dout1_113) AT=800.025n

* CHECK dout1_114 Vdout1_114ck159 = 0 time = 800
.meas tran vdout1_114ck159 FIND v(dout1_114) AT=800.025n

* CHECK dout1_115 Vdout1_115ck159 = 0 time = 800
.meas tran vdout1_115ck159 FIND v(dout1_115) AT=800.025n

* CHECK dout1_116 Vdout1_116ck159 = 0 time = 800
.meas tran vdout1_116ck159 FIND v(dout1_116) AT=800.025n

* CHECK dout1_117 Vdout1_117ck159 = 0 time = 800
.meas tran vdout1_117ck159 FIND v(dout1_117) AT=800.025n

* CHECK dout1_118 Vdout1_118ck159 = 0 time = 800
.meas tran vdout1_118ck159 FIND v(dout1_118) AT=800.025n

* CHECK dout1_119 Vdout1_119ck159 = 0.9 time = 800
.meas tran vdout1_119ck159 FIND v(dout1_119) AT=800.025n

* CHECK dout1_0 Vdout1_0ck163 = 0 time = 820
.meas tran vdout1_0ck163 FIND v(dout1_0) AT=820.025n

* CHECK dout1_1 Vdout1_1ck163 = 0 time = 820
.meas tran vdout1_1ck163 FIND v(dout1_1) AT=820.025n

* CHECK dout1_2 Vdout1_2ck163 = 0.9 time = 820
.meas tran vdout1_2ck163 FIND v(dout1_2) AT=820.025n

* CHECK dout1_3 Vdout1_3ck163 = 0.9 time = 820
.meas tran vdout1_3ck163 FIND v(dout1_3) AT=820.025n

* CHECK dout1_4 Vdout1_4ck163 = 0 time = 820
.meas tran vdout1_4ck163 FIND v(dout1_4) AT=820.025n

* CHECK dout1_5 Vdout1_5ck163 = 0 time = 820
.meas tran vdout1_5ck163 FIND v(dout1_5) AT=820.025n

* CHECK dout1_6 Vdout1_6ck163 = 0 time = 820
.meas tran vdout1_6ck163 FIND v(dout1_6) AT=820.025n

* CHECK dout1_7 Vdout1_7ck163 = 0 time = 820
.meas tran vdout1_7ck163 FIND v(dout1_7) AT=820.025n

* CHECK dout1_8 Vdout1_8ck163 = 0.9 time = 820
.meas tran vdout1_8ck163 FIND v(dout1_8) AT=820.025n

* CHECK dout1_9 Vdout1_9ck163 = 0 time = 820
.meas tran vdout1_9ck163 FIND v(dout1_9) AT=820.025n

* CHECK dout1_10 Vdout1_10ck163 = 0 time = 820
.meas tran vdout1_10ck163 FIND v(dout1_10) AT=820.025n

* CHECK dout1_11 Vdout1_11ck163 = 0 time = 820
.meas tran vdout1_11ck163 FIND v(dout1_11) AT=820.025n

* CHECK dout1_12 Vdout1_12ck163 = 0 time = 820
.meas tran vdout1_12ck163 FIND v(dout1_12) AT=820.025n

* CHECK dout1_13 Vdout1_13ck163 = 0 time = 820
.meas tran vdout1_13ck163 FIND v(dout1_13) AT=820.025n

* CHECK dout1_14 Vdout1_14ck163 = 0 time = 820
.meas tran vdout1_14ck163 FIND v(dout1_14) AT=820.025n

* CHECK dout1_15 Vdout1_15ck163 = 0 time = 820
.meas tran vdout1_15ck163 FIND v(dout1_15) AT=820.025n

* CHECK dout1_16 Vdout1_16ck163 = 0.9 time = 820
.meas tran vdout1_16ck163 FIND v(dout1_16) AT=820.025n

* CHECK dout1_17 Vdout1_17ck163 = 0 time = 820
.meas tran vdout1_17ck163 FIND v(dout1_17) AT=820.025n

* CHECK dout1_18 Vdout1_18ck163 = 0 time = 820
.meas tran vdout1_18ck163 FIND v(dout1_18) AT=820.025n

* CHECK dout1_19 Vdout1_19ck163 = 0 time = 820
.meas tran vdout1_19ck163 FIND v(dout1_19) AT=820.025n

* CHECK dout1_20 Vdout1_20ck163 = 0 time = 820
.meas tran vdout1_20ck163 FIND v(dout1_20) AT=820.025n

* CHECK dout1_21 Vdout1_21ck163 = 0.9 time = 820
.meas tran vdout1_21ck163 FIND v(dout1_21) AT=820.025n

* CHECK dout1_22 Vdout1_22ck163 = 0 time = 820
.meas tran vdout1_22ck163 FIND v(dout1_22) AT=820.025n

* CHECK dout1_23 Vdout1_23ck163 = 0.9 time = 820
.meas tran vdout1_23ck163 FIND v(dout1_23) AT=820.025n

* CHECK dout1_24 Vdout1_24ck163 = 0 time = 820
.meas tran vdout1_24ck163 FIND v(dout1_24) AT=820.025n

* CHECK dout1_25 Vdout1_25ck163 = 0.9 time = 820
.meas tran vdout1_25ck163 FIND v(dout1_25) AT=820.025n

* CHECK dout1_26 Vdout1_26ck163 = 0.9 time = 820
.meas tran vdout1_26ck163 FIND v(dout1_26) AT=820.025n

* CHECK dout1_27 Vdout1_27ck163 = 0 time = 820
.meas tran vdout1_27ck163 FIND v(dout1_27) AT=820.025n

* CHECK dout1_28 Vdout1_28ck163 = 0.9 time = 820
.meas tran vdout1_28ck163 FIND v(dout1_28) AT=820.025n

* CHECK dout1_29 Vdout1_29ck163 = 0.9 time = 820
.meas tran vdout1_29ck163 FIND v(dout1_29) AT=820.025n

* CHECK dout1_30 Vdout1_30ck163 = 0 time = 820
.meas tran vdout1_30ck163 FIND v(dout1_30) AT=820.025n

* CHECK dout1_31 Vdout1_31ck163 = 0.9 time = 820
.meas tran vdout1_31ck163 FIND v(dout1_31) AT=820.025n

* CHECK dout1_32 Vdout1_32ck163 = 0 time = 820
.meas tran vdout1_32ck163 FIND v(dout1_32) AT=820.025n

* CHECK dout1_33 Vdout1_33ck163 = 0 time = 820
.meas tran vdout1_33ck163 FIND v(dout1_33) AT=820.025n

* CHECK dout1_34 Vdout1_34ck163 = 0 time = 820
.meas tran vdout1_34ck163 FIND v(dout1_34) AT=820.025n

* CHECK dout1_35 Vdout1_35ck163 = 0.9 time = 820
.meas tran vdout1_35ck163 FIND v(dout1_35) AT=820.025n

* CHECK dout1_36 Vdout1_36ck163 = 0.9 time = 820
.meas tran vdout1_36ck163 FIND v(dout1_36) AT=820.025n

* CHECK dout1_37 Vdout1_37ck163 = 0.9 time = 820
.meas tran vdout1_37ck163 FIND v(dout1_37) AT=820.025n

* CHECK dout1_38 Vdout1_38ck163 = 0.9 time = 820
.meas tran vdout1_38ck163 FIND v(dout1_38) AT=820.025n

* CHECK dout1_39 Vdout1_39ck163 = 0 time = 820
.meas tran vdout1_39ck163 FIND v(dout1_39) AT=820.025n

* CHECK dout1_40 Vdout1_40ck163 = 0 time = 820
.meas tran vdout1_40ck163 FIND v(dout1_40) AT=820.025n

* CHECK dout1_41 Vdout1_41ck163 = 0.9 time = 820
.meas tran vdout1_41ck163 FIND v(dout1_41) AT=820.025n

* CHECK dout1_42 Vdout1_42ck163 = 0 time = 820
.meas tran vdout1_42ck163 FIND v(dout1_42) AT=820.025n

* CHECK dout1_43 Vdout1_43ck163 = 0 time = 820
.meas tran vdout1_43ck163 FIND v(dout1_43) AT=820.025n

* CHECK dout1_44 Vdout1_44ck163 = 0 time = 820
.meas tran vdout1_44ck163 FIND v(dout1_44) AT=820.025n

* CHECK dout1_45 Vdout1_45ck163 = 0 time = 820
.meas tran vdout1_45ck163 FIND v(dout1_45) AT=820.025n

* CHECK dout1_46 Vdout1_46ck163 = 0.9 time = 820
.meas tran vdout1_46ck163 FIND v(dout1_46) AT=820.025n

* CHECK dout1_47 Vdout1_47ck163 = 0.9 time = 820
.meas tran vdout1_47ck163 FIND v(dout1_47) AT=820.025n

* CHECK dout1_48 Vdout1_48ck163 = 0 time = 820
.meas tran vdout1_48ck163 FIND v(dout1_48) AT=820.025n

* CHECK dout1_49 Vdout1_49ck163 = 0.9 time = 820
.meas tran vdout1_49ck163 FIND v(dout1_49) AT=820.025n

* CHECK dout1_50 Vdout1_50ck163 = 0.9 time = 820
.meas tran vdout1_50ck163 FIND v(dout1_50) AT=820.025n

* CHECK dout1_51 Vdout1_51ck163 = 0 time = 820
.meas tran vdout1_51ck163 FIND v(dout1_51) AT=820.025n

* CHECK dout1_52 Vdout1_52ck163 = 0.9 time = 820
.meas tran vdout1_52ck163 FIND v(dout1_52) AT=820.025n

* CHECK dout1_53 Vdout1_53ck163 = 0 time = 820
.meas tran vdout1_53ck163 FIND v(dout1_53) AT=820.025n

* CHECK dout1_54 Vdout1_54ck163 = 0 time = 820
.meas tran vdout1_54ck163 FIND v(dout1_54) AT=820.025n

* CHECK dout1_55 Vdout1_55ck163 = 0.9 time = 820
.meas tran vdout1_55ck163 FIND v(dout1_55) AT=820.025n

* CHECK dout1_56 Vdout1_56ck163 = 0 time = 820
.meas tran vdout1_56ck163 FIND v(dout1_56) AT=820.025n

* CHECK dout1_57 Vdout1_57ck163 = 0 time = 820
.meas tran vdout1_57ck163 FIND v(dout1_57) AT=820.025n

* CHECK dout1_58 Vdout1_58ck163 = 0.9 time = 820
.meas tran vdout1_58ck163 FIND v(dout1_58) AT=820.025n

* CHECK dout1_59 Vdout1_59ck163 = 0.9 time = 820
.meas tran vdout1_59ck163 FIND v(dout1_59) AT=820.025n

* CHECK dout1_60 Vdout1_60ck163 = 0 time = 820
.meas tran vdout1_60ck163 FIND v(dout1_60) AT=820.025n

* CHECK dout1_61 Vdout1_61ck163 = 0.9 time = 820
.meas tran vdout1_61ck163 FIND v(dout1_61) AT=820.025n

* CHECK dout1_62 Vdout1_62ck163 = 0.9 time = 820
.meas tran vdout1_62ck163 FIND v(dout1_62) AT=820.025n

* CHECK dout1_63 Vdout1_63ck163 = 0 time = 820
.meas tran vdout1_63ck163 FIND v(dout1_63) AT=820.025n

* CHECK dout1_64 Vdout1_64ck163 = 0.9 time = 820
.meas tran vdout1_64ck163 FIND v(dout1_64) AT=820.025n

* CHECK dout1_65 Vdout1_65ck163 = 0.9 time = 820
.meas tran vdout1_65ck163 FIND v(dout1_65) AT=820.025n

* CHECK dout1_66 Vdout1_66ck163 = 0.9 time = 820
.meas tran vdout1_66ck163 FIND v(dout1_66) AT=820.025n

* CHECK dout1_67 Vdout1_67ck163 = 0.9 time = 820
.meas tran vdout1_67ck163 FIND v(dout1_67) AT=820.025n

* CHECK dout1_68 Vdout1_68ck163 = 0 time = 820
.meas tran vdout1_68ck163 FIND v(dout1_68) AT=820.025n

* CHECK dout1_69 Vdout1_69ck163 = 0 time = 820
.meas tran vdout1_69ck163 FIND v(dout1_69) AT=820.025n

* CHECK dout1_70 Vdout1_70ck163 = 0 time = 820
.meas tran vdout1_70ck163 FIND v(dout1_70) AT=820.025n

* CHECK dout1_71 Vdout1_71ck163 = 0 time = 820
.meas tran vdout1_71ck163 FIND v(dout1_71) AT=820.025n

* CHECK dout1_72 Vdout1_72ck163 = 0 time = 820
.meas tran vdout1_72ck163 FIND v(dout1_72) AT=820.025n

* CHECK dout1_73 Vdout1_73ck163 = 0.9 time = 820
.meas tran vdout1_73ck163 FIND v(dout1_73) AT=820.025n

* CHECK dout1_74 Vdout1_74ck163 = 0.9 time = 820
.meas tran vdout1_74ck163 FIND v(dout1_74) AT=820.025n

* CHECK dout1_75 Vdout1_75ck163 = 0 time = 820
.meas tran vdout1_75ck163 FIND v(dout1_75) AT=820.025n

* CHECK dout1_76 Vdout1_76ck163 = 0 time = 820
.meas tran vdout1_76ck163 FIND v(dout1_76) AT=820.025n

* CHECK dout1_77 Vdout1_77ck163 = 0.9 time = 820
.meas tran vdout1_77ck163 FIND v(dout1_77) AT=820.025n

* CHECK dout1_78 Vdout1_78ck163 = 0 time = 820
.meas tran vdout1_78ck163 FIND v(dout1_78) AT=820.025n

* CHECK dout1_79 Vdout1_79ck163 = 0 time = 820
.meas tran vdout1_79ck163 FIND v(dout1_79) AT=820.025n

* CHECK dout1_80 Vdout1_80ck163 = 0 time = 820
.meas tran vdout1_80ck163 FIND v(dout1_80) AT=820.025n

* CHECK dout1_81 Vdout1_81ck163 = 0 time = 820
.meas tran vdout1_81ck163 FIND v(dout1_81) AT=820.025n

* CHECK dout1_82 Vdout1_82ck163 = 0 time = 820
.meas tran vdout1_82ck163 FIND v(dout1_82) AT=820.025n

* CHECK dout1_83 Vdout1_83ck163 = 0.9 time = 820
.meas tran vdout1_83ck163 FIND v(dout1_83) AT=820.025n

* CHECK dout1_84 Vdout1_84ck163 = 0 time = 820
.meas tran vdout1_84ck163 FIND v(dout1_84) AT=820.025n

* CHECK dout1_85 Vdout1_85ck163 = 0.9 time = 820
.meas tran vdout1_85ck163 FIND v(dout1_85) AT=820.025n

* CHECK dout1_86 Vdout1_86ck163 = 0.9 time = 820
.meas tran vdout1_86ck163 FIND v(dout1_86) AT=820.025n

* CHECK dout1_87 Vdout1_87ck163 = 0.9 time = 820
.meas tran vdout1_87ck163 FIND v(dout1_87) AT=820.025n

* CHECK dout1_88 Vdout1_88ck163 = 0 time = 820
.meas tran vdout1_88ck163 FIND v(dout1_88) AT=820.025n

* CHECK dout1_89 Vdout1_89ck163 = 0.9 time = 820
.meas tran vdout1_89ck163 FIND v(dout1_89) AT=820.025n

* CHECK dout1_90 Vdout1_90ck163 = 0.9 time = 820
.meas tran vdout1_90ck163 FIND v(dout1_90) AT=820.025n

* CHECK dout1_91 Vdout1_91ck163 = 0 time = 820
.meas tran vdout1_91ck163 FIND v(dout1_91) AT=820.025n

* CHECK dout1_92 Vdout1_92ck163 = 0.9 time = 820
.meas tran vdout1_92ck163 FIND v(dout1_92) AT=820.025n

* CHECK dout1_93 Vdout1_93ck163 = 0.9 time = 820
.meas tran vdout1_93ck163 FIND v(dout1_93) AT=820.025n

* CHECK dout1_94 Vdout1_94ck163 = 0.9 time = 820
.meas tran vdout1_94ck163 FIND v(dout1_94) AT=820.025n

* CHECK dout1_95 Vdout1_95ck163 = 0.9 time = 820
.meas tran vdout1_95ck163 FIND v(dout1_95) AT=820.025n

* CHECK dout1_96 Vdout1_96ck163 = 0 time = 820
.meas tran vdout1_96ck163 FIND v(dout1_96) AT=820.025n

* CHECK dout1_97 Vdout1_97ck163 = 0.9 time = 820
.meas tran vdout1_97ck163 FIND v(dout1_97) AT=820.025n

* CHECK dout1_98 Vdout1_98ck163 = 0.9 time = 820
.meas tran vdout1_98ck163 FIND v(dout1_98) AT=820.025n

* CHECK dout1_99 Vdout1_99ck163 = 0 time = 820
.meas tran vdout1_99ck163 FIND v(dout1_99) AT=820.025n

* CHECK dout1_100 Vdout1_100ck163 = 0 time = 820
.meas tran vdout1_100ck163 FIND v(dout1_100) AT=820.025n

* CHECK dout1_101 Vdout1_101ck163 = 0.9 time = 820
.meas tran vdout1_101ck163 FIND v(dout1_101) AT=820.025n

* CHECK dout1_102 Vdout1_102ck163 = 0 time = 820
.meas tran vdout1_102ck163 FIND v(dout1_102) AT=820.025n

* CHECK dout1_103 Vdout1_103ck163 = 0 time = 820
.meas tran vdout1_103ck163 FIND v(dout1_103) AT=820.025n

* CHECK dout1_104 Vdout1_104ck163 = 0 time = 820
.meas tran vdout1_104ck163 FIND v(dout1_104) AT=820.025n

* CHECK dout1_105 Vdout1_105ck163 = 0 time = 820
.meas tran vdout1_105ck163 FIND v(dout1_105) AT=820.025n

* CHECK dout1_106 Vdout1_106ck163 = 0.9 time = 820
.meas tran vdout1_106ck163 FIND v(dout1_106) AT=820.025n

* CHECK dout1_107 Vdout1_107ck163 = 0 time = 820
.meas tran vdout1_107ck163 FIND v(dout1_107) AT=820.025n

* CHECK dout1_108 Vdout1_108ck163 = 0 time = 820
.meas tran vdout1_108ck163 FIND v(dout1_108) AT=820.025n

* CHECK dout1_109 Vdout1_109ck163 = 0.9 time = 820
.meas tran vdout1_109ck163 FIND v(dout1_109) AT=820.025n

* CHECK dout1_110 Vdout1_110ck163 = 0.9 time = 820
.meas tran vdout1_110ck163 FIND v(dout1_110) AT=820.025n

* CHECK dout1_111 Vdout1_111ck163 = 0.9 time = 820
.meas tran vdout1_111ck163 FIND v(dout1_111) AT=820.025n

* CHECK dout1_112 Vdout1_112ck163 = 0.9 time = 820
.meas tran vdout1_112ck163 FIND v(dout1_112) AT=820.025n

* CHECK dout1_113 Vdout1_113ck163 = 0.9 time = 820
.meas tran vdout1_113ck163 FIND v(dout1_113) AT=820.025n

* CHECK dout1_114 Vdout1_114ck163 = 0 time = 820
.meas tran vdout1_114ck163 FIND v(dout1_114) AT=820.025n

* CHECK dout1_115 Vdout1_115ck163 = 0 time = 820
.meas tran vdout1_115ck163 FIND v(dout1_115) AT=820.025n

* CHECK dout1_116 Vdout1_116ck163 = 0 time = 820
.meas tran vdout1_116ck163 FIND v(dout1_116) AT=820.025n

* CHECK dout1_117 Vdout1_117ck163 = 0.9 time = 820
.meas tran vdout1_117ck163 FIND v(dout1_117) AT=820.025n

* CHECK dout1_118 Vdout1_118ck163 = 0.9 time = 820
.meas tran vdout1_118ck163 FIND v(dout1_118) AT=820.025n

* CHECK dout1_119 Vdout1_119ck163 = 0 time = 820
.meas tran vdout1_119ck163 FIND v(dout1_119) AT=820.025n

* CHECK dout1_0 Vdout1_0ck173 = 0.9 time = 870
.meas tran vdout1_0ck173 FIND v(dout1_0) AT=870.025n

* CHECK dout1_1 Vdout1_1ck173 = 0.9 time = 870
.meas tran vdout1_1ck173 FIND v(dout1_1) AT=870.025n

* CHECK dout1_2 Vdout1_2ck173 = 0 time = 870
.meas tran vdout1_2ck173 FIND v(dout1_2) AT=870.025n

* CHECK dout1_3 Vdout1_3ck173 = 0 time = 870
.meas tran vdout1_3ck173 FIND v(dout1_3) AT=870.025n

* CHECK dout1_4 Vdout1_4ck173 = 0.9 time = 870
.meas tran vdout1_4ck173 FIND v(dout1_4) AT=870.025n

* CHECK dout1_5 Vdout1_5ck173 = 0 time = 870
.meas tran vdout1_5ck173 FIND v(dout1_5) AT=870.025n

* CHECK dout1_6 Vdout1_6ck173 = 0 time = 870
.meas tran vdout1_6ck173 FIND v(dout1_6) AT=870.025n

* CHECK dout1_7 Vdout1_7ck173 = 0.9 time = 870
.meas tran vdout1_7ck173 FIND v(dout1_7) AT=870.025n

* CHECK dout1_8 Vdout1_8ck173 = 0.9 time = 870
.meas tran vdout1_8ck173 FIND v(dout1_8) AT=870.025n

* CHECK dout1_9 Vdout1_9ck173 = 0 time = 870
.meas tran vdout1_9ck173 FIND v(dout1_9) AT=870.025n

* CHECK dout1_10 Vdout1_10ck173 = 0.9 time = 870
.meas tran vdout1_10ck173 FIND v(dout1_10) AT=870.025n

* CHECK dout1_11 Vdout1_11ck173 = 0 time = 870
.meas tran vdout1_11ck173 FIND v(dout1_11) AT=870.025n

* CHECK dout1_12 Vdout1_12ck173 = 0 time = 870
.meas tran vdout1_12ck173 FIND v(dout1_12) AT=870.025n

* CHECK dout1_13 Vdout1_13ck173 = 0 time = 870
.meas tran vdout1_13ck173 FIND v(dout1_13) AT=870.025n

* CHECK dout1_14 Vdout1_14ck173 = 0.9 time = 870
.meas tran vdout1_14ck173 FIND v(dout1_14) AT=870.025n

* CHECK dout1_15 Vdout1_15ck173 = 0.9 time = 870
.meas tran vdout1_15ck173 FIND v(dout1_15) AT=870.025n

* CHECK dout1_16 Vdout1_16ck173 = 0 time = 870
.meas tran vdout1_16ck173 FIND v(dout1_16) AT=870.025n

* CHECK dout1_17 Vdout1_17ck173 = 0.9 time = 870
.meas tran vdout1_17ck173 FIND v(dout1_17) AT=870.025n

* CHECK dout1_18 Vdout1_18ck173 = 0 time = 870
.meas tran vdout1_18ck173 FIND v(dout1_18) AT=870.025n

* CHECK dout1_19 Vdout1_19ck173 = 0 time = 870
.meas tran vdout1_19ck173 FIND v(dout1_19) AT=870.025n

* CHECK dout1_20 Vdout1_20ck173 = 0 time = 870
.meas tran vdout1_20ck173 FIND v(dout1_20) AT=870.025n

* CHECK dout1_21 Vdout1_21ck173 = 0 time = 870
.meas tran vdout1_21ck173 FIND v(dout1_21) AT=870.025n

* CHECK dout1_22 Vdout1_22ck173 = 0 time = 870
.meas tran vdout1_22ck173 FIND v(dout1_22) AT=870.025n

* CHECK dout1_23 Vdout1_23ck173 = 0 time = 870
.meas tran vdout1_23ck173 FIND v(dout1_23) AT=870.025n

* CHECK dout1_24 Vdout1_24ck173 = 0 time = 870
.meas tran vdout1_24ck173 FIND v(dout1_24) AT=870.025n

* CHECK dout1_25 Vdout1_25ck173 = 0 time = 870
.meas tran vdout1_25ck173 FIND v(dout1_25) AT=870.025n

* CHECK dout1_26 Vdout1_26ck173 = 0 time = 870
.meas tran vdout1_26ck173 FIND v(dout1_26) AT=870.025n

* CHECK dout1_27 Vdout1_27ck173 = 0 time = 870
.meas tran vdout1_27ck173 FIND v(dout1_27) AT=870.025n

* CHECK dout1_28 Vdout1_28ck173 = 0 time = 870
.meas tran vdout1_28ck173 FIND v(dout1_28) AT=870.025n

* CHECK dout1_29 Vdout1_29ck173 = 0 time = 870
.meas tran vdout1_29ck173 FIND v(dout1_29) AT=870.025n

* CHECK dout1_30 Vdout1_30ck173 = 0 time = 870
.meas tran vdout1_30ck173 FIND v(dout1_30) AT=870.025n

* CHECK dout1_31 Vdout1_31ck173 = 0.9 time = 870
.meas tran vdout1_31ck173 FIND v(dout1_31) AT=870.025n

* CHECK dout1_32 Vdout1_32ck173 = 0 time = 870
.meas tran vdout1_32ck173 FIND v(dout1_32) AT=870.025n

* CHECK dout1_33 Vdout1_33ck173 = 0 time = 870
.meas tran vdout1_33ck173 FIND v(dout1_33) AT=870.025n

* CHECK dout1_34 Vdout1_34ck173 = 0 time = 870
.meas tran vdout1_34ck173 FIND v(dout1_34) AT=870.025n

* CHECK dout1_35 Vdout1_35ck173 = 0.9 time = 870
.meas tran vdout1_35ck173 FIND v(dout1_35) AT=870.025n

* CHECK dout1_36 Vdout1_36ck173 = 0.9 time = 870
.meas tran vdout1_36ck173 FIND v(dout1_36) AT=870.025n

* CHECK dout1_37 Vdout1_37ck173 = 0 time = 870
.meas tran vdout1_37ck173 FIND v(dout1_37) AT=870.025n

* CHECK dout1_38 Vdout1_38ck173 = 0 time = 870
.meas tran vdout1_38ck173 FIND v(dout1_38) AT=870.025n

* CHECK dout1_39 Vdout1_39ck173 = 0.9 time = 870
.meas tran vdout1_39ck173 FIND v(dout1_39) AT=870.025n

* CHECK dout1_40 Vdout1_40ck173 = 0 time = 870
.meas tran vdout1_40ck173 FIND v(dout1_40) AT=870.025n

* CHECK dout1_41 Vdout1_41ck173 = 0.9 time = 870
.meas tran vdout1_41ck173 FIND v(dout1_41) AT=870.025n

* CHECK dout1_42 Vdout1_42ck173 = 0 time = 870
.meas tran vdout1_42ck173 FIND v(dout1_42) AT=870.025n

* CHECK dout1_43 Vdout1_43ck173 = 0.9 time = 870
.meas tran vdout1_43ck173 FIND v(dout1_43) AT=870.025n

* CHECK dout1_44 Vdout1_44ck173 = 0.9 time = 870
.meas tran vdout1_44ck173 FIND v(dout1_44) AT=870.025n

* CHECK dout1_45 Vdout1_45ck173 = 0 time = 870
.meas tran vdout1_45ck173 FIND v(dout1_45) AT=870.025n

* CHECK dout1_46 Vdout1_46ck173 = 0 time = 870
.meas tran vdout1_46ck173 FIND v(dout1_46) AT=870.025n

* CHECK dout1_47 Vdout1_47ck173 = 0.9 time = 870
.meas tran vdout1_47ck173 FIND v(dout1_47) AT=870.025n

* CHECK dout1_48 Vdout1_48ck173 = 0.9 time = 870
.meas tran vdout1_48ck173 FIND v(dout1_48) AT=870.025n

* CHECK dout1_49 Vdout1_49ck173 = 0 time = 870
.meas tran vdout1_49ck173 FIND v(dout1_49) AT=870.025n

* CHECK dout1_50 Vdout1_50ck173 = 0 time = 870
.meas tran vdout1_50ck173 FIND v(dout1_50) AT=870.025n

* CHECK dout1_51 Vdout1_51ck173 = 0 time = 870
.meas tran vdout1_51ck173 FIND v(dout1_51) AT=870.025n

* CHECK dout1_52 Vdout1_52ck173 = 0 time = 870
.meas tran vdout1_52ck173 FIND v(dout1_52) AT=870.025n

* CHECK dout1_53 Vdout1_53ck173 = 0.9 time = 870
.meas tran vdout1_53ck173 FIND v(dout1_53) AT=870.025n

* CHECK dout1_54 Vdout1_54ck173 = 0.9 time = 870
.meas tran vdout1_54ck173 FIND v(dout1_54) AT=870.025n

* CHECK dout1_55 Vdout1_55ck173 = 0 time = 870
.meas tran vdout1_55ck173 FIND v(dout1_55) AT=870.025n

* CHECK dout1_56 Vdout1_56ck173 = 0 time = 870
.meas tran vdout1_56ck173 FIND v(dout1_56) AT=870.025n

* CHECK dout1_57 Vdout1_57ck173 = 0 time = 870
.meas tran vdout1_57ck173 FIND v(dout1_57) AT=870.025n

* CHECK dout1_58 Vdout1_58ck173 = 0 time = 870
.meas tran vdout1_58ck173 FIND v(dout1_58) AT=870.025n

* CHECK dout1_59 Vdout1_59ck173 = 0.9 time = 870
.meas tran vdout1_59ck173 FIND v(dout1_59) AT=870.025n

* CHECK dout1_60 Vdout1_60ck173 = 0.9 time = 870
.meas tran vdout1_60ck173 FIND v(dout1_60) AT=870.025n

* CHECK dout1_61 Vdout1_61ck173 = 0.9 time = 870
.meas tran vdout1_61ck173 FIND v(dout1_61) AT=870.025n

* CHECK dout1_62 Vdout1_62ck173 = 0 time = 870
.meas tran vdout1_62ck173 FIND v(dout1_62) AT=870.025n

* CHECK dout1_63 Vdout1_63ck173 = 0.9 time = 870
.meas tran vdout1_63ck173 FIND v(dout1_63) AT=870.025n

* CHECK dout1_64 Vdout1_64ck173 = 0.9 time = 870
.meas tran vdout1_64ck173 FIND v(dout1_64) AT=870.025n

* CHECK dout1_65 Vdout1_65ck173 = 0 time = 870
.meas tran vdout1_65ck173 FIND v(dout1_65) AT=870.025n

* CHECK dout1_66 Vdout1_66ck173 = 0.9 time = 870
.meas tran vdout1_66ck173 FIND v(dout1_66) AT=870.025n

* CHECK dout1_67 Vdout1_67ck173 = 0.9 time = 870
.meas tran vdout1_67ck173 FIND v(dout1_67) AT=870.025n

* CHECK dout1_68 Vdout1_68ck173 = 0.9 time = 870
.meas tran vdout1_68ck173 FIND v(dout1_68) AT=870.025n

* CHECK dout1_69 Vdout1_69ck173 = 0.9 time = 870
.meas tran vdout1_69ck173 FIND v(dout1_69) AT=870.025n

* CHECK dout1_70 Vdout1_70ck173 = 0.9 time = 870
.meas tran vdout1_70ck173 FIND v(dout1_70) AT=870.025n

* CHECK dout1_71 Vdout1_71ck173 = 0.9 time = 870
.meas tran vdout1_71ck173 FIND v(dout1_71) AT=870.025n

* CHECK dout1_72 Vdout1_72ck173 = 0.9 time = 870
.meas tran vdout1_72ck173 FIND v(dout1_72) AT=870.025n

* CHECK dout1_73 Vdout1_73ck173 = 0 time = 870
.meas tran vdout1_73ck173 FIND v(dout1_73) AT=870.025n

* CHECK dout1_74 Vdout1_74ck173 = 0.9 time = 870
.meas tran vdout1_74ck173 FIND v(dout1_74) AT=870.025n

* CHECK dout1_75 Vdout1_75ck173 = 0.9 time = 870
.meas tran vdout1_75ck173 FIND v(dout1_75) AT=870.025n

* CHECK dout1_76 Vdout1_76ck173 = 0 time = 870
.meas tran vdout1_76ck173 FIND v(dout1_76) AT=870.025n

* CHECK dout1_77 Vdout1_77ck173 = 0 time = 870
.meas tran vdout1_77ck173 FIND v(dout1_77) AT=870.025n

* CHECK dout1_78 Vdout1_78ck173 = 0 time = 870
.meas tran vdout1_78ck173 FIND v(dout1_78) AT=870.025n

* CHECK dout1_79 Vdout1_79ck173 = 0.9 time = 870
.meas tran vdout1_79ck173 FIND v(dout1_79) AT=870.025n

* CHECK dout1_80 Vdout1_80ck173 = 0 time = 870
.meas tran vdout1_80ck173 FIND v(dout1_80) AT=870.025n

* CHECK dout1_81 Vdout1_81ck173 = 0.9 time = 870
.meas tran vdout1_81ck173 FIND v(dout1_81) AT=870.025n

* CHECK dout1_82 Vdout1_82ck173 = 0.9 time = 870
.meas tran vdout1_82ck173 FIND v(dout1_82) AT=870.025n

* CHECK dout1_83 Vdout1_83ck173 = 0 time = 870
.meas tran vdout1_83ck173 FIND v(dout1_83) AT=870.025n

* CHECK dout1_84 Vdout1_84ck173 = 0.9 time = 870
.meas tran vdout1_84ck173 FIND v(dout1_84) AT=870.025n

* CHECK dout1_85 Vdout1_85ck173 = 0 time = 870
.meas tran vdout1_85ck173 FIND v(dout1_85) AT=870.025n

* CHECK dout1_86 Vdout1_86ck173 = 0 time = 870
.meas tran vdout1_86ck173 FIND v(dout1_86) AT=870.025n

* CHECK dout1_87 Vdout1_87ck173 = 0.9 time = 870
.meas tran vdout1_87ck173 FIND v(dout1_87) AT=870.025n

* CHECK dout1_88 Vdout1_88ck173 = 0.9 time = 870
.meas tran vdout1_88ck173 FIND v(dout1_88) AT=870.025n

* CHECK dout1_89 Vdout1_89ck173 = 0.9 time = 870
.meas tran vdout1_89ck173 FIND v(dout1_89) AT=870.025n

* CHECK dout1_90 Vdout1_90ck173 = 0.9 time = 870
.meas tran vdout1_90ck173 FIND v(dout1_90) AT=870.025n

* CHECK dout1_91 Vdout1_91ck173 = 0 time = 870
.meas tran vdout1_91ck173 FIND v(dout1_91) AT=870.025n

* CHECK dout1_92 Vdout1_92ck173 = 0 time = 870
.meas tran vdout1_92ck173 FIND v(dout1_92) AT=870.025n

* CHECK dout1_93 Vdout1_93ck173 = 0.9 time = 870
.meas tran vdout1_93ck173 FIND v(dout1_93) AT=870.025n

* CHECK dout1_94 Vdout1_94ck173 = 0.9 time = 870
.meas tran vdout1_94ck173 FIND v(dout1_94) AT=870.025n

* CHECK dout1_95 Vdout1_95ck173 = 0.9 time = 870
.meas tran vdout1_95ck173 FIND v(dout1_95) AT=870.025n

* CHECK dout1_96 Vdout1_96ck173 = 0.9 time = 870
.meas tran vdout1_96ck173 FIND v(dout1_96) AT=870.025n

* CHECK dout1_97 Vdout1_97ck173 = 0.9 time = 870
.meas tran vdout1_97ck173 FIND v(dout1_97) AT=870.025n

* CHECK dout1_98 Vdout1_98ck173 = 0 time = 870
.meas tran vdout1_98ck173 FIND v(dout1_98) AT=870.025n

* CHECK dout1_99 Vdout1_99ck173 = 0 time = 870
.meas tran vdout1_99ck173 FIND v(dout1_99) AT=870.025n

* CHECK dout1_100 Vdout1_100ck173 = 0 time = 870
.meas tran vdout1_100ck173 FIND v(dout1_100) AT=870.025n

* CHECK dout1_101 Vdout1_101ck173 = 0 time = 870
.meas tran vdout1_101ck173 FIND v(dout1_101) AT=870.025n

* CHECK dout1_102 Vdout1_102ck173 = 0 time = 870
.meas tran vdout1_102ck173 FIND v(dout1_102) AT=870.025n

* CHECK dout1_103 Vdout1_103ck173 = 0 time = 870
.meas tran vdout1_103ck173 FIND v(dout1_103) AT=870.025n

* CHECK dout1_104 Vdout1_104ck173 = 0 time = 870
.meas tran vdout1_104ck173 FIND v(dout1_104) AT=870.025n

* CHECK dout1_105 Vdout1_105ck173 = 0.9 time = 870
.meas tran vdout1_105ck173 FIND v(dout1_105) AT=870.025n

* CHECK dout1_106 Vdout1_106ck173 = 0.9 time = 870
.meas tran vdout1_106ck173 FIND v(dout1_106) AT=870.025n

* CHECK dout1_107 Vdout1_107ck173 = 0.9 time = 870
.meas tran vdout1_107ck173 FIND v(dout1_107) AT=870.025n

* CHECK dout1_108 Vdout1_108ck173 = 0.9 time = 870
.meas tran vdout1_108ck173 FIND v(dout1_108) AT=870.025n

* CHECK dout1_109 Vdout1_109ck173 = 0 time = 870
.meas tran vdout1_109ck173 FIND v(dout1_109) AT=870.025n

* CHECK dout1_110 Vdout1_110ck173 = 0 time = 870
.meas tran vdout1_110ck173 FIND v(dout1_110) AT=870.025n

* CHECK dout1_111 Vdout1_111ck173 = 0 time = 870
.meas tran vdout1_111ck173 FIND v(dout1_111) AT=870.025n

* CHECK dout1_112 Vdout1_112ck173 = 0.9 time = 870
.meas tran vdout1_112ck173 FIND v(dout1_112) AT=870.025n

* CHECK dout1_113 Vdout1_113ck173 = 0.9 time = 870
.meas tran vdout1_113ck173 FIND v(dout1_113) AT=870.025n

* CHECK dout1_114 Vdout1_114ck173 = 0.9 time = 870
.meas tran vdout1_114ck173 FIND v(dout1_114) AT=870.025n

* CHECK dout1_115 Vdout1_115ck173 = 0 time = 870
.meas tran vdout1_115ck173 FIND v(dout1_115) AT=870.025n

* CHECK dout1_116 Vdout1_116ck173 = 0 time = 870
.meas tran vdout1_116ck173 FIND v(dout1_116) AT=870.025n

* CHECK dout1_117 Vdout1_117ck173 = 0.9 time = 870
.meas tran vdout1_117ck173 FIND v(dout1_117) AT=870.025n

* CHECK dout1_118 Vdout1_118ck173 = 0 time = 870
.meas tran vdout1_118ck173 FIND v(dout1_118) AT=870.025n

* CHECK dout1_119 Vdout1_119ck173 = 0.9 time = 870
.meas tran vdout1_119ck173 FIND v(dout1_119) AT=870.025n

* CHECK dout1_0 Vdout1_0ck174 = 0.9 time = 875
.meas tran vdout1_0ck174 FIND v(dout1_0) AT=875.025n

* CHECK dout1_1 Vdout1_1ck174 = 0.9 time = 875
.meas tran vdout1_1ck174 FIND v(dout1_1) AT=875.025n

* CHECK dout1_2 Vdout1_2ck174 = 0 time = 875
.meas tran vdout1_2ck174 FIND v(dout1_2) AT=875.025n

* CHECK dout1_3 Vdout1_3ck174 = 0 time = 875
.meas tran vdout1_3ck174 FIND v(dout1_3) AT=875.025n

* CHECK dout1_4 Vdout1_4ck174 = 0.9 time = 875
.meas tran vdout1_4ck174 FIND v(dout1_4) AT=875.025n

* CHECK dout1_5 Vdout1_5ck174 = 0 time = 875
.meas tran vdout1_5ck174 FIND v(dout1_5) AT=875.025n

* CHECK dout1_6 Vdout1_6ck174 = 0 time = 875
.meas tran vdout1_6ck174 FIND v(dout1_6) AT=875.025n

* CHECK dout1_7 Vdout1_7ck174 = 0.9 time = 875
.meas tran vdout1_7ck174 FIND v(dout1_7) AT=875.025n

* CHECK dout1_8 Vdout1_8ck174 = 0.9 time = 875
.meas tran vdout1_8ck174 FIND v(dout1_8) AT=875.025n

* CHECK dout1_9 Vdout1_9ck174 = 0 time = 875
.meas tran vdout1_9ck174 FIND v(dout1_9) AT=875.025n

* CHECK dout1_10 Vdout1_10ck174 = 0.9 time = 875
.meas tran vdout1_10ck174 FIND v(dout1_10) AT=875.025n

* CHECK dout1_11 Vdout1_11ck174 = 0 time = 875
.meas tran vdout1_11ck174 FIND v(dout1_11) AT=875.025n

* CHECK dout1_12 Vdout1_12ck174 = 0 time = 875
.meas tran vdout1_12ck174 FIND v(dout1_12) AT=875.025n

* CHECK dout1_13 Vdout1_13ck174 = 0 time = 875
.meas tran vdout1_13ck174 FIND v(dout1_13) AT=875.025n

* CHECK dout1_14 Vdout1_14ck174 = 0.9 time = 875
.meas tran vdout1_14ck174 FIND v(dout1_14) AT=875.025n

* CHECK dout1_15 Vdout1_15ck174 = 0.9 time = 875
.meas tran vdout1_15ck174 FIND v(dout1_15) AT=875.025n

* CHECK dout1_16 Vdout1_16ck174 = 0 time = 875
.meas tran vdout1_16ck174 FIND v(dout1_16) AT=875.025n

* CHECK dout1_17 Vdout1_17ck174 = 0.9 time = 875
.meas tran vdout1_17ck174 FIND v(dout1_17) AT=875.025n

* CHECK dout1_18 Vdout1_18ck174 = 0 time = 875
.meas tran vdout1_18ck174 FIND v(dout1_18) AT=875.025n

* CHECK dout1_19 Vdout1_19ck174 = 0 time = 875
.meas tran vdout1_19ck174 FIND v(dout1_19) AT=875.025n

* CHECK dout1_20 Vdout1_20ck174 = 0 time = 875
.meas tran vdout1_20ck174 FIND v(dout1_20) AT=875.025n

* CHECK dout1_21 Vdout1_21ck174 = 0 time = 875
.meas tran vdout1_21ck174 FIND v(dout1_21) AT=875.025n

* CHECK dout1_22 Vdout1_22ck174 = 0 time = 875
.meas tran vdout1_22ck174 FIND v(dout1_22) AT=875.025n

* CHECK dout1_23 Vdout1_23ck174 = 0 time = 875
.meas tran vdout1_23ck174 FIND v(dout1_23) AT=875.025n

* CHECK dout1_24 Vdout1_24ck174 = 0 time = 875
.meas tran vdout1_24ck174 FIND v(dout1_24) AT=875.025n

* CHECK dout1_25 Vdout1_25ck174 = 0 time = 875
.meas tran vdout1_25ck174 FIND v(dout1_25) AT=875.025n

* CHECK dout1_26 Vdout1_26ck174 = 0 time = 875
.meas tran vdout1_26ck174 FIND v(dout1_26) AT=875.025n

* CHECK dout1_27 Vdout1_27ck174 = 0 time = 875
.meas tran vdout1_27ck174 FIND v(dout1_27) AT=875.025n

* CHECK dout1_28 Vdout1_28ck174 = 0 time = 875
.meas tran vdout1_28ck174 FIND v(dout1_28) AT=875.025n

* CHECK dout1_29 Vdout1_29ck174 = 0 time = 875
.meas tran vdout1_29ck174 FIND v(dout1_29) AT=875.025n

* CHECK dout1_30 Vdout1_30ck174 = 0 time = 875
.meas tran vdout1_30ck174 FIND v(dout1_30) AT=875.025n

* CHECK dout1_31 Vdout1_31ck174 = 0.9 time = 875
.meas tran vdout1_31ck174 FIND v(dout1_31) AT=875.025n

* CHECK dout1_32 Vdout1_32ck174 = 0 time = 875
.meas tran vdout1_32ck174 FIND v(dout1_32) AT=875.025n

* CHECK dout1_33 Vdout1_33ck174 = 0 time = 875
.meas tran vdout1_33ck174 FIND v(dout1_33) AT=875.025n

* CHECK dout1_34 Vdout1_34ck174 = 0 time = 875
.meas tran vdout1_34ck174 FIND v(dout1_34) AT=875.025n

* CHECK dout1_35 Vdout1_35ck174 = 0.9 time = 875
.meas tran vdout1_35ck174 FIND v(dout1_35) AT=875.025n

* CHECK dout1_36 Vdout1_36ck174 = 0.9 time = 875
.meas tran vdout1_36ck174 FIND v(dout1_36) AT=875.025n

* CHECK dout1_37 Vdout1_37ck174 = 0 time = 875
.meas tran vdout1_37ck174 FIND v(dout1_37) AT=875.025n

* CHECK dout1_38 Vdout1_38ck174 = 0 time = 875
.meas tran vdout1_38ck174 FIND v(dout1_38) AT=875.025n

* CHECK dout1_39 Vdout1_39ck174 = 0.9 time = 875
.meas tran vdout1_39ck174 FIND v(dout1_39) AT=875.025n

* CHECK dout1_40 Vdout1_40ck174 = 0 time = 875
.meas tran vdout1_40ck174 FIND v(dout1_40) AT=875.025n

* CHECK dout1_41 Vdout1_41ck174 = 0.9 time = 875
.meas tran vdout1_41ck174 FIND v(dout1_41) AT=875.025n

* CHECK dout1_42 Vdout1_42ck174 = 0 time = 875
.meas tran vdout1_42ck174 FIND v(dout1_42) AT=875.025n

* CHECK dout1_43 Vdout1_43ck174 = 0.9 time = 875
.meas tran vdout1_43ck174 FIND v(dout1_43) AT=875.025n

* CHECK dout1_44 Vdout1_44ck174 = 0.9 time = 875
.meas tran vdout1_44ck174 FIND v(dout1_44) AT=875.025n

* CHECK dout1_45 Vdout1_45ck174 = 0 time = 875
.meas tran vdout1_45ck174 FIND v(dout1_45) AT=875.025n

* CHECK dout1_46 Vdout1_46ck174 = 0 time = 875
.meas tran vdout1_46ck174 FIND v(dout1_46) AT=875.025n

* CHECK dout1_47 Vdout1_47ck174 = 0.9 time = 875
.meas tran vdout1_47ck174 FIND v(dout1_47) AT=875.025n

* CHECK dout1_48 Vdout1_48ck174 = 0.9 time = 875
.meas tran vdout1_48ck174 FIND v(dout1_48) AT=875.025n

* CHECK dout1_49 Vdout1_49ck174 = 0 time = 875
.meas tran vdout1_49ck174 FIND v(dout1_49) AT=875.025n

* CHECK dout1_50 Vdout1_50ck174 = 0 time = 875
.meas tran vdout1_50ck174 FIND v(dout1_50) AT=875.025n

* CHECK dout1_51 Vdout1_51ck174 = 0 time = 875
.meas tran vdout1_51ck174 FIND v(dout1_51) AT=875.025n

* CHECK dout1_52 Vdout1_52ck174 = 0 time = 875
.meas tran vdout1_52ck174 FIND v(dout1_52) AT=875.025n

* CHECK dout1_53 Vdout1_53ck174 = 0.9 time = 875
.meas tran vdout1_53ck174 FIND v(dout1_53) AT=875.025n

* CHECK dout1_54 Vdout1_54ck174 = 0.9 time = 875
.meas tran vdout1_54ck174 FIND v(dout1_54) AT=875.025n

* CHECK dout1_55 Vdout1_55ck174 = 0 time = 875
.meas tran vdout1_55ck174 FIND v(dout1_55) AT=875.025n

* CHECK dout1_56 Vdout1_56ck174 = 0 time = 875
.meas tran vdout1_56ck174 FIND v(dout1_56) AT=875.025n

* CHECK dout1_57 Vdout1_57ck174 = 0 time = 875
.meas tran vdout1_57ck174 FIND v(dout1_57) AT=875.025n

* CHECK dout1_58 Vdout1_58ck174 = 0 time = 875
.meas tran vdout1_58ck174 FIND v(dout1_58) AT=875.025n

* CHECK dout1_59 Vdout1_59ck174 = 0.9 time = 875
.meas tran vdout1_59ck174 FIND v(dout1_59) AT=875.025n

* CHECK dout1_60 Vdout1_60ck174 = 0.9 time = 875
.meas tran vdout1_60ck174 FIND v(dout1_60) AT=875.025n

* CHECK dout1_61 Vdout1_61ck174 = 0.9 time = 875
.meas tran vdout1_61ck174 FIND v(dout1_61) AT=875.025n

* CHECK dout1_62 Vdout1_62ck174 = 0 time = 875
.meas tran vdout1_62ck174 FIND v(dout1_62) AT=875.025n

* CHECK dout1_63 Vdout1_63ck174 = 0.9 time = 875
.meas tran vdout1_63ck174 FIND v(dout1_63) AT=875.025n

* CHECK dout1_64 Vdout1_64ck174 = 0.9 time = 875
.meas tran vdout1_64ck174 FIND v(dout1_64) AT=875.025n

* CHECK dout1_65 Vdout1_65ck174 = 0 time = 875
.meas tran vdout1_65ck174 FIND v(dout1_65) AT=875.025n

* CHECK dout1_66 Vdout1_66ck174 = 0.9 time = 875
.meas tran vdout1_66ck174 FIND v(dout1_66) AT=875.025n

* CHECK dout1_67 Vdout1_67ck174 = 0.9 time = 875
.meas tran vdout1_67ck174 FIND v(dout1_67) AT=875.025n

* CHECK dout1_68 Vdout1_68ck174 = 0.9 time = 875
.meas tran vdout1_68ck174 FIND v(dout1_68) AT=875.025n

* CHECK dout1_69 Vdout1_69ck174 = 0.9 time = 875
.meas tran vdout1_69ck174 FIND v(dout1_69) AT=875.025n

* CHECK dout1_70 Vdout1_70ck174 = 0.9 time = 875
.meas tran vdout1_70ck174 FIND v(dout1_70) AT=875.025n

* CHECK dout1_71 Vdout1_71ck174 = 0.9 time = 875
.meas tran vdout1_71ck174 FIND v(dout1_71) AT=875.025n

* CHECK dout1_72 Vdout1_72ck174 = 0.9 time = 875
.meas tran vdout1_72ck174 FIND v(dout1_72) AT=875.025n

* CHECK dout1_73 Vdout1_73ck174 = 0 time = 875
.meas tran vdout1_73ck174 FIND v(dout1_73) AT=875.025n

* CHECK dout1_74 Vdout1_74ck174 = 0.9 time = 875
.meas tran vdout1_74ck174 FIND v(dout1_74) AT=875.025n

* CHECK dout1_75 Vdout1_75ck174 = 0.9 time = 875
.meas tran vdout1_75ck174 FIND v(dout1_75) AT=875.025n

* CHECK dout1_76 Vdout1_76ck174 = 0 time = 875
.meas tran vdout1_76ck174 FIND v(dout1_76) AT=875.025n

* CHECK dout1_77 Vdout1_77ck174 = 0 time = 875
.meas tran vdout1_77ck174 FIND v(dout1_77) AT=875.025n

* CHECK dout1_78 Vdout1_78ck174 = 0 time = 875
.meas tran vdout1_78ck174 FIND v(dout1_78) AT=875.025n

* CHECK dout1_79 Vdout1_79ck174 = 0.9 time = 875
.meas tran vdout1_79ck174 FIND v(dout1_79) AT=875.025n

* CHECK dout1_80 Vdout1_80ck174 = 0 time = 875
.meas tran vdout1_80ck174 FIND v(dout1_80) AT=875.025n

* CHECK dout1_81 Vdout1_81ck174 = 0.9 time = 875
.meas tran vdout1_81ck174 FIND v(dout1_81) AT=875.025n

* CHECK dout1_82 Vdout1_82ck174 = 0.9 time = 875
.meas tran vdout1_82ck174 FIND v(dout1_82) AT=875.025n

* CHECK dout1_83 Vdout1_83ck174 = 0 time = 875
.meas tran vdout1_83ck174 FIND v(dout1_83) AT=875.025n

* CHECK dout1_84 Vdout1_84ck174 = 0.9 time = 875
.meas tran vdout1_84ck174 FIND v(dout1_84) AT=875.025n

* CHECK dout1_85 Vdout1_85ck174 = 0 time = 875
.meas tran vdout1_85ck174 FIND v(dout1_85) AT=875.025n

* CHECK dout1_86 Vdout1_86ck174 = 0 time = 875
.meas tran vdout1_86ck174 FIND v(dout1_86) AT=875.025n

* CHECK dout1_87 Vdout1_87ck174 = 0.9 time = 875
.meas tran vdout1_87ck174 FIND v(dout1_87) AT=875.025n

* CHECK dout1_88 Vdout1_88ck174 = 0.9 time = 875
.meas tran vdout1_88ck174 FIND v(dout1_88) AT=875.025n

* CHECK dout1_89 Vdout1_89ck174 = 0.9 time = 875
.meas tran vdout1_89ck174 FIND v(dout1_89) AT=875.025n

* CHECK dout1_90 Vdout1_90ck174 = 0.9 time = 875
.meas tran vdout1_90ck174 FIND v(dout1_90) AT=875.025n

* CHECK dout1_91 Vdout1_91ck174 = 0 time = 875
.meas tran vdout1_91ck174 FIND v(dout1_91) AT=875.025n

* CHECK dout1_92 Vdout1_92ck174 = 0 time = 875
.meas tran vdout1_92ck174 FIND v(dout1_92) AT=875.025n

* CHECK dout1_93 Vdout1_93ck174 = 0.9 time = 875
.meas tran vdout1_93ck174 FIND v(dout1_93) AT=875.025n

* CHECK dout1_94 Vdout1_94ck174 = 0.9 time = 875
.meas tran vdout1_94ck174 FIND v(dout1_94) AT=875.025n

* CHECK dout1_95 Vdout1_95ck174 = 0.9 time = 875
.meas tran vdout1_95ck174 FIND v(dout1_95) AT=875.025n

* CHECK dout1_96 Vdout1_96ck174 = 0.9 time = 875
.meas tran vdout1_96ck174 FIND v(dout1_96) AT=875.025n

* CHECK dout1_97 Vdout1_97ck174 = 0.9 time = 875
.meas tran vdout1_97ck174 FIND v(dout1_97) AT=875.025n

* CHECK dout1_98 Vdout1_98ck174 = 0 time = 875
.meas tran vdout1_98ck174 FIND v(dout1_98) AT=875.025n

* CHECK dout1_99 Vdout1_99ck174 = 0 time = 875
.meas tran vdout1_99ck174 FIND v(dout1_99) AT=875.025n

* CHECK dout1_100 Vdout1_100ck174 = 0 time = 875
.meas tran vdout1_100ck174 FIND v(dout1_100) AT=875.025n

* CHECK dout1_101 Vdout1_101ck174 = 0 time = 875
.meas tran vdout1_101ck174 FIND v(dout1_101) AT=875.025n

* CHECK dout1_102 Vdout1_102ck174 = 0 time = 875
.meas tran vdout1_102ck174 FIND v(dout1_102) AT=875.025n

* CHECK dout1_103 Vdout1_103ck174 = 0 time = 875
.meas tran vdout1_103ck174 FIND v(dout1_103) AT=875.025n

* CHECK dout1_104 Vdout1_104ck174 = 0 time = 875
.meas tran vdout1_104ck174 FIND v(dout1_104) AT=875.025n

* CHECK dout1_105 Vdout1_105ck174 = 0.9 time = 875
.meas tran vdout1_105ck174 FIND v(dout1_105) AT=875.025n

* CHECK dout1_106 Vdout1_106ck174 = 0.9 time = 875
.meas tran vdout1_106ck174 FIND v(dout1_106) AT=875.025n

* CHECK dout1_107 Vdout1_107ck174 = 0.9 time = 875
.meas tran vdout1_107ck174 FIND v(dout1_107) AT=875.025n

* CHECK dout1_108 Vdout1_108ck174 = 0.9 time = 875
.meas tran vdout1_108ck174 FIND v(dout1_108) AT=875.025n

* CHECK dout1_109 Vdout1_109ck174 = 0 time = 875
.meas tran vdout1_109ck174 FIND v(dout1_109) AT=875.025n

* CHECK dout1_110 Vdout1_110ck174 = 0 time = 875
.meas tran vdout1_110ck174 FIND v(dout1_110) AT=875.025n

* CHECK dout1_111 Vdout1_111ck174 = 0 time = 875
.meas tran vdout1_111ck174 FIND v(dout1_111) AT=875.025n

* CHECK dout1_112 Vdout1_112ck174 = 0.9 time = 875
.meas tran vdout1_112ck174 FIND v(dout1_112) AT=875.025n

* CHECK dout1_113 Vdout1_113ck174 = 0.9 time = 875
.meas tran vdout1_113ck174 FIND v(dout1_113) AT=875.025n

* CHECK dout1_114 Vdout1_114ck174 = 0.9 time = 875
.meas tran vdout1_114ck174 FIND v(dout1_114) AT=875.025n

* CHECK dout1_115 Vdout1_115ck174 = 0 time = 875
.meas tran vdout1_115ck174 FIND v(dout1_115) AT=875.025n

* CHECK dout1_116 Vdout1_116ck174 = 0 time = 875
.meas tran vdout1_116ck174 FIND v(dout1_116) AT=875.025n

* CHECK dout1_117 Vdout1_117ck174 = 0.9 time = 875
.meas tran vdout1_117ck174 FIND v(dout1_117) AT=875.025n

* CHECK dout1_118 Vdout1_118ck174 = 0 time = 875
.meas tran vdout1_118ck174 FIND v(dout1_118) AT=875.025n

* CHECK dout1_119 Vdout1_119ck174 = 0.9 time = 875
.meas tran vdout1_119ck174 FIND v(dout1_119) AT=875.025n

* CHECK dout1_0 Vdout1_0ck175 = 0.9 time = 880
.meas tran vdout1_0ck175 FIND v(dout1_0) AT=880.025n

* CHECK dout1_1 Vdout1_1ck175 = 0 time = 880
.meas tran vdout1_1ck175 FIND v(dout1_1) AT=880.025n

* CHECK dout1_2 Vdout1_2ck175 = 0 time = 880
.meas tran vdout1_2ck175 FIND v(dout1_2) AT=880.025n

* CHECK dout1_3 Vdout1_3ck175 = 0 time = 880
.meas tran vdout1_3ck175 FIND v(dout1_3) AT=880.025n

* CHECK dout1_4 Vdout1_4ck175 = 0 time = 880
.meas tran vdout1_4ck175 FIND v(dout1_4) AT=880.025n

* CHECK dout1_5 Vdout1_5ck175 = 0 time = 880
.meas tran vdout1_5ck175 FIND v(dout1_5) AT=880.025n

* CHECK dout1_6 Vdout1_6ck175 = 0 time = 880
.meas tran vdout1_6ck175 FIND v(dout1_6) AT=880.025n

* CHECK dout1_7 Vdout1_7ck175 = 0 time = 880
.meas tran vdout1_7ck175 FIND v(dout1_7) AT=880.025n

* CHECK dout1_8 Vdout1_8ck175 = 0 time = 880
.meas tran vdout1_8ck175 FIND v(dout1_8) AT=880.025n

* CHECK dout1_9 Vdout1_9ck175 = 0.9 time = 880
.meas tran vdout1_9ck175 FIND v(dout1_9) AT=880.025n

* CHECK dout1_10 Vdout1_10ck175 = 0.9 time = 880
.meas tran vdout1_10ck175 FIND v(dout1_10) AT=880.025n

* CHECK dout1_11 Vdout1_11ck175 = 0.9 time = 880
.meas tran vdout1_11ck175 FIND v(dout1_11) AT=880.025n

* CHECK dout1_12 Vdout1_12ck175 = 0.9 time = 880
.meas tran vdout1_12ck175 FIND v(dout1_12) AT=880.025n

* CHECK dout1_13 Vdout1_13ck175 = 0.9 time = 880
.meas tran vdout1_13ck175 FIND v(dout1_13) AT=880.025n

* CHECK dout1_14 Vdout1_14ck175 = 0 time = 880
.meas tran vdout1_14ck175 FIND v(dout1_14) AT=880.025n

* CHECK dout1_15 Vdout1_15ck175 = 0.9 time = 880
.meas tran vdout1_15ck175 FIND v(dout1_15) AT=880.025n

* CHECK dout1_16 Vdout1_16ck175 = 0.9 time = 880
.meas tran vdout1_16ck175 FIND v(dout1_16) AT=880.025n

* CHECK dout1_17 Vdout1_17ck175 = 0 time = 880
.meas tran vdout1_17ck175 FIND v(dout1_17) AT=880.025n

* CHECK dout1_18 Vdout1_18ck175 = 0.9 time = 880
.meas tran vdout1_18ck175 FIND v(dout1_18) AT=880.025n

* CHECK dout1_19 Vdout1_19ck175 = 0.9 time = 880
.meas tran vdout1_19ck175 FIND v(dout1_19) AT=880.025n

* CHECK dout1_20 Vdout1_20ck175 = 0.9 time = 880
.meas tran vdout1_20ck175 FIND v(dout1_20) AT=880.025n

* CHECK dout1_21 Vdout1_21ck175 = 0.9 time = 880
.meas tran vdout1_21ck175 FIND v(dout1_21) AT=880.025n

* CHECK dout1_22 Vdout1_22ck175 = 0 time = 880
.meas tran vdout1_22ck175 FIND v(dout1_22) AT=880.025n

* CHECK dout1_23 Vdout1_23ck175 = 0.9 time = 880
.meas tran vdout1_23ck175 FIND v(dout1_23) AT=880.025n

* CHECK dout1_24 Vdout1_24ck175 = 0 time = 880
.meas tran vdout1_24ck175 FIND v(dout1_24) AT=880.025n

* CHECK dout1_25 Vdout1_25ck175 = 0 time = 880
.meas tran vdout1_25ck175 FIND v(dout1_25) AT=880.025n

* CHECK dout1_26 Vdout1_26ck175 = 0.9 time = 880
.meas tran vdout1_26ck175 FIND v(dout1_26) AT=880.025n

* CHECK dout1_27 Vdout1_27ck175 = 0.9 time = 880
.meas tran vdout1_27ck175 FIND v(dout1_27) AT=880.025n

* CHECK dout1_28 Vdout1_28ck175 = 0 time = 880
.meas tran vdout1_28ck175 FIND v(dout1_28) AT=880.025n

* CHECK dout1_29 Vdout1_29ck175 = 0 time = 880
.meas tran vdout1_29ck175 FIND v(dout1_29) AT=880.025n

* CHECK dout1_30 Vdout1_30ck175 = 0.9 time = 880
.meas tran vdout1_30ck175 FIND v(dout1_30) AT=880.025n

* CHECK dout1_31 Vdout1_31ck175 = 0.9 time = 880
.meas tran vdout1_31ck175 FIND v(dout1_31) AT=880.025n

* CHECK dout1_32 Vdout1_32ck175 = 0 time = 880
.meas tran vdout1_32ck175 FIND v(dout1_32) AT=880.025n

* CHECK dout1_33 Vdout1_33ck175 = 0 time = 880
.meas tran vdout1_33ck175 FIND v(dout1_33) AT=880.025n

* CHECK dout1_34 Vdout1_34ck175 = 0 time = 880
.meas tran vdout1_34ck175 FIND v(dout1_34) AT=880.025n

* CHECK dout1_35 Vdout1_35ck175 = 0.9 time = 880
.meas tran vdout1_35ck175 FIND v(dout1_35) AT=880.025n

* CHECK dout1_36 Vdout1_36ck175 = 0.9 time = 880
.meas tran vdout1_36ck175 FIND v(dout1_36) AT=880.025n

* CHECK dout1_37 Vdout1_37ck175 = 0 time = 880
.meas tran vdout1_37ck175 FIND v(dout1_37) AT=880.025n

* CHECK dout1_38 Vdout1_38ck175 = 0 time = 880
.meas tran vdout1_38ck175 FIND v(dout1_38) AT=880.025n

* CHECK dout1_39 Vdout1_39ck175 = 0.9 time = 880
.meas tran vdout1_39ck175 FIND v(dout1_39) AT=880.025n

* CHECK dout1_40 Vdout1_40ck175 = 0.9 time = 880
.meas tran vdout1_40ck175 FIND v(dout1_40) AT=880.025n

* CHECK dout1_41 Vdout1_41ck175 = 0.9 time = 880
.meas tran vdout1_41ck175 FIND v(dout1_41) AT=880.025n

* CHECK dout1_42 Vdout1_42ck175 = 0.9 time = 880
.meas tran vdout1_42ck175 FIND v(dout1_42) AT=880.025n

* CHECK dout1_43 Vdout1_43ck175 = 0 time = 880
.meas tran vdout1_43ck175 FIND v(dout1_43) AT=880.025n

* CHECK dout1_44 Vdout1_44ck175 = 0 time = 880
.meas tran vdout1_44ck175 FIND v(dout1_44) AT=880.025n

* CHECK dout1_45 Vdout1_45ck175 = 0 time = 880
.meas tran vdout1_45ck175 FIND v(dout1_45) AT=880.025n

* CHECK dout1_46 Vdout1_46ck175 = 0.9 time = 880
.meas tran vdout1_46ck175 FIND v(dout1_46) AT=880.025n

* CHECK dout1_47 Vdout1_47ck175 = 0.9 time = 880
.meas tran vdout1_47ck175 FIND v(dout1_47) AT=880.025n

* CHECK dout1_48 Vdout1_48ck175 = 0.9 time = 880
.meas tran vdout1_48ck175 FIND v(dout1_48) AT=880.025n

* CHECK dout1_49 Vdout1_49ck175 = 0.9 time = 880
.meas tran vdout1_49ck175 FIND v(dout1_49) AT=880.025n

* CHECK dout1_50 Vdout1_50ck175 = 0 time = 880
.meas tran vdout1_50ck175 FIND v(dout1_50) AT=880.025n

* CHECK dout1_51 Vdout1_51ck175 = 0.9 time = 880
.meas tran vdout1_51ck175 FIND v(dout1_51) AT=880.025n

* CHECK dout1_52 Vdout1_52ck175 = 0 time = 880
.meas tran vdout1_52ck175 FIND v(dout1_52) AT=880.025n

* CHECK dout1_53 Vdout1_53ck175 = 0 time = 880
.meas tran vdout1_53ck175 FIND v(dout1_53) AT=880.025n

* CHECK dout1_54 Vdout1_54ck175 = 0 time = 880
.meas tran vdout1_54ck175 FIND v(dout1_54) AT=880.025n

* CHECK dout1_55 Vdout1_55ck175 = 0.9 time = 880
.meas tran vdout1_55ck175 FIND v(dout1_55) AT=880.025n

* CHECK dout1_56 Vdout1_56ck175 = 0 time = 880
.meas tran vdout1_56ck175 FIND v(dout1_56) AT=880.025n

* CHECK dout1_57 Vdout1_57ck175 = 0 time = 880
.meas tran vdout1_57ck175 FIND v(dout1_57) AT=880.025n

* CHECK dout1_58 Vdout1_58ck175 = 0 time = 880
.meas tran vdout1_58ck175 FIND v(dout1_58) AT=880.025n

* CHECK dout1_59 Vdout1_59ck175 = 0 time = 880
.meas tran vdout1_59ck175 FIND v(dout1_59) AT=880.025n

* CHECK dout1_60 Vdout1_60ck175 = 0.9 time = 880
.meas tran vdout1_60ck175 FIND v(dout1_60) AT=880.025n

* CHECK dout1_61 Vdout1_61ck175 = 0.9 time = 880
.meas tran vdout1_61ck175 FIND v(dout1_61) AT=880.025n

* CHECK dout1_62 Vdout1_62ck175 = 0 time = 880
.meas tran vdout1_62ck175 FIND v(dout1_62) AT=880.025n

* CHECK dout1_63 Vdout1_63ck175 = 0.9 time = 880
.meas tran vdout1_63ck175 FIND v(dout1_63) AT=880.025n

* CHECK dout1_64 Vdout1_64ck175 = 0 time = 880
.meas tran vdout1_64ck175 FIND v(dout1_64) AT=880.025n

* CHECK dout1_65 Vdout1_65ck175 = 0 time = 880
.meas tran vdout1_65ck175 FIND v(dout1_65) AT=880.025n

* CHECK dout1_66 Vdout1_66ck175 = 0.9 time = 880
.meas tran vdout1_66ck175 FIND v(dout1_66) AT=880.025n

* CHECK dout1_67 Vdout1_67ck175 = 0 time = 880
.meas tran vdout1_67ck175 FIND v(dout1_67) AT=880.025n

* CHECK dout1_68 Vdout1_68ck175 = 0 time = 880
.meas tran vdout1_68ck175 FIND v(dout1_68) AT=880.025n

* CHECK dout1_69 Vdout1_69ck175 = 0.9 time = 880
.meas tran vdout1_69ck175 FIND v(dout1_69) AT=880.025n

* CHECK dout1_70 Vdout1_70ck175 = 0.9 time = 880
.meas tran vdout1_70ck175 FIND v(dout1_70) AT=880.025n

* CHECK dout1_71 Vdout1_71ck175 = 0 time = 880
.meas tran vdout1_71ck175 FIND v(dout1_71) AT=880.025n

* CHECK dout1_72 Vdout1_72ck175 = 0.9 time = 880
.meas tran vdout1_72ck175 FIND v(dout1_72) AT=880.025n

* CHECK dout1_73 Vdout1_73ck175 = 0.9 time = 880
.meas tran vdout1_73ck175 FIND v(dout1_73) AT=880.025n

* CHECK dout1_74 Vdout1_74ck175 = 0.9 time = 880
.meas tran vdout1_74ck175 FIND v(dout1_74) AT=880.025n

* CHECK dout1_75 Vdout1_75ck175 = 0.9 time = 880
.meas tran vdout1_75ck175 FIND v(dout1_75) AT=880.025n

* CHECK dout1_76 Vdout1_76ck175 = 0.9 time = 880
.meas tran vdout1_76ck175 FIND v(dout1_76) AT=880.025n

* CHECK dout1_77 Vdout1_77ck175 = 0.9 time = 880
.meas tran vdout1_77ck175 FIND v(dout1_77) AT=880.025n

* CHECK dout1_78 Vdout1_78ck175 = 0 time = 880
.meas tran vdout1_78ck175 FIND v(dout1_78) AT=880.025n

* CHECK dout1_79 Vdout1_79ck175 = 0 time = 880
.meas tran vdout1_79ck175 FIND v(dout1_79) AT=880.025n

* CHECK dout1_80 Vdout1_80ck175 = 0 time = 880
.meas tran vdout1_80ck175 FIND v(dout1_80) AT=880.025n

* CHECK dout1_81 Vdout1_81ck175 = 0.9 time = 880
.meas tran vdout1_81ck175 FIND v(dout1_81) AT=880.025n

* CHECK dout1_82 Vdout1_82ck175 = 0 time = 880
.meas tran vdout1_82ck175 FIND v(dout1_82) AT=880.025n

* CHECK dout1_83 Vdout1_83ck175 = 0.9 time = 880
.meas tran vdout1_83ck175 FIND v(dout1_83) AT=880.025n

* CHECK dout1_84 Vdout1_84ck175 = 0 time = 880
.meas tran vdout1_84ck175 FIND v(dout1_84) AT=880.025n

* CHECK dout1_85 Vdout1_85ck175 = 0 time = 880
.meas tran vdout1_85ck175 FIND v(dout1_85) AT=880.025n

* CHECK dout1_86 Vdout1_86ck175 = 0.9 time = 880
.meas tran vdout1_86ck175 FIND v(dout1_86) AT=880.025n

* CHECK dout1_87 Vdout1_87ck175 = 0 time = 880
.meas tran vdout1_87ck175 FIND v(dout1_87) AT=880.025n

* CHECK dout1_88 Vdout1_88ck175 = 0 time = 880
.meas tran vdout1_88ck175 FIND v(dout1_88) AT=880.025n

* CHECK dout1_89 Vdout1_89ck175 = 0 time = 880
.meas tran vdout1_89ck175 FIND v(dout1_89) AT=880.025n

* CHECK dout1_90 Vdout1_90ck175 = 0 time = 880
.meas tran vdout1_90ck175 FIND v(dout1_90) AT=880.025n

* CHECK dout1_91 Vdout1_91ck175 = 0 time = 880
.meas tran vdout1_91ck175 FIND v(dout1_91) AT=880.025n

* CHECK dout1_92 Vdout1_92ck175 = 0.9 time = 880
.meas tran vdout1_92ck175 FIND v(dout1_92) AT=880.025n

* CHECK dout1_93 Vdout1_93ck175 = 0.9 time = 880
.meas tran vdout1_93ck175 FIND v(dout1_93) AT=880.025n

* CHECK dout1_94 Vdout1_94ck175 = 0 time = 880
.meas tran vdout1_94ck175 FIND v(dout1_94) AT=880.025n

* CHECK dout1_95 Vdout1_95ck175 = 0.9 time = 880
.meas tran vdout1_95ck175 FIND v(dout1_95) AT=880.025n

* CHECK dout1_96 Vdout1_96ck175 = 0 time = 880
.meas tran vdout1_96ck175 FIND v(dout1_96) AT=880.025n

* CHECK dout1_97 Vdout1_97ck175 = 0 time = 880
.meas tran vdout1_97ck175 FIND v(dout1_97) AT=880.025n

* CHECK dout1_98 Vdout1_98ck175 = 0.9 time = 880
.meas tran vdout1_98ck175 FIND v(dout1_98) AT=880.025n

* CHECK dout1_99 Vdout1_99ck175 = 0.9 time = 880
.meas tran vdout1_99ck175 FIND v(dout1_99) AT=880.025n

* CHECK dout1_100 Vdout1_100ck175 = 0 time = 880
.meas tran vdout1_100ck175 FIND v(dout1_100) AT=880.025n

* CHECK dout1_101 Vdout1_101ck175 = 0.9 time = 880
.meas tran vdout1_101ck175 FIND v(dout1_101) AT=880.025n

* CHECK dout1_102 Vdout1_102ck175 = 0 time = 880
.meas tran vdout1_102ck175 FIND v(dout1_102) AT=880.025n

* CHECK dout1_103 Vdout1_103ck175 = 0 time = 880
.meas tran vdout1_103ck175 FIND v(dout1_103) AT=880.025n

* CHECK dout1_104 Vdout1_104ck175 = 0.9 time = 880
.meas tran vdout1_104ck175 FIND v(dout1_104) AT=880.025n

* CHECK dout1_105 Vdout1_105ck175 = 0 time = 880
.meas tran vdout1_105ck175 FIND v(dout1_105) AT=880.025n

* CHECK dout1_106 Vdout1_106ck175 = 0 time = 880
.meas tran vdout1_106ck175 FIND v(dout1_106) AT=880.025n

* CHECK dout1_107 Vdout1_107ck175 = 0.9 time = 880
.meas tran vdout1_107ck175 FIND v(dout1_107) AT=880.025n

* CHECK dout1_108 Vdout1_108ck175 = 0 time = 880
.meas tran vdout1_108ck175 FIND v(dout1_108) AT=880.025n

* CHECK dout1_109 Vdout1_109ck175 = 0 time = 880
.meas tran vdout1_109ck175 FIND v(dout1_109) AT=880.025n

* CHECK dout1_110 Vdout1_110ck175 = 0.9 time = 880
.meas tran vdout1_110ck175 FIND v(dout1_110) AT=880.025n

* CHECK dout1_111 Vdout1_111ck175 = 0.9 time = 880
.meas tran vdout1_111ck175 FIND v(dout1_111) AT=880.025n

* CHECK dout1_112 Vdout1_112ck175 = 0 time = 880
.meas tran vdout1_112ck175 FIND v(dout1_112) AT=880.025n

* CHECK dout1_113 Vdout1_113ck175 = 0.9 time = 880
.meas tran vdout1_113ck175 FIND v(dout1_113) AT=880.025n

* CHECK dout1_114 Vdout1_114ck175 = 0.9 time = 880
.meas tran vdout1_114ck175 FIND v(dout1_114) AT=880.025n

* CHECK dout1_115 Vdout1_115ck175 = 0 time = 880
.meas tran vdout1_115ck175 FIND v(dout1_115) AT=880.025n

* CHECK dout1_116 Vdout1_116ck175 = 0 time = 880
.meas tran vdout1_116ck175 FIND v(dout1_116) AT=880.025n

* CHECK dout1_117 Vdout1_117ck175 = 0.9 time = 880
.meas tran vdout1_117ck175 FIND v(dout1_117) AT=880.025n

* CHECK dout1_118 Vdout1_118ck175 = 0.9 time = 880
.meas tran vdout1_118ck175 FIND v(dout1_118) AT=880.025n

* CHECK dout1_119 Vdout1_119ck175 = 0.9 time = 880
.meas tran vdout1_119ck175 FIND v(dout1_119) AT=880.025n

* CHECK dout1_0 Vdout1_0ck177 = 0.9 time = 890
.meas tran vdout1_0ck177 FIND v(dout1_0) AT=890.025n

* CHECK dout1_1 Vdout1_1ck177 = 0.9 time = 890
.meas tran vdout1_1ck177 FIND v(dout1_1) AT=890.025n

* CHECK dout1_2 Vdout1_2ck177 = 0 time = 890
.meas tran vdout1_2ck177 FIND v(dout1_2) AT=890.025n

* CHECK dout1_3 Vdout1_3ck177 = 0 time = 890
.meas tran vdout1_3ck177 FIND v(dout1_3) AT=890.025n

* CHECK dout1_4 Vdout1_4ck177 = 0.9 time = 890
.meas tran vdout1_4ck177 FIND v(dout1_4) AT=890.025n

* CHECK dout1_5 Vdout1_5ck177 = 0 time = 890
.meas tran vdout1_5ck177 FIND v(dout1_5) AT=890.025n

* CHECK dout1_6 Vdout1_6ck177 = 0 time = 890
.meas tran vdout1_6ck177 FIND v(dout1_6) AT=890.025n

* CHECK dout1_7 Vdout1_7ck177 = 0.9 time = 890
.meas tran vdout1_7ck177 FIND v(dout1_7) AT=890.025n

* CHECK dout1_8 Vdout1_8ck177 = 0.9 time = 890
.meas tran vdout1_8ck177 FIND v(dout1_8) AT=890.025n

* CHECK dout1_9 Vdout1_9ck177 = 0 time = 890
.meas tran vdout1_9ck177 FIND v(dout1_9) AT=890.025n

* CHECK dout1_10 Vdout1_10ck177 = 0.9 time = 890
.meas tran vdout1_10ck177 FIND v(dout1_10) AT=890.025n

* CHECK dout1_11 Vdout1_11ck177 = 0 time = 890
.meas tran vdout1_11ck177 FIND v(dout1_11) AT=890.025n

* CHECK dout1_12 Vdout1_12ck177 = 0 time = 890
.meas tran vdout1_12ck177 FIND v(dout1_12) AT=890.025n

* CHECK dout1_13 Vdout1_13ck177 = 0 time = 890
.meas tran vdout1_13ck177 FIND v(dout1_13) AT=890.025n

* CHECK dout1_14 Vdout1_14ck177 = 0.9 time = 890
.meas tran vdout1_14ck177 FIND v(dout1_14) AT=890.025n

* CHECK dout1_15 Vdout1_15ck177 = 0.9 time = 890
.meas tran vdout1_15ck177 FIND v(dout1_15) AT=890.025n

* CHECK dout1_16 Vdout1_16ck177 = 0 time = 890
.meas tran vdout1_16ck177 FIND v(dout1_16) AT=890.025n

* CHECK dout1_17 Vdout1_17ck177 = 0.9 time = 890
.meas tran vdout1_17ck177 FIND v(dout1_17) AT=890.025n

* CHECK dout1_18 Vdout1_18ck177 = 0 time = 890
.meas tran vdout1_18ck177 FIND v(dout1_18) AT=890.025n

* CHECK dout1_19 Vdout1_19ck177 = 0 time = 890
.meas tran vdout1_19ck177 FIND v(dout1_19) AT=890.025n

* CHECK dout1_20 Vdout1_20ck177 = 0 time = 890
.meas tran vdout1_20ck177 FIND v(dout1_20) AT=890.025n

* CHECK dout1_21 Vdout1_21ck177 = 0 time = 890
.meas tran vdout1_21ck177 FIND v(dout1_21) AT=890.025n

* CHECK dout1_22 Vdout1_22ck177 = 0 time = 890
.meas tran vdout1_22ck177 FIND v(dout1_22) AT=890.025n

* CHECK dout1_23 Vdout1_23ck177 = 0 time = 890
.meas tran vdout1_23ck177 FIND v(dout1_23) AT=890.025n

* CHECK dout1_24 Vdout1_24ck177 = 0 time = 890
.meas tran vdout1_24ck177 FIND v(dout1_24) AT=890.025n

* CHECK dout1_25 Vdout1_25ck177 = 0 time = 890
.meas tran vdout1_25ck177 FIND v(dout1_25) AT=890.025n

* CHECK dout1_26 Vdout1_26ck177 = 0 time = 890
.meas tran vdout1_26ck177 FIND v(dout1_26) AT=890.025n

* CHECK dout1_27 Vdout1_27ck177 = 0 time = 890
.meas tran vdout1_27ck177 FIND v(dout1_27) AT=890.025n

* CHECK dout1_28 Vdout1_28ck177 = 0 time = 890
.meas tran vdout1_28ck177 FIND v(dout1_28) AT=890.025n

* CHECK dout1_29 Vdout1_29ck177 = 0 time = 890
.meas tran vdout1_29ck177 FIND v(dout1_29) AT=890.025n

* CHECK dout1_30 Vdout1_30ck177 = 0 time = 890
.meas tran vdout1_30ck177 FIND v(dout1_30) AT=890.025n

* CHECK dout1_31 Vdout1_31ck177 = 0.9 time = 890
.meas tran vdout1_31ck177 FIND v(dout1_31) AT=890.025n

* CHECK dout1_32 Vdout1_32ck177 = 0 time = 890
.meas tran vdout1_32ck177 FIND v(dout1_32) AT=890.025n

* CHECK dout1_33 Vdout1_33ck177 = 0 time = 890
.meas tran vdout1_33ck177 FIND v(dout1_33) AT=890.025n

* CHECK dout1_34 Vdout1_34ck177 = 0 time = 890
.meas tran vdout1_34ck177 FIND v(dout1_34) AT=890.025n

* CHECK dout1_35 Vdout1_35ck177 = 0.9 time = 890
.meas tran vdout1_35ck177 FIND v(dout1_35) AT=890.025n

* CHECK dout1_36 Vdout1_36ck177 = 0.9 time = 890
.meas tran vdout1_36ck177 FIND v(dout1_36) AT=890.025n

* CHECK dout1_37 Vdout1_37ck177 = 0 time = 890
.meas tran vdout1_37ck177 FIND v(dout1_37) AT=890.025n

* CHECK dout1_38 Vdout1_38ck177 = 0 time = 890
.meas tran vdout1_38ck177 FIND v(dout1_38) AT=890.025n

* CHECK dout1_39 Vdout1_39ck177 = 0.9 time = 890
.meas tran vdout1_39ck177 FIND v(dout1_39) AT=890.025n

* CHECK dout1_40 Vdout1_40ck177 = 0 time = 890
.meas tran vdout1_40ck177 FIND v(dout1_40) AT=890.025n

* CHECK dout1_41 Vdout1_41ck177 = 0.9 time = 890
.meas tran vdout1_41ck177 FIND v(dout1_41) AT=890.025n

* CHECK dout1_42 Vdout1_42ck177 = 0 time = 890
.meas tran vdout1_42ck177 FIND v(dout1_42) AT=890.025n

* CHECK dout1_43 Vdout1_43ck177 = 0.9 time = 890
.meas tran vdout1_43ck177 FIND v(dout1_43) AT=890.025n

* CHECK dout1_44 Vdout1_44ck177 = 0.9 time = 890
.meas tran vdout1_44ck177 FIND v(dout1_44) AT=890.025n

* CHECK dout1_45 Vdout1_45ck177 = 0 time = 890
.meas tran vdout1_45ck177 FIND v(dout1_45) AT=890.025n

* CHECK dout1_46 Vdout1_46ck177 = 0 time = 890
.meas tran vdout1_46ck177 FIND v(dout1_46) AT=890.025n

* CHECK dout1_47 Vdout1_47ck177 = 0.9 time = 890
.meas tran vdout1_47ck177 FIND v(dout1_47) AT=890.025n

* CHECK dout1_48 Vdout1_48ck177 = 0.9 time = 890
.meas tran vdout1_48ck177 FIND v(dout1_48) AT=890.025n

* CHECK dout1_49 Vdout1_49ck177 = 0 time = 890
.meas tran vdout1_49ck177 FIND v(dout1_49) AT=890.025n

* CHECK dout1_50 Vdout1_50ck177 = 0 time = 890
.meas tran vdout1_50ck177 FIND v(dout1_50) AT=890.025n

* CHECK dout1_51 Vdout1_51ck177 = 0 time = 890
.meas tran vdout1_51ck177 FIND v(dout1_51) AT=890.025n

* CHECK dout1_52 Vdout1_52ck177 = 0 time = 890
.meas tran vdout1_52ck177 FIND v(dout1_52) AT=890.025n

* CHECK dout1_53 Vdout1_53ck177 = 0.9 time = 890
.meas tran vdout1_53ck177 FIND v(dout1_53) AT=890.025n

* CHECK dout1_54 Vdout1_54ck177 = 0.9 time = 890
.meas tran vdout1_54ck177 FIND v(dout1_54) AT=890.025n

* CHECK dout1_55 Vdout1_55ck177 = 0 time = 890
.meas tran vdout1_55ck177 FIND v(dout1_55) AT=890.025n

* CHECK dout1_56 Vdout1_56ck177 = 0 time = 890
.meas tran vdout1_56ck177 FIND v(dout1_56) AT=890.025n

* CHECK dout1_57 Vdout1_57ck177 = 0 time = 890
.meas tran vdout1_57ck177 FIND v(dout1_57) AT=890.025n

* CHECK dout1_58 Vdout1_58ck177 = 0 time = 890
.meas tran vdout1_58ck177 FIND v(dout1_58) AT=890.025n

* CHECK dout1_59 Vdout1_59ck177 = 0.9 time = 890
.meas tran vdout1_59ck177 FIND v(dout1_59) AT=890.025n

* CHECK dout1_60 Vdout1_60ck177 = 0.9 time = 890
.meas tran vdout1_60ck177 FIND v(dout1_60) AT=890.025n

* CHECK dout1_61 Vdout1_61ck177 = 0.9 time = 890
.meas tran vdout1_61ck177 FIND v(dout1_61) AT=890.025n

* CHECK dout1_62 Vdout1_62ck177 = 0 time = 890
.meas tran vdout1_62ck177 FIND v(dout1_62) AT=890.025n

* CHECK dout1_63 Vdout1_63ck177 = 0.9 time = 890
.meas tran vdout1_63ck177 FIND v(dout1_63) AT=890.025n

* CHECK dout1_64 Vdout1_64ck177 = 0.9 time = 890
.meas tran vdout1_64ck177 FIND v(dout1_64) AT=890.025n

* CHECK dout1_65 Vdout1_65ck177 = 0 time = 890
.meas tran vdout1_65ck177 FIND v(dout1_65) AT=890.025n

* CHECK dout1_66 Vdout1_66ck177 = 0.9 time = 890
.meas tran vdout1_66ck177 FIND v(dout1_66) AT=890.025n

* CHECK dout1_67 Vdout1_67ck177 = 0.9 time = 890
.meas tran vdout1_67ck177 FIND v(dout1_67) AT=890.025n

* CHECK dout1_68 Vdout1_68ck177 = 0.9 time = 890
.meas tran vdout1_68ck177 FIND v(dout1_68) AT=890.025n

* CHECK dout1_69 Vdout1_69ck177 = 0.9 time = 890
.meas tran vdout1_69ck177 FIND v(dout1_69) AT=890.025n

* CHECK dout1_70 Vdout1_70ck177 = 0.9 time = 890
.meas tran vdout1_70ck177 FIND v(dout1_70) AT=890.025n

* CHECK dout1_71 Vdout1_71ck177 = 0.9 time = 890
.meas tran vdout1_71ck177 FIND v(dout1_71) AT=890.025n

* CHECK dout1_72 Vdout1_72ck177 = 0.9 time = 890
.meas tran vdout1_72ck177 FIND v(dout1_72) AT=890.025n

* CHECK dout1_73 Vdout1_73ck177 = 0 time = 890
.meas tran vdout1_73ck177 FIND v(dout1_73) AT=890.025n

* CHECK dout1_74 Vdout1_74ck177 = 0.9 time = 890
.meas tran vdout1_74ck177 FIND v(dout1_74) AT=890.025n

* CHECK dout1_75 Vdout1_75ck177 = 0.9 time = 890
.meas tran vdout1_75ck177 FIND v(dout1_75) AT=890.025n

* CHECK dout1_76 Vdout1_76ck177 = 0 time = 890
.meas tran vdout1_76ck177 FIND v(dout1_76) AT=890.025n

* CHECK dout1_77 Vdout1_77ck177 = 0 time = 890
.meas tran vdout1_77ck177 FIND v(dout1_77) AT=890.025n

* CHECK dout1_78 Vdout1_78ck177 = 0 time = 890
.meas tran vdout1_78ck177 FIND v(dout1_78) AT=890.025n

* CHECK dout1_79 Vdout1_79ck177 = 0.9 time = 890
.meas tran vdout1_79ck177 FIND v(dout1_79) AT=890.025n

* CHECK dout1_80 Vdout1_80ck177 = 0 time = 890
.meas tran vdout1_80ck177 FIND v(dout1_80) AT=890.025n

* CHECK dout1_81 Vdout1_81ck177 = 0.9 time = 890
.meas tran vdout1_81ck177 FIND v(dout1_81) AT=890.025n

* CHECK dout1_82 Vdout1_82ck177 = 0.9 time = 890
.meas tran vdout1_82ck177 FIND v(dout1_82) AT=890.025n

* CHECK dout1_83 Vdout1_83ck177 = 0 time = 890
.meas tran vdout1_83ck177 FIND v(dout1_83) AT=890.025n

* CHECK dout1_84 Vdout1_84ck177 = 0.9 time = 890
.meas tran vdout1_84ck177 FIND v(dout1_84) AT=890.025n

* CHECK dout1_85 Vdout1_85ck177 = 0 time = 890
.meas tran vdout1_85ck177 FIND v(dout1_85) AT=890.025n

* CHECK dout1_86 Vdout1_86ck177 = 0 time = 890
.meas tran vdout1_86ck177 FIND v(dout1_86) AT=890.025n

* CHECK dout1_87 Vdout1_87ck177 = 0.9 time = 890
.meas tran vdout1_87ck177 FIND v(dout1_87) AT=890.025n

* CHECK dout1_88 Vdout1_88ck177 = 0.9 time = 890
.meas tran vdout1_88ck177 FIND v(dout1_88) AT=890.025n

* CHECK dout1_89 Vdout1_89ck177 = 0.9 time = 890
.meas tran vdout1_89ck177 FIND v(dout1_89) AT=890.025n

* CHECK dout1_90 Vdout1_90ck177 = 0.9 time = 890
.meas tran vdout1_90ck177 FIND v(dout1_90) AT=890.025n

* CHECK dout1_91 Vdout1_91ck177 = 0 time = 890
.meas tran vdout1_91ck177 FIND v(dout1_91) AT=890.025n

* CHECK dout1_92 Vdout1_92ck177 = 0 time = 890
.meas tran vdout1_92ck177 FIND v(dout1_92) AT=890.025n

* CHECK dout1_93 Vdout1_93ck177 = 0.9 time = 890
.meas tran vdout1_93ck177 FIND v(dout1_93) AT=890.025n

* CHECK dout1_94 Vdout1_94ck177 = 0.9 time = 890
.meas tran vdout1_94ck177 FIND v(dout1_94) AT=890.025n

* CHECK dout1_95 Vdout1_95ck177 = 0.9 time = 890
.meas tran vdout1_95ck177 FIND v(dout1_95) AT=890.025n

* CHECK dout1_96 Vdout1_96ck177 = 0.9 time = 890
.meas tran vdout1_96ck177 FIND v(dout1_96) AT=890.025n

* CHECK dout1_97 Vdout1_97ck177 = 0.9 time = 890
.meas tran vdout1_97ck177 FIND v(dout1_97) AT=890.025n

* CHECK dout1_98 Vdout1_98ck177 = 0 time = 890
.meas tran vdout1_98ck177 FIND v(dout1_98) AT=890.025n

* CHECK dout1_99 Vdout1_99ck177 = 0 time = 890
.meas tran vdout1_99ck177 FIND v(dout1_99) AT=890.025n

* CHECK dout1_100 Vdout1_100ck177 = 0 time = 890
.meas tran vdout1_100ck177 FIND v(dout1_100) AT=890.025n

* CHECK dout1_101 Vdout1_101ck177 = 0 time = 890
.meas tran vdout1_101ck177 FIND v(dout1_101) AT=890.025n

* CHECK dout1_102 Vdout1_102ck177 = 0 time = 890
.meas tran vdout1_102ck177 FIND v(dout1_102) AT=890.025n

* CHECK dout1_103 Vdout1_103ck177 = 0 time = 890
.meas tran vdout1_103ck177 FIND v(dout1_103) AT=890.025n

* CHECK dout1_104 Vdout1_104ck177 = 0 time = 890
.meas tran vdout1_104ck177 FIND v(dout1_104) AT=890.025n

* CHECK dout1_105 Vdout1_105ck177 = 0.9 time = 890
.meas tran vdout1_105ck177 FIND v(dout1_105) AT=890.025n

* CHECK dout1_106 Vdout1_106ck177 = 0.9 time = 890
.meas tran vdout1_106ck177 FIND v(dout1_106) AT=890.025n

* CHECK dout1_107 Vdout1_107ck177 = 0.9 time = 890
.meas tran vdout1_107ck177 FIND v(dout1_107) AT=890.025n

* CHECK dout1_108 Vdout1_108ck177 = 0.9 time = 890
.meas tran vdout1_108ck177 FIND v(dout1_108) AT=890.025n

* CHECK dout1_109 Vdout1_109ck177 = 0 time = 890
.meas tran vdout1_109ck177 FIND v(dout1_109) AT=890.025n

* CHECK dout1_110 Vdout1_110ck177 = 0 time = 890
.meas tran vdout1_110ck177 FIND v(dout1_110) AT=890.025n

* CHECK dout1_111 Vdout1_111ck177 = 0 time = 890
.meas tran vdout1_111ck177 FIND v(dout1_111) AT=890.025n

* CHECK dout1_112 Vdout1_112ck177 = 0.9 time = 890
.meas tran vdout1_112ck177 FIND v(dout1_112) AT=890.025n

* CHECK dout1_113 Vdout1_113ck177 = 0.9 time = 890
.meas tran vdout1_113ck177 FIND v(dout1_113) AT=890.025n

* CHECK dout1_114 Vdout1_114ck177 = 0.9 time = 890
.meas tran vdout1_114ck177 FIND v(dout1_114) AT=890.025n

* CHECK dout1_115 Vdout1_115ck177 = 0 time = 890
.meas tran vdout1_115ck177 FIND v(dout1_115) AT=890.025n

* CHECK dout1_116 Vdout1_116ck177 = 0 time = 890
.meas tran vdout1_116ck177 FIND v(dout1_116) AT=890.025n

* CHECK dout1_117 Vdout1_117ck177 = 0.9 time = 890
.meas tran vdout1_117ck177 FIND v(dout1_117) AT=890.025n

* CHECK dout1_118 Vdout1_118ck177 = 0 time = 890
.meas tran vdout1_118ck177 FIND v(dout1_118) AT=890.025n

* CHECK dout1_119 Vdout1_119ck177 = 0.9 time = 890
.meas tran vdout1_119ck177 FIND v(dout1_119) AT=890.025n

* CHECK dout1_0 Vdout1_0ck178 = 0.9 time = 895
.meas tran vdout1_0ck178 FIND v(dout1_0) AT=895.025n

* CHECK dout1_1 Vdout1_1ck178 = 0.9 time = 895
.meas tran vdout1_1ck178 FIND v(dout1_1) AT=895.025n

* CHECK dout1_2 Vdout1_2ck178 = 0 time = 895
.meas tran vdout1_2ck178 FIND v(dout1_2) AT=895.025n

* CHECK dout1_3 Vdout1_3ck178 = 0 time = 895
.meas tran vdout1_3ck178 FIND v(dout1_3) AT=895.025n

* CHECK dout1_4 Vdout1_4ck178 = 0.9 time = 895
.meas tran vdout1_4ck178 FIND v(dout1_4) AT=895.025n

* CHECK dout1_5 Vdout1_5ck178 = 0 time = 895
.meas tran vdout1_5ck178 FIND v(dout1_5) AT=895.025n

* CHECK dout1_6 Vdout1_6ck178 = 0 time = 895
.meas tran vdout1_6ck178 FIND v(dout1_6) AT=895.025n

* CHECK dout1_7 Vdout1_7ck178 = 0.9 time = 895
.meas tran vdout1_7ck178 FIND v(dout1_7) AT=895.025n

* CHECK dout1_8 Vdout1_8ck178 = 0.9 time = 895
.meas tran vdout1_8ck178 FIND v(dout1_8) AT=895.025n

* CHECK dout1_9 Vdout1_9ck178 = 0 time = 895
.meas tran vdout1_9ck178 FIND v(dout1_9) AT=895.025n

* CHECK dout1_10 Vdout1_10ck178 = 0.9 time = 895
.meas tran vdout1_10ck178 FIND v(dout1_10) AT=895.025n

* CHECK dout1_11 Vdout1_11ck178 = 0 time = 895
.meas tran vdout1_11ck178 FIND v(dout1_11) AT=895.025n

* CHECK dout1_12 Vdout1_12ck178 = 0 time = 895
.meas tran vdout1_12ck178 FIND v(dout1_12) AT=895.025n

* CHECK dout1_13 Vdout1_13ck178 = 0 time = 895
.meas tran vdout1_13ck178 FIND v(dout1_13) AT=895.025n

* CHECK dout1_14 Vdout1_14ck178 = 0.9 time = 895
.meas tran vdout1_14ck178 FIND v(dout1_14) AT=895.025n

* CHECK dout1_15 Vdout1_15ck178 = 0.9 time = 895
.meas tran vdout1_15ck178 FIND v(dout1_15) AT=895.025n

* CHECK dout1_16 Vdout1_16ck178 = 0 time = 895
.meas tran vdout1_16ck178 FIND v(dout1_16) AT=895.025n

* CHECK dout1_17 Vdout1_17ck178 = 0.9 time = 895
.meas tran vdout1_17ck178 FIND v(dout1_17) AT=895.025n

* CHECK dout1_18 Vdout1_18ck178 = 0 time = 895
.meas tran vdout1_18ck178 FIND v(dout1_18) AT=895.025n

* CHECK dout1_19 Vdout1_19ck178 = 0 time = 895
.meas tran vdout1_19ck178 FIND v(dout1_19) AT=895.025n

* CHECK dout1_20 Vdout1_20ck178 = 0 time = 895
.meas tran vdout1_20ck178 FIND v(dout1_20) AT=895.025n

* CHECK dout1_21 Vdout1_21ck178 = 0 time = 895
.meas tran vdout1_21ck178 FIND v(dout1_21) AT=895.025n

* CHECK dout1_22 Vdout1_22ck178 = 0 time = 895
.meas tran vdout1_22ck178 FIND v(dout1_22) AT=895.025n

* CHECK dout1_23 Vdout1_23ck178 = 0 time = 895
.meas tran vdout1_23ck178 FIND v(dout1_23) AT=895.025n

* CHECK dout1_24 Vdout1_24ck178 = 0 time = 895
.meas tran vdout1_24ck178 FIND v(dout1_24) AT=895.025n

* CHECK dout1_25 Vdout1_25ck178 = 0 time = 895
.meas tran vdout1_25ck178 FIND v(dout1_25) AT=895.025n

* CHECK dout1_26 Vdout1_26ck178 = 0 time = 895
.meas tran vdout1_26ck178 FIND v(dout1_26) AT=895.025n

* CHECK dout1_27 Vdout1_27ck178 = 0 time = 895
.meas tran vdout1_27ck178 FIND v(dout1_27) AT=895.025n

* CHECK dout1_28 Vdout1_28ck178 = 0 time = 895
.meas tran vdout1_28ck178 FIND v(dout1_28) AT=895.025n

* CHECK dout1_29 Vdout1_29ck178 = 0 time = 895
.meas tran vdout1_29ck178 FIND v(dout1_29) AT=895.025n

* CHECK dout1_30 Vdout1_30ck178 = 0 time = 895
.meas tran vdout1_30ck178 FIND v(dout1_30) AT=895.025n

* CHECK dout1_31 Vdout1_31ck178 = 0.9 time = 895
.meas tran vdout1_31ck178 FIND v(dout1_31) AT=895.025n

* CHECK dout1_32 Vdout1_32ck178 = 0 time = 895
.meas tran vdout1_32ck178 FIND v(dout1_32) AT=895.025n

* CHECK dout1_33 Vdout1_33ck178 = 0 time = 895
.meas tran vdout1_33ck178 FIND v(dout1_33) AT=895.025n

* CHECK dout1_34 Vdout1_34ck178 = 0 time = 895
.meas tran vdout1_34ck178 FIND v(dout1_34) AT=895.025n

* CHECK dout1_35 Vdout1_35ck178 = 0.9 time = 895
.meas tran vdout1_35ck178 FIND v(dout1_35) AT=895.025n

* CHECK dout1_36 Vdout1_36ck178 = 0.9 time = 895
.meas tran vdout1_36ck178 FIND v(dout1_36) AT=895.025n

* CHECK dout1_37 Vdout1_37ck178 = 0 time = 895
.meas tran vdout1_37ck178 FIND v(dout1_37) AT=895.025n

* CHECK dout1_38 Vdout1_38ck178 = 0 time = 895
.meas tran vdout1_38ck178 FIND v(dout1_38) AT=895.025n

* CHECK dout1_39 Vdout1_39ck178 = 0.9 time = 895
.meas tran vdout1_39ck178 FIND v(dout1_39) AT=895.025n

* CHECK dout1_40 Vdout1_40ck178 = 0 time = 895
.meas tran vdout1_40ck178 FIND v(dout1_40) AT=895.025n

* CHECK dout1_41 Vdout1_41ck178 = 0.9 time = 895
.meas tran vdout1_41ck178 FIND v(dout1_41) AT=895.025n

* CHECK dout1_42 Vdout1_42ck178 = 0 time = 895
.meas tran vdout1_42ck178 FIND v(dout1_42) AT=895.025n

* CHECK dout1_43 Vdout1_43ck178 = 0.9 time = 895
.meas tran vdout1_43ck178 FIND v(dout1_43) AT=895.025n

* CHECK dout1_44 Vdout1_44ck178 = 0.9 time = 895
.meas tran vdout1_44ck178 FIND v(dout1_44) AT=895.025n

* CHECK dout1_45 Vdout1_45ck178 = 0 time = 895
.meas tran vdout1_45ck178 FIND v(dout1_45) AT=895.025n

* CHECK dout1_46 Vdout1_46ck178 = 0 time = 895
.meas tran vdout1_46ck178 FIND v(dout1_46) AT=895.025n

* CHECK dout1_47 Vdout1_47ck178 = 0.9 time = 895
.meas tran vdout1_47ck178 FIND v(dout1_47) AT=895.025n

* CHECK dout1_48 Vdout1_48ck178 = 0.9 time = 895
.meas tran vdout1_48ck178 FIND v(dout1_48) AT=895.025n

* CHECK dout1_49 Vdout1_49ck178 = 0 time = 895
.meas tran vdout1_49ck178 FIND v(dout1_49) AT=895.025n

* CHECK dout1_50 Vdout1_50ck178 = 0 time = 895
.meas tran vdout1_50ck178 FIND v(dout1_50) AT=895.025n

* CHECK dout1_51 Vdout1_51ck178 = 0 time = 895
.meas tran vdout1_51ck178 FIND v(dout1_51) AT=895.025n

* CHECK dout1_52 Vdout1_52ck178 = 0 time = 895
.meas tran vdout1_52ck178 FIND v(dout1_52) AT=895.025n

* CHECK dout1_53 Vdout1_53ck178 = 0.9 time = 895
.meas tran vdout1_53ck178 FIND v(dout1_53) AT=895.025n

* CHECK dout1_54 Vdout1_54ck178 = 0.9 time = 895
.meas tran vdout1_54ck178 FIND v(dout1_54) AT=895.025n

* CHECK dout1_55 Vdout1_55ck178 = 0 time = 895
.meas tran vdout1_55ck178 FIND v(dout1_55) AT=895.025n

* CHECK dout1_56 Vdout1_56ck178 = 0 time = 895
.meas tran vdout1_56ck178 FIND v(dout1_56) AT=895.025n

* CHECK dout1_57 Vdout1_57ck178 = 0 time = 895
.meas tran vdout1_57ck178 FIND v(dout1_57) AT=895.025n

* CHECK dout1_58 Vdout1_58ck178 = 0 time = 895
.meas tran vdout1_58ck178 FIND v(dout1_58) AT=895.025n

* CHECK dout1_59 Vdout1_59ck178 = 0.9 time = 895
.meas tran vdout1_59ck178 FIND v(dout1_59) AT=895.025n

* CHECK dout1_60 Vdout1_60ck178 = 0.9 time = 895
.meas tran vdout1_60ck178 FIND v(dout1_60) AT=895.025n

* CHECK dout1_61 Vdout1_61ck178 = 0.9 time = 895
.meas tran vdout1_61ck178 FIND v(dout1_61) AT=895.025n

* CHECK dout1_62 Vdout1_62ck178 = 0 time = 895
.meas tran vdout1_62ck178 FIND v(dout1_62) AT=895.025n

* CHECK dout1_63 Vdout1_63ck178 = 0.9 time = 895
.meas tran vdout1_63ck178 FIND v(dout1_63) AT=895.025n

* CHECK dout1_64 Vdout1_64ck178 = 0.9 time = 895
.meas tran vdout1_64ck178 FIND v(dout1_64) AT=895.025n

* CHECK dout1_65 Vdout1_65ck178 = 0 time = 895
.meas tran vdout1_65ck178 FIND v(dout1_65) AT=895.025n

* CHECK dout1_66 Vdout1_66ck178 = 0.9 time = 895
.meas tran vdout1_66ck178 FIND v(dout1_66) AT=895.025n

* CHECK dout1_67 Vdout1_67ck178 = 0.9 time = 895
.meas tran vdout1_67ck178 FIND v(dout1_67) AT=895.025n

* CHECK dout1_68 Vdout1_68ck178 = 0.9 time = 895
.meas tran vdout1_68ck178 FIND v(dout1_68) AT=895.025n

* CHECK dout1_69 Vdout1_69ck178 = 0.9 time = 895
.meas tran vdout1_69ck178 FIND v(dout1_69) AT=895.025n

* CHECK dout1_70 Vdout1_70ck178 = 0.9 time = 895
.meas tran vdout1_70ck178 FIND v(dout1_70) AT=895.025n

* CHECK dout1_71 Vdout1_71ck178 = 0.9 time = 895
.meas tran vdout1_71ck178 FIND v(dout1_71) AT=895.025n

* CHECK dout1_72 Vdout1_72ck178 = 0.9 time = 895
.meas tran vdout1_72ck178 FIND v(dout1_72) AT=895.025n

* CHECK dout1_73 Vdout1_73ck178 = 0 time = 895
.meas tran vdout1_73ck178 FIND v(dout1_73) AT=895.025n

* CHECK dout1_74 Vdout1_74ck178 = 0.9 time = 895
.meas tran vdout1_74ck178 FIND v(dout1_74) AT=895.025n

* CHECK dout1_75 Vdout1_75ck178 = 0.9 time = 895
.meas tran vdout1_75ck178 FIND v(dout1_75) AT=895.025n

* CHECK dout1_76 Vdout1_76ck178 = 0 time = 895
.meas tran vdout1_76ck178 FIND v(dout1_76) AT=895.025n

* CHECK dout1_77 Vdout1_77ck178 = 0 time = 895
.meas tran vdout1_77ck178 FIND v(dout1_77) AT=895.025n

* CHECK dout1_78 Vdout1_78ck178 = 0 time = 895
.meas tran vdout1_78ck178 FIND v(dout1_78) AT=895.025n

* CHECK dout1_79 Vdout1_79ck178 = 0.9 time = 895
.meas tran vdout1_79ck178 FIND v(dout1_79) AT=895.025n

* CHECK dout1_80 Vdout1_80ck178 = 0 time = 895
.meas tran vdout1_80ck178 FIND v(dout1_80) AT=895.025n

* CHECK dout1_81 Vdout1_81ck178 = 0.9 time = 895
.meas tran vdout1_81ck178 FIND v(dout1_81) AT=895.025n

* CHECK dout1_82 Vdout1_82ck178 = 0.9 time = 895
.meas tran vdout1_82ck178 FIND v(dout1_82) AT=895.025n

* CHECK dout1_83 Vdout1_83ck178 = 0 time = 895
.meas tran vdout1_83ck178 FIND v(dout1_83) AT=895.025n

* CHECK dout1_84 Vdout1_84ck178 = 0.9 time = 895
.meas tran vdout1_84ck178 FIND v(dout1_84) AT=895.025n

* CHECK dout1_85 Vdout1_85ck178 = 0 time = 895
.meas tran vdout1_85ck178 FIND v(dout1_85) AT=895.025n

* CHECK dout1_86 Vdout1_86ck178 = 0 time = 895
.meas tran vdout1_86ck178 FIND v(dout1_86) AT=895.025n

* CHECK dout1_87 Vdout1_87ck178 = 0.9 time = 895
.meas tran vdout1_87ck178 FIND v(dout1_87) AT=895.025n

* CHECK dout1_88 Vdout1_88ck178 = 0.9 time = 895
.meas tran vdout1_88ck178 FIND v(dout1_88) AT=895.025n

* CHECK dout1_89 Vdout1_89ck178 = 0.9 time = 895
.meas tran vdout1_89ck178 FIND v(dout1_89) AT=895.025n

* CHECK dout1_90 Vdout1_90ck178 = 0.9 time = 895
.meas tran vdout1_90ck178 FIND v(dout1_90) AT=895.025n

* CHECK dout1_91 Vdout1_91ck178 = 0 time = 895
.meas tran vdout1_91ck178 FIND v(dout1_91) AT=895.025n

* CHECK dout1_92 Vdout1_92ck178 = 0 time = 895
.meas tran vdout1_92ck178 FIND v(dout1_92) AT=895.025n

* CHECK dout1_93 Vdout1_93ck178 = 0.9 time = 895
.meas tran vdout1_93ck178 FIND v(dout1_93) AT=895.025n

* CHECK dout1_94 Vdout1_94ck178 = 0.9 time = 895
.meas tran vdout1_94ck178 FIND v(dout1_94) AT=895.025n

* CHECK dout1_95 Vdout1_95ck178 = 0.9 time = 895
.meas tran vdout1_95ck178 FIND v(dout1_95) AT=895.025n

* CHECK dout1_96 Vdout1_96ck178 = 0.9 time = 895
.meas tran vdout1_96ck178 FIND v(dout1_96) AT=895.025n

* CHECK dout1_97 Vdout1_97ck178 = 0.9 time = 895
.meas tran vdout1_97ck178 FIND v(dout1_97) AT=895.025n

* CHECK dout1_98 Vdout1_98ck178 = 0 time = 895
.meas tran vdout1_98ck178 FIND v(dout1_98) AT=895.025n

* CHECK dout1_99 Vdout1_99ck178 = 0 time = 895
.meas tran vdout1_99ck178 FIND v(dout1_99) AT=895.025n

* CHECK dout1_100 Vdout1_100ck178 = 0 time = 895
.meas tran vdout1_100ck178 FIND v(dout1_100) AT=895.025n

* CHECK dout1_101 Vdout1_101ck178 = 0 time = 895
.meas tran vdout1_101ck178 FIND v(dout1_101) AT=895.025n

* CHECK dout1_102 Vdout1_102ck178 = 0 time = 895
.meas tran vdout1_102ck178 FIND v(dout1_102) AT=895.025n

* CHECK dout1_103 Vdout1_103ck178 = 0 time = 895
.meas tran vdout1_103ck178 FIND v(dout1_103) AT=895.025n

* CHECK dout1_104 Vdout1_104ck178 = 0 time = 895
.meas tran vdout1_104ck178 FIND v(dout1_104) AT=895.025n

* CHECK dout1_105 Vdout1_105ck178 = 0.9 time = 895
.meas tran vdout1_105ck178 FIND v(dout1_105) AT=895.025n

* CHECK dout1_106 Vdout1_106ck178 = 0.9 time = 895
.meas tran vdout1_106ck178 FIND v(dout1_106) AT=895.025n

* CHECK dout1_107 Vdout1_107ck178 = 0.9 time = 895
.meas tran vdout1_107ck178 FIND v(dout1_107) AT=895.025n

* CHECK dout1_108 Vdout1_108ck178 = 0.9 time = 895
.meas tran vdout1_108ck178 FIND v(dout1_108) AT=895.025n

* CHECK dout1_109 Vdout1_109ck178 = 0 time = 895
.meas tran vdout1_109ck178 FIND v(dout1_109) AT=895.025n

* CHECK dout1_110 Vdout1_110ck178 = 0 time = 895
.meas tran vdout1_110ck178 FIND v(dout1_110) AT=895.025n

* CHECK dout1_111 Vdout1_111ck178 = 0 time = 895
.meas tran vdout1_111ck178 FIND v(dout1_111) AT=895.025n

* CHECK dout1_112 Vdout1_112ck178 = 0.9 time = 895
.meas tran vdout1_112ck178 FIND v(dout1_112) AT=895.025n

* CHECK dout1_113 Vdout1_113ck178 = 0.9 time = 895
.meas tran vdout1_113ck178 FIND v(dout1_113) AT=895.025n

* CHECK dout1_114 Vdout1_114ck178 = 0.9 time = 895
.meas tran vdout1_114ck178 FIND v(dout1_114) AT=895.025n

* CHECK dout1_115 Vdout1_115ck178 = 0 time = 895
.meas tran vdout1_115ck178 FIND v(dout1_115) AT=895.025n

* CHECK dout1_116 Vdout1_116ck178 = 0 time = 895
.meas tran vdout1_116ck178 FIND v(dout1_116) AT=895.025n

* CHECK dout1_117 Vdout1_117ck178 = 0.9 time = 895
.meas tran vdout1_117ck178 FIND v(dout1_117) AT=895.025n

* CHECK dout1_118 Vdout1_118ck178 = 0 time = 895
.meas tran vdout1_118ck178 FIND v(dout1_118) AT=895.025n

* CHECK dout1_119 Vdout1_119ck178 = 0.9 time = 895
.meas tran vdout1_119ck178 FIND v(dout1_119) AT=895.025n

* CHECK dout1_0 Vdout1_0ck179 = 0.9 time = 900
.meas tran vdout1_0ck179 FIND v(dout1_0) AT=900.025n

* CHECK dout1_1 Vdout1_1ck179 = 0.9 time = 900
.meas tran vdout1_1ck179 FIND v(dout1_1) AT=900.025n

* CHECK dout1_2 Vdout1_2ck179 = 0 time = 900
.meas tran vdout1_2ck179 FIND v(dout1_2) AT=900.025n

* CHECK dout1_3 Vdout1_3ck179 = 0 time = 900
.meas tran vdout1_3ck179 FIND v(dout1_3) AT=900.025n

* CHECK dout1_4 Vdout1_4ck179 = 0.9 time = 900
.meas tran vdout1_4ck179 FIND v(dout1_4) AT=900.025n

* CHECK dout1_5 Vdout1_5ck179 = 0 time = 900
.meas tran vdout1_5ck179 FIND v(dout1_5) AT=900.025n

* CHECK dout1_6 Vdout1_6ck179 = 0 time = 900
.meas tran vdout1_6ck179 FIND v(dout1_6) AT=900.025n

* CHECK dout1_7 Vdout1_7ck179 = 0.9 time = 900
.meas tran vdout1_7ck179 FIND v(dout1_7) AT=900.025n

* CHECK dout1_8 Vdout1_8ck179 = 0.9 time = 900
.meas tran vdout1_8ck179 FIND v(dout1_8) AT=900.025n

* CHECK dout1_9 Vdout1_9ck179 = 0 time = 900
.meas tran vdout1_9ck179 FIND v(dout1_9) AT=900.025n

* CHECK dout1_10 Vdout1_10ck179 = 0.9 time = 900
.meas tran vdout1_10ck179 FIND v(dout1_10) AT=900.025n

* CHECK dout1_11 Vdout1_11ck179 = 0 time = 900
.meas tran vdout1_11ck179 FIND v(dout1_11) AT=900.025n

* CHECK dout1_12 Vdout1_12ck179 = 0 time = 900
.meas tran vdout1_12ck179 FIND v(dout1_12) AT=900.025n

* CHECK dout1_13 Vdout1_13ck179 = 0 time = 900
.meas tran vdout1_13ck179 FIND v(dout1_13) AT=900.025n

* CHECK dout1_14 Vdout1_14ck179 = 0.9 time = 900
.meas tran vdout1_14ck179 FIND v(dout1_14) AT=900.025n

* CHECK dout1_15 Vdout1_15ck179 = 0.9 time = 900
.meas tran vdout1_15ck179 FIND v(dout1_15) AT=900.025n

* CHECK dout1_16 Vdout1_16ck179 = 0 time = 900
.meas tran vdout1_16ck179 FIND v(dout1_16) AT=900.025n

* CHECK dout1_17 Vdout1_17ck179 = 0.9 time = 900
.meas tran vdout1_17ck179 FIND v(dout1_17) AT=900.025n

* CHECK dout1_18 Vdout1_18ck179 = 0 time = 900
.meas tran vdout1_18ck179 FIND v(dout1_18) AT=900.025n

* CHECK dout1_19 Vdout1_19ck179 = 0 time = 900
.meas tran vdout1_19ck179 FIND v(dout1_19) AT=900.025n

* CHECK dout1_20 Vdout1_20ck179 = 0 time = 900
.meas tran vdout1_20ck179 FIND v(dout1_20) AT=900.025n

* CHECK dout1_21 Vdout1_21ck179 = 0 time = 900
.meas tran vdout1_21ck179 FIND v(dout1_21) AT=900.025n

* CHECK dout1_22 Vdout1_22ck179 = 0 time = 900
.meas tran vdout1_22ck179 FIND v(dout1_22) AT=900.025n

* CHECK dout1_23 Vdout1_23ck179 = 0 time = 900
.meas tran vdout1_23ck179 FIND v(dout1_23) AT=900.025n

* CHECK dout1_24 Vdout1_24ck179 = 0 time = 900
.meas tran vdout1_24ck179 FIND v(dout1_24) AT=900.025n

* CHECK dout1_25 Vdout1_25ck179 = 0 time = 900
.meas tran vdout1_25ck179 FIND v(dout1_25) AT=900.025n

* CHECK dout1_26 Vdout1_26ck179 = 0 time = 900
.meas tran vdout1_26ck179 FIND v(dout1_26) AT=900.025n

* CHECK dout1_27 Vdout1_27ck179 = 0 time = 900
.meas tran vdout1_27ck179 FIND v(dout1_27) AT=900.025n

* CHECK dout1_28 Vdout1_28ck179 = 0 time = 900
.meas tran vdout1_28ck179 FIND v(dout1_28) AT=900.025n

* CHECK dout1_29 Vdout1_29ck179 = 0 time = 900
.meas tran vdout1_29ck179 FIND v(dout1_29) AT=900.025n

* CHECK dout1_30 Vdout1_30ck179 = 0 time = 900
.meas tran vdout1_30ck179 FIND v(dout1_30) AT=900.025n

* CHECK dout1_31 Vdout1_31ck179 = 0.9 time = 900
.meas tran vdout1_31ck179 FIND v(dout1_31) AT=900.025n

* CHECK dout1_32 Vdout1_32ck179 = 0 time = 900
.meas tran vdout1_32ck179 FIND v(dout1_32) AT=900.025n

* CHECK dout1_33 Vdout1_33ck179 = 0 time = 900
.meas tran vdout1_33ck179 FIND v(dout1_33) AT=900.025n

* CHECK dout1_34 Vdout1_34ck179 = 0 time = 900
.meas tran vdout1_34ck179 FIND v(dout1_34) AT=900.025n

* CHECK dout1_35 Vdout1_35ck179 = 0.9 time = 900
.meas tran vdout1_35ck179 FIND v(dout1_35) AT=900.025n

* CHECK dout1_36 Vdout1_36ck179 = 0.9 time = 900
.meas tran vdout1_36ck179 FIND v(dout1_36) AT=900.025n

* CHECK dout1_37 Vdout1_37ck179 = 0 time = 900
.meas tran vdout1_37ck179 FIND v(dout1_37) AT=900.025n

* CHECK dout1_38 Vdout1_38ck179 = 0 time = 900
.meas tran vdout1_38ck179 FIND v(dout1_38) AT=900.025n

* CHECK dout1_39 Vdout1_39ck179 = 0.9 time = 900
.meas tran vdout1_39ck179 FIND v(dout1_39) AT=900.025n

* CHECK dout1_40 Vdout1_40ck179 = 0 time = 900
.meas tran vdout1_40ck179 FIND v(dout1_40) AT=900.025n

* CHECK dout1_41 Vdout1_41ck179 = 0.9 time = 900
.meas tran vdout1_41ck179 FIND v(dout1_41) AT=900.025n

* CHECK dout1_42 Vdout1_42ck179 = 0 time = 900
.meas tran vdout1_42ck179 FIND v(dout1_42) AT=900.025n

* CHECK dout1_43 Vdout1_43ck179 = 0.9 time = 900
.meas tran vdout1_43ck179 FIND v(dout1_43) AT=900.025n

* CHECK dout1_44 Vdout1_44ck179 = 0.9 time = 900
.meas tran vdout1_44ck179 FIND v(dout1_44) AT=900.025n

* CHECK dout1_45 Vdout1_45ck179 = 0 time = 900
.meas tran vdout1_45ck179 FIND v(dout1_45) AT=900.025n

* CHECK dout1_46 Vdout1_46ck179 = 0 time = 900
.meas tran vdout1_46ck179 FIND v(dout1_46) AT=900.025n

* CHECK dout1_47 Vdout1_47ck179 = 0.9 time = 900
.meas tran vdout1_47ck179 FIND v(dout1_47) AT=900.025n

* CHECK dout1_48 Vdout1_48ck179 = 0.9 time = 900
.meas tran vdout1_48ck179 FIND v(dout1_48) AT=900.025n

* CHECK dout1_49 Vdout1_49ck179 = 0 time = 900
.meas tran vdout1_49ck179 FIND v(dout1_49) AT=900.025n

* CHECK dout1_50 Vdout1_50ck179 = 0 time = 900
.meas tran vdout1_50ck179 FIND v(dout1_50) AT=900.025n

* CHECK dout1_51 Vdout1_51ck179 = 0 time = 900
.meas tran vdout1_51ck179 FIND v(dout1_51) AT=900.025n

* CHECK dout1_52 Vdout1_52ck179 = 0 time = 900
.meas tran vdout1_52ck179 FIND v(dout1_52) AT=900.025n

* CHECK dout1_53 Vdout1_53ck179 = 0.9 time = 900
.meas tran vdout1_53ck179 FIND v(dout1_53) AT=900.025n

* CHECK dout1_54 Vdout1_54ck179 = 0.9 time = 900
.meas tran vdout1_54ck179 FIND v(dout1_54) AT=900.025n

* CHECK dout1_55 Vdout1_55ck179 = 0 time = 900
.meas tran vdout1_55ck179 FIND v(dout1_55) AT=900.025n

* CHECK dout1_56 Vdout1_56ck179 = 0 time = 900
.meas tran vdout1_56ck179 FIND v(dout1_56) AT=900.025n

* CHECK dout1_57 Vdout1_57ck179 = 0 time = 900
.meas tran vdout1_57ck179 FIND v(dout1_57) AT=900.025n

* CHECK dout1_58 Vdout1_58ck179 = 0 time = 900
.meas tran vdout1_58ck179 FIND v(dout1_58) AT=900.025n

* CHECK dout1_59 Vdout1_59ck179 = 0.9 time = 900
.meas tran vdout1_59ck179 FIND v(dout1_59) AT=900.025n

* CHECK dout1_60 Vdout1_60ck179 = 0.9 time = 900
.meas tran vdout1_60ck179 FIND v(dout1_60) AT=900.025n

* CHECK dout1_61 Vdout1_61ck179 = 0.9 time = 900
.meas tran vdout1_61ck179 FIND v(dout1_61) AT=900.025n

* CHECK dout1_62 Vdout1_62ck179 = 0 time = 900
.meas tran vdout1_62ck179 FIND v(dout1_62) AT=900.025n

* CHECK dout1_63 Vdout1_63ck179 = 0.9 time = 900
.meas tran vdout1_63ck179 FIND v(dout1_63) AT=900.025n

* CHECK dout1_64 Vdout1_64ck179 = 0.9 time = 900
.meas tran vdout1_64ck179 FIND v(dout1_64) AT=900.025n

* CHECK dout1_65 Vdout1_65ck179 = 0 time = 900
.meas tran vdout1_65ck179 FIND v(dout1_65) AT=900.025n

* CHECK dout1_66 Vdout1_66ck179 = 0.9 time = 900
.meas tran vdout1_66ck179 FIND v(dout1_66) AT=900.025n

* CHECK dout1_67 Vdout1_67ck179 = 0.9 time = 900
.meas tran vdout1_67ck179 FIND v(dout1_67) AT=900.025n

* CHECK dout1_68 Vdout1_68ck179 = 0.9 time = 900
.meas tran vdout1_68ck179 FIND v(dout1_68) AT=900.025n

* CHECK dout1_69 Vdout1_69ck179 = 0.9 time = 900
.meas tran vdout1_69ck179 FIND v(dout1_69) AT=900.025n

* CHECK dout1_70 Vdout1_70ck179 = 0.9 time = 900
.meas tran vdout1_70ck179 FIND v(dout1_70) AT=900.025n

* CHECK dout1_71 Vdout1_71ck179 = 0.9 time = 900
.meas tran vdout1_71ck179 FIND v(dout1_71) AT=900.025n

* CHECK dout1_72 Vdout1_72ck179 = 0.9 time = 900
.meas tran vdout1_72ck179 FIND v(dout1_72) AT=900.025n

* CHECK dout1_73 Vdout1_73ck179 = 0 time = 900
.meas tran vdout1_73ck179 FIND v(dout1_73) AT=900.025n

* CHECK dout1_74 Vdout1_74ck179 = 0.9 time = 900
.meas tran vdout1_74ck179 FIND v(dout1_74) AT=900.025n

* CHECK dout1_75 Vdout1_75ck179 = 0.9 time = 900
.meas tran vdout1_75ck179 FIND v(dout1_75) AT=900.025n

* CHECK dout1_76 Vdout1_76ck179 = 0 time = 900
.meas tran vdout1_76ck179 FIND v(dout1_76) AT=900.025n

* CHECK dout1_77 Vdout1_77ck179 = 0 time = 900
.meas tran vdout1_77ck179 FIND v(dout1_77) AT=900.025n

* CHECK dout1_78 Vdout1_78ck179 = 0 time = 900
.meas tran vdout1_78ck179 FIND v(dout1_78) AT=900.025n

* CHECK dout1_79 Vdout1_79ck179 = 0.9 time = 900
.meas tran vdout1_79ck179 FIND v(dout1_79) AT=900.025n

* CHECK dout1_80 Vdout1_80ck179 = 0 time = 900
.meas tran vdout1_80ck179 FIND v(dout1_80) AT=900.025n

* CHECK dout1_81 Vdout1_81ck179 = 0.9 time = 900
.meas tran vdout1_81ck179 FIND v(dout1_81) AT=900.025n

* CHECK dout1_82 Vdout1_82ck179 = 0.9 time = 900
.meas tran vdout1_82ck179 FIND v(dout1_82) AT=900.025n

* CHECK dout1_83 Vdout1_83ck179 = 0 time = 900
.meas tran vdout1_83ck179 FIND v(dout1_83) AT=900.025n

* CHECK dout1_84 Vdout1_84ck179 = 0.9 time = 900
.meas tran vdout1_84ck179 FIND v(dout1_84) AT=900.025n

* CHECK dout1_85 Vdout1_85ck179 = 0 time = 900
.meas tran vdout1_85ck179 FIND v(dout1_85) AT=900.025n

* CHECK dout1_86 Vdout1_86ck179 = 0 time = 900
.meas tran vdout1_86ck179 FIND v(dout1_86) AT=900.025n

* CHECK dout1_87 Vdout1_87ck179 = 0.9 time = 900
.meas tran vdout1_87ck179 FIND v(dout1_87) AT=900.025n

* CHECK dout1_88 Vdout1_88ck179 = 0.9 time = 900
.meas tran vdout1_88ck179 FIND v(dout1_88) AT=900.025n

* CHECK dout1_89 Vdout1_89ck179 = 0.9 time = 900
.meas tran vdout1_89ck179 FIND v(dout1_89) AT=900.025n

* CHECK dout1_90 Vdout1_90ck179 = 0.9 time = 900
.meas tran vdout1_90ck179 FIND v(dout1_90) AT=900.025n

* CHECK dout1_91 Vdout1_91ck179 = 0 time = 900
.meas tran vdout1_91ck179 FIND v(dout1_91) AT=900.025n

* CHECK dout1_92 Vdout1_92ck179 = 0 time = 900
.meas tran vdout1_92ck179 FIND v(dout1_92) AT=900.025n

* CHECK dout1_93 Vdout1_93ck179 = 0.9 time = 900
.meas tran vdout1_93ck179 FIND v(dout1_93) AT=900.025n

* CHECK dout1_94 Vdout1_94ck179 = 0.9 time = 900
.meas tran vdout1_94ck179 FIND v(dout1_94) AT=900.025n

* CHECK dout1_95 Vdout1_95ck179 = 0.9 time = 900
.meas tran vdout1_95ck179 FIND v(dout1_95) AT=900.025n

* CHECK dout1_96 Vdout1_96ck179 = 0.9 time = 900
.meas tran vdout1_96ck179 FIND v(dout1_96) AT=900.025n

* CHECK dout1_97 Vdout1_97ck179 = 0.9 time = 900
.meas tran vdout1_97ck179 FIND v(dout1_97) AT=900.025n

* CHECK dout1_98 Vdout1_98ck179 = 0 time = 900
.meas tran vdout1_98ck179 FIND v(dout1_98) AT=900.025n

* CHECK dout1_99 Vdout1_99ck179 = 0 time = 900
.meas tran vdout1_99ck179 FIND v(dout1_99) AT=900.025n

* CHECK dout1_100 Vdout1_100ck179 = 0 time = 900
.meas tran vdout1_100ck179 FIND v(dout1_100) AT=900.025n

* CHECK dout1_101 Vdout1_101ck179 = 0 time = 900
.meas tran vdout1_101ck179 FIND v(dout1_101) AT=900.025n

* CHECK dout1_102 Vdout1_102ck179 = 0 time = 900
.meas tran vdout1_102ck179 FIND v(dout1_102) AT=900.025n

* CHECK dout1_103 Vdout1_103ck179 = 0 time = 900
.meas tran vdout1_103ck179 FIND v(dout1_103) AT=900.025n

* CHECK dout1_104 Vdout1_104ck179 = 0 time = 900
.meas tran vdout1_104ck179 FIND v(dout1_104) AT=900.025n

* CHECK dout1_105 Vdout1_105ck179 = 0.9 time = 900
.meas tran vdout1_105ck179 FIND v(dout1_105) AT=900.025n

* CHECK dout1_106 Vdout1_106ck179 = 0.9 time = 900
.meas tran vdout1_106ck179 FIND v(dout1_106) AT=900.025n

* CHECK dout1_107 Vdout1_107ck179 = 0.9 time = 900
.meas tran vdout1_107ck179 FIND v(dout1_107) AT=900.025n

* CHECK dout1_108 Vdout1_108ck179 = 0.9 time = 900
.meas tran vdout1_108ck179 FIND v(dout1_108) AT=900.025n

* CHECK dout1_109 Vdout1_109ck179 = 0 time = 900
.meas tran vdout1_109ck179 FIND v(dout1_109) AT=900.025n

* CHECK dout1_110 Vdout1_110ck179 = 0 time = 900
.meas tran vdout1_110ck179 FIND v(dout1_110) AT=900.025n

* CHECK dout1_111 Vdout1_111ck179 = 0 time = 900
.meas tran vdout1_111ck179 FIND v(dout1_111) AT=900.025n

* CHECK dout1_112 Vdout1_112ck179 = 0.9 time = 900
.meas tran vdout1_112ck179 FIND v(dout1_112) AT=900.025n

* CHECK dout1_113 Vdout1_113ck179 = 0.9 time = 900
.meas tran vdout1_113ck179 FIND v(dout1_113) AT=900.025n

* CHECK dout1_114 Vdout1_114ck179 = 0.9 time = 900
.meas tran vdout1_114ck179 FIND v(dout1_114) AT=900.025n

* CHECK dout1_115 Vdout1_115ck179 = 0 time = 900
.meas tran vdout1_115ck179 FIND v(dout1_115) AT=900.025n

* CHECK dout1_116 Vdout1_116ck179 = 0 time = 900
.meas tran vdout1_116ck179 FIND v(dout1_116) AT=900.025n

* CHECK dout1_117 Vdout1_117ck179 = 0.9 time = 900
.meas tran vdout1_117ck179 FIND v(dout1_117) AT=900.025n

* CHECK dout1_118 Vdout1_118ck179 = 0 time = 900
.meas tran vdout1_118ck179 FIND v(dout1_118) AT=900.025n

* CHECK dout1_119 Vdout1_119ck179 = 0.9 time = 900
.meas tran vdout1_119ck179 FIND v(dout1_119) AT=900.025n

* CHECK dout1_0 Vdout1_0ck180 = 0.9 time = 905
.meas tran vdout1_0ck180 FIND v(dout1_0) AT=905.025n

* CHECK dout1_1 Vdout1_1ck180 = 0 time = 905
.meas tran vdout1_1ck180 FIND v(dout1_1) AT=905.025n

* CHECK dout1_2 Vdout1_2ck180 = 0 time = 905
.meas tran vdout1_2ck180 FIND v(dout1_2) AT=905.025n

* CHECK dout1_3 Vdout1_3ck180 = 0 time = 905
.meas tran vdout1_3ck180 FIND v(dout1_3) AT=905.025n

* CHECK dout1_4 Vdout1_4ck180 = 0 time = 905
.meas tran vdout1_4ck180 FIND v(dout1_4) AT=905.025n

* CHECK dout1_5 Vdout1_5ck180 = 0 time = 905
.meas tran vdout1_5ck180 FIND v(dout1_5) AT=905.025n

* CHECK dout1_6 Vdout1_6ck180 = 0 time = 905
.meas tran vdout1_6ck180 FIND v(dout1_6) AT=905.025n

* CHECK dout1_7 Vdout1_7ck180 = 0 time = 905
.meas tran vdout1_7ck180 FIND v(dout1_7) AT=905.025n

* CHECK dout1_8 Vdout1_8ck180 = 0 time = 905
.meas tran vdout1_8ck180 FIND v(dout1_8) AT=905.025n

* CHECK dout1_9 Vdout1_9ck180 = 0.9 time = 905
.meas tran vdout1_9ck180 FIND v(dout1_9) AT=905.025n

* CHECK dout1_10 Vdout1_10ck180 = 0.9 time = 905
.meas tran vdout1_10ck180 FIND v(dout1_10) AT=905.025n

* CHECK dout1_11 Vdout1_11ck180 = 0.9 time = 905
.meas tran vdout1_11ck180 FIND v(dout1_11) AT=905.025n

* CHECK dout1_12 Vdout1_12ck180 = 0.9 time = 905
.meas tran vdout1_12ck180 FIND v(dout1_12) AT=905.025n

* CHECK dout1_13 Vdout1_13ck180 = 0.9 time = 905
.meas tran vdout1_13ck180 FIND v(dout1_13) AT=905.025n

* CHECK dout1_14 Vdout1_14ck180 = 0 time = 905
.meas tran vdout1_14ck180 FIND v(dout1_14) AT=905.025n

* CHECK dout1_15 Vdout1_15ck180 = 0.9 time = 905
.meas tran vdout1_15ck180 FIND v(dout1_15) AT=905.025n

* CHECK dout1_16 Vdout1_16ck180 = 0.9 time = 905
.meas tran vdout1_16ck180 FIND v(dout1_16) AT=905.025n

* CHECK dout1_17 Vdout1_17ck180 = 0 time = 905
.meas tran vdout1_17ck180 FIND v(dout1_17) AT=905.025n

* CHECK dout1_18 Vdout1_18ck180 = 0.9 time = 905
.meas tran vdout1_18ck180 FIND v(dout1_18) AT=905.025n

* CHECK dout1_19 Vdout1_19ck180 = 0.9 time = 905
.meas tran vdout1_19ck180 FIND v(dout1_19) AT=905.025n

* CHECK dout1_20 Vdout1_20ck180 = 0.9 time = 905
.meas tran vdout1_20ck180 FIND v(dout1_20) AT=905.025n

* CHECK dout1_21 Vdout1_21ck180 = 0.9 time = 905
.meas tran vdout1_21ck180 FIND v(dout1_21) AT=905.025n

* CHECK dout1_22 Vdout1_22ck180 = 0 time = 905
.meas tran vdout1_22ck180 FIND v(dout1_22) AT=905.025n

* CHECK dout1_23 Vdout1_23ck180 = 0.9 time = 905
.meas tran vdout1_23ck180 FIND v(dout1_23) AT=905.025n

* CHECK dout1_24 Vdout1_24ck180 = 0 time = 905
.meas tran vdout1_24ck180 FIND v(dout1_24) AT=905.025n

* CHECK dout1_25 Vdout1_25ck180 = 0 time = 905
.meas tran vdout1_25ck180 FIND v(dout1_25) AT=905.025n

* CHECK dout1_26 Vdout1_26ck180 = 0.9 time = 905
.meas tran vdout1_26ck180 FIND v(dout1_26) AT=905.025n

* CHECK dout1_27 Vdout1_27ck180 = 0.9 time = 905
.meas tran vdout1_27ck180 FIND v(dout1_27) AT=905.025n

* CHECK dout1_28 Vdout1_28ck180 = 0 time = 905
.meas tran vdout1_28ck180 FIND v(dout1_28) AT=905.025n

* CHECK dout1_29 Vdout1_29ck180 = 0 time = 905
.meas tran vdout1_29ck180 FIND v(dout1_29) AT=905.025n

* CHECK dout1_30 Vdout1_30ck180 = 0.9 time = 905
.meas tran vdout1_30ck180 FIND v(dout1_30) AT=905.025n

* CHECK dout1_31 Vdout1_31ck180 = 0.9 time = 905
.meas tran vdout1_31ck180 FIND v(dout1_31) AT=905.025n

* CHECK dout1_32 Vdout1_32ck180 = 0 time = 905
.meas tran vdout1_32ck180 FIND v(dout1_32) AT=905.025n

* CHECK dout1_33 Vdout1_33ck180 = 0 time = 905
.meas tran vdout1_33ck180 FIND v(dout1_33) AT=905.025n

* CHECK dout1_34 Vdout1_34ck180 = 0 time = 905
.meas tran vdout1_34ck180 FIND v(dout1_34) AT=905.025n

* CHECK dout1_35 Vdout1_35ck180 = 0.9 time = 905
.meas tran vdout1_35ck180 FIND v(dout1_35) AT=905.025n

* CHECK dout1_36 Vdout1_36ck180 = 0.9 time = 905
.meas tran vdout1_36ck180 FIND v(dout1_36) AT=905.025n

* CHECK dout1_37 Vdout1_37ck180 = 0 time = 905
.meas tran vdout1_37ck180 FIND v(dout1_37) AT=905.025n

* CHECK dout1_38 Vdout1_38ck180 = 0 time = 905
.meas tran vdout1_38ck180 FIND v(dout1_38) AT=905.025n

* CHECK dout1_39 Vdout1_39ck180 = 0.9 time = 905
.meas tran vdout1_39ck180 FIND v(dout1_39) AT=905.025n

* CHECK dout1_40 Vdout1_40ck180 = 0.9 time = 905
.meas tran vdout1_40ck180 FIND v(dout1_40) AT=905.025n

* CHECK dout1_41 Vdout1_41ck180 = 0.9 time = 905
.meas tran vdout1_41ck180 FIND v(dout1_41) AT=905.025n

* CHECK dout1_42 Vdout1_42ck180 = 0.9 time = 905
.meas tran vdout1_42ck180 FIND v(dout1_42) AT=905.025n

* CHECK dout1_43 Vdout1_43ck180 = 0 time = 905
.meas tran vdout1_43ck180 FIND v(dout1_43) AT=905.025n

* CHECK dout1_44 Vdout1_44ck180 = 0 time = 905
.meas tran vdout1_44ck180 FIND v(dout1_44) AT=905.025n

* CHECK dout1_45 Vdout1_45ck180 = 0 time = 905
.meas tran vdout1_45ck180 FIND v(dout1_45) AT=905.025n

* CHECK dout1_46 Vdout1_46ck180 = 0.9 time = 905
.meas tran vdout1_46ck180 FIND v(dout1_46) AT=905.025n

* CHECK dout1_47 Vdout1_47ck180 = 0.9 time = 905
.meas tran vdout1_47ck180 FIND v(dout1_47) AT=905.025n

* CHECK dout1_48 Vdout1_48ck180 = 0.9 time = 905
.meas tran vdout1_48ck180 FIND v(dout1_48) AT=905.025n

* CHECK dout1_49 Vdout1_49ck180 = 0.9 time = 905
.meas tran vdout1_49ck180 FIND v(dout1_49) AT=905.025n

* CHECK dout1_50 Vdout1_50ck180 = 0 time = 905
.meas tran vdout1_50ck180 FIND v(dout1_50) AT=905.025n

* CHECK dout1_51 Vdout1_51ck180 = 0.9 time = 905
.meas tran vdout1_51ck180 FIND v(dout1_51) AT=905.025n

* CHECK dout1_52 Vdout1_52ck180 = 0 time = 905
.meas tran vdout1_52ck180 FIND v(dout1_52) AT=905.025n

* CHECK dout1_53 Vdout1_53ck180 = 0 time = 905
.meas tran vdout1_53ck180 FIND v(dout1_53) AT=905.025n

* CHECK dout1_54 Vdout1_54ck180 = 0 time = 905
.meas tran vdout1_54ck180 FIND v(dout1_54) AT=905.025n

* CHECK dout1_55 Vdout1_55ck180 = 0.9 time = 905
.meas tran vdout1_55ck180 FIND v(dout1_55) AT=905.025n

* CHECK dout1_56 Vdout1_56ck180 = 0 time = 905
.meas tran vdout1_56ck180 FIND v(dout1_56) AT=905.025n

* CHECK dout1_57 Vdout1_57ck180 = 0 time = 905
.meas tran vdout1_57ck180 FIND v(dout1_57) AT=905.025n

* CHECK dout1_58 Vdout1_58ck180 = 0 time = 905
.meas tran vdout1_58ck180 FIND v(dout1_58) AT=905.025n

* CHECK dout1_59 Vdout1_59ck180 = 0 time = 905
.meas tran vdout1_59ck180 FIND v(dout1_59) AT=905.025n

* CHECK dout1_60 Vdout1_60ck180 = 0.9 time = 905
.meas tran vdout1_60ck180 FIND v(dout1_60) AT=905.025n

* CHECK dout1_61 Vdout1_61ck180 = 0.9 time = 905
.meas tran vdout1_61ck180 FIND v(dout1_61) AT=905.025n

* CHECK dout1_62 Vdout1_62ck180 = 0 time = 905
.meas tran vdout1_62ck180 FIND v(dout1_62) AT=905.025n

* CHECK dout1_63 Vdout1_63ck180 = 0.9 time = 905
.meas tran vdout1_63ck180 FIND v(dout1_63) AT=905.025n

* CHECK dout1_64 Vdout1_64ck180 = 0 time = 905
.meas tran vdout1_64ck180 FIND v(dout1_64) AT=905.025n

* CHECK dout1_65 Vdout1_65ck180 = 0 time = 905
.meas tran vdout1_65ck180 FIND v(dout1_65) AT=905.025n

* CHECK dout1_66 Vdout1_66ck180 = 0.9 time = 905
.meas tran vdout1_66ck180 FIND v(dout1_66) AT=905.025n

* CHECK dout1_67 Vdout1_67ck180 = 0 time = 905
.meas tran vdout1_67ck180 FIND v(dout1_67) AT=905.025n

* CHECK dout1_68 Vdout1_68ck180 = 0 time = 905
.meas tran vdout1_68ck180 FIND v(dout1_68) AT=905.025n

* CHECK dout1_69 Vdout1_69ck180 = 0.9 time = 905
.meas tran vdout1_69ck180 FIND v(dout1_69) AT=905.025n

* CHECK dout1_70 Vdout1_70ck180 = 0.9 time = 905
.meas tran vdout1_70ck180 FIND v(dout1_70) AT=905.025n

* CHECK dout1_71 Vdout1_71ck180 = 0 time = 905
.meas tran vdout1_71ck180 FIND v(dout1_71) AT=905.025n

* CHECK dout1_72 Vdout1_72ck180 = 0.9 time = 905
.meas tran vdout1_72ck180 FIND v(dout1_72) AT=905.025n

* CHECK dout1_73 Vdout1_73ck180 = 0.9 time = 905
.meas tran vdout1_73ck180 FIND v(dout1_73) AT=905.025n

* CHECK dout1_74 Vdout1_74ck180 = 0.9 time = 905
.meas tran vdout1_74ck180 FIND v(dout1_74) AT=905.025n

* CHECK dout1_75 Vdout1_75ck180 = 0.9 time = 905
.meas tran vdout1_75ck180 FIND v(dout1_75) AT=905.025n

* CHECK dout1_76 Vdout1_76ck180 = 0.9 time = 905
.meas tran vdout1_76ck180 FIND v(dout1_76) AT=905.025n

* CHECK dout1_77 Vdout1_77ck180 = 0.9 time = 905
.meas tran vdout1_77ck180 FIND v(dout1_77) AT=905.025n

* CHECK dout1_78 Vdout1_78ck180 = 0 time = 905
.meas tran vdout1_78ck180 FIND v(dout1_78) AT=905.025n

* CHECK dout1_79 Vdout1_79ck180 = 0 time = 905
.meas tran vdout1_79ck180 FIND v(dout1_79) AT=905.025n

* CHECK dout1_80 Vdout1_80ck180 = 0 time = 905
.meas tran vdout1_80ck180 FIND v(dout1_80) AT=905.025n

* CHECK dout1_81 Vdout1_81ck180 = 0.9 time = 905
.meas tran vdout1_81ck180 FIND v(dout1_81) AT=905.025n

* CHECK dout1_82 Vdout1_82ck180 = 0 time = 905
.meas tran vdout1_82ck180 FIND v(dout1_82) AT=905.025n

* CHECK dout1_83 Vdout1_83ck180 = 0.9 time = 905
.meas tran vdout1_83ck180 FIND v(dout1_83) AT=905.025n

* CHECK dout1_84 Vdout1_84ck180 = 0 time = 905
.meas tran vdout1_84ck180 FIND v(dout1_84) AT=905.025n

* CHECK dout1_85 Vdout1_85ck180 = 0 time = 905
.meas tran vdout1_85ck180 FIND v(dout1_85) AT=905.025n

* CHECK dout1_86 Vdout1_86ck180 = 0.9 time = 905
.meas tran vdout1_86ck180 FIND v(dout1_86) AT=905.025n

* CHECK dout1_87 Vdout1_87ck180 = 0 time = 905
.meas tran vdout1_87ck180 FIND v(dout1_87) AT=905.025n

* CHECK dout1_88 Vdout1_88ck180 = 0 time = 905
.meas tran vdout1_88ck180 FIND v(dout1_88) AT=905.025n

* CHECK dout1_89 Vdout1_89ck180 = 0 time = 905
.meas tran vdout1_89ck180 FIND v(dout1_89) AT=905.025n

* CHECK dout1_90 Vdout1_90ck180 = 0 time = 905
.meas tran vdout1_90ck180 FIND v(dout1_90) AT=905.025n

* CHECK dout1_91 Vdout1_91ck180 = 0 time = 905
.meas tran vdout1_91ck180 FIND v(dout1_91) AT=905.025n

* CHECK dout1_92 Vdout1_92ck180 = 0.9 time = 905
.meas tran vdout1_92ck180 FIND v(dout1_92) AT=905.025n

* CHECK dout1_93 Vdout1_93ck180 = 0.9 time = 905
.meas tran vdout1_93ck180 FIND v(dout1_93) AT=905.025n

* CHECK dout1_94 Vdout1_94ck180 = 0 time = 905
.meas tran vdout1_94ck180 FIND v(dout1_94) AT=905.025n

* CHECK dout1_95 Vdout1_95ck180 = 0.9 time = 905
.meas tran vdout1_95ck180 FIND v(dout1_95) AT=905.025n

* CHECK dout1_96 Vdout1_96ck180 = 0 time = 905
.meas tran vdout1_96ck180 FIND v(dout1_96) AT=905.025n

* CHECK dout1_97 Vdout1_97ck180 = 0 time = 905
.meas tran vdout1_97ck180 FIND v(dout1_97) AT=905.025n

* CHECK dout1_98 Vdout1_98ck180 = 0.9 time = 905
.meas tran vdout1_98ck180 FIND v(dout1_98) AT=905.025n

* CHECK dout1_99 Vdout1_99ck180 = 0.9 time = 905
.meas tran vdout1_99ck180 FIND v(dout1_99) AT=905.025n

* CHECK dout1_100 Vdout1_100ck180 = 0 time = 905
.meas tran vdout1_100ck180 FIND v(dout1_100) AT=905.025n

* CHECK dout1_101 Vdout1_101ck180 = 0.9 time = 905
.meas tran vdout1_101ck180 FIND v(dout1_101) AT=905.025n

* CHECK dout1_102 Vdout1_102ck180 = 0 time = 905
.meas tran vdout1_102ck180 FIND v(dout1_102) AT=905.025n

* CHECK dout1_103 Vdout1_103ck180 = 0 time = 905
.meas tran vdout1_103ck180 FIND v(dout1_103) AT=905.025n

* CHECK dout1_104 Vdout1_104ck180 = 0.9 time = 905
.meas tran vdout1_104ck180 FIND v(dout1_104) AT=905.025n

* CHECK dout1_105 Vdout1_105ck180 = 0 time = 905
.meas tran vdout1_105ck180 FIND v(dout1_105) AT=905.025n

* CHECK dout1_106 Vdout1_106ck180 = 0 time = 905
.meas tran vdout1_106ck180 FIND v(dout1_106) AT=905.025n

* CHECK dout1_107 Vdout1_107ck180 = 0.9 time = 905
.meas tran vdout1_107ck180 FIND v(dout1_107) AT=905.025n

* CHECK dout1_108 Vdout1_108ck180 = 0 time = 905
.meas tran vdout1_108ck180 FIND v(dout1_108) AT=905.025n

* CHECK dout1_109 Vdout1_109ck180 = 0 time = 905
.meas tran vdout1_109ck180 FIND v(dout1_109) AT=905.025n

* CHECK dout1_110 Vdout1_110ck180 = 0.9 time = 905
.meas tran vdout1_110ck180 FIND v(dout1_110) AT=905.025n

* CHECK dout1_111 Vdout1_111ck180 = 0.9 time = 905
.meas tran vdout1_111ck180 FIND v(dout1_111) AT=905.025n

* CHECK dout1_112 Vdout1_112ck180 = 0 time = 905
.meas tran vdout1_112ck180 FIND v(dout1_112) AT=905.025n

* CHECK dout1_113 Vdout1_113ck180 = 0.9 time = 905
.meas tran vdout1_113ck180 FIND v(dout1_113) AT=905.025n

* CHECK dout1_114 Vdout1_114ck180 = 0.9 time = 905
.meas tran vdout1_114ck180 FIND v(dout1_114) AT=905.025n

* CHECK dout1_115 Vdout1_115ck180 = 0 time = 905
.meas tran vdout1_115ck180 FIND v(dout1_115) AT=905.025n

* CHECK dout1_116 Vdout1_116ck180 = 0 time = 905
.meas tran vdout1_116ck180 FIND v(dout1_116) AT=905.025n

* CHECK dout1_117 Vdout1_117ck180 = 0.9 time = 905
.meas tran vdout1_117ck180 FIND v(dout1_117) AT=905.025n

* CHECK dout1_118 Vdout1_118ck180 = 0.9 time = 905
.meas tran vdout1_118ck180 FIND v(dout1_118) AT=905.025n

* CHECK dout1_119 Vdout1_119ck180 = 0.9 time = 905
.meas tran vdout1_119ck180 FIND v(dout1_119) AT=905.025n

* CHECK dout1_0 Vdout1_0ck181 = 0 time = 910
.meas tran vdout1_0ck181 FIND v(dout1_0) AT=910.025n

* CHECK dout1_1 Vdout1_1ck181 = 0.9 time = 910
.meas tran vdout1_1ck181 FIND v(dout1_1) AT=910.025n

* CHECK dout1_2 Vdout1_2ck181 = 0.9 time = 910
.meas tran vdout1_2ck181 FIND v(dout1_2) AT=910.025n

* CHECK dout1_3 Vdout1_3ck181 = 0.9 time = 910
.meas tran vdout1_3ck181 FIND v(dout1_3) AT=910.025n

* CHECK dout1_4 Vdout1_4ck181 = 0.9 time = 910
.meas tran vdout1_4ck181 FIND v(dout1_4) AT=910.025n

* CHECK dout1_5 Vdout1_5ck181 = 0 time = 910
.meas tran vdout1_5ck181 FIND v(dout1_5) AT=910.025n

* CHECK dout1_6 Vdout1_6ck181 = 0.9 time = 910
.meas tran vdout1_6ck181 FIND v(dout1_6) AT=910.025n

* CHECK dout1_7 Vdout1_7ck181 = 0.9 time = 910
.meas tran vdout1_7ck181 FIND v(dout1_7) AT=910.025n

* CHECK dout1_8 Vdout1_8ck181 = 0.9 time = 910
.meas tran vdout1_8ck181 FIND v(dout1_8) AT=910.025n

* CHECK dout1_9 Vdout1_9ck181 = 0.9 time = 910
.meas tran vdout1_9ck181 FIND v(dout1_9) AT=910.025n

* CHECK dout1_10 Vdout1_10ck181 = 0.9 time = 910
.meas tran vdout1_10ck181 FIND v(dout1_10) AT=910.025n

* CHECK dout1_11 Vdout1_11ck181 = 0 time = 910
.meas tran vdout1_11ck181 FIND v(dout1_11) AT=910.025n

* CHECK dout1_12 Vdout1_12ck181 = 0.9 time = 910
.meas tran vdout1_12ck181 FIND v(dout1_12) AT=910.025n

* CHECK dout1_13 Vdout1_13ck181 = 0.9 time = 910
.meas tran vdout1_13ck181 FIND v(dout1_13) AT=910.025n

* CHECK dout1_14 Vdout1_14ck181 = 0.9 time = 910
.meas tran vdout1_14ck181 FIND v(dout1_14) AT=910.025n

* CHECK dout1_15 Vdout1_15ck181 = 0 time = 910
.meas tran vdout1_15ck181 FIND v(dout1_15) AT=910.025n

* CHECK dout1_16 Vdout1_16ck181 = 0 time = 910
.meas tran vdout1_16ck181 FIND v(dout1_16) AT=910.025n

* CHECK dout1_17 Vdout1_17ck181 = 0 time = 910
.meas tran vdout1_17ck181 FIND v(dout1_17) AT=910.025n

* CHECK dout1_18 Vdout1_18ck181 = 0.9 time = 910
.meas tran vdout1_18ck181 FIND v(dout1_18) AT=910.025n

* CHECK dout1_19 Vdout1_19ck181 = 0.9 time = 910
.meas tran vdout1_19ck181 FIND v(dout1_19) AT=910.025n

* CHECK dout1_20 Vdout1_20ck181 = 0.9 time = 910
.meas tran vdout1_20ck181 FIND v(dout1_20) AT=910.025n

* CHECK dout1_21 Vdout1_21ck181 = 0.9 time = 910
.meas tran vdout1_21ck181 FIND v(dout1_21) AT=910.025n

* CHECK dout1_22 Vdout1_22ck181 = 0.9 time = 910
.meas tran vdout1_22ck181 FIND v(dout1_22) AT=910.025n

* CHECK dout1_23 Vdout1_23ck181 = 0 time = 910
.meas tran vdout1_23ck181 FIND v(dout1_23) AT=910.025n

* CHECK dout1_24 Vdout1_24ck181 = 0 time = 910
.meas tran vdout1_24ck181 FIND v(dout1_24) AT=910.025n

* CHECK dout1_25 Vdout1_25ck181 = 0.9 time = 910
.meas tran vdout1_25ck181 FIND v(dout1_25) AT=910.025n

* CHECK dout1_26 Vdout1_26ck181 = 0 time = 910
.meas tran vdout1_26ck181 FIND v(dout1_26) AT=910.025n

* CHECK dout1_27 Vdout1_27ck181 = 0.9 time = 910
.meas tran vdout1_27ck181 FIND v(dout1_27) AT=910.025n

* CHECK dout1_28 Vdout1_28ck181 = 0 time = 910
.meas tran vdout1_28ck181 FIND v(dout1_28) AT=910.025n

* CHECK dout1_29 Vdout1_29ck181 = 0.9 time = 910
.meas tran vdout1_29ck181 FIND v(dout1_29) AT=910.025n

* CHECK dout1_30 Vdout1_30ck181 = 0.9 time = 910
.meas tran vdout1_30ck181 FIND v(dout1_30) AT=910.025n

* CHECK dout1_31 Vdout1_31ck181 = 0.9 time = 910
.meas tran vdout1_31ck181 FIND v(dout1_31) AT=910.025n

* CHECK dout1_32 Vdout1_32ck181 = 0 time = 910
.meas tran vdout1_32ck181 FIND v(dout1_32) AT=910.025n

* CHECK dout1_33 Vdout1_33ck181 = 0.9 time = 910
.meas tran vdout1_33ck181 FIND v(dout1_33) AT=910.025n

* CHECK dout1_34 Vdout1_34ck181 = 0 time = 910
.meas tran vdout1_34ck181 FIND v(dout1_34) AT=910.025n

* CHECK dout1_35 Vdout1_35ck181 = 0.9 time = 910
.meas tran vdout1_35ck181 FIND v(dout1_35) AT=910.025n

* CHECK dout1_36 Vdout1_36ck181 = 0.9 time = 910
.meas tran vdout1_36ck181 FIND v(dout1_36) AT=910.025n

* CHECK dout1_37 Vdout1_37ck181 = 0 time = 910
.meas tran vdout1_37ck181 FIND v(dout1_37) AT=910.025n

* CHECK dout1_38 Vdout1_38ck181 = 0.9 time = 910
.meas tran vdout1_38ck181 FIND v(dout1_38) AT=910.025n

* CHECK dout1_39 Vdout1_39ck181 = 0 time = 910
.meas tran vdout1_39ck181 FIND v(dout1_39) AT=910.025n

* CHECK dout1_40 Vdout1_40ck181 = 0.9 time = 910
.meas tran vdout1_40ck181 FIND v(dout1_40) AT=910.025n

* CHECK dout1_41 Vdout1_41ck181 = 0 time = 910
.meas tran vdout1_41ck181 FIND v(dout1_41) AT=910.025n

* CHECK dout1_42 Vdout1_42ck181 = 0 time = 910
.meas tran vdout1_42ck181 FIND v(dout1_42) AT=910.025n

* CHECK dout1_43 Vdout1_43ck181 = 0.9 time = 910
.meas tran vdout1_43ck181 FIND v(dout1_43) AT=910.025n

* CHECK dout1_44 Vdout1_44ck181 = 0 time = 910
.meas tran vdout1_44ck181 FIND v(dout1_44) AT=910.025n

* CHECK dout1_45 Vdout1_45ck181 = 0 time = 910
.meas tran vdout1_45ck181 FIND v(dout1_45) AT=910.025n

* CHECK dout1_46 Vdout1_46ck181 = 0 time = 910
.meas tran vdout1_46ck181 FIND v(dout1_46) AT=910.025n

* CHECK dout1_47 Vdout1_47ck181 = 0.9 time = 910
.meas tran vdout1_47ck181 FIND v(dout1_47) AT=910.025n

* CHECK dout1_48 Vdout1_48ck181 = 0.9 time = 910
.meas tran vdout1_48ck181 FIND v(dout1_48) AT=910.025n

* CHECK dout1_49 Vdout1_49ck181 = 0 time = 910
.meas tran vdout1_49ck181 FIND v(dout1_49) AT=910.025n

* CHECK dout1_50 Vdout1_50ck181 = 0.9 time = 910
.meas tran vdout1_50ck181 FIND v(dout1_50) AT=910.025n

* CHECK dout1_51 Vdout1_51ck181 = 0 time = 910
.meas tran vdout1_51ck181 FIND v(dout1_51) AT=910.025n

* CHECK dout1_52 Vdout1_52ck181 = 0.9 time = 910
.meas tran vdout1_52ck181 FIND v(dout1_52) AT=910.025n

* CHECK dout1_53 Vdout1_53ck181 = 0.9 time = 910
.meas tran vdout1_53ck181 FIND v(dout1_53) AT=910.025n

* CHECK dout1_54 Vdout1_54ck181 = 0 time = 910
.meas tran vdout1_54ck181 FIND v(dout1_54) AT=910.025n

* CHECK dout1_55 Vdout1_55ck181 = 0.9 time = 910
.meas tran vdout1_55ck181 FIND v(dout1_55) AT=910.025n

* CHECK dout1_56 Vdout1_56ck181 = 0 time = 910
.meas tran vdout1_56ck181 FIND v(dout1_56) AT=910.025n

* CHECK dout1_57 Vdout1_57ck181 = 0 time = 910
.meas tran vdout1_57ck181 FIND v(dout1_57) AT=910.025n

* CHECK dout1_58 Vdout1_58ck181 = 0.9 time = 910
.meas tran vdout1_58ck181 FIND v(dout1_58) AT=910.025n

* CHECK dout1_59 Vdout1_59ck181 = 0.9 time = 910
.meas tran vdout1_59ck181 FIND v(dout1_59) AT=910.025n

* CHECK dout1_60 Vdout1_60ck181 = 0 time = 910
.meas tran vdout1_60ck181 FIND v(dout1_60) AT=910.025n

* CHECK dout1_61 Vdout1_61ck181 = 0 time = 910
.meas tran vdout1_61ck181 FIND v(dout1_61) AT=910.025n

* CHECK dout1_62 Vdout1_62ck181 = 0 time = 910
.meas tran vdout1_62ck181 FIND v(dout1_62) AT=910.025n

* CHECK dout1_63 Vdout1_63ck181 = 0 time = 910
.meas tran vdout1_63ck181 FIND v(dout1_63) AT=910.025n

* CHECK dout1_64 Vdout1_64ck181 = 0 time = 910
.meas tran vdout1_64ck181 FIND v(dout1_64) AT=910.025n

* CHECK dout1_65 Vdout1_65ck181 = 0.9 time = 910
.meas tran vdout1_65ck181 FIND v(dout1_65) AT=910.025n

* CHECK dout1_66 Vdout1_66ck181 = 0 time = 910
.meas tran vdout1_66ck181 FIND v(dout1_66) AT=910.025n

* CHECK dout1_67 Vdout1_67ck181 = 0.9 time = 910
.meas tran vdout1_67ck181 FIND v(dout1_67) AT=910.025n

* CHECK dout1_68 Vdout1_68ck181 = 0 time = 910
.meas tran vdout1_68ck181 FIND v(dout1_68) AT=910.025n

* CHECK dout1_69 Vdout1_69ck181 = 0 time = 910
.meas tran vdout1_69ck181 FIND v(dout1_69) AT=910.025n

* CHECK dout1_70 Vdout1_70ck181 = 0.9 time = 910
.meas tran vdout1_70ck181 FIND v(dout1_70) AT=910.025n

* CHECK dout1_71 Vdout1_71ck181 = 0.9 time = 910
.meas tran vdout1_71ck181 FIND v(dout1_71) AT=910.025n

* CHECK dout1_72 Vdout1_72ck181 = 0 time = 910
.meas tran vdout1_72ck181 FIND v(dout1_72) AT=910.025n

* CHECK dout1_73 Vdout1_73ck181 = 0 time = 910
.meas tran vdout1_73ck181 FIND v(dout1_73) AT=910.025n

* CHECK dout1_74 Vdout1_74ck181 = 0.9 time = 910
.meas tran vdout1_74ck181 FIND v(dout1_74) AT=910.025n

* CHECK dout1_75 Vdout1_75ck181 = 0 time = 910
.meas tran vdout1_75ck181 FIND v(dout1_75) AT=910.025n

* CHECK dout1_76 Vdout1_76ck181 = 0 time = 910
.meas tran vdout1_76ck181 FIND v(dout1_76) AT=910.025n

* CHECK dout1_77 Vdout1_77ck181 = 0.9 time = 910
.meas tran vdout1_77ck181 FIND v(dout1_77) AT=910.025n

* CHECK dout1_78 Vdout1_78ck181 = 0.9 time = 910
.meas tran vdout1_78ck181 FIND v(dout1_78) AT=910.025n

* CHECK dout1_79 Vdout1_79ck181 = 0 time = 910
.meas tran vdout1_79ck181 FIND v(dout1_79) AT=910.025n

* CHECK dout1_80 Vdout1_80ck181 = 0.9 time = 910
.meas tran vdout1_80ck181 FIND v(dout1_80) AT=910.025n

* CHECK dout1_81 Vdout1_81ck181 = 0 time = 910
.meas tran vdout1_81ck181 FIND v(dout1_81) AT=910.025n

* CHECK dout1_82 Vdout1_82ck181 = 0.9 time = 910
.meas tran vdout1_82ck181 FIND v(dout1_82) AT=910.025n

* CHECK dout1_83 Vdout1_83ck181 = 0 time = 910
.meas tran vdout1_83ck181 FIND v(dout1_83) AT=910.025n

* CHECK dout1_84 Vdout1_84ck181 = 0.9 time = 910
.meas tran vdout1_84ck181 FIND v(dout1_84) AT=910.025n

* CHECK dout1_85 Vdout1_85ck181 = 0.9 time = 910
.meas tran vdout1_85ck181 FIND v(dout1_85) AT=910.025n

* CHECK dout1_86 Vdout1_86ck181 = 0.9 time = 910
.meas tran vdout1_86ck181 FIND v(dout1_86) AT=910.025n

* CHECK dout1_87 Vdout1_87ck181 = 0 time = 910
.meas tran vdout1_87ck181 FIND v(dout1_87) AT=910.025n

* CHECK dout1_88 Vdout1_88ck181 = 0 time = 910
.meas tran vdout1_88ck181 FIND v(dout1_88) AT=910.025n

* CHECK dout1_89 Vdout1_89ck181 = 0 time = 910
.meas tran vdout1_89ck181 FIND v(dout1_89) AT=910.025n

* CHECK dout1_90 Vdout1_90ck181 = 0 time = 910
.meas tran vdout1_90ck181 FIND v(dout1_90) AT=910.025n

* CHECK dout1_91 Vdout1_91ck181 = 0.9 time = 910
.meas tran vdout1_91ck181 FIND v(dout1_91) AT=910.025n

* CHECK dout1_92 Vdout1_92ck181 = 0.9 time = 910
.meas tran vdout1_92ck181 FIND v(dout1_92) AT=910.025n

* CHECK dout1_93 Vdout1_93ck181 = 0.9 time = 910
.meas tran vdout1_93ck181 FIND v(dout1_93) AT=910.025n

* CHECK dout1_94 Vdout1_94ck181 = 0.9 time = 910
.meas tran vdout1_94ck181 FIND v(dout1_94) AT=910.025n

* CHECK dout1_95 Vdout1_95ck181 = 0.9 time = 910
.meas tran vdout1_95ck181 FIND v(dout1_95) AT=910.025n

* CHECK dout1_96 Vdout1_96ck181 = 0.9 time = 910
.meas tran vdout1_96ck181 FIND v(dout1_96) AT=910.025n

* CHECK dout1_97 Vdout1_97ck181 = 0.9 time = 910
.meas tran vdout1_97ck181 FIND v(dout1_97) AT=910.025n

* CHECK dout1_98 Vdout1_98ck181 = 0 time = 910
.meas tran vdout1_98ck181 FIND v(dout1_98) AT=910.025n

* CHECK dout1_99 Vdout1_99ck181 = 0 time = 910
.meas tran vdout1_99ck181 FIND v(dout1_99) AT=910.025n

* CHECK dout1_100 Vdout1_100ck181 = 0.9 time = 910
.meas tran vdout1_100ck181 FIND v(dout1_100) AT=910.025n

* CHECK dout1_101 Vdout1_101ck181 = 0 time = 910
.meas tran vdout1_101ck181 FIND v(dout1_101) AT=910.025n

* CHECK dout1_102 Vdout1_102ck181 = 0 time = 910
.meas tran vdout1_102ck181 FIND v(dout1_102) AT=910.025n

* CHECK dout1_103 Vdout1_103ck181 = 0.9 time = 910
.meas tran vdout1_103ck181 FIND v(dout1_103) AT=910.025n

* CHECK dout1_104 Vdout1_104ck181 = 0 time = 910
.meas tran vdout1_104ck181 FIND v(dout1_104) AT=910.025n

* CHECK dout1_105 Vdout1_105ck181 = 0 time = 910
.meas tran vdout1_105ck181 FIND v(dout1_105) AT=910.025n

* CHECK dout1_106 Vdout1_106ck181 = 0 time = 910
.meas tran vdout1_106ck181 FIND v(dout1_106) AT=910.025n

* CHECK dout1_107 Vdout1_107ck181 = 0 time = 910
.meas tran vdout1_107ck181 FIND v(dout1_107) AT=910.025n

* CHECK dout1_108 Vdout1_108ck181 = 0 time = 910
.meas tran vdout1_108ck181 FIND v(dout1_108) AT=910.025n

* CHECK dout1_109 Vdout1_109ck181 = 0.9 time = 910
.meas tran vdout1_109ck181 FIND v(dout1_109) AT=910.025n

* CHECK dout1_110 Vdout1_110ck181 = 0.9 time = 910
.meas tran vdout1_110ck181 FIND v(dout1_110) AT=910.025n

* CHECK dout1_111 Vdout1_111ck181 = 0 time = 910
.meas tran vdout1_111ck181 FIND v(dout1_111) AT=910.025n

* CHECK dout1_112 Vdout1_112ck181 = 0 time = 910
.meas tran vdout1_112ck181 FIND v(dout1_112) AT=910.025n

* CHECK dout1_113 Vdout1_113ck181 = 0.9 time = 910
.meas tran vdout1_113ck181 FIND v(dout1_113) AT=910.025n

* CHECK dout1_114 Vdout1_114ck181 = 0.9 time = 910
.meas tran vdout1_114ck181 FIND v(dout1_114) AT=910.025n

* CHECK dout1_115 Vdout1_115ck181 = 0.9 time = 910
.meas tran vdout1_115ck181 FIND v(dout1_115) AT=910.025n

* CHECK dout1_116 Vdout1_116ck181 = 0.9 time = 910
.meas tran vdout1_116ck181 FIND v(dout1_116) AT=910.025n

* CHECK dout1_117 Vdout1_117ck181 = 0.9 time = 910
.meas tran vdout1_117ck181 FIND v(dout1_117) AT=910.025n

* CHECK dout1_118 Vdout1_118ck181 = 0 time = 910
.meas tran vdout1_118ck181 FIND v(dout1_118) AT=910.025n

* CHECK dout1_119 Vdout1_119ck181 = 0 time = 910
.meas tran vdout1_119ck181 FIND v(dout1_119) AT=910.025n

* CHECK dout1_0 Vdout1_0ck182 = 0.9 time = 915
.meas tran vdout1_0ck182 FIND v(dout1_0) AT=915.025n

* CHECK dout1_1 Vdout1_1ck182 = 0 time = 915
.meas tran vdout1_1ck182 FIND v(dout1_1) AT=915.025n

* CHECK dout1_2 Vdout1_2ck182 = 0 time = 915
.meas tran vdout1_2ck182 FIND v(dout1_2) AT=915.025n

* CHECK dout1_3 Vdout1_3ck182 = 0 time = 915
.meas tran vdout1_3ck182 FIND v(dout1_3) AT=915.025n

* CHECK dout1_4 Vdout1_4ck182 = 0 time = 915
.meas tran vdout1_4ck182 FIND v(dout1_4) AT=915.025n

* CHECK dout1_5 Vdout1_5ck182 = 0 time = 915
.meas tran vdout1_5ck182 FIND v(dout1_5) AT=915.025n

* CHECK dout1_6 Vdout1_6ck182 = 0 time = 915
.meas tran vdout1_6ck182 FIND v(dout1_6) AT=915.025n

* CHECK dout1_7 Vdout1_7ck182 = 0 time = 915
.meas tran vdout1_7ck182 FIND v(dout1_7) AT=915.025n

* CHECK dout1_8 Vdout1_8ck182 = 0 time = 915
.meas tran vdout1_8ck182 FIND v(dout1_8) AT=915.025n

* CHECK dout1_9 Vdout1_9ck182 = 0.9 time = 915
.meas tran vdout1_9ck182 FIND v(dout1_9) AT=915.025n

* CHECK dout1_10 Vdout1_10ck182 = 0.9 time = 915
.meas tran vdout1_10ck182 FIND v(dout1_10) AT=915.025n

* CHECK dout1_11 Vdout1_11ck182 = 0.9 time = 915
.meas tran vdout1_11ck182 FIND v(dout1_11) AT=915.025n

* CHECK dout1_12 Vdout1_12ck182 = 0.9 time = 915
.meas tran vdout1_12ck182 FIND v(dout1_12) AT=915.025n

* CHECK dout1_13 Vdout1_13ck182 = 0.9 time = 915
.meas tran vdout1_13ck182 FIND v(dout1_13) AT=915.025n

* CHECK dout1_14 Vdout1_14ck182 = 0 time = 915
.meas tran vdout1_14ck182 FIND v(dout1_14) AT=915.025n

* CHECK dout1_15 Vdout1_15ck182 = 0.9 time = 915
.meas tran vdout1_15ck182 FIND v(dout1_15) AT=915.025n

* CHECK dout1_16 Vdout1_16ck182 = 0.9 time = 915
.meas tran vdout1_16ck182 FIND v(dout1_16) AT=915.025n

* CHECK dout1_17 Vdout1_17ck182 = 0 time = 915
.meas tran vdout1_17ck182 FIND v(dout1_17) AT=915.025n

* CHECK dout1_18 Vdout1_18ck182 = 0.9 time = 915
.meas tran vdout1_18ck182 FIND v(dout1_18) AT=915.025n

* CHECK dout1_19 Vdout1_19ck182 = 0.9 time = 915
.meas tran vdout1_19ck182 FIND v(dout1_19) AT=915.025n

* CHECK dout1_20 Vdout1_20ck182 = 0.9 time = 915
.meas tran vdout1_20ck182 FIND v(dout1_20) AT=915.025n

* CHECK dout1_21 Vdout1_21ck182 = 0.9 time = 915
.meas tran vdout1_21ck182 FIND v(dout1_21) AT=915.025n

* CHECK dout1_22 Vdout1_22ck182 = 0 time = 915
.meas tran vdout1_22ck182 FIND v(dout1_22) AT=915.025n

* CHECK dout1_23 Vdout1_23ck182 = 0.9 time = 915
.meas tran vdout1_23ck182 FIND v(dout1_23) AT=915.025n

* CHECK dout1_24 Vdout1_24ck182 = 0 time = 915
.meas tran vdout1_24ck182 FIND v(dout1_24) AT=915.025n

* CHECK dout1_25 Vdout1_25ck182 = 0 time = 915
.meas tran vdout1_25ck182 FIND v(dout1_25) AT=915.025n

* CHECK dout1_26 Vdout1_26ck182 = 0.9 time = 915
.meas tran vdout1_26ck182 FIND v(dout1_26) AT=915.025n

* CHECK dout1_27 Vdout1_27ck182 = 0.9 time = 915
.meas tran vdout1_27ck182 FIND v(dout1_27) AT=915.025n

* CHECK dout1_28 Vdout1_28ck182 = 0 time = 915
.meas tran vdout1_28ck182 FIND v(dout1_28) AT=915.025n

* CHECK dout1_29 Vdout1_29ck182 = 0 time = 915
.meas tran vdout1_29ck182 FIND v(dout1_29) AT=915.025n

* CHECK dout1_30 Vdout1_30ck182 = 0.9 time = 915
.meas tran vdout1_30ck182 FIND v(dout1_30) AT=915.025n

* CHECK dout1_31 Vdout1_31ck182 = 0.9 time = 915
.meas tran vdout1_31ck182 FIND v(dout1_31) AT=915.025n

* CHECK dout1_32 Vdout1_32ck182 = 0 time = 915
.meas tran vdout1_32ck182 FIND v(dout1_32) AT=915.025n

* CHECK dout1_33 Vdout1_33ck182 = 0 time = 915
.meas tran vdout1_33ck182 FIND v(dout1_33) AT=915.025n

* CHECK dout1_34 Vdout1_34ck182 = 0 time = 915
.meas tran vdout1_34ck182 FIND v(dout1_34) AT=915.025n

* CHECK dout1_35 Vdout1_35ck182 = 0.9 time = 915
.meas tran vdout1_35ck182 FIND v(dout1_35) AT=915.025n

* CHECK dout1_36 Vdout1_36ck182 = 0.9 time = 915
.meas tran vdout1_36ck182 FIND v(dout1_36) AT=915.025n

* CHECK dout1_37 Vdout1_37ck182 = 0 time = 915
.meas tran vdout1_37ck182 FIND v(dout1_37) AT=915.025n

* CHECK dout1_38 Vdout1_38ck182 = 0 time = 915
.meas tran vdout1_38ck182 FIND v(dout1_38) AT=915.025n

* CHECK dout1_39 Vdout1_39ck182 = 0.9 time = 915
.meas tran vdout1_39ck182 FIND v(dout1_39) AT=915.025n

* CHECK dout1_40 Vdout1_40ck182 = 0.9 time = 915
.meas tran vdout1_40ck182 FIND v(dout1_40) AT=915.025n

* CHECK dout1_41 Vdout1_41ck182 = 0.9 time = 915
.meas tran vdout1_41ck182 FIND v(dout1_41) AT=915.025n

* CHECK dout1_42 Vdout1_42ck182 = 0.9 time = 915
.meas tran vdout1_42ck182 FIND v(dout1_42) AT=915.025n

* CHECK dout1_43 Vdout1_43ck182 = 0 time = 915
.meas tran vdout1_43ck182 FIND v(dout1_43) AT=915.025n

* CHECK dout1_44 Vdout1_44ck182 = 0 time = 915
.meas tran vdout1_44ck182 FIND v(dout1_44) AT=915.025n

* CHECK dout1_45 Vdout1_45ck182 = 0 time = 915
.meas tran vdout1_45ck182 FIND v(dout1_45) AT=915.025n

* CHECK dout1_46 Vdout1_46ck182 = 0.9 time = 915
.meas tran vdout1_46ck182 FIND v(dout1_46) AT=915.025n

* CHECK dout1_47 Vdout1_47ck182 = 0.9 time = 915
.meas tran vdout1_47ck182 FIND v(dout1_47) AT=915.025n

* CHECK dout1_48 Vdout1_48ck182 = 0.9 time = 915
.meas tran vdout1_48ck182 FIND v(dout1_48) AT=915.025n

* CHECK dout1_49 Vdout1_49ck182 = 0.9 time = 915
.meas tran vdout1_49ck182 FIND v(dout1_49) AT=915.025n

* CHECK dout1_50 Vdout1_50ck182 = 0 time = 915
.meas tran vdout1_50ck182 FIND v(dout1_50) AT=915.025n

* CHECK dout1_51 Vdout1_51ck182 = 0.9 time = 915
.meas tran vdout1_51ck182 FIND v(dout1_51) AT=915.025n

* CHECK dout1_52 Vdout1_52ck182 = 0 time = 915
.meas tran vdout1_52ck182 FIND v(dout1_52) AT=915.025n

* CHECK dout1_53 Vdout1_53ck182 = 0 time = 915
.meas tran vdout1_53ck182 FIND v(dout1_53) AT=915.025n

* CHECK dout1_54 Vdout1_54ck182 = 0 time = 915
.meas tran vdout1_54ck182 FIND v(dout1_54) AT=915.025n

* CHECK dout1_55 Vdout1_55ck182 = 0.9 time = 915
.meas tran vdout1_55ck182 FIND v(dout1_55) AT=915.025n

* CHECK dout1_56 Vdout1_56ck182 = 0 time = 915
.meas tran vdout1_56ck182 FIND v(dout1_56) AT=915.025n

* CHECK dout1_57 Vdout1_57ck182 = 0 time = 915
.meas tran vdout1_57ck182 FIND v(dout1_57) AT=915.025n

* CHECK dout1_58 Vdout1_58ck182 = 0 time = 915
.meas tran vdout1_58ck182 FIND v(dout1_58) AT=915.025n

* CHECK dout1_59 Vdout1_59ck182 = 0 time = 915
.meas tran vdout1_59ck182 FIND v(dout1_59) AT=915.025n

* CHECK dout1_60 Vdout1_60ck182 = 0.9 time = 915
.meas tran vdout1_60ck182 FIND v(dout1_60) AT=915.025n

* CHECK dout1_61 Vdout1_61ck182 = 0.9 time = 915
.meas tran vdout1_61ck182 FIND v(dout1_61) AT=915.025n

* CHECK dout1_62 Vdout1_62ck182 = 0 time = 915
.meas tran vdout1_62ck182 FIND v(dout1_62) AT=915.025n

* CHECK dout1_63 Vdout1_63ck182 = 0.9 time = 915
.meas tran vdout1_63ck182 FIND v(dout1_63) AT=915.025n

* CHECK dout1_64 Vdout1_64ck182 = 0 time = 915
.meas tran vdout1_64ck182 FIND v(dout1_64) AT=915.025n

* CHECK dout1_65 Vdout1_65ck182 = 0 time = 915
.meas tran vdout1_65ck182 FIND v(dout1_65) AT=915.025n

* CHECK dout1_66 Vdout1_66ck182 = 0.9 time = 915
.meas tran vdout1_66ck182 FIND v(dout1_66) AT=915.025n

* CHECK dout1_67 Vdout1_67ck182 = 0 time = 915
.meas tran vdout1_67ck182 FIND v(dout1_67) AT=915.025n

* CHECK dout1_68 Vdout1_68ck182 = 0 time = 915
.meas tran vdout1_68ck182 FIND v(dout1_68) AT=915.025n

* CHECK dout1_69 Vdout1_69ck182 = 0.9 time = 915
.meas tran vdout1_69ck182 FIND v(dout1_69) AT=915.025n

* CHECK dout1_70 Vdout1_70ck182 = 0.9 time = 915
.meas tran vdout1_70ck182 FIND v(dout1_70) AT=915.025n

* CHECK dout1_71 Vdout1_71ck182 = 0 time = 915
.meas tran vdout1_71ck182 FIND v(dout1_71) AT=915.025n

* CHECK dout1_72 Vdout1_72ck182 = 0.9 time = 915
.meas tran vdout1_72ck182 FIND v(dout1_72) AT=915.025n

* CHECK dout1_73 Vdout1_73ck182 = 0.9 time = 915
.meas tran vdout1_73ck182 FIND v(dout1_73) AT=915.025n

* CHECK dout1_74 Vdout1_74ck182 = 0.9 time = 915
.meas tran vdout1_74ck182 FIND v(dout1_74) AT=915.025n

* CHECK dout1_75 Vdout1_75ck182 = 0.9 time = 915
.meas tran vdout1_75ck182 FIND v(dout1_75) AT=915.025n

* CHECK dout1_76 Vdout1_76ck182 = 0.9 time = 915
.meas tran vdout1_76ck182 FIND v(dout1_76) AT=915.025n

* CHECK dout1_77 Vdout1_77ck182 = 0.9 time = 915
.meas tran vdout1_77ck182 FIND v(dout1_77) AT=915.025n

* CHECK dout1_78 Vdout1_78ck182 = 0 time = 915
.meas tran vdout1_78ck182 FIND v(dout1_78) AT=915.025n

* CHECK dout1_79 Vdout1_79ck182 = 0 time = 915
.meas tran vdout1_79ck182 FIND v(dout1_79) AT=915.025n

* CHECK dout1_80 Vdout1_80ck182 = 0 time = 915
.meas tran vdout1_80ck182 FIND v(dout1_80) AT=915.025n

* CHECK dout1_81 Vdout1_81ck182 = 0.9 time = 915
.meas tran vdout1_81ck182 FIND v(dout1_81) AT=915.025n

* CHECK dout1_82 Vdout1_82ck182 = 0 time = 915
.meas tran vdout1_82ck182 FIND v(dout1_82) AT=915.025n

* CHECK dout1_83 Vdout1_83ck182 = 0.9 time = 915
.meas tran vdout1_83ck182 FIND v(dout1_83) AT=915.025n

* CHECK dout1_84 Vdout1_84ck182 = 0 time = 915
.meas tran vdout1_84ck182 FIND v(dout1_84) AT=915.025n

* CHECK dout1_85 Vdout1_85ck182 = 0 time = 915
.meas tran vdout1_85ck182 FIND v(dout1_85) AT=915.025n

* CHECK dout1_86 Vdout1_86ck182 = 0.9 time = 915
.meas tran vdout1_86ck182 FIND v(dout1_86) AT=915.025n

* CHECK dout1_87 Vdout1_87ck182 = 0 time = 915
.meas tran vdout1_87ck182 FIND v(dout1_87) AT=915.025n

* CHECK dout1_88 Vdout1_88ck182 = 0 time = 915
.meas tran vdout1_88ck182 FIND v(dout1_88) AT=915.025n

* CHECK dout1_89 Vdout1_89ck182 = 0 time = 915
.meas tran vdout1_89ck182 FIND v(dout1_89) AT=915.025n

* CHECK dout1_90 Vdout1_90ck182 = 0 time = 915
.meas tran vdout1_90ck182 FIND v(dout1_90) AT=915.025n

* CHECK dout1_91 Vdout1_91ck182 = 0 time = 915
.meas tran vdout1_91ck182 FIND v(dout1_91) AT=915.025n

* CHECK dout1_92 Vdout1_92ck182 = 0.9 time = 915
.meas tran vdout1_92ck182 FIND v(dout1_92) AT=915.025n

* CHECK dout1_93 Vdout1_93ck182 = 0.9 time = 915
.meas tran vdout1_93ck182 FIND v(dout1_93) AT=915.025n

* CHECK dout1_94 Vdout1_94ck182 = 0 time = 915
.meas tran vdout1_94ck182 FIND v(dout1_94) AT=915.025n

* CHECK dout1_95 Vdout1_95ck182 = 0.9 time = 915
.meas tran vdout1_95ck182 FIND v(dout1_95) AT=915.025n

* CHECK dout1_96 Vdout1_96ck182 = 0 time = 915
.meas tran vdout1_96ck182 FIND v(dout1_96) AT=915.025n

* CHECK dout1_97 Vdout1_97ck182 = 0 time = 915
.meas tran vdout1_97ck182 FIND v(dout1_97) AT=915.025n

* CHECK dout1_98 Vdout1_98ck182 = 0.9 time = 915
.meas tran vdout1_98ck182 FIND v(dout1_98) AT=915.025n

* CHECK dout1_99 Vdout1_99ck182 = 0.9 time = 915
.meas tran vdout1_99ck182 FIND v(dout1_99) AT=915.025n

* CHECK dout1_100 Vdout1_100ck182 = 0 time = 915
.meas tran vdout1_100ck182 FIND v(dout1_100) AT=915.025n

* CHECK dout1_101 Vdout1_101ck182 = 0.9 time = 915
.meas tran vdout1_101ck182 FIND v(dout1_101) AT=915.025n

* CHECK dout1_102 Vdout1_102ck182 = 0 time = 915
.meas tran vdout1_102ck182 FIND v(dout1_102) AT=915.025n

* CHECK dout1_103 Vdout1_103ck182 = 0 time = 915
.meas tran vdout1_103ck182 FIND v(dout1_103) AT=915.025n

* CHECK dout1_104 Vdout1_104ck182 = 0.9 time = 915
.meas tran vdout1_104ck182 FIND v(dout1_104) AT=915.025n

* CHECK dout1_105 Vdout1_105ck182 = 0 time = 915
.meas tran vdout1_105ck182 FIND v(dout1_105) AT=915.025n

* CHECK dout1_106 Vdout1_106ck182 = 0 time = 915
.meas tran vdout1_106ck182 FIND v(dout1_106) AT=915.025n

* CHECK dout1_107 Vdout1_107ck182 = 0.9 time = 915
.meas tran vdout1_107ck182 FIND v(dout1_107) AT=915.025n

* CHECK dout1_108 Vdout1_108ck182 = 0 time = 915
.meas tran vdout1_108ck182 FIND v(dout1_108) AT=915.025n

* CHECK dout1_109 Vdout1_109ck182 = 0 time = 915
.meas tran vdout1_109ck182 FIND v(dout1_109) AT=915.025n

* CHECK dout1_110 Vdout1_110ck182 = 0.9 time = 915
.meas tran vdout1_110ck182 FIND v(dout1_110) AT=915.025n

* CHECK dout1_111 Vdout1_111ck182 = 0.9 time = 915
.meas tran vdout1_111ck182 FIND v(dout1_111) AT=915.025n

* CHECK dout1_112 Vdout1_112ck182 = 0 time = 915
.meas tran vdout1_112ck182 FIND v(dout1_112) AT=915.025n

* CHECK dout1_113 Vdout1_113ck182 = 0.9 time = 915
.meas tran vdout1_113ck182 FIND v(dout1_113) AT=915.025n

* CHECK dout1_114 Vdout1_114ck182 = 0.9 time = 915
.meas tran vdout1_114ck182 FIND v(dout1_114) AT=915.025n

* CHECK dout1_115 Vdout1_115ck182 = 0 time = 915
.meas tran vdout1_115ck182 FIND v(dout1_115) AT=915.025n

* CHECK dout1_116 Vdout1_116ck182 = 0 time = 915
.meas tran vdout1_116ck182 FIND v(dout1_116) AT=915.025n

* CHECK dout1_117 Vdout1_117ck182 = 0.9 time = 915
.meas tran vdout1_117ck182 FIND v(dout1_117) AT=915.025n

* CHECK dout1_118 Vdout1_118ck182 = 0.9 time = 915
.meas tran vdout1_118ck182 FIND v(dout1_118) AT=915.025n

* CHECK dout1_119 Vdout1_119ck182 = 0.9 time = 915
.meas tran vdout1_119ck182 FIND v(dout1_119) AT=915.025n

* CHECK dout1_0 Vdout1_0ck186 = 0.9 time = 935
.meas tran vdout1_0ck186 FIND v(dout1_0) AT=935.025n

* CHECK dout1_1 Vdout1_1ck186 = 0.9 time = 935
.meas tran vdout1_1ck186 FIND v(dout1_1) AT=935.025n

* CHECK dout1_2 Vdout1_2ck186 = 0 time = 935
.meas tran vdout1_2ck186 FIND v(dout1_2) AT=935.025n

* CHECK dout1_3 Vdout1_3ck186 = 0.9 time = 935
.meas tran vdout1_3ck186 FIND v(dout1_3) AT=935.025n

* CHECK dout1_4 Vdout1_4ck186 = 0.9 time = 935
.meas tran vdout1_4ck186 FIND v(dout1_4) AT=935.025n

* CHECK dout1_5 Vdout1_5ck186 = 0.9 time = 935
.meas tran vdout1_5ck186 FIND v(dout1_5) AT=935.025n

* CHECK dout1_6 Vdout1_6ck186 = 0.9 time = 935
.meas tran vdout1_6ck186 FIND v(dout1_6) AT=935.025n

* CHECK dout1_7 Vdout1_7ck186 = 0.9 time = 935
.meas tran vdout1_7ck186 FIND v(dout1_7) AT=935.025n

* CHECK dout1_8 Vdout1_8ck186 = 0 time = 935
.meas tran vdout1_8ck186 FIND v(dout1_8) AT=935.025n

* CHECK dout1_9 Vdout1_9ck186 = 0 time = 935
.meas tran vdout1_9ck186 FIND v(dout1_9) AT=935.025n

* CHECK dout1_10 Vdout1_10ck186 = 0.9 time = 935
.meas tran vdout1_10ck186 FIND v(dout1_10) AT=935.025n

* CHECK dout1_11 Vdout1_11ck186 = 0.9 time = 935
.meas tran vdout1_11ck186 FIND v(dout1_11) AT=935.025n

* CHECK dout1_12 Vdout1_12ck186 = 0.9 time = 935
.meas tran vdout1_12ck186 FIND v(dout1_12) AT=935.025n

* CHECK dout1_13 Vdout1_13ck186 = 0 time = 935
.meas tran vdout1_13ck186 FIND v(dout1_13) AT=935.025n

* CHECK dout1_14 Vdout1_14ck186 = 0.9 time = 935
.meas tran vdout1_14ck186 FIND v(dout1_14) AT=935.025n

* CHECK dout1_15 Vdout1_15ck186 = 0 time = 935
.meas tran vdout1_15ck186 FIND v(dout1_15) AT=935.025n

* CHECK dout1_16 Vdout1_16ck186 = 0 time = 935
.meas tran vdout1_16ck186 FIND v(dout1_16) AT=935.025n

* CHECK dout1_17 Vdout1_17ck186 = 0 time = 935
.meas tran vdout1_17ck186 FIND v(dout1_17) AT=935.025n

* CHECK dout1_18 Vdout1_18ck186 = 0.9 time = 935
.meas tran vdout1_18ck186 FIND v(dout1_18) AT=935.025n

* CHECK dout1_19 Vdout1_19ck186 = 0 time = 935
.meas tran vdout1_19ck186 FIND v(dout1_19) AT=935.025n

* CHECK dout1_20 Vdout1_20ck186 = 0.9 time = 935
.meas tran vdout1_20ck186 FIND v(dout1_20) AT=935.025n

* CHECK dout1_21 Vdout1_21ck186 = 0 time = 935
.meas tran vdout1_21ck186 FIND v(dout1_21) AT=935.025n

* CHECK dout1_22 Vdout1_22ck186 = 0.9 time = 935
.meas tran vdout1_22ck186 FIND v(dout1_22) AT=935.025n

* CHECK dout1_23 Vdout1_23ck186 = 0.9 time = 935
.meas tran vdout1_23ck186 FIND v(dout1_23) AT=935.025n

* CHECK dout1_24 Vdout1_24ck186 = 0 time = 935
.meas tran vdout1_24ck186 FIND v(dout1_24) AT=935.025n

* CHECK dout1_25 Vdout1_25ck186 = 0 time = 935
.meas tran vdout1_25ck186 FIND v(dout1_25) AT=935.025n

* CHECK dout1_26 Vdout1_26ck186 = 0.9 time = 935
.meas tran vdout1_26ck186 FIND v(dout1_26) AT=935.025n

* CHECK dout1_27 Vdout1_27ck186 = 0 time = 935
.meas tran vdout1_27ck186 FIND v(dout1_27) AT=935.025n

* CHECK dout1_28 Vdout1_28ck186 = 0.9 time = 935
.meas tran vdout1_28ck186 FIND v(dout1_28) AT=935.025n

* CHECK dout1_29 Vdout1_29ck186 = 0.9 time = 935
.meas tran vdout1_29ck186 FIND v(dout1_29) AT=935.025n

* CHECK dout1_30 Vdout1_30ck186 = 0 time = 935
.meas tran vdout1_30ck186 FIND v(dout1_30) AT=935.025n

* CHECK dout1_31 Vdout1_31ck186 = 0 time = 935
.meas tran vdout1_31ck186 FIND v(dout1_31) AT=935.025n

* CHECK dout1_32 Vdout1_32ck186 = 0 time = 935
.meas tran vdout1_32ck186 FIND v(dout1_32) AT=935.025n

* CHECK dout1_33 Vdout1_33ck186 = 0 time = 935
.meas tran vdout1_33ck186 FIND v(dout1_33) AT=935.025n

* CHECK dout1_34 Vdout1_34ck186 = 0 time = 935
.meas tran vdout1_34ck186 FIND v(dout1_34) AT=935.025n

* CHECK dout1_35 Vdout1_35ck186 = 0.9 time = 935
.meas tran vdout1_35ck186 FIND v(dout1_35) AT=935.025n

* CHECK dout1_36 Vdout1_36ck186 = 0.9 time = 935
.meas tran vdout1_36ck186 FIND v(dout1_36) AT=935.025n

* CHECK dout1_37 Vdout1_37ck186 = 0.9 time = 935
.meas tran vdout1_37ck186 FIND v(dout1_37) AT=935.025n

* CHECK dout1_38 Vdout1_38ck186 = 0.9 time = 935
.meas tran vdout1_38ck186 FIND v(dout1_38) AT=935.025n

* CHECK dout1_39 Vdout1_39ck186 = 0 time = 935
.meas tran vdout1_39ck186 FIND v(dout1_39) AT=935.025n

* CHECK dout1_40 Vdout1_40ck186 = 0 time = 935
.meas tran vdout1_40ck186 FIND v(dout1_40) AT=935.025n

* CHECK dout1_41 Vdout1_41ck186 = 0.9 time = 935
.meas tran vdout1_41ck186 FIND v(dout1_41) AT=935.025n

* CHECK dout1_42 Vdout1_42ck186 = 0 time = 935
.meas tran vdout1_42ck186 FIND v(dout1_42) AT=935.025n

* CHECK dout1_43 Vdout1_43ck186 = 0 time = 935
.meas tran vdout1_43ck186 FIND v(dout1_43) AT=935.025n

* CHECK dout1_44 Vdout1_44ck186 = 0 time = 935
.meas tran vdout1_44ck186 FIND v(dout1_44) AT=935.025n

* CHECK dout1_45 Vdout1_45ck186 = 0.9 time = 935
.meas tran vdout1_45ck186 FIND v(dout1_45) AT=935.025n

* CHECK dout1_46 Vdout1_46ck186 = 0 time = 935
.meas tran vdout1_46ck186 FIND v(dout1_46) AT=935.025n

* CHECK dout1_47 Vdout1_47ck186 = 0.9 time = 935
.meas tran vdout1_47ck186 FIND v(dout1_47) AT=935.025n

* CHECK dout1_48 Vdout1_48ck186 = 0 time = 935
.meas tran vdout1_48ck186 FIND v(dout1_48) AT=935.025n

* CHECK dout1_49 Vdout1_49ck186 = 0 time = 935
.meas tran vdout1_49ck186 FIND v(dout1_49) AT=935.025n

* CHECK dout1_50 Vdout1_50ck186 = 0 time = 935
.meas tran vdout1_50ck186 FIND v(dout1_50) AT=935.025n

* CHECK dout1_51 Vdout1_51ck186 = 0.9 time = 935
.meas tran vdout1_51ck186 FIND v(dout1_51) AT=935.025n

* CHECK dout1_52 Vdout1_52ck186 = 0.9 time = 935
.meas tran vdout1_52ck186 FIND v(dout1_52) AT=935.025n

* CHECK dout1_53 Vdout1_53ck186 = 0 time = 935
.meas tran vdout1_53ck186 FIND v(dout1_53) AT=935.025n

* CHECK dout1_54 Vdout1_54ck186 = 0 time = 935
.meas tran vdout1_54ck186 FIND v(dout1_54) AT=935.025n

* CHECK dout1_55 Vdout1_55ck186 = 0 time = 935
.meas tran vdout1_55ck186 FIND v(dout1_55) AT=935.025n

* CHECK dout1_56 Vdout1_56ck186 = 0.9 time = 935
.meas tran vdout1_56ck186 FIND v(dout1_56) AT=935.025n

* CHECK dout1_57 Vdout1_57ck186 = 0 time = 935
.meas tran vdout1_57ck186 FIND v(dout1_57) AT=935.025n

* CHECK dout1_58 Vdout1_58ck186 = 0 time = 935
.meas tran vdout1_58ck186 FIND v(dout1_58) AT=935.025n

* CHECK dout1_59 Vdout1_59ck186 = 0 time = 935
.meas tran vdout1_59ck186 FIND v(dout1_59) AT=935.025n

* CHECK dout1_60 Vdout1_60ck186 = 0 time = 935
.meas tran vdout1_60ck186 FIND v(dout1_60) AT=935.025n

* CHECK dout1_61 Vdout1_61ck186 = 0 time = 935
.meas tran vdout1_61ck186 FIND v(dout1_61) AT=935.025n

* CHECK dout1_62 Vdout1_62ck186 = 0.9 time = 935
.meas tran vdout1_62ck186 FIND v(dout1_62) AT=935.025n

* CHECK dout1_63 Vdout1_63ck186 = 0.9 time = 935
.meas tran vdout1_63ck186 FIND v(dout1_63) AT=935.025n

* CHECK dout1_64 Vdout1_64ck186 = 0.9 time = 935
.meas tran vdout1_64ck186 FIND v(dout1_64) AT=935.025n

* CHECK dout1_65 Vdout1_65ck186 = 0.9 time = 935
.meas tran vdout1_65ck186 FIND v(dout1_65) AT=935.025n

* CHECK dout1_66 Vdout1_66ck186 = 0 time = 935
.meas tran vdout1_66ck186 FIND v(dout1_66) AT=935.025n

* CHECK dout1_67 Vdout1_67ck186 = 0.9 time = 935
.meas tran vdout1_67ck186 FIND v(dout1_67) AT=935.025n

* CHECK dout1_68 Vdout1_68ck186 = 0 time = 935
.meas tran vdout1_68ck186 FIND v(dout1_68) AT=935.025n

* CHECK dout1_69 Vdout1_69ck186 = 0 time = 935
.meas tran vdout1_69ck186 FIND v(dout1_69) AT=935.025n

* CHECK dout1_70 Vdout1_70ck186 = 0.9 time = 935
.meas tran vdout1_70ck186 FIND v(dout1_70) AT=935.025n

* CHECK dout1_71 Vdout1_71ck186 = 0.9 time = 935
.meas tran vdout1_71ck186 FIND v(dout1_71) AT=935.025n

* CHECK dout1_72 Vdout1_72ck186 = 0.9 time = 935
.meas tran vdout1_72ck186 FIND v(dout1_72) AT=935.025n

* CHECK dout1_73 Vdout1_73ck186 = 0 time = 935
.meas tran vdout1_73ck186 FIND v(dout1_73) AT=935.025n

* CHECK dout1_74 Vdout1_74ck186 = 0 time = 935
.meas tran vdout1_74ck186 FIND v(dout1_74) AT=935.025n

* CHECK dout1_75 Vdout1_75ck186 = 0 time = 935
.meas tran vdout1_75ck186 FIND v(dout1_75) AT=935.025n

* CHECK dout1_76 Vdout1_76ck186 = 0 time = 935
.meas tran vdout1_76ck186 FIND v(dout1_76) AT=935.025n

* CHECK dout1_77 Vdout1_77ck186 = 0.9 time = 935
.meas tran vdout1_77ck186 FIND v(dout1_77) AT=935.025n

* CHECK dout1_78 Vdout1_78ck186 = 0 time = 935
.meas tran vdout1_78ck186 FIND v(dout1_78) AT=935.025n

* CHECK dout1_79 Vdout1_79ck186 = 0 time = 935
.meas tran vdout1_79ck186 FIND v(dout1_79) AT=935.025n

* CHECK dout1_80 Vdout1_80ck186 = 0.9 time = 935
.meas tran vdout1_80ck186 FIND v(dout1_80) AT=935.025n

* CHECK dout1_81 Vdout1_81ck186 = 0.9 time = 935
.meas tran vdout1_81ck186 FIND v(dout1_81) AT=935.025n

* CHECK dout1_82 Vdout1_82ck186 = 0 time = 935
.meas tran vdout1_82ck186 FIND v(dout1_82) AT=935.025n

* CHECK dout1_83 Vdout1_83ck186 = 0.9 time = 935
.meas tran vdout1_83ck186 FIND v(dout1_83) AT=935.025n

* CHECK dout1_84 Vdout1_84ck186 = 0 time = 935
.meas tran vdout1_84ck186 FIND v(dout1_84) AT=935.025n

* CHECK dout1_85 Vdout1_85ck186 = 0.9 time = 935
.meas tran vdout1_85ck186 FIND v(dout1_85) AT=935.025n

* CHECK dout1_86 Vdout1_86ck186 = 0.9 time = 935
.meas tran vdout1_86ck186 FIND v(dout1_86) AT=935.025n

* CHECK dout1_87 Vdout1_87ck186 = 0.9 time = 935
.meas tran vdout1_87ck186 FIND v(dout1_87) AT=935.025n

* CHECK dout1_88 Vdout1_88ck186 = 0 time = 935
.meas tran vdout1_88ck186 FIND v(dout1_88) AT=935.025n

* CHECK dout1_89 Vdout1_89ck186 = 0.9 time = 935
.meas tran vdout1_89ck186 FIND v(dout1_89) AT=935.025n

* CHECK dout1_90 Vdout1_90ck186 = 0 time = 935
.meas tran vdout1_90ck186 FIND v(dout1_90) AT=935.025n

* CHECK dout1_91 Vdout1_91ck186 = 0.9 time = 935
.meas tran vdout1_91ck186 FIND v(dout1_91) AT=935.025n

* CHECK dout1_92 Vdout1_92ck186 = 0.9 time = 935
.meas tran vdout1_92ck186 FIND v(dout1_92) AT=935.025n

* CHECK dout1_93 Vdout1_93ck186 = 0.9 time = 935
.meas tran vdout1_93ck186 FIND v(dout1_93) AT=935.025n

* CHECK dout1_94 Vdout1_94ck186 = 0.9 time = 935
.meas tran vdout1_94ck186 FIND v(dout1_94) AT=935.025n

* CHECK dout1_95 Vdout1_95ck186 = 0 time = 935
.meas tran vdout1_95ck186 FIND v(dout1_95) AT=935.025n

* CHECK dout1_96 Vdout1_96ck186 = 0.9 time = 935
.meas tran vdout1_96ck186 FIND v(dout1_96) AT=935.025n

* CHECK dout1_97 Vdout1_97ck186 = 0.9 time = 935
.meas tran vdout1_97ck186 FIND v(dout1_97) AT=935.025n

* CHECK dout1_98 Vdout1_98ck186 = 0 time = 935
.meas tran vdout1_98ck186 FIND v(dout1_98) AT=935.025n

* CHECK dout1_99 Vdout1_99ck186 = 0.9 time = 935
.meas tran vdout1_99ck186 FIND v(dout1_99) AT=935.025n

* CHECK dout1_100 Vdout1_100ck186 = 0.9 time = 935
.meas tran vdout1_100ck186 FIND v(dout1_100) AT=935.025n

* CHECK dout1_101 Vdout1_101ck186 = 0 time = 935
.meas tran vdout1_101ck186 FIND v(dout1_101) AT=935.025n

* CHECK dout1_102 Vdout1_102ck186 = 0.9 time = 935
.meas tran vdout1_102ck186 FIND v(dout1_102) AT=935.025n

* CHECK dout1_103 Vdout1_103ck186 = 0 time = 935
.meas tran vdout1_103ck186 FIND v(dout1_103) AT=935.025n

* CHECK dout1_104 Vdout1_104ck186 = 0.9 time = 935
.meas tran vdout1_104ck186 FIND v(dout1_104) AT=935.025n

* CHECK dout1_105 Vdout1_105ck186 = 0 time = 935
.meas tran vdout1_105ck186 FIND v(dout1_105) AT=935.025n

* CHECK dout1_106 Vdout1_106ck186 = 0 time = 935
.meas tran vdout1_106ck186 FIND v(dout1_106) AT=935.025n

* CHECK dout1_107 Vdout1_107ck186 = 0.9 time = 935
.meas tran vdout1_107ck186 FIND v(dout1_107) AT=935.025n

* CHECK dout1_108 Vdout1_108ck186 = 0 time = 935
.meas tran vdout1_108ck186 FIND v(dout1_108) AT=935.025n

* CHECK dout1_109 Vdout1_109ck186 = 0 time = 935
.meas tran vdout1_109ck186 FIND v(dout1_109) AT=935.025n

* CHECK dout1_110 Vdout1_110ck186 = 0 time = 935
.meas tran vdout1_110ck186 FIND v(dout1_110) AT=935.025n

* CHECK dout1_111 Vdout1_111ck186 = 0 time = 935
.meas tran vdout1_111ck186 FIND v(dout1_111) AT=935.025n

* CHECK dout1_112 Vdout1_112ck186 = 0.9 time = 935
.meas tran vdout1_112ck186 FIND v(dout1_112) AT=935.025n

* CHECK dout1_113 Vdout1_113ck186 = 0 time = 935
.meas tran vdout1_113ck186 FIND v(dout1_113) AT=935.025n

* CHECK dout1_114 Vdout1_114ck186 = 0 time = 935
.meas tran vdout1_114ck186 FIND v(dout1_114) AT=935.025n

* CHECK dout1_115 Vdout1_115ck186 = 0 time = 935
.meas tran vdout1_115ck186 FIND v(dout1_115) AT=935.025n

* CHECK dout1_116 Vdout1_116ck186 = 0.9 time = 935
.meas tran vdout1_116ck186 FIND v(dout1_116) AT=935.025n

* CHECK dout1_117 Vdout1_117ck186 = 0 time = 935
.meas tran vdout1_117ck186 FIND v(dout1_117) AT=935.025n

* CHECK dout1_118 Vdout1_118ck186 = 0.9 time = 935
.meas tran vdout1_118ck186 FIND v(dout1_118) AT=935.025n

* CHECK dout1_119 Vdout1_119ck186 = 0 time = 935
.meas tran vdout1_119ck186 FIND v(dout1_119) AT=935.025n

* CHECK dout1_0 Vdout1_0ck190 = 0.9 time = 955
.meas tran vdout1_0ck190 FIND v(dout1_0) AT=955.025n

* CHECK dout1_1 Vdout1_1ck190 = 0.9 time = 955
.meas tran vdout1_1ck190 FIND v(dout1_1) AT=955.025n

* CHECK dout1_2 Vdout1_2ck190 = 0 time = 955
.meas tran vdout1_2ck190 FIND v(dout1_2) AT=955.025n

* CHECK dout1_3 Vdout1_3ck190 = 0.9 time = 955
.meas tran vdout1_3ck190 FIND v(dout1_3) AT=955.025n

* CHECK dout1_4 Vdout1_4ck190 = 0.9 time = 955
.meas tran vdout1_4ck190 FIND v(dout1_4) AT=955.025n

* CHECK dout1_5 Vdout1_5ck190 = 0.9 time = 955
.meas tran vdout1_5ck190 FIND v(dout1_5) AT=955.025n

* CHECK dout1_6 Vdout1_6ck190 = 0.9 time = 955
.meas tran vdout1_6ck190 FIND v(dout1_6) AT=955.025n

* CHECK dout1_7 Vdout1_7ck190 = 0.9 time = 955
.meas tran vdout1_7ck190 FIND v(dout1_7) AT=955.025n

* CHECK dout1_8 Vdout1_8ck190 = 0 time = 955
.meas tran vdout1_8ck190 FIND v(dout1_8) AT=955.025n

* CHECK dout1_9 Vdout1_9ck190 = 0 time = 955
.meas tran vdout1_9ck190 FIND v(dout1_9) AT=955.025n

* CHECK dout1_10 Vdout1_10ck190 = 0.9 time = 955
.meas tran vdout1_10ck190 FIND v(dout1_10) AT=955.025n

* CHECK dout1_11 Vdout1_11ck190 = 0.9 time = 955
.meas tran vdout1_11ck190 FIND v(dout1_11) AT=955.025n

* CHECK dout1_12 Vdout1_12ck190 = 0.9 time = 955
.meas tran vdout1_12ck190 FIND v(dout1_12) AT=955.025n

* CHECK dout1_13 Vdout1_13ck190 = 0 time = 955
.meas tran vdout1_13ck190 FIND v(dout1_13) AT=955.025n

* CHECK dout1_14 Vdout1_14ck190 = 0.9 time = 955
.meas tran vdout1_14ck190 FIND v(dout1_14) AT=955.025n

* CHECK dout1_15 Vdout1_15ck190 = 0 time = 955
.meas tran vdout1_15ck190 FIND v(dout1_15) AT=955.025n

* CHECK dout1_16 Vdout1_16ck190 = 0 time = 955
.meas tran vdout1_16ck190 FIND v(dout1_16) AT=955.025n

* CHECK dout1_17 Vdout1_17ck190 = 0 time = 955
.meas tran vdout1_17ck190 FIND v(dout1_17) AT=955.025n

* CHECK dout1_18 Vdout1_18ck190 = 0.9 time = 955
.meas tran vdout1_18ck190 FIND v(dout1_18) AT=955.025n

* CHECK dout1_19 Vdout1_19ck190 = 0 time = 955
.meas tran vdout1_19ck190 FIND v(dout1_19) AT=955.025n

* CHECK dout1_20 Vdout1_20ck190 = 0.9 time = 955
.meas tran vdout1_20ck190 FIND v(dout1_20) AT=955.025n

* CHECK dout1_21 Vdout1_21ck190 = 0 time = 955
.meas tran vdout1_21ck190 FIND v(dout1_21) AT=955.025n

* CHECK dout1_22 Vdout1_22ck190 = 0.9 time = 955
.meas tran vdout1_22ck190 FIND v(dout1_22) AT=955.025n

* CHECK dout1_23 Vdout1_23ck190 = 0.9 time = 955
.meas tran vdout1_23ck190 FIND v(dout1_23) AT=955.025n

* CHECK dout1_24 Vdout1_24ck190 = 0 time = 955
.meas tran vdout1_24ck190 FIND v(dout1_24) AT=955.025n

* CHECK dout1_25 Vdout1_25ck190 = 0 time = 955
.meas tran vdout1_25ck190 FIND v(dout1_25) AT=955.025n

* CHECK dout1_26 Vdout1_26ck190 = 0.9 time = 955
.meas tran vdout1_26ck190 FIND v(dout1_26) AT=955.025n

* CHECK dout1_27 Vdout1_27ck190 = 0 time = 955
.meas tran vdout1_27ck190 FIND v(dout1_27) AT=955.025n

* CHECK dout1_28 Vdout1_28ck190 = 0.9 time = 955
.meas tran vdout1_28ck190 FIND v(dout1_28) AT=955.025n

* CHECK dout1_29 Vdout1_29ck190 = 0.9 time = 955
.meas tran vdout1_29ck190 FIND v(dout1_29) AT=955.025n

* CHECK dout1_30 Vdout1_30ck190 = 0 time = 955
.meas tran vdout1_30ck190 FIND v(dout1_30) AT=955.025n

* CHECK dout1_31 Vdout1_31ck190 = 0 time = 955
.meas tran vdout1_31ck190 FIND v(dout1_31) AT=955.025n

* CHECK dout1_32 Vdout1_32ck190 = 0 time = 955
.meas tran vdout1_32ck190 FIND v(dout1_32) AT=955.025n

* CHECK dout1_33 Vdout1_33ck190 = 0 time = 955
.meas tran vdout1_33ck190 FIND v(dout1_33) AT=955.025n

* CHECK dout1_34 Vdout1_34ck190 = 0 time = 955
.meas tran vdout1_34ck190 FIND v(dout1_34) AT=955.025n

* CHECK dout1_35 Vdout1_35ck190 = 0.9 time = 955
.meas tran vdout1_35ck190 FIND v(dout1_35) AT=955.025n

* CHECK dout1_36 Vdout1_36ck190 = 0.9 time = 955
.meas tran vdout1_36ck190 FIND v(dout1_36) AT=955.025n

* CHECK dout1_37 Vdout1_37ck190 = 0.9 time = 955
.meas tran vdout1_37ck190 FIND v(dout1_37) AT=955.025n

* CHECK dout1_38 Vdout1_38ck190 = 0.9 time = 955
.meas tran vdout1_38ck190 FIND v(dout1_38) AT=955.025n

* CHECK dout1_39 Vdout1_39ck190 = 0 time = 955
.meas tran vdout1_39ck190 FIND v(dout1_39) AT=955.025n

* CHECK dout1_40 Vdout1_40ck190 = 0 time = 955
.meas tran vdout1_40ck190 FIND v(dout1_40) AT=955.025n

* CHECK dout1_41 Vdout1_41ck190 = 0.9 time = 955
.meas tran vdout1_41ck190 FIND v(dout1_41) AT=955.025n

* CHECK dout1_42 Vdout1_42ck190 = 0 time = 955
.meas tran vdout1_42ck190 FIND v(dout1_42) AT=955.025n

* CHECK dout1_43 Vdout1_43ck190 = 0 time = 955
.meas tran vdout1_43ck190 FIND v(dout1_43) AT=955.025n

* CHECK dout1_44 Vdout1_44ck190 = 0 time = 955
.meas tran vdout1_44ck190 FIND v(dout1_44) AT=955.025n

* CHECK dout1_45 Vdout1_45ck190 = 0.9 time = 955
.meas tran vdout1_45ck190 FIND v(dout1_45) AT=955.025n

* CHECK dout1_46 Vdout1_46ck190 = 0 time = 955
.meas tran vdout1_46ck190 FIND v(dout1_46) AT=955.025n

* CHECK dout1_47 Vdout1_47ck190 = 0.9 time = 955
.meas tran vdout1_47ck190 FIND v(dout1_47) AT=955.025n

* CHECK dout1_48 Vdout1_48ck190 = 0 time = 955
.meas tran vdout1_48ck190 FIND v(dout1_48) AT=955.025n

* CHECK dout1_49 Vdout1_49ck190 = 0 time = 955
.meas tran vdout1_49ck190 FIND v(dout1_49) AT=955.025n

* CHECK dout1_50 Vdout1_50ck190 = 0 time = 955
.meas tran vdout1_50ck190 FIND v(dout1_50) AT=955.025n

* CHECK dout1_51 Vdout1_51ck190 = 0.9 time = 955
.meas tran vdout1_51ck190 FIND v(dout1_51) AT=955.025n

* CHECK dout1_52 Vdout1_52ck190 = 0.9 time = 955
.meas tran vdout1_52ck190 FIND v(dout1_52) AT=955.025n

* CHECK dout1_53 Vdout1_53ck190 = 0 time = 955
.meas tran vdout1_53ck190 FIND v(dout1_53) AT=955.025n

* CHECK dout1_54 Vdout1_54ck190 = 0 time = 955
.meas tran vdout1_54ck190 FIND v(dout1_54) AT=955.025n

* CHECK dout1_55 Vdout1_55ck190 = 0 time = 955
.meas tran vdout1_55ck190 FIND v(dout1_55) AT=955.025n

* CHECK dout1_56 Vdout1_56ck190 = 0.9 time = 955
.meas tran vdout1_56ck190 FIND v(dout1_56) AT=955.025n

* CHECK dout1_57 Vdout1_57ck190 = 0 time = 955
.meas tran vdout1_57ck190 FIND v(dout1_57) AT=955.025n

* CHECK dout1_58 Vdout1_58ck190 = 0 time = 955
.meas tran vdout1_58ck190 FIND v(dout1_58) AT=955.025n

* CHECK dout1_59 Vdout1_59ck190 = 0 time = 955
.meas tran vdout1_59ck190 FIND v(dout1_59) AT=955.025n

* CHECK dout1_60 Vdout1_60ck190 = 0 time = 955
.meas tran vdout1_60ck190 FIND v(dout1_60) AT=955.025n

* CHECK dout1_61 Vdout1_61ck190 = 0 time = 955
.meas tran vdout1_61ck190 FIND v(dout1_61) AT=955.025n

* CHECK dout1_62 Vdout1_62ck190 = 0.9 time = 955
.meas tran vdout1_62ck190 FIND v(dout1_62) AT=955.025n

* CHECK dout1_63 Vdout1_63ck190 = 0.9 time = 955
.meas tran vdout1_63ck190 FIND v(dout1_63) AT=955.025n

* CHECK dout1_64 Vdout1_64ck190 = 0.9 time = 955
.meas tran vdout1_64ck190 FIND v(dout1_64) AT=955.025n

* CHECK dout1_65 Vdout1_65ck190 = 0.9 time = 955
.meas tran vdout1_65ck190 FIND v(dout1_65) AT=955.025n

* CHECK dout1_66 Vdout1_66ck190 = 0 time = 955
.meas tran vdout1_66ck190 FIND v(dout1_66) AT=955.025n

* CHECK dout1_67 Vdout1_67ck190 = 0.9 time = 955
.meas tran vdout1_67ck190 FIND v(dout1_67) AT=955.025n

* CHECK dout1_68 Vdout1_68ck190 = 0 time = 955
.meas tran vdout1_68ck190 FIND v(dout1_68) AT=955.025n

* CHECK dout1_69 Vdout1_69ck190 = 0 time = 955
.meas tran vdout1_69ck190 FIND v(dout1_69) AT=955.025n

* CHECK dout1_70 Vdout1_70ck190 = 0.9 time = 955
.meas tran vdout1_70ck190 FIND v(dout1_70) AT=955.025n

* CHECK dout1_71 Vdout1_71ck190 = 0.9 time = 955
.meas tran vdout1_71ck190 FIND v(dout1_71) AT=955.025n

* CHECK dout1_72 Vdout1_72ck190 = 0.9 time = 955
.meas tran vdout1_72ck190 FIND v(dout1_72) AT=955.025n

* CHECK dout1_73 Vdout1_73ck190 = 0 time = 955
.meas tran vdout1_73ck190 FIND v(dout1_73) AT=955.025n

* CHECK dout1_74 Vdout1_74ck190 = 0 time = 955
.meas tran vdout1_74ck190 FIND v(dout1_74) AT=955.025n

* CHECK dout1_75 Vdout1_75ck190 = 0 time = 955
.meas tran vdout1_75ck190 FIND v(dout1_75) AT=955.025n

* CHECK dout1_76 Vdout1_76ck190 = 0 time = 955
.meas tran vdout1_76ck190 FIND v(dout1_76) AT=955.025n

* CHECK dout1_77 Vdout1_77ck190 = 0.9 time = 955
.meas tran vdout1_77ck190 FIND v(dout1_77) AT=955.025n

* CHECK dout1_78 Vdout1_78ck190 = 0 time = 955
.meas tran vdout1_78ck190 FIND v(dout1_78) AT=955.025n

* CHECK dout1_79 Vdout1_79ck190 = 0 time = 955
.meas tran vdout1_79ck190 FIND v(dout1_79) AT=955.025n

* CHECK dout1_80 Vdout1_80ck190 = 0.9 time = 955
.meas tran vdout1_80ck190 FIND v(dout1_80) AT=955.025n

* CHECK dout1_81 Vdout1_81ck190 = 0.9 time = 955
.meas tran vdout1_81ck190 FIND v(dout1_81) AT=955.025n

* CHECK dout1_82 Vdout1_82ck190 = 0 time = 955
.meas tran vdout1_82ck190 FIND v(dout1_82) AT=955.025n

* CHECK dout1_83 Vdout1_83ck190 = 0.9 time = 955
.meas tran vdout1_83ck190 FIND v(dout1_83) AT=955.025n

* CHECK dout1_84 Vdout1_84ck190 = 0 time = 955
.meas tran vdout1_84ck190 FIND v(dout1_84) AT=955.025n

* CHECK dout1_85 Vdout1_85ck190 = 0.9 time = 955
.meas tran vdout1_85ck190 FIND v(dout1_85) AT=955.025n

* CHECK dout1_86 Vdout1_86ck190 = 0.9 time = 955
.meas tran vdout1_86ck190 FIND v(dout1_86) AT=955.025n

* CHECK dout1_87 Vdout1_87ck190 = 0.9 time = 955
.meas tran vdout1_87ck190 FIND v(dout1_87) AT=955.025n

* CHECK dout1_88 Vdout1_88ck190 = 0 time = 955
.meas tran vdout1_88ck190 FIND v(dout1_88) AT=955.025n

* CHECK dout1_89 Vdout1_89ck190 = 0.9 time = 955
.meas tran vdout1_89ck190 FIND v(dout1_89) AT=955.025n

* CHECK dout1_90 Vdout1_90ck190 = 0 time = 955
.meas tran vdout1_90ck190 FIND v(dout1_90) AT=955.025n

* CHECK dout1_91 Vdout1_91ck190 = 0.9 time = 955
.meas tran vdout1_91ck190 FIND v(dout1_91) AT=955.025n

* CHECK dout1_92 Vdout1_92ck190 = 0.9 time = 955
.meas tran vdout1_92ck190 FIND v(dout1_92) AT=955.025n

* CHECK dout1_93 Vdout1_93ck190 = 0.9 time = 955
.meas tran vdout1_93ck190 FIND v(dout1_93) AT=955.025n

* CHECK dout1_94 Vdout1_94ck190 = 0.9 time = 955
.meas tran vdout1_94ck190 FIND v(dout1_94) AT=955.025n

* CHECK dout1_95 Vdout1_95ck190 = 0 time = 955
.meas tran vdout1_95ck190 FIND v(dout1_95) AT=955.025n

* CHECK dout1_96 Vdout1_96ck190 = 0.9 time = 955
.meas tran vdout1_96ck190 FIND v(dout1_96) AT=955.025n

* CHECK dout1_97 Vdout1_97ck190 = 0.9 time = 955
.meas tran vdout1_97ck190 FIND v(dout1_97) AT=955.025n

* CHECK dout1_98 Vdout1_98ck190 = 0 time = 955
.meas tran vdout1_98ck190 FIND v(dout1_98) AT=955.025n

* CHECK dout1_99 Vdout1_99ck190 = 0.9 time = 955
.meas tran vdout1_99ck190 FIND v(dout1_99) AT=955.025n

* CHECK dout1_100 Vdout1_100ck190 = 0.9 time = 955
.meas tran vdout1_100ck190 FIND v(dout1_100) AT=955.025n

* CHECK dout1_101 Vdout1_101ck190 = 0 time = 955
.meas tran vdout1_101ck190 FIND v(dout1_101) AT=955.025n

* CHECK dout1_102 Vdout1_102ck190 = 0.9 time = 955
.meas tran vdout1_102ck190 FIND v(dout1_102) AT=955.025n

* CHECK dout1_103 Vdout1_103ck190 = 0 time = 955
.meas tran vdout1_103ck190 FIND v(dout1_103) AT=955.025n

* CHECK dout1_104 Vdout1_104ck190 = 0.9 time = 955
.meas tran vdout1_104ck190 FIND v(dout1_104) AT=955.025n

* CHECK dout1_105 Vdout1_105ck190 = 0 time = 955
.meas tran vdout1_105ck190 FIND v(dout1_105) AT=955.025n

* CHECK dout1_106 Vdout1_106ck190 = 0 time = 955
.meas tran vdout1_106ck190 FIND v(dout1_106) AT=955.025n

* CHECK dout1_107 Vdout1_107ck190 = 0.9 time = 955
.meas tran vdout1_107ck190 FIND v(dout1_107) AT=955.025n

* CHECK dout1_108 Vdout1_108ck190 = 0 time = 955
.meas tran vdout1_108ck190 FIND v(dout1_108) AT=955.025n

* CHECK dout1_109 Vdout1_109ck190 = 0 time = 955
.meas tran vdout1_109ck190 FIND v(dout1_109) AT=955.025n

* CHECK dout1_110 Vdout1_110ck190 = 0 time = 955
.meas tran vdout1_110ck190 FIND v(dout1_110) AT=955.025n

* CHECK dout1_111 Vdout1_111ck190 = 0 time = 955
.meas tran vdout1_111ck190 FIND v(dout1_111) AT=955.025n

* CHECK dout1_112 Vdout1_112ck190 = 0.9 time = 955
.meas tran vdout1_112ck190 FIND v(dout1_112) AT=955.025n

* CHECK dout1_113 Vdout1_113ck190 = 0 time = 955
.meas tran vdout1_113ck190 FIND v(dout1_113) AT=955.025n

* CHECK dout1_114 Vdout1_114ck190 = 0 time = 955
.meas tran vdout1_114ck190 FIND v(dout1_114) AT=955.025n

* CHECK dout1_115 Vdout1_115ck190 = 0 time = 955
.meas tran vdout1_115ck190 FIND v(dout1_115) AT=955.025n

* CHECK dout1_116 Vdout1_116ck190 = 0.9 time = 955
.meas tran vdout1_116ck190 FIND v(dout1_116) AT=955.025n

* CHECK dout1_117 Vdout1_117ck190 = 0 time = 955
.meas tran vdout1_117ck190 FIND v(dout1_117) AT=955.025n

* CHECK dout1_118 Vdout1_118ck190 = 0.9 time = 955
.meas tran vdout1_118ck190 FIND v(dout1_118) AT=955.025n

* CHECK dout1_119 Vdout1_119ck190 = 0 time = 955
.meas tran vdout1_119ck190 FIND v(dout1_119) AT=955.025n

* CHECK dout1_0 Vdout1_0ck191 = 0 time = 960
.meas tran vdout1_0ck191 FIND v(dout1_0) AT=960.025n

* CHECK dout1_1 Vdout1_1ck191 = 0.9 time = 960
.meas tran vdout1_1ck191 FIND v(dout1_1) AT=960.025n

* CHECK dout1_2 Vdout1_2ck191 = 0 time = 960
.meas tran vdout1_2ck191 FIND v(dout1_2) AT=960.025n

* CHECK dout1_3 Vdout1_3ck191 = 0 time = 960
.meas tran vdout1_3ck191 FIND v(dout1_3) AT=960.025n

* CHECK dout1_4 Vdout1_4ck191 = 0 time = 960
.meas tran vdout1_4ck191 FIND v(dout1_4) AT=960.025n

* CHECK dout1_5 Vdout1_5ck191 = 0 time = 960
.meas tran vdout1_5ck191 FIND v(dout1_5) AT=960.025n

* CHECK dout1_6 Vdout1_6ck191 = 0.9 time = 960
.meas tran vdout1_6ck191 FIND v(dout1_6) AT=960.025n

* CHECK dout1_7 Vdout1_7ck191 = 0.9 time = 960
.meas tran vdout1_7ck191 FIND v(dout1_7) AT=960.025n

* CHECK dout1_8 Vdout1_8ck191 = 0 time = 960
.meas tran vdout1_8ck191 FIND v(dout1_8) AT=960.025n

* CHECK dout1_9 Vdout1_9ck191 = 0.9 time = 960
.meas tran vdout1_9ck191 FIND v(dout1_9) AT=960.025n

* CHECK dout1_10 Vdout1_10ck191 = 0.9 time = 960
.meas tran vdout1_10ck191 FIND v(dout1_10) AT=960.025n

* CHECK dout1_11 Vdout1_11ck191 = 0 time = 960
.meas tran vdout1_11ck191 FIND v(dout1_11) AT=960.025n

* CHECK dout1_12 Vdout1_12ck191 = 0.9 time = 960
.meas tran vdout1_12ck191 FIND v(dout1_12) AT=960.025n

* CHECK dout1_13 Vdout1_13ck191 = 0 time = 960
.meas tran vdout1_13ck191 FIND v(dout1_13) AT=960.025n

* CHECK dout1_14 Vdout1_14ck191 = 0.9 time = 960
.meas tran vdout1_14ck191 FIND v(dout1_14) AT=960.025n

* CHECK dout1_15 Vdout1_15ck191 = 0 time = 960
.meas tran vdout1_15ck191 FIND v(dout1_15) AT=960.025n

* CHECK dout1_16 Vdout1_16ck191 = 0 time = 960
.meas tran vdout1_16ck191 FIND v(dout1_16) AT=960.025n

* CHECK dout1_17 Vdout1_17ck191 = 0.9 time = 960
.meas tran vdout1_17ck191 FIND v(dout1_17) AT=960.025n

* CHECK dout1_18 Vdout1_18ck191 = 0 time = 960
.meas tran vdout1_18ck191 FIND v(dout1_18) AT=960.025n

* CHECK dout1_19 Vdout1_19ck191 = 0.9 time = 960
.meas tran vdout1_19ck191 FIND v(dout1_19) AT=960.025n

* CHECK dout1_20 Vdout1_20ck191 = 0.9 time = 960
.meas tran vdout1_20ck191 FIND v(dout1_20) AT=960.025n

* CHECK dout1_21 Vdout1_21ck191 = 0 time = 960
.meas tran vdout1_21ck191 FIND v(dout1_21) AT=960.025n

* CHECK dout1_22 Vdout1_22ck191 = 0.9 time = 960
.meas tran vdout1_22ck191 FIND v(dout1_22) AT=960.025n

* CHECK dout1_23 Vdout1_23ck191 = 0 time = 960
.meas tran vdout1_23ck191 FIND v(dout1_23) AT=960.025n

* CHECK dout1_24 Vdout1_24ck191 = 0.9 time = 960
.meas tran vdout1_24ck191 FIND v(dout1_24) AT=960.025n

* CHECK dout1_25 Vdout1_25ck191 = 0.9 time = 960
.meas tran vdout1_25ck191 FIND v(dout1_25) AT=960.025n

* CHECK dout1_26 Vdout1_26ck191 = 0 time = 960
.meas tran vdout1_26ck191 FIND v(dout1_26) AT=960.025n

* CHECK dout1_27 Vdout1_27ck191 = 0.9 time = 960
.meas tran vdout1_27ck191 FIND v(dout1_27) AT=960.025n

* CHECK dout1_28 Vdout1_28ck191 = 0.9 time = 960
.meas tran vdout1_28ck191 FIND v(dout1_28) AT=960.025n

* CHECK dout1_29 Vdout1_29ck191 = 0 time = 960
.meas tran vdout1_29ck191 FIND v(dout1_29) AT=960.025n

* CHECK dout1_30 Vdout1_30ck191 = 0 time = 960
.meas tran vdout1_30ck191 FIND v(dout1_30) AT=960.025n

* CHECK dout1_31 Vdout1_31ck191 = 0 time = 960
.meas tran vdout1_31ck191 FIND v(dout1_31) AT=960.025n

* CHECK dout1_32 Vdout1_32ck191 = 0 time = 960
.meas tran vdout1_32ck191 FIND v(dout1_32) AT=960.025n

* CHECK dout1_33 Vdout1_33ck191 = 0 time = 960
.meas tran vdout1_33ck191 FIND v(dout1_33) AT=960.025n

* CHECK dout1_34 Vdout1_34ck191 = 0 time = 960
.meas tran vdout1_34ck191 FIND v(dout1_34) AT=960.025n

* CHECK dout1_35 Vdout1_35ck191 = 0 time = 960
.meas tran vdout1_35ck191 FIND v(dout1_35) AT=960.025n

* CHECK dout1_36 Vdout1_36ck191 = 0.9 time = 960
.meas tran vdout1_36ck191 FIND v(dout1_36) AT=960.025n

* CHECK dout1_37 Vdout1_37ck191 = 0 time = 960
.meas tran vdout1_37ck191 FIND v(dout1_37) AT=960.025n

* CHECK dout1_38 Vdout1_38ck191 = 0 time = 960
.meas tran vdout1_38ck191 FIND v(dout1_38) AT=960.025n

* CHECK dout1_39 Vdout1_39ck191 = 0 time = 960
.meas tran vdout1_39ck191 FIND v(dout1_39) AT=960.025n

* CHECK dout1_40 Vdout1_40ck191 = 0 time = 960
.meas tran vdout1_40ck191 FIND v(dout1_40) AT=960.025n

* CHECK dout1_41 Vdout1_41ck191 = 0.9 time = 960
.meas tran vdout1_41ck191 FIND v(dout1_41) AT=960.025n

* CHECK dout1_42 Vdout1_42ck191 = 0 time = 960
.meas tran vdout1_42ck191 FIND v(dout1_42) AT=960.025n

* CHECK dout1_43 Vdout1_43ck191 = 0.9 time = 960
.meas tran vdout1_43ck191 FIND v(dout1_43) AT=960.025n

* CHECK dout1_44 Vdout1_44ck191 = 0 time = 960
.meas tran vdout1_44ck191 FIND v(dout1_44) AT=960.025n

* CHECK dout1_45 Vdout1_45ck191 = 0.9 time = 960
.meas tran vdout1_45ck191 FIND v(dout1_45) AT=960.025n

* CHECK dout1_46 Vdout1_46ck191 = 0 time = 960
.meas tran vdout1_46ck191 FIND v(dout1_46) AT=960.025n

* CHECK dout1_47 Vdout1_47ck191 = 0.9 time = 960
.meas tran vdout1_47ck191 FIND v(dout1_47) AT=960.025n

* CHECK dout1_48 Vdout1_48ck191 = 0.9 time = 960
.meas tran vdout1_48ck191 FIND v(dout1_48) AT=960.025n

* CHECK dout1_49 Vdout1_49ck191 = 0.9 time = 960
.meas tran vdout1_49ck191 FIND v(dout1_49) AT=960.025n

* CHECK dout1_50 Vdout1_50ck191 = 0 time = 960
.meas tran vdout1_50ck191 FIND v(dout1_50) AT=960.025n

* CHECK dout1_51 Vdout1_51ck191 = 0.9 time = 960
.meas tran vdout1_51ck191 FIND v(dout1_51) AT=960.025n

* CHECK dout1_52 Vdout1_52ck191 = 0.9 time = 960
.meas tran vdout1_52ck191 FIND v(dout1_52) AT=960.025n

* CHECK dout1_53 Vdout1_53ck191 = 0 time = 960
.meas tran vdout1_53ck191 FIND v(dout1_53) AT=960.025n

* CHECK dout1_54 Vdout1_54ck191 = 0.9 time = 960
.meas tran vdout1_54ck191 FIND v(dout1_54) AT=960.025n

* CHECK dout1_55 Vdout1_55ck191 = 0.9 time = 960
.meas tran vdout1_55ck191 FIND v(dout1_55) AT=960.025n

* CHECK dout1_56 Vdout1_56ck191 = 0 time = 960
.meas tran vdout1_56ck191 FIND v(dout1_56) AT=960.025n

* CHECK dout1_57 Vdout1_57ck191 = 0 time = 960
.meas tran vdout1_57ck191 FIND v(dout1_57) AT=960.025n

* CHECK dout1_58 Vdout1_58ck191 = 0 time = 960
.meas tran vdout1_58ck191 FIND v(dout1_58) AT=960.025n

* CHECK dout1_59 Vdout1_59ck191 = 0 time = 960
.meas tran vdout1_59ck191 FIND v(dout1_59) AT=960.025n

* CHECK dout1_60 Vdout1_60ck191 = 0 time = 960
.meas tran vdout1_60ck191 FIND v(dout1_60) AT=960.025n

* CHECK dout1_61 Vdout1_61ck191 = 0.9 time = 960
.meas tran vdout1_61ck191 FIND v(dout1_61) AT=960.025n

* CHECK dout1_62 Vdout1_62ck191 = 0.9 time = 960
.meas tran vdout1_62ck191 FIND v(dout1_62) AT=960.025n

* CHECK dout1_63 Vdout1_63ck191 = 0.9 time = 960
.meas tran vdout1_63ck191 FIND v(dout1_63) AT=960.025n

* CHECK dout1_64 Vdout1_64ck191 = 0 time = 960
.meas tran vdout1_64ck191 FIND v(dout1_64) AT=960.025n

* CHECK dout1_65 Vdout1_65ck191 = 0 time = 960
.meas tran vdout1_65ck191 FIND v(dout1_65) AT=960.025n

* CHECK dout1_66 Vdout1_66ck191 = 0.9 time = 960
.meas tran vdout1_66ck191 FIND v(dout1_66) AT=960.025n

* CHECK dout1_67 Vdout1_67ck191 = 0 time = 960
.meas tran vdout1_67ck191 FIND v(dout1_67) AT=960.025n

* CHECK dout1_68 Vdout1_68ck191 = 0 time = 960
.meas tran vdout1_68ck191 FIND v(dout1_68) AT=960.025n

* CHECK dout1_69 Vdout1_69ck191 = 0.9 time = 960
.meas tran vdout1_69ck191 FIND v(dout1_69) AT=960.025n

* CHECK dout1_70 Vdout1_70ck191 = 0.9 time = 960
.meas tran vdout1_70ck191 FIND v(dout1_70) AT=960.025n

* CHECK dout1_71 Vdout1_71ck191 = 0 time = 960
.meas tran vdout1_71ck191 FIND v(dout1_71) AT=960.025n

* CHECK dout1_72 Vdout1_72ck191 = 0 time = 960
.meas tran vdout1_72ck191 FIND v(dout1_72) AT=960.025n

* CHECK dout1_73 Vdout1_73ck191 = 0.9 time = 960
.meas tran vdout1_73ck191 FIND v(dout1_73) AT=960.025n

* CHECK dout1_74 Vdout1_74ck191 = 0 time = 960
.meas tran vdout1_74ck191 FIND v(dout1_74) AT=960.025n

* CHECK dout1_75 Vdout1_75ck191 = 0.9 time = 960
.meas tran vdout1_75ck191 FIND v(dout1_75) AT=960.025n

* CHECK dout1_76 Vdout1_76ck191 = 0.9 time = 960
.meas tran vdout1_76ck191 FIND v(dout1_76) AT=960.025n

* CHECK dout1_77 Vdout1_77ck191 = 0 time = 960
.meas tran vdout1_77ck191 FIND v(dout1_77) AT=960.025n

* CHECK dout1_78 Vdout1_78ck191 = 0 time = 960
.meas tran vdout1_78ck191 FIND v(dout1_78) AT=960.025n

* CHECK dout1_79 Vdout1_79ck191 = 0.9 time = 960
.meas tran vdout1_79ck191 FIND v(dout1_79) AT=960.025n

* CHECK dout1_80 Vdout1_80ck191 = 0.9 time = 960
.meas tran vdout1_80ck191 FIND v(dout1_80) AT=960.025n

* CHECK dout1_81 Vdout1_81ck191 = 0 time = 960
.meas tran vdout1_81ck191 FIND v(dout1_81) AT=960.025n

* CHECK dout1_82 Vdout1_82ck191 = 0 time = 960
.meas tran vdout1_82ck191 FIND v(dout1_82) AT=960.025n

* CHECK dout1_83 Vdout1_83ck191 = 0 time = 960
.meas tran vdout1_83ck191 FIND v(dout1_83) AT=960.025n

* CHECK dout1_84 Vdout1_84ck191 = 0.9 time = 960
.meas tran vdout1_84ck191 FIND v(dout1_84) AT=960.025n

* CHECK dout1_85 Vdout1_85ck191 = 0.9 time = 960
.meas tran vdout1_85ck191 FIND v(dout1_85) AT=960.025n

* CHECK dout1_86 Vdout1_86ck191 = 0 time = 960
.meas tran vdout1_86ck191 FIND v(dout1_86) AT=960.025n

* CHECK dout1_87 Vdout1_87ck191 = 0.9 time = 960
.meas tran vdout1_87ck191 FIND v(dout1_87) AT=960.025n

* CHECK dout1_88 Vdout1_88ck191 = 0.9 time = 960
.meas tran vdout1_88ck191 FIND v(dout1_88) AT=960.025n

* CHECK dout1_89 Vdout1_89ck191 = 0.9 time = 960
.meas tran vdout1_89ck191 FIND v(dout1_89) AT=960.025n

* CHECK dout1_90 Vdout1_90ck191 = 0 time = 960
.meas tran vdout1_90ck191 FIND v(dout1_90) AT=960.025n

* CHECK dout1_91 Vdout1_91ck191 = 0.9 time = 960
.meas tran vdout1_91ck191 FIND v(dout1_91) AT=960.025n

* CHECK dout1_92 Vdout1_92ck191 = 0.9 time = 960
.meas tran vdout1_92ck191 FIND v(dout1_92) AT=960.025n

* CHECK dout1_93 Vdout1_93ck191 = 0.9 time = 960
.meas tran vdout1_93ck191 FIND v(dout1_93) AT=960.025n

* CHECK dout1_94 Vdout1_94ck191 = 0.9 time = 960
.meas tran vdout1_94ck191 FIND v(dout1_94) AT=960.025n

* CHECK dout1_95 Vdout1_95ck191 = 0 time = 960
.meas tran vdout1_95ck191 FIND v(dout1_95) AT=960.025n

* CHECK dout1_96 Vdout1_96ck191 = 0.9 time = 960
.meas tran vdout1_96ck191 FIND v(dout1_96) AT=960.025n

* CHECK dout1_97 Vdout1_97ck191 = 0 time = 960
.meas tran vdout1_97ck191 FIND v(dout1_97) AT=960.025n

* CHECK dout1_98 Vdout1_98ck191 = 0 time = 960
.meas tran vdout1_98ck191 FIND v(dout1_98) AT=960.025n

* CHECK dout1_99 Vdout1_99ck191 = 0.9 time = 960
.meas tran vdout1_99ck191 FIND v(dout1_99) AT=960.025n

* CHECK dout1_100 Vdout1_100ck191 = 0 time = 960
.meas tran vdout1_100ck191 FIND v(dout1_100) AT=960.025n

* CHECK dout1_101 Vdout1_101ck191 = 0.9 time = 960
.meas tran vdout1_101ck191 FIND v(dout1_101) AT=960.025n

* CHECK dout1_102 Vdout1_102ck191 = 0 time = 960
.meas tran vdout1_102ck191 FIND v(dout1_102) AT=960.025n

* CHECK dout1_103 Vdout1_103ck191 = 0.9 time = 960
.meas tran vdout1_103ck191 FIND v(dout1_103) AT=960.025n

* CHECK dout1_104 Vdout1_104ck191 = 0 time = 960
.meas tran vdout1_104ck191 FIND v(dout1_104) AT=960.025n

* CHECK dout1_105 Vdout1_105ck191 = 0.9 time = 960
.meas tran vdout1_105ck191 FIND v(dout1_105) AT=960.025n

* CHECK dout1_106 Vdout1_106ck191 = 0.9 time = 960
.meas tran vdout1_106ck191 FIND v(dout1_106) AT=960.025n

* CHECK dout1_107 Vdout1_107ck191 = 0 time = 960
.meas tran vdout1_107ck191 FIND v(dout1_107) AT=960.025n

* CHECK dout1_108 Vdout1_108ck191 = 0 time = 960
.meas tran vdout1_108ck191 FIND v(dout1_108) AT=960.025n

* CHECK dout1_109 Vdout1_109ck191 = 0.9 time = 960
.meas tran vdout1_109ck191 FIND v(dout1_109) AT=960.025n

* CHECK dout1_110 Vdout1_110ck191 = 0 time = 960
.meas tran vdout1_110ck191 FIND v(dout1_110) AT=960.025n

* CHECK dout1_111 Vdout1_111ck191 = 0 time = 960
.meas tran vdout1_111ck191 FIND v(dout1_111) AT=960.025n

* CHECK dout1_112 Vdout1_112ck191 = 0.9 time = 960
.meas tran vdout1_112ck191 FIND v(dout1_112) AT=960.025n

* CHECK dout1_113 Vdout1_113ck191 = 0.9 time = 960
.meas tran vdout1_113ck191 FIND v(dout1_113) AT=960.025n

* CHECK dout1_114 Vdout1_114ck191 = 0.9 time = 960
.meas tran vdout1_114ck191 FIND v(dout1_114) AT=960.025n

* CHECK dout1_115 Vdout1_115ck191 = 0 time = 960
.meas tran vdout1_115ck191 FIND v(dout1_115) AT=960.025n

* CHECK dout1_116 Vdout1_116ck191 = 0 time = 960
.meas tran vdout1_116ck191 FIND v(dout1_116) AT=960.025n

* CHECK dout1_117 Vdout1_117ck191 = 0 time = 960
.meas tran vdout1_117ck191 FIND v(dout1_117) AT=960.025n

* CHECK dout1_118 Vdout1_118ck191 = 0.9 time = 960
.meas tran vdout1_118ck191 FIND v(dout1_118) AT=960.025n

* CHECK dout1_119 Vdout1_119ck191 = 0.9 time = 960
.meas tran vdout1_119ck191 FIND v(dout1_119) AT=960.025n

* CHECK dout1_0 Vdout1_0ck193 = 0.9 time = 970
.meas tran vdout1_0ck193 FIND v(dout1_0) AT=970.025n

* CHECK dout1_1 Vdout1_1ck193 = 0.9 time = 970
.meas tran vdout1_1ck193 FIND v(dout1_1) AT=970.025n

* CHECK dout1_2 Vdout1_2ck193 = 0 time = 970
.meas tran vdout1_2ck193 FIND v(dout1_2) AT=970.025n

* CHECK dout1_3 Vdout1_3ck193 = 0.9 time = 970
.meas tran vdout1_3ck193 FIND v(dout1_3) AT=970.025n

* CHECK dout1_4 Vdout1_4ck193 = 0.9 time = 970
.meas tran vdout1_4ck193 FIND v(dout1_4) AT=970.025n

* CHECK dout1_5 Vdout1_5ck193 = 0.9 time = 970
.meas tran vdout1_5ck193 FIND v(dout1_5) AT=970.025n

* CHECK dout1_6 Vdout1_6ck193 = 0.9 time = 970
.meas tran vdout1_6ck193 FIND v(dout1_6) AT=970.025n

* CHECK dout1_7 Vdout1_7ck193 = 0.9 time = 970
.meas tran vdout1_7ck193 FIND v(dout1_7) AT=970.025n

* CHECK dout1_8 Vdout1_8ck193 = 0 time = 970
.meas tran vdout1_8ck193 FIND v(dout1_8) AT=970.025n

* CHECK dout1_9 Vdout1_9ck193 = 0 time = 970
.meas tran vdout1_9ck193 FIND v(dout1_9) AT=970.025n

* CHECK dout1_10 Vdout1_10ck193 = 0.9 time = 970
.meas tran vdout1_10ck193 FIND v(dout1_10) AT=970.025n

* CHECK dout1_11 Vdout1_11ck193 = 0.9 time = 970
.meas tran vdout1_11ck193 FIND v(dout1_11) AT=970.025n

* CHECK dout1_12 Vdout1_12ck193 = 0.9 time = 970
.meas tran vdout1_12ck193 FIND v(dout1_12) AT=970.025n

* CHECK dout1_13 Vdout1_13ck193 = 0 time = 970
.meas tran vdout1_13ck193 FIND v(dout1_13) AT=970.025n

* CHECK dout1_14 Vdout1_14ck193 = 0.9 time = 970
.meas tran vdout1_14ck193 FIND v(dout1_14) AT=970.025n

* CHECK dout1_15 Vdout1_15ck193 = 0 time = 970
.meas tran vdout1_15ck193 FIND v(dout1_15) AT=970.025n

* CHECK dout1_16 Vdout1_16ck193 = 0 time = 970
.meas tran vdout1_16ck193 FIND v(dout1_16) AT=970.025n

* CHECK dout1_17 Vdout1_17ck193 = 0 time = 970
.meas tran vdout1_17ck193 FIND v(dout1_17) AT=970.025n

* CHECK dout1_18 Vdout1_18ck193 = 0.9 time = 970
.meas tran vdout1_18ck193 FIND v(dout1_18) AT=970.025n

* CHECK dout1_19 Vdout1_19ck193 = 0 time = 970
.meas tran vdout1_19ck193 FIND v(dout1_19) AT=970.025n

* CHECK dout1_20 Vdout1_20ck193 = 0.9 time = 970
.meas tran vdout1_20ck193 FIND v(dout1_20) AT=970.025n

* CHECK dout1_21 Vdout1_21ck193 = 0 time = 970
.meas tran vdout1_21ck193 FIND v(dout1_21) AT=970.025n

* CHECK dout1_22 Vdout1_22ck193 = 0.9 time = 970
.meas tran vdout1_22ck193 FIND v(dout1_22) AT=970.025n

* CHECK dout1_23 Vdout1_23ck193 = 0.9 time = 970
.meas tran vdout1_23ck193 FIND v(dout1_23) AT=970.025n

* CHECK dout1_24 Vdout1_24ck193 = 0 time = 970
.meas tran vdout1_24ck193 FIND v(dout1_24) AT=970.025n

* CHECK dout1_25 Vdout1_25ck193 = 0 time = 970
.meas tran vdout1_25ck193 FIND v(dout1_25) AT=970.025n

* CHECK dout1_26 Vdout1_26ck193 = 0.9 time = 970
.meas tran vdout1_26ck193 FIND v(dout1_26) AT=970.025n

* CHECK dout1_27 Vdout1_27ck193 = 0 time = 970
.meas tran vdout1_27ck193 FIND v(dout1_27) AT=970.025n

* CHECK dout1_28 Vdout1_28ck193 = 0.9 time = 970
.meas tran vdout1_28ck193 FIND v(dout1_28) AT=970.025n

* CHECK dout1_29 Vdout1_29ck193 = 0.9 time = 970
.meas tran vdout1_29ck193 FIND v(dout1_29) AT=970.025n

* CHECK dout1_30 Vdout1_30ck193 = 0 time = 970
.meas tran vdout1_30ck193 FIND v(dout1_30) AT=970.025n

* CHECK dout1_31 Vdout1_31ck193 = 0 time = 970
.meas tran vdout1_31ck193 FIND v(dout1_31) AT=970.025n

* CHECK dout1_32 Vdout1_32ck193 = 0 time = 970
.meas tran vdout1_32ck193 FIND v(dout1_32) AT=970.025n

* CHECK dout1_33 Vdout1_33ck193 = 0 time = 970
.meas tran vdout1_33ck193 FIND v(dout1_33) AT=970.025n

* CHECK dout1_34 Vdout1_34ck193 = 0 time = 970
.meas tran vdout1_34ck193 FIND v(dout1_34) AT=970.025n

* CHECK dout1_35 Vdout1_35ck193 = 0.9 time = 970
.meas tran vdout1_35ck193 FIND v(dout1_35) AT=970.025n

* CHECK dout1_36 Vdout1_36ck193 = 0.9 time = 970
.meas tran vdout1_36ck193 FIND v(dout1_36) AT=970.025n

* CHECK dout1_37 Vdout1_37ck193 = 0.9 time = 970
.meas tran vdout1_37ck193 FIND v(dout1_37) AT=970.025n

* CHECK dout1_38 Vdout1_38ck193 = 0.9 time = 970
.meas tran vdout1_38ck193 FIND v(dout1_38) AT=970.025n

* CHECK dout1_39 Vdout1_39ck193 = 0 time = 970
.meas tran vdout1_39ck193 FIND v(dout1_39) AT=970.025n

* CHECK dout1_40 Vdout1_40ck193 = 0 time = 970
.meas tran vdout1_40ck193 FIND v(dout1_40) AT=970.025n

* CHECK dout1_41 Vdout1_41ck193 = 0.9 time = 970
.meas tran vdout1_41ck193 FIND v(dout1_41) AT=970.025n

* CHECK dout1_42 Vdout1_42ck193 = 0 time = 970
.meas tran vdout1_42ck193 FIND v(dout1_42) AT=970.025n

* CHECK dout1_43 Vdout1_43ck193 = 0 time = 970
.meas tran vdout1_43ck193 FIND v(dout1_43) AT=970.025n

* CHECK dout1_44 Vdout1_44ck193 = 0 time = 970
.meas tran vdout1_44ck193 FIND v(dout1_44) AT=970.025n

* CHECK dout1_45 Vdout1_45ck193 = 0.9 time = 970
.meas tran vdout1_45ck193 FIND v(dout1_45) AT=970.025n

* CHECK dout1_46 Vdout1_46ck193 = 0 time = 970
.meas tran vdout1_46ck193 FIND v(dout1_46) AT=970.025n

* CHECK dout1_47 Vdout1_47ck193 = 0.9 time = 970
.meas tran vdout1_47ck193 FIND v(dout1_47) AT=970.025n

* CHECK dout1_48 Vdout1_48ck193 = 0 time = 970
.meas tran vdout1_48ck193 FIND v(dout1_48) AT=970.025n

* CHECK dout1_49 Vdout1_49ck193 = 0 time = 970
.meas tran vdout1_49ck193 FIND v(dout1_49) AT=970.025n

* CHECK dout1_50 Vdout1_50ck193 = 0 time = 970
.meas tran vdout1_50ck193 FIND v(dout1_50) AT=970.025n

* CHECK dout1_51 Vdout1_51ck193 = 0.9 time = 970
.meas tran vdout1_51ck193 FIND v(dout1_51) AT=970.025n

* CHECK dout1_52 Vdout1_52ck193 = 0.9 time = 970
.meas tran vdout1_52ck193 FIND v(dout1_52) AT=970.025n

* CHECK dout1_53 Vdout1_53ck193 = 0 time = 970
.meas tran vdout1_53ck193 FIND v(dout1_53) AT=970.025n

* CHECK dout1_54 Vdout1_54ck193 = 0 time = 970
.meas tran vdout1_54ck193 FIND v(dout1_54) AT=970.025n

* CHECK dout1_55 Vdout1_55ck193 = 0 time = 970
.meas tran vdout1_55ck193 FIND v(dout1_55) AT=970.025n

* CHECK dout1_56 Vdout1_56ck193 = 0.9 time = 970
.meas tran vdout1_56ck193 FIND v(dout1_56) AT=970.025n

* CHECK dout1_57 Vdout1_57ck193 = 0 time = 970
.meas tran vdout1_57ck193 FIND v(dout1_57) AT=970.025n

* CHECK dout1_58 Vdout1_58ck193 = 0 time = 970
.meas tran vdout1_58ck193 FIND v(dout1_58) AT=970.025n

* CHECK dout1_59 Vdout1_59ck193 = 0 time = 970
.meas tran vdout1_59ck193 FIND v(dout1_59) AT=970.025n

* CHECK dout1_60 Vdout1_60ck193 = 0 time = 970
.meas tran vdout1_60ck193 FIND v(dout1_60) AT=970.025n

* CHECK dout1_61 Vdout1_61ck193 = 0 time = 970
.meas tran vdout1_61ck193 FIND v(dout1_61) AT=970.025n

* CHECK dout1_62 Vdout1_62ck193 = 0.9 time = 970
.meas tran vdout1_62ck193 FIND v(dout1_62) AT=970.025n

* CHECK dout1_63 Vdout1_63ck193 = 0.9 time = 970
.meas tran vdout1_63ck193 FIND v(dout1_63) AT=970.025n

* CHECK dout1_64 Vdout1_64ck193 = 0.9 time = 970
.meas tran vdout1_64ck193 FIND v(dout1_64) AT=970.025n

* CHECK dout1_65 Vdout1_65ck193 = 0.9 time = 970
.meas tran vdout1_65ck193 FIND v(dout1_65) AT=970.025n

* CHECK dout1_66 Vdout1_66ck193 = 0 time = 970
.meas tran vdout1_66ck193 FIND v(dout1_66) AT=970.025n

* CHECK dout1_67 Vdout1_67ck193 = 0.9 time = 970
.meas tran vdout1_67ck193 FIND v(dout1_67) AT=970.025n

* CHECK dout1_68 Vdout1_68ck193 = 0 time = 970
.meas tran vdout1_68ck193 FIND v(dout1_68) AT=970.025n

* CHECK dout1_69 Vdout1_69ck193 = 0 time = 970
.meas tran vdout1_69ck193 FIND v(dout1_69) AT=970.025n

* CHECK dout1_70 Vdout1_70ck193 = 0.9 time = 970
.meas tran vdout1_70ck193 FIND v(dout1_70) AT=970.025n

* CHECK dout1_71 Vdout1_71ck193 = 0.9 time = 970
.meas tran vdout1_71ck193 FIND v(dout1_71) AT=970.025n

* CHECK dout1_72 Vdout1_72ck193 = 0.9 time = 970
.meas tran vdout1_72ck193 FIND v(dout1_72) AT=970.025n

* CHECK dout1_73 Vdout1_73ck193 = 0 time = 970
.meas tran vdout1_73ck193 FIND v(dout1_73) AT=970.025n

* CHECK dout1_74 Vdout1_74ck193 = 0 time = 970
.meas tran vdout1_74ck193 FIND v(dout1_74) AT=970.025n

* CHECK dout1_75 Vdout1_75ck193 = 0 time = 970
.meas tran vdout1_75ck193 FIND v(dout1_75) AT=970.025n

* CHECK dout1_76 Vdout1_76ck193 = 0 time = 970
.meas tran vdout1_76ck193 FIND v(dout1_76) AT=970.025n

* CHECK dout1_77 Vdout1_77ck193 = 0.9 time = 970
.meas tran vdout1_77ck193 FIND v(dout1_77) AT=970.025n

* CHECK dout1_78 Vdout1_78ck193 = 0 time = 970
.meas tran vdout1_78ck193 FIND v(dout1_78) AT=970.025n

* CHECK dout1_79 Vdout1_79ck193 = 0 time = 970
.meas tran vdout1_79ck193 FIND v(dout1_79) AT=970.025n

* CHECK dout1_80 Vdout1_80ck193 = 0.9 time = 970
.meas tran vdout1_80ck193 FIND v(dout1_80) AT=970.025n

* CHECK dout1_81 Vdout1_81ck193 = 0.9 time = 970
.meas tran vdout1_81ck193 FIND v(dout1_81) AT=970.025n

* CHECK dout1_82 Vdout1_82ck193 = 0 time = 970
.meas tran vdout1_82ck193 FIND v(dout1_82) AT=970.025n

* CHECK dout1_83 Vdout1_83ck193 = 0.9 time = 970
.meas tran vdout1_83ck193 FIND v(dout1_83) AT=970.025n

* CHECK dout1_84 Vdout1_84ck193 = 0 time = 970
.meas tran vdout1_84ck193 FIND v(dout1_84) AT=970.025n

* CHECK dout1_85 Vdout1_85ck193 = 0.9 time = 970
.meas tran vdout1_85ck193 FIND v(dout1_85) AT=970.025n

* CHECK dout1_86 Vdout1_86ck193 = 0.9 time = 970
.meas tran vdout1_86ck193 FIND v(dout1_86) AT=970.025n

* CHECK dout1_87 Vdout1_87ck193 = 0.9 time = 970
.meas tran vdout1_87ck193 FIND v(dout1_87) AT=970.025n

* CHECK dout1_88 Vdout1_88ck193 = 0 time = 970
.meas tran vdout1_88ck193 FIND v(dout1_88) AT=970.025n

* CHECK dout1_89 Vdout1_89ck193 = 0.9 time = 970
.meas tran vdout1_89ck193 FIND v(dout1_89) AT=970.025n

* CHECK dout1_90 Vdout1_90ck193 = 0 time = 970
.meas tran vdout1_90ck193 FIND v(dout1_90) AT=970.025n

* CHECK dout1_91 Vdout1_91ck193 = 0.9 time = 970
.meas tran vdout1_91ck193 FIND v(dout1_91) AT=970.025n

* CHECK dout1_92 Vdout1_92ck193 = 0.9 time = 970
.meas tran vdout1_92ck193 FIND v(dout1_92) AT=970.025n

* CHECK dout1_93 Vdout1_93ck193 = 0.9 time = 970
.meas tran vdout1_93ck193 FIND v(dout1_93) AT=970.025n

* CHECK dout1_94 Vdout1_94ck193 = 0.9 time = 970
.meas tran vdout1_94ck193 FIND v(dout1_94) AT=970.025n

* CHECK dout1_95 Vdout1_95ck193 = 0 time = 970
.meas tran vdout1_95ck193 FIND v(dout1_95) AT=970.025n

* CHECK dout1_96 Vdout1_96ck193 = 0.9 time = 970
.meas tran vdout1_96ck193 FIND v(dout1_96) AT=970.025n

* CHECK dout1_97 Vdout1_97ck193 = 0.9 time = 970
.meas tran vdout1_97ck193 FIND v(dout1_97) AT=970.025n

* CHECK dout1_98 Vdout1_98ck193 = 0 time = 970
.meas tran vdout1_98ck193 FIND v(dout1_98) AT=970.025n

* CHECK dout1_99 Vdout1_99ck193 = 0.9 time = 970
.meas tran vdout1_99ck193 FIND v(dout1_99) AT=970.025n

* CHECK dout1_100 Vdout1_100ck193 = 0.9 time = 970
.meas tran vdout1_100ck193 FIND v(dout1_100) AT=970.025n

* CHECK dout1_101 Vdout1_101ck193 = 0 time = 970
.meas tran vdout1_101ck193 FIND v(dout1_101) AT=970.025n

* CHECK dout1_102 Vdout1_102ck193 = 0.9 time = 970
.meas tran vdout1_102ck193 FIND v(dout1_102) AT=970.025n

* CHECK dout1_103 Vdout1_103ck193 = 0 time = 970
.meas tran vdout1_103ck193 FIND v(dout1_103) AT=970.025n

* CHECK dout1_104 Vdout1_104ck193 = 0.9 time = 970
.meas tran vdout1_104ck193 FIND v(dout1_104) AT=970.025n

* CHECK dout1_105 Vdout1_105ck193 = 0 time = 970
.meas tran vdout1_105ck193 FIND v(dout1_105) AT=970.025n

* CHECK dout1_106 Vdout1_106ck193 = 0 time = 970
.meas tran vdout1_106ck193 FIND v(dout1_106) AT=970.025n

* CHECK dout1_107 Vdout1_107ck193 = 0.9 time = 970
.meas tran vdout1_107ck193 FIND v(dout1_107) AT=970.025n

* CHECK dout1_108 Vdout1_108ck193 = 0 time = 970
.meas tran vdout1_108ck193 FIND v(dout1_108) AT=970.025n

* CHECK dout1_109 Vdout1_109ck193 = 0 time = 970
.meas tran vdout1_109ck193 FIND v(dout1_109) AT=970.025n

* CHECK dout1_110 Vdout1_110ck193 = 0 time = 970
.meas tran vdout1_110ck193 FIND v(dout1_110) AT=970.025n

* CHECK dout1_111 Vdout1_111ck193 = 0 time = 970
.meas tran vdout1_111ck193 FIND v(dout1_111) AT=970.025n

* CHECK dout1_112 Vdout1_112ck193 = 0.9 time = 970
.meas tran vdout1_112ck193 FIND v(dout1_112) AT=970.025n

* CHECK dout1_113 Vdout1_113ck193 = 0 time = 970
.meas tran vdout1_113ck193 FIND v(dout1_113) AT=970.025n

* CHECK dout1_114 Vdout1_114ck193 = 0 time = 970
.meas tran vdout1_114ck193 FIND v(dout1_114) AT=970.025n

* CHECK dout1_115 Vdout1_115ck193 = 0 time = 970
.meas tran vdout1_115ck193 FIND v(dout1_115) AT=970.025n

* CHECK dout1_116 Vdout1_116ck193 = 0.9 time = 970
.meas tran vdout1_116ck193 FIND v(dout1_116) AT=970.025n

* CHECK dout1_117 Vdout1_117ck193 = 0 time = 970
.meas tran vdout1_117ck193 FIND v(dout1_117) AT=970.025n

* CHECK dout1_118 Vdout1_118ck193 = 0.9 time = 970
.meas tran vdout1_118ck193 FIND v(dout1_118) AT=970.025n

* CHECK dout1_119 Vdout1_119ck193 = 0 time = 970
.meas tran vdout1_119ck193 FIND v(dout1_119) AT=970.025n

* CHECK dout1_0 Vdout1_0ck194 = 0.9 time = 975
.meas tran vdout1_0ck194 FIND v(dout1_0) AT=975.025n

* CHECK dout1_1 Vdout1_1ck194 = 0.9 time = 975
.meas tran vdout1_1ck194 FIND v(dout1_1) AT=975.025n

* CHECK dout1_2 Vdout1_2ck194 = 0 time = 975
.meas tran vdout1_2ck194 FIND v(dout1_2) AT=975.025n

* CHECK dout1_3 Vdout1_3ck194 = 0.9 time = 975
.meas tran vdout1_3ck194 FIND v(dout1_3) AT=975.025n

* CHECK dout1_4 Vdout1_4ck194 = 0.9 time = 975
.meas tran vdout1_4ck194 FIND v(dout1_4) AT=975.025n

* CHECK dout1_5 Vdout1_5ck194 = 0.9 time = 975
.meas tran vdout1_5ck194 FIND v(dout1_5) AT=975.025n

* CHECK dout1_6 Vdout1_6ck194 = 0.9 time = 975
.meas tran vdout1_6ck194 FIND v(dout1_6) AT=975.025n

* CHECK dout1_7 Vdout1_7ck194 = 0.9 time = 975
.meas tran vdout1_7ck194 FIND v(dout1_7) AT=975.025n

* CHECK dout1_8 Vdout1_8ck194 = 0 time = 975
.meas tran vdout1_8ck194 FIND v(dout1_8) AT=975.025n

* CHECK dout1_9 Vdout1_9ck194 = 0 time = 975
.meas tran vdout1_9ck194 FIND v(dout1_9) AT=975.025n

* CHECK dout1_10 Vdout1_10ck194 = 0.9 time = 975
.meas tran vdout1_10ck194 FIND v(dout1_10) AT=975.025n

* CHECK dout1_11 Vdout1_11ck194 = 0.9 time = 975
.meas tran vdout1_11ck194 FIND v(dout1_11) AT=975.025n

* CHECK dout1_12 Vdout1_12ck194 = 0.9 time = 975
.meas tran vdout1_12ck194 FIND v(dout1_12) AT=975.025n

* CHECK dout1_13 Vdout1_13ck194 = 0 time = 975
.meas tran vdout1_13ck194 FIND v(dout1_13) AT=975.025n

* CHECK dout1_14 Vdout1_14ck194 = 0.9 time = 975
.meas tran vdout1_14ck194 FIND v(dout1_14) AT=975.025n

* CHECK dout1_15 Vdout1_15ck194 = 0 time = 975
.meas tran vdout1_15ck194 FIND v(dout1_15) AT=975.025n

* CHECK dout1_16 Vdout1_16ck194 = 0 time = 975
.meas tran vdout1_16ck194 FIND v(dout1_16) AT=975.025n

* CHECK dout1_17 Vdout1_17ck194 = 0 time = 975
.meas tran vdout1_17ck194 FIND v(dout1_17) AT=975.025n

* CHECK dout1_18 Vdout1_18ck194 = 0.9 time = 975
.meas tran vdout1_18ck194 FIND v(dout1_18) AT=975.025n

* CHECK dout1_19 Vdout1_19ck194 = 0 time = 975
.meas tran vdout1_19ck194 FIND v(dout1_19) AT=975.025n

* CHECK dout1_20 Vdout1_20ck194 = 0.9 time = 975
.meas tran vdout1_20ck194 FIND v(dout1_20) AT=975.025n

* CHECK dout1_21 Vdout1_21ck194 = 0 time = 975
.meas tran vdout1_21ck194 FIND v(dout1_21) AT=975.025n

* CHECK dout1_22 Vdout1_22ck194 = 0.9 time = 975
.meas tran vdout1_22ck194 FIND v(dout1_22) AT=975.025n

* CHECK dout1_23 Vdout1_23ck194 = 0.9 time = 975
.meas tran vdout1_23ck194 FIND v(dout1_23) AT=975.025n

* CHECK dout1_24 Vdout1_24ck194 = 0 time = 975
.meas tran vdout1_24ck194 FIND v(dout1_24) AT=975.025n

* CHECK dout1_25 Vdout1_25ck194 = 0 time = 975
.meas tran vdout1_25ck194 FIND v(dout1_25) AT=975.025n

* CHECK dout1_26 Vdout1_26ck194 = 0.9 time = 975
.meas tran vdout1_26ck194 FIND v(dout1_26) AT=975.025n

* CHECK dout1_27 Vdout1_27ck194 = 0 time = 975
.meas tran vdout1_27ck194 FIND v(dout1_27) AT=975.025n

* CHECK dout1_28 Vdout1_28ck194 = 0.9 time = 975
.meas tran vdout1_28ck194 FIND v(dout1_28) AT=975.025n

* CHECK dout1_29 Vdout1_29ck194 = 0.9 time = 975
.meas tran vdout1_29ck194 FIND v(dout1_29) AT=975.025n

* CHECK dout1_30 Vdout1_30ck194 = 0 time = 975
.meas tran vdout1_30ck194 FIND v(dout1_30) AT=975.025n

* CHECK dout1_31 Vdout1_31ck194 = 0 time = 975
.meas tran vdout1_31ck194 FIND v(dout1_31) AT=975.025n

* CHECK dout1_32 Vdout1_32ck194 = 0 time = 975
.meas tran vdout1_32ck194 FIND v(dout1_32) AT=975.025n

* CHECK dout1_33 Vdout1_33ck194 = 0 time = 975
.meas tran vdout1_33ck194 FIND v(dout1_33) AT=975.025n

* CHECK dout1_34 Vdout1_34ck194 = 0 time = 975
.meas tran vdout1_34ck194 FIND v(dout1_34) AT=975.025n

* CHECK dout1_35 Vdout1_35ck194 = 0.9 time = 975
.meas tran vdout1_35ck194 FIND v(dout1_35) AT=975.025n

* CHECK dout1_36 Vdout1_36ck194 = 0.9 time = 975
.meas tran vdout1_36ck194 FIND v(dout1_36) AT=975.025n

* CHECK dout1_37 Vdout1_37ck194 = 0.9 time = 975
.meas tran vdout1_37ck194 FIND v(dout1_37) AT=975.025n

* CHECK dout1_38 Vdout1_38ck194 = 0.9 time = 975
.meas tran vdout1_38ck194 FIND v(dout1_38) AT=975.025n

* CHECK dout1_39 Vdout1_39ck194 = 0 time = 975
.meas tran vdout1_39ck194 FIND v(dout1_39) AT=975.025n

* CHECK dout1_40 Vdout1_40ck194 = 0 time = 975
.meas tran vdout1_40ck194 FIND v(dout1_40) AT=975.025n

* CHECK dout1_41 Vdout1_41ck194 = 0.9 time = 975
.meas tran vdout1_41ck194 FIND v(dout1_41) AT=975.025n

* CHECK dout1_42 Vdout1_42ck194 = 0 time = 975
.meas tran vdout1_42ck194 FIND v(dout1_42) AT=975.025n

* CHECK dout1_43 Vdout1_43ck194 = 0 time = 975
.meas tran vdout1_43ck194 FIND v(dout1_43) AT=975.025n

* CHECK dout1_44 Vdout1_44ck194 = 0 time = 975
.meas tran vdout1_44ck194 FIND v(dout1_44) AT=975.025n

* CHECK dout1_45 Vdout1_45ck194 = 0.9 time = 975
.meas tran vdout1_45ck194 FIND v(dout1_45) AT=975.025n

* CHECK dout1_46 Vdout1_46ck194 = 0 time = 975
.meas tran vdout1_46ck194 FIND v(dout1_46) AT=975.025n

* CHECK dout1_47 Vdout1_47ck194 = 0.9 time = 975
.meas tran vdout1_47ck194 FIND v(dout1_47) AT=975.025n

* CHECK dout1_48 Vdout1_48ck194 = 0 time = 975
.meas tran vdout1_48ck194 FIND v(dout1_48) AT=975.025n

* CHECK dout1_49 Vdout1_49ck194 = 0 time = 975
.meas tran vdout1_49ck194 FIND v(dout1_49) AT=975.025n

* CHECK dout1_50 Vdout1_50ck194 = 0 time = 975
.meas tran vdout1_50ck194 FIND v(dout1_50) AT=975.025n

* CHECK dout1_51 Vdout1_51ck194 = 0.9 time = 975
.meas tran vdout1_51ck194 FIND v(dout1_51) AT=975.025n

* CHECK dout1_52 Vdout1_52ck194 = 0.9 time = 975
.meas tran vdout1_52ck194 FIND v(dout1_52) AT=975.025n

* CHECK dout1_53 Vdout1_53ck194 = 0 time = 975
.meas tran vdout1_53ck194 FIND v(dout1_53) AT=975.025n

* CHECK dout1_54 Vdout1_54ck194 = 0 time = 975
.meas tran vdout1_54ck194 FIND v(dout1_54) AT=975.025n

* CHECK dout1_55 Vdout1_55ck194 = 0 time = 975
.meas tran vdout1_55ck194 FIND v(dout1_55) AT=975.025n

* CHECK dout1_56 Vdout1_56ck194 = 0.9 time = 975
.meas tran vdout1_56ck194 FIND v(dout1_56) AT=975.025n

* CHECK dout1_57 Vdout1_57ck194 = 0 time = 975
.meas tran vdout1_57ck194 FIND v(dout1_57) AT=975.025n

* CHECK dout1_58 Vdout1_58ck194 = 0 time = 975
.meas tran vdout1_58ck194 FIND v(dout1_58) AT=975.025n

* CHECK dout1_59 Vdout1_59ck194 = 0 time = 975
.meas tran vdout1_59ck194 FIND v(dout1_59) AT=975.025n

* CHECK dout1_60 Vdout1_60ck194 = 0 time = 975
.meas tran vdout1_60ck194 FIND v(dout1_60) AT=975.025n

* CHECK dout1_61 Vdout1_61ck194 = 0 time = 975
.meas tran vdout1_61ck194 FIND v(dout1_61) AT=975.025n

* CHECK dout1_62 Vdout1_62ck194 = 0.9 time = 975
.meas tran vdout1_62ck194 FIND v(dout1_62) AT=975.025n

* CHECK dout1_63 Vdout1_63ck194 = 0.9 time = 975
.meas tran vdout1_63ck194 FIND v(dout1_63) AT=975.025n

* CHECK dout1_64 Vdout1_64ck194 = 0.9 time = 975
.meas tran vdout1_64ck194 FIND v(dout1_64) AT=975.025n

* CHECK dout1_65 Vdout1_65ck194 = 0.9 time = 975
.meas tran vdout1_65ck194 FIND v(dout1_65) AT=975.025n

* CHECK dout1_66 Vdout1_66ck194 = 0 time = 975
.meas tran vdout1_66ck194 FIND v(dout1_66) AT=975.025n

* CHECK dout1_67 Vdout1_67ck194 = 0.9 time = 975
.meas tran vdout1_67ck194 FIND v(dout1_67) AT=975.025n

* CHECK dout1_68 Vdout1_68ck194 = 0 time = 975
.meas tran vdout1_68ck194 FIND v(dout1_68) AT=975.025n

* CHECK dout1_69 Vdout1_69ck194 = 0 time = 975
.meas tran vdout1_69ck194 FIND v(dout1_69) AT=975.025n

* CHECK dout1_70 Vdout1_70ck194 = 0.9 time = 975
.meas tran vdout1_70ck194 FIND v(dout1_70) AT=975.025n

* CHECK dout1_71 Vdout1_71ck194 = 0.9 time = 975
.meas tran vdout1_71ck194 FIND v(dout1_71) AT=975.025n

* CHECK dout1_72 Vdout1_72ck194 = 0.9 time = 975
.meas tran vdout1_72ck194 FIND v(dout1_72) AT=975.025n

* CHECK dout1_73 Vdout1_73ck194 = 0 time = 975
.meas tran vdout1_73ck194 FIND v(dout1_73) AT=975.025n

* CHECK dout1_74 Vdout1_74ck194 = 0 time = 975
.meas tran vdout1_74ck194 FIND v(dout1_74) AT=975.025n

* CHECK dout1_75 Vdout1_75ck194 = 0 time = 975
.meas tran vdout1_75ck194 FIND v(dout1_75) AT=975.025n

* CHECK dout1_76 Vdout1_76ck194 = 0 time = 975
.meas tran vdout1_76ck194 FIND v(dout1_76) AT=975.025n

* CHECK dout1_77 Vdout1_77ck194 = 0.9 time = 975
.meas tran vdout1_77ck194 FIND v(dout1_77) AT=975.025n

* CHECK dout1_78 Vdout1_78ck194 = 0 time = 975
.meas tran vdout1_78ck194 FIND v(dout1_78) AT=975.025n

* CHECK dout1_79 Vdout1_79ck194 = 0 time = 975
.meas tran vdout1_79ck194 FIND v(dout1_79) AT=975.025n

* CHECK dout1_80 Vdout1_80ck194 = 0.9 time = 975
.meas tran vdout1_80ck194 FIND v(dout1_80) AT=975.025n

* CHECK dout1_81 Vdout1_81ck194 = 0.9 time = 975
.meas tran vdout1_81ck194 FIND v(dout1_81) AT=975.025n

* CHECK dout1_82 Vdout1_82ck194 = 0 time = 975
.meas tran vdout1_82ck194 FIND v(dout1_82) AT=975.025n

* CHECK dout1_83 Vdout1_83ck194 = 0.9 time = 975
.meas tran vdout1_83ck194 FIND v(dout1_83) AT=975.025n

* CHECK dout1_84 Vdout1_84ck194 = 0 time = 975
.meas tran vdout1_84ck194 FIND v(dout1_84) AT=975.025n

* CHECK dout1_85 Vdout1_85ck194 = 0.9 time = 975
.meas tran vdout1_85ck194 FIND v(dout1_85) AT=975.025n

* CHECK dout1_86 Vdout1_86ck194 = 0.9 time = 975
.meas tran vdout1_86ck194 FIND v(dout1_86) AT=975.025n

* CHECK dout1_87 Vdout1_87ck194 = 0.9 time = 975
.meas tran vdout1_87ck194 FIND v(dout1_87) AT=975.025n

* CHECK dout1_88 Vdout1_88ck194 = 0 time = 975
.meas tran vdout1_88ck194 FIND v(dout1_88) AT=975.025n

* CHECK dout1_89 Vdout1_89ck194 = 0.9 time = 975
.meas tran vdout1_89ck194 FIND v(dout1_89) AT=975.025n

* CHECK dout1_90 Vdout1_90ck194 = 0 time = 975
.meas tran vdout1_90ck194 FIND v(dout1_90) AT=975.025n

* CHECK dout1_91 Vdout1_91ck194 = 0.9 time = 975
.meas tran vdout1_91ck194 FIND v(dout1_91) AT=975.025n

* CHECK dout1_92 Vdout1_92ck194 = 0.9 time = 975
.meas tran vdout1_92ck194 FIND v(dout1_92) AT=975.025n

* CHECK dout1_93 Vdout1_93ck194 = 0.9 time = 975
.meas tran vdout1_93ck194 FIND v(dout1_93) AT=975.025n

* CHECK dout1_94 Vdout1_94ck194 = 0.9 time = 975
.meas tran vdout1_94ck194 FIND v(dout1_94) AT=975.025n

* CHECK dout1_95 Vdout1_95ck194 = 0 time = 975
.meas tran vdout1_95ck194 FIND v(dout1_95) AT=975.025n

* CHECK dout1_96 Vdout1_96ck194 = 0.9 time = 975
.meas tran vdout1_96ck194 FIND v(dout1_96) AT=975.025n

* CHECK dout1_97 Vdout1_97ck194 = 0.9 time = 975
.meas tran vdout1_97ck194 FIND v(dout1_97) AT=975.025n

* CHECK dout1_98 Vdout1_98ck194 = 0 time = 975
.meas tran vdout1_98ck194 FIND v(dout1_98) AT=975.025n

* CHECK dout1_99 Vdout1_99ck194 = 0.9 time = 975
.meas tran vdout1_99ck194 FIND v(dout1_99) AT=975.025n

* CHECK dout1_100 Vdout1_100ck194 = 0.9 time = 975
.meas tran vdout1_100ck194 FIND v(dout1_100) AT=975.025n

* CHECK dout1_101 Vdout1_101ck194 = 0 time = 975
.meas tran vdout1_101ck194 FIND v(dout1_101) AT=975.025n

* CHECK dout1_102 Vdout1_102ck194 = 0.9 time = 975
.meas tran vdout1_102ck194 FIND v(dout1_102) AT=975.025n

* CHECK dout1_103 Vdout1_103ck194 = 0 time = 975
.meas tran vdout1_103ck194 FIND v(dout1_103) AT=975.025n

* CHECK dout1_104 Vdout1_104ck194 = 0.9 time = 975
.meas tran vdout1_104ck194 FIND v(dout1_104) AT=975.025n

* CHECK dout1_105 Vdout1_105ck194 = 0 time = 975
.meas tran vdout1_105ck194 FIND v(dout1_105) AT=975.025n

* CHECK dout1_106 Vdout1_106ck194 = 0 time = 975
.meas tran vdout1_106ck194 FIND v(dout1_106) AT=975.025n

* CHECK dout1_107 Vdout1_107ck194 = 0.9 time = 975
.meas tran vdout1_107ck194 FIND v(dout1_107) AT=975.025n

* CHECK dout1_108 Vdout1_108ck194 = 0 time = 975
.meas tran vdout1_108ck194 FIND v(dout1_108) AT=975.025n

* CHECK dout1_109 Vdout1_109ck194 = 0 time = 975
.meas tran vdout1_109ck194 FIND v(dout1_109) AT=975.025n

* CHECK dout1_110 Vdout1_110ck194 = 0 time = 975
.meas tran vdout1_110ck194 FIND v(dout1_110) AT=975.025n

* CHECK dout1_111 Vdout1_111ck194 = 0 time = 975
.meas tran vdout1_111ck194 FIND v(dout1_111) AT=975.025n

* CHECK dout1_112 Vdout1_112ck194 = 0.9 time = 975
.meas tran vdout1_112ck194 FIND v(dout1_112) AT=975.025n

* CHECK dout1_113 Vdout1_113ck194 = 0 time = 975
.meas tran vdout1_113ck194 FIND v(dout1_113) AT=975.025n

* CHECK dout1_114 Vdout1_114ck194 = 0 time = 975
.meas tran vdout1_114ck194 FIND v(dout1_114) AT=975.025n

* CHECK dout1_115 Vdout1_115ck194 = 0 time = 975
.meas tran vdout1_115ck194 FIND v(dout1_115) AT=975.025n

* CHECK dout1_116 Vdout1_116ck194 = 0.9 time = 975
.meas tran vdout1_116ck194 FIND v(dout1_116) AT=975.025n

* CHECK dout1_117 Vdout1_117ck194 = 0 time = 975
.meas tran vdout1_117ck194 FIND v(dout1_117) AT=975.025n

* CHECK dout1_118 Vdout1_118ck194 = 0.9 time = 975
.meas tran vdout1_118ck194 FIND v(dout1_118) AT=975.025n

* CHECK dout1_119 Vdout1_119ck194 = 0 time = 975
.meas tran vdout1_119ck194 FIND v(dout1_119) AT=975.025n

* CHECK dout1_0 Vdout1_0ck196 = 0.9 time = 985
.meas tran vdout1_0ck196 FIND v(dout1_0) AT=985.025n

* CHECK dout1_1 Vdout1_1ck196 = 0.9 time = 985
.meas tran vdout1_1ck196 FIND v(dout1_1) AT=985.025n

* CHECK dout1_2 Vdout1_2ck196 = 0 time = 985
.meas tran vdout1_2ck196 FIND v(dout1_2) AT=985.025n

* CHECK dout1_3 Vdout1_3ck196 = 0.9 time = 985
.meas tran vdout1_3ck196 FIND v(dout1_3) AT=985.025n

* CHECK dout1_4 Vdout1_4ck196 = 0.9 time = 985
.meas tran vdout1_4ck196 FIND v(dout1_4) AT=985.025n

* CHECK dout1_5 Vdout1_5ck196 = 0.9 time = 985
.meas tran vdout1_5ck196 FIND v(dout1_5) AT=985.025n

* CHECK dout1_6 Vdout1_6ck196 = 0.9 time = 985
.meas tran vdout1_6ck196 FIND v(dout1_6) AT=985.025n

* CHECK dout1_7 Vdout1_7ck196 = 0.9 time = 985
.meas tran vdout1_7ck196 FIND v(dout1_7) AT=985.025n

* CHECK dout1_8 Vdout1_8ck196 = 0 time = 985
.meas tran vdout1_8ck196 FIND v(dout1_8) AT=985.025n

* CHECK dout1_9 Vdout1_9ck196 = 0 time = 985
.meas tran vdout1_9ck196 FIND v(dout1_9) AT=985.025n

* CHECK dout1_10 Vdout1_10ck196 = 0.9 time = 985
.meas tran vdout1_10ck196 FIND v(dout1_10) AT=985.025n

* CHECK dout1_11 Vdout1_11ck196 = 0.9 time = 985
.meas tran vdout1_11ck196 FIND v(dout1_11) AT=985.025n

* CHECK dout1_12 Vdout1_12ck196 = 0.9 time = 985
.meas tran vdout1_12ck196 FIND v(dout1_12) AT=985.025n

* CHECK dout1_13 Vdout1_13ck196 = 0 time = 985
.meas tran vdout1_13ck196 FIND v(dout1_13) AT=985.025n

* CHECK dout1_14 Vdout1_14ck196 = 0.9 time = 985
.meas tran vdout1_14ck196 FIND v(dout1_14) AT=985.025n

* CHECK dout1_15 Vdout1_15ck196 = 0 time = 985
.meas tran vdout1_15ck196 FIND v(dout1_15) AT=985.025n

* CHECK dout1_16 Vdout1_16ck196 = 0 time = 985
.meas tran vdout1_16ck196 FIND v(dout1_16) AT=985.025n

* CHECK dout1_17 Vdout1_17ck196 = 0 time = 985
.meas tran vdout1_17ck196 FIND v(dout1_17) AT=985.025n

* CHECK dout1_18 Vdout1_18ck196 = 0.9 time = 985
.meas tran vdout1_18ck196 FIND v(dout1_18) AT=985.025n

* CHECK dout1_19 Vdout1_19ck196 = 0 time = 985
.meas tran vdout1_19ck196 FIND v(dout1_19) AT=985.025n

* CHECK dout1_20 Vdout1_20ck196 = 0.9 time = 985
.meas tran vdout1_20ck196 FIND v(dout1_20) AT=985.025n

* CHECK dout1_21 Vdout1_21ck196 = 0 time = 985
.meas tran vdout1_21ck196 FIND v(dout1_21) AT=985.025n

* CHECK dout1_22 Vdout1_22ck196 = 0.9 time = 985
.meas tran vdout1_22ck196 FIND v(dout1_22) AT=985.025n

* CHECK dout1_23 Vdout1_23ck196 = 0.9 time = 985
.meas tran vdout1_23ck196 FIND v(dout1_23) AT=985.025n

* CHECK dout1_24 Vdout1_24ck196 = 0 time = 985
.meas tran vdout1_24ck196 FIND v(dout1_24) AT=985.025n

* CHECK dout1_25 Vdout1_25ck196 = 0 time = 985
.meas tran vdout1_25ck196 FIND v(dout1_25) AT=985.025n

* CHECK dout1_26 Vdout1_26ck196 = 0.9 time = 985
.meas tran vdout1_26ck196 FIND v(dout1_26) AT=985.025n

* CHECK dout1_27 Vdout1_27ck196 = 0 time = 985
.meas tran vdout1_27ck196 FIND v(dout1_27) AT=985.025n

* CHECK dout1_28 Vdout1_28ck196 = 0.9 time = 985
.meas tran vdout1_28ck196 FIND v(dout1_28) AT=985.025n

* CHECK dout1_29 Vdout1_29ck196 = 0.9 time = 985
.meas tran vdout1_29ck196 FIND v(dout1_29) AT=985.025n

* CHECK dout1_30 Vdout1_30ck196 = 0 time = 985
.meas tran vdout1_30ck196 FIND v(dout1_30) AT=985.025n

* CHECK dout1_31 Vdout1_31ck196 = 0 time = 985
.meas tran vdout1_31ck196 FIND v(dout1_31) AT=985.025n

* CHECK dout1_32 Vdout1_32ck196 = 0 time = 985
.meas tran vdout1_32ck196 FIND v(dout1_32) AT=985.025n

* CHECK dout1_33 Vdout1_33ck196 = 0 time = 985
.meas tran vdout1_33ck196 FIND v(dout1_33) AT=985.025n

* CHECK dout1_34 Vdout1_34ck196 = 0 time = 985
.meas tran vdout1_34ck196 FIND v(dout1_34) AT=985.025n

* CHECK dout1_35 Vdout1_35ck196 = 0.9 time = 985
.meas tran vdout1_35ck196 FIND v(dout1_35) AT=985.025n

* CHECK dout1_36 Vdout1_36ck196 = 0.9 time = 985
.meas tran vdout1_36ck196 FIND v(dout1_36) AT=985.025n

* CHECK dout1_37 Vdout1_37ck196 = 0.9 time = 985
.meas tran vdout1_37ck196 FIND v(dout1_37) AT=985.025n

* CHECK dout1_38 Vdout1_38ck196 = 0.9 time = 985
.meas tran vdout1_38ck196 FIND v(dout1_38) AT=985.025n

* CHECK dout1_39 Vdout1_39ck196 = 0 time = 985
.meas tran vdout1_39ck196 FIND v(dout1_39) AT=985.025n

* CHECK dout1_40 Vdout1_40ck196 = 0 time = 985
.meas tran vdout1_40ck196 FIND v(dout1_40) AT=985.025n

* CHECK dout1_41 Vdout1_41ck196 = 0.9 time = 985
.meas tran vdout1_41ck196 FIND v(dout1_41) AT=985.025n

* CHECK dout1_42 Vdout1_42ck196 = 0 time = 985
.meas tran vdout1_42ck196 FIND v(dout1_42) AT=985.025n

* CHECK dout1_43 Vdout1_43ck196 = 0 time = 985
.meas tran vdout1_43ck196 FIND v(dout1_43) AT=985.025n

* CHECK dout1_44 Vdout1_44ck196 = 0 time = 985
.meas tran vdout1_44ck196 FIND v(dout1_44) AT=985.025n

* CHECK dout1_45 Vdout1_45ck196 = 0.9 time = 985
.meas tran vdout1_45ck196 FIND v(dout1_45) AT=985.025n

* CHECK dout1_46 Vdout1_46ck196 = 0 time = 985
.meas tran vdout1_46ck196 FIND v(dout1_46) AT=985.025n

* CHECK dout1_47 Vdout1_47ck196 = 0.9 time = 985
.meas tran vdout1_47ck196 FIND v(dout1_47) AT=985.025n

* CHECK dout1_48 Vdout1_48ck196 = 0 time = 985
.meas tran vdout1_48ck196 FIND v(dout1_48) AT=985.025n

* CHECK dout1_49 Vdout1_49ck196 = 0 time = 985
.meas tran vdout1_49ck196 FIND v(dout1_49) AT=985.025n

* CHECK dout1_50 Vdout1_50ck196 = 0 time = 985
.meas tran vdout1_50ck196 FIND v(dout1_50) AT=985.025n

* CHECK dout1_51 Vdout1_51ck196 = 0.9 time = 985
.meas tran vdout1_51ck196 FIND v(dout1_51) AT=985.025n

* CHECK dout1_52 Vdout1_52ck196 = 0.9 time = 985
.meas tran vdout1_52ck196 FIND v(dout1_52) AT=985.025n

* CHECK dout1_53 Vdout1_53ck196 = 0 time = 985
.meas tran vdout1_53ck196 FIND v(dout1_53) AT=985.025n

* CHECK dout1_54 Vdout1_54ck196 = 0 time = 985
.meas tran vdout1_54ck196 FIND v(dout1_54) AT=985.025n

* CHECK dout1_55 Vdout1_55ck196 = 0 time = 985
.meas tran vdout1_55ck196 FIND v(dout1_55) AT=985.025n

* CHECK dout1_56 Vdout1_56ck196 = 0.9 time = 985
.meas tran vdout1_56ck196 FIND v(dout1_56) AT=985.025n

* CHECK dout1_57 Vdout1_57ck196 = 0 time = 985
.meas tran vdout1_57ck196 FIND v(dout1_57) AT=985.025n

* CHECK dout1_58 Vdout1_58ck196 = 0 time = 985
.meas tran vdout1_58ck196 FIND v(dout1_58) AT=985.025n

* CHECK dout1_59 Vdout1_59ck196 = 0 time = 985
.meas tran vdout1_59ck196 FIND v(dout1_59) AT=985.025n

* CHECK dout1_60 Vdout1_60ck196 = 0 time = 985
.meas tran vdout1_60ck196 FIND v(dout1_60) AT=985.025n

* CHECK dout1_61 Vdout1_61ck196 = 0 time = 985
.meas tran vdout1_61ck196 FIND v(dout1_61) AT=985.025n

* CHECK dout1_62 Vdout1_62ck196 = 0.9 time = 985
.meas tran vdout1_62ck196 FIND v(dout1_62) AT=985.025n

* CHECK dout1_63 Vdout1_63ck196 = 0.9 time = 985
.meas tran vdout1_63ck196 FIND v(dout1_63) AT=985.025n

* CHECK dout1_64 Vdout1_64ck196 = 0.9 time = 985
.meas tran vdout1_64ck196 FIND v(dout1_64) AT=985.025n

* CHECK dout1_65 Vdout1_65ck196 = 0.9 time = 985
.meas tran vdout1_65ck196 FIND v(dout1_65) AT=985.025n

* CHECK dout1_66 Vdout1_66ck196 = 0 time = 985
.meas tran vdout1_66ck196 FIND v(dout1_66) AT=985.025n

* CHECK dout1_67 Vdout1_67ck196 = 0.9 time = 985
.meas tran vdout1_67ck196 FIND v(dout1_67) AT=985.025n

* CHECK dout1_68 Vdout1_68ck196 = 0 time = 985
.meas tran vdout1_68ck196 FIND v(dout1_68) AT=985.025n

* CHECK dout1_69 Vdout1_69ck196 = 0 time = 985
.meas tran vdout1_69ck196 FIND v(dout1_69) AT=985.025n

* CHECK dout1_70 Vdout1_70ck196 = 0.9 time = 985
.meas tran vdout1_70ck196 FIND v(dout1_70) AT=985.025n

* CHECK dout1_71 Vdout1_71ck196 = 0.9 time = 985
.meas tran vdout1_71ck196 FIND v(dout1_71) AT=985.025n

* CHECK dout1_72 Vdout1_72ck196 = 0.9 time = 985
.meas tran vdout1_72ck196 FIND v(dout1_72) AT=985.025n

* CHECK dout1_73 Vdout1_73ck196 = 0 time = 985
.meas tran vdout1_73ck196 FIND v(dout1_73) AT=985.025n

* CHECK dout1_74 Vdout1_74ck196 = 0 time = 985
.meas tran vdout1_74ck196 FIND v(dout1_74) AT=985.025n

* CHECK dout1_75 Vdout1_75ck196 = 0 time = 985
.meas tran vdout1_75ck196 FIND v(dout1_75) AT=985.025n

* CHECK dout1_76 Vdout1_76ck196 = 0 time = 985
.meas tran vdout1_76ck196 FIND v(dout1_76) AT=985.025n

* CHECK dout1_77 Vdout1_77ck196 = 0.9 time = 985
.meas tran vdout1_77ck196 FIND v(dout1_77) AT=985.025n

* CHECK dout1_78 Vdout1_78ck196 = 0 time = 985
.meas tran vdout1_78ck196 FIND v(dout1_78) AT=985.025n

* CHECK dout1_79 Vdout1_79ck196 = 0 time = 985
.meas tran vdout1_79ck196 FIND v(dout1_79) AT=985.025n

* CHECK dout1_80 Vdout1_80ck196 = 0.9 time = 985
.meas tran vdout1_80ck196 FIND v(dout1_80) AT=985.025n

* CHECK dout1_81 Vdout1_81ck196 = 0.9 time = 985
.meas tran vdout1_81ck196 FIND v(dout1_81) AT=985.025n

* CHECK dout1_82 Vdout1_82ck196 = 0 time = 985
.meas tran vdout1_82ck196 FIND v(dout1_82) AT=985.025n

* CHECK dout1_83 Vdout1_83ck196 = 0.9 time = 985
.meas tran vdout1_83ck196 FIND v(dout1_83) AT=985.025n

* CHECK dout1_84 Vdout1_84ck196 = 0 time = 985
.meas tran vdout1_84ck196 FIND v(dout1_84) AT=985.025n

* CHECK dout1_85 Vdout1_85ck196 = 0.9 time = 985
.meas tran vdout1_85ck196 FIND v(dout1_85) AT=985.025n

* CHECK dout1_86 Vdout1_86ck196 = 0.9 time = 985
.meas tran vdout1_86ck196 FIND v(dout1_86) AT=985.025n

* CHECK dout1_87 Vdout1_87ck196 = 0.9 time = 985
.meas tran vdout1_87ck196 FIND v(dout1_87) AT=985.025n

* CHECK dout1_88 Vdout1_88ck196 = 0 time = 985
.meas tran vdout1_88ck196 FIND v(dout1_88) AT=985.025n

* CHECK dout1_89 Vdout1_89ck196 = 0.9 time = 985
.meas tran vdout1_89ck196 FIND v(dout1_89) AT=985.025n

* CHECK dout1_90 Vdout1_90ck196 = 0 time = 985
.meas tran vdout1_90ck196 FIND v(dout1_90) AT=985.025n

* CHECK dout1_91 Vdout1_91ck196 = 0.9 time = 985
.meas tran vdout1_91ck196 FIND v(dout1_91) AT=985.025n

* CHECK dout1_92 Vdout1_92ck196 = 0.9 time = 985
.meas tran vdout1_92ck196 FIND v(dout1_92) AT=985.025n

* CHECK dout1_93 Vdout1_93ck196 = 0.9 time = 985
.meas tran vdout1_93ck196 FIND v(dout1_93) AT=985.025n

* CHECK dout1_94 Vdout1_94ck196 = 0.9 time = 985
.meas tran vdout1_94ck196 FIND v(dout1_94) AT=985.025n

* CHECK dout1_95 Vdout1_95ck196 = 0 time = 985
.meas tran vdout1_95ck196 FIND v(dout1_95) AT=985.025n

* CHECK dout1_96 Vdout1_96ck196 = 0.9 time = 985
.meas tran vdout1_96ck196 FIND v(dout1_96) AT=985.025n

* CHECK dout1_97 Vdout1_97ck196 = 0.9 time = 985
.meas tran vdout1_97ck196 FIND v(dout1_97) AT=985.025n

* CHECK dout1_98 Vdout1_98ck196 = 0 time = 985
.meas tran vdout1_98ck196 FIND v(dout1_98) AT=985.025n

* CHECK dout1_99 Vdout1_99ck196 = 0.9 time = 985
.meas tran vdout1_99ck196 FIND v(dout1_99) AT=985.025n

* CHECK dout1_100 Vdout1_100ck196 = 0.9 time = 985
.meas tran vdout1_100ck196 FIND v(dout1_100) AT=985.025n

* CHECK dout1_101 Vdout1_101ck196 = 0 time = 985
.meas tran vdout1_101ck196 FIND v(dout1_101) AT=985.025n

* CHECK dout1_102 Vdout1_102ck196 = 0.9 time = 985
.meas tran vdout1_102ck196 FIND v(dout1_102) AT=985.025n

* CHECK dout1_103 Vdout1_103ck196 = 0 time = 985
.meas tran vdout1_103ck196 FIND v(dout1_103) AT=985.025n

* CHECK dout1_104 Vdout1_104ck196 = 0.9 time = 985
.meas tran vdout1_104ck196 FIND v(dout1_104) AT=985.025n

* CHECK dout1_105 Vdout1_105ck196 = 0 time = 985
.meas tran vdout1_105ck196 FIND v(dout1_105) AT=985.025n

* CHECK dout1_106 Vdout1_106ck196 = 0 time = 985
.meas tran vdout1_106ck196 FIND v(dout1_106) AT=985.025n

* CHECK dout1_107 Vdout1_107ck196 = 0.9 time = 985
.meas tran vdout1_107ck196 FIND v(dout1_107) AT=985.025n

* CHECK dout1_108 Vdout1_108ck196 = 0 time = 985
.meas tran vdout1_108ck196 FIND v(dout1_108) AT=985.025n

* CHECK dout1_109 Vdout1_109ck196 = 0 time = 985
.meas tran vdout1_109ck196 FIND v(dout1_109) AT=985.025n

* CHECK dout1_110 Vdout1_110ck196 = 0 time = 985
.meas tran vdout1_110ck196 FIND v(dout1_110) AT=985.025n

* CHECK dout1_111 Vdout1_111ck196 = 0 time = 985
.meas tran vdout1_111ck196 FIND v(dout1_111) AT=985.025n

* CHECK dout1_112 Vdout1_112ck196 = 0.9 time = 985
.meas tran vdout1_112ck196 FIND v(dout1_112) AT=985.025n

* CHECK dout1_113 Vdout1_113ck196 = 0 time = 985
.meas tran vdout1_113ck196 FIND v(dout1_113) AT=985.025n

* CHECK dout1_114 Vdout1_114ck196 = 0 time = 985
.meas tran vdout1_114ck196 FIND v(dout1_114) AT=985.025n

* CHECK dout1_115 Vdout1_115ck196 = 0 time = 985
.meas tran vdout1_115ck196 FIND v(dout1_115) AT=985.025n

* CHECK dout1_116 Vdout1_116ck196 = 0.9 time = 985
.meas tran vdout1_116ck196 FIND v(dout1_116) AT=985.025n

* CHECK dout1_117 Vdout1_117ck196 = 0 time = 985
.meas tran vdout1_117ck196 FIND v(dout1_117) AT=985.025n

* CHECK dout1_118 Vdout1_118ck196 = 0.9 time = 985
.meas tran vdout1_118ck196 FIND v(dout1_118) AT=985.025n

* CHECK dout1_119 Vdout1_119ck196 = 0 time = 985
.meas tran vdout1_119ck196 FIND v(dout1_119) AT=985.025n

* CHECK dout1_0 Vdout1_0ck198 = 0 time = 995
.meas tran vdout1_0ck198 FIND v(dout1_0) AT=995.025n

* CHECK dout1_1 Vdout1_1ck198 = 0.9 time = 995
.meas tran vdout1_1ck198 FIND v(dout1_1) AT=995.025n

* CHECK dout1_2 Vdout1_2ck198 = 0 time = 995
.meas tran vdout1_2ck198 FIND v(dout1_2) AT=995.025n

* CHECK dout1_3 Vdout1_3ck198 = 0.9 time = 995
.meas tran vdout1_3ck198 FIND v(dout1_3) AT=995.025n

* CHECK dout1_4 Vdout1_4ck198 = 0 time = 995
.meas tran vdout1_4ck198 FIND v(dout1_4) AT=995.025n

* CHECK dout1_5 Vdout1_5ck198 = 0 time = 995
.meas tran vdout1_5ck198 FIND v(dout1_5) AT=995.025n

* CHECK dout1_6 Vdout1_6ck198 = 0.9 time = 995
.meas tran vdout1_6ck198 FIND v(dout1_6) AT=995.025n

* CHECK dout1_7 Vdout1_7ck198 = 0 time = 995
.meas tran vdout1_7ck198 FIND v(dout1_7) AT=995.025n

* CHECK dout1_8 Vdout1_8ck198 = 0 time = 995
.meas tran vdout1_8ck198 FIND v(dout1_8) AT=995.025n

* CHECK dout1_9 Vdout1_9ck198 = 0 time = 995
.meas tran vdout1_9ck198 FIND v(dout1_9) AT=995.025n

* CHECK dout1_10 Vdout1_10ck198 = 0 time = 995
.meas tran vdout1_10ck198 FIND v(dout1_10) AT=995.025n

* CHECK dout1_11 Vdout1_11ck198 = 0.9 time = 995
.meas tran vdout1_11ck198 FIND v(dout1_11) AT=995.025n

* CHECK dout1_12 Vdout1_12ck198 = 0.9 time = 995
.meas tran vdout1_12ck198 FIND v(dout1_12) AT=995.025n

* CHECK dout1_13 Vdout1_13ck198 = 0.9 time = 995
.meas tran vdout1_13ck198 FIND v(dout1_13) AT=995.025n

* CHECK dout1_14 Vdout1_14ck198 = 0 time = 995
.meas tran vdout1_14ck198 FIND v(dout1_14) AT=995.025n

* CHECK dout1_15 Vdout1_15ck198 = 0.9 time = 995
.meas tran vdout1_15ck198 FIND v(dout1_15) AT=995.025n

* CHECK dout1_16 Vdout1_16ck198 = 0.9 time = 995
.meas tran vdout1_16ck198 FIND v(dout1_16) AT=995.025n

* CHECK dout1_17 Vdout1_17ck198 = 0.9 time = 995
.meas tran vdout1_17ck198 FIND v(dout1_17) AT=995.025n

* CHECK dout1_18 Vdout1_18ck198 = 0 time = 995
.meas tran vdout1_18ck198 FIND v(dout1_18) AT=995.025n

* CHECK dout1_19 Vdout1_19ck198 = 0.9 time = 995
.meas tran vdout1_19ck198 FIND v(dout1_19) AT=995.025n

* CHECK dout1_20 Vdout1_20ck198 = 0.9 time = 995
.meas tran vdout1_20ck198 FIND v(dout1_20) AT=995.025n

* CHECK dout1_21 Vdout1_21ck198 = 0 time = 995
.meas tran vdout1_21ck198 FIND v(dout1_21) AT=995.025n

* CHECK dout1_22 Vdout1_22ck198 = 0.9 time = 995
.meas tran vdout1_22ck198 FIND v(dout1_22) AT=995.025n

* CHECK dout1_23 Vdout1_23ck198 = 0.9 time = 995
.meas tran vdout1_23ck198 FIND v(dout1_23) AT=995.025n

* CHECK dout1_24 Vdout1_24ck198 = 0 time = 995
.meas tran vdout1_24ck198 FIND v(dout1_24) AT=995.025n

* CHECK dout1_25 Vdout1_25ck198 = 0.9 time = 995
.meas tran vdout1_25ck198 FIND v(dout1_25) AT=995.025n

* CHECK dout1_26 Vdout1_26ck198 = 0 time = 995
.meas tran vdout1_26ck198 FIND v(dout1_26) AT=995.025n

* CHECK dout1_27 Vdout1_27ck198 = 0 time = 995
.meas tran vdout1_27ck198 FIND v(dout1_27) AT=995.025n

* CHECK dout1_28 Vdout1_28ck198 = 0 time = 995
.meas tran vdout1_28ck198 FIND v(dout1_28) AT=995.025n

* CHECK dout1_29 Vdout1_29ck198 = 0 time = 995
.meas tran vdout1_29ck198 FIND v(dout1_29) AT=995.025n

* CHECK dout1_30 Vdout1_30ck198 = 0.9 time = 995
.meas tran vdout1_30ck198 FIND v(dout1_30) AT=995.025n

* CHECK dout1_31 Vdout1_31ck198 = 0.9 time = 995
.meas tran vdout1_31ck198 FIND v(dout1_31) AT=995.025n

* CHECK dout1_32 Vdout1_32ck198 = 0.9 time = 995
.meas tran vdout1_32ck198 FIND v(dout1_32) AT=995.025n

* CHECK dout1_33 Vdout1_33ck198 = 0 time = 995
.meas tran vdout1_33ck198 FIND v(dout1_33) AT=995.025n

* CHECK dout1_34 Vdout1_34ck198 = 0 time = 995
.meas tran vdout1_34ck198 FIND v(dout1_34) AT=995.025n

* CHECK dout1_35 Vdout1_35ck198 = 0.9 time = 995
.meas tran vdout1_35ck198 FIND v(dout1_35) AT=995.025n

* CHECK dout1_36 Vdout1_36ck198 = 0 time = 995
.meas tran vdout1_36ck198 FIND v(dout1_36) AT=995.025n

* CHECK dout1_37 Vdout1_37ck198 = 0.9 time = 995
.meas tran vdout1_37ck198 FIND v(dout1_37) AT=995.025n

* CHECK dout1_38 Vdout1_38ck198 = 0.9 time = 995
.meas tran vdout1_38ck198 FIND v(dout1_38) AT=995.025n

* CHECK dout1_39 Vdout1_39ck198 = 0 time = 995
.meas tran vdout1_39ck198 FIND v(dout1_39) AT=995.025n

* CHECK dout1_40 Vdout1_40ck198 = 0.9 time = 995
.meas tran vdout1_40ck198 FIND v(dout1_40) AT=995.025n

* CHECK dout1_41 Vdout1_41ck198 = 0.9 time = 995
.meas tran vdout1_41ck198 FIND v(dout1_41) AT=995.025n

* CHECK dout1_42 Vdout1_42ck198 = 0.9 time = 995
.meas tran vdout1_42ck198 FIND v(dout1_42) AT=995.025n

* CHECK dout1_43 Vdout1_43ck198 = 0.9 time = 995
.meas tran vdout1_43ck198 FIND v(dout1_43) AT=995.025n

* CHECK dout1_44 Vdout1_44ck198 = 0.9 time = 995
.meas tran vdout1_44ck198 FIND v(dout1_44) AT=995.025n

* CHECK dout1_45 Vdout1_45ck198 = 0.9 time = 995
.meas tran vdout1_45ck198 FIND v(dout1_45) AT=995.025n

* CHECK dout1_46 Vdout1_46ck198 = 0 time = 995
.meas tran vdout1_46ck198 FIND v(dout1_46) AT=995.025n

* CHECK dout1_47 Vdout1_47ck198 = 0.9 time = 995
.meas tran vdout1_47ck198 FIND v(dout1_47) AT=995.025n

* CHECK dout1_48 Vdout1_48ck198 = 0 time = 995
.meas tran vdout1_48ck198 FIND v(dout1_48) AT=995.025n

* CHECK dout1_49 Vdout1_49ck198 = 0.9 time = 995
.meas tran vdout1_49ck198 FIND v(dout1_49) AT=995.025n

* CHECK dout1_50 Vdout1_50ck198 = 0.9 time = 995
.meas tran vdout1_50ck198 FIND v(dout1_50) AT=995.025n

* CHECK dout1_51 Vdout1_51ck198 = 0 time = 995
.meas tran vdout1_51ck198 FIND v(dout1_51) AT=995.025n

* CHECK dout1_52 Vdout1_52ck198 = 0.9 time = 995
.meas tran vdout1_52ck198 FIND v(dout1_52) AT=995.025n

* CHECK dout1_53 Vdout1_53ck198 = 0.9 time = 995
.meas tran vdout1_53ck198 FIND v(dout1_53) AT=995.025n

* CHECK dout1_54 Vdout1_54ck198 = 0.9 time = 995
.meas tran vdout1_54ck198 FIND v(dout1_54) AT=995.025n

* CHECK dout1_55 Vdout1_55ck198 = 0.9 time = 995
.meas tran vdout1_55ck198 FIND v(dout1_55) AT=995.025n

* CHECK dout1_56 Vdout1_56ck198 = 0 time = 995
.meas tran vdout1_56ck198 FIND v(dout1_56) AT=995.025n

* CHECK dout1_57 Vdout1_57ck198 = 0.9 time = 995
.meas tran vdout1_57ck198 FIND v(dout1_57) AT=995.025n

* CHECK dout1_58 Vdout1_58ck198 = 0.9 time = 995
.meas tran vdout1_58ck198 FIND v(dout1_58) AT=995.025n

* CHECK dout1_59 Vdout1_59ck198 = 0 time = 995
.meas tran vdout1_59ck198 FIND v(dout1_59) AT=995.025n

* CHECK dout1_60 Vdout1_60ck198 = 0.9 time = 995
.meas tran vdout1_60ck198 FIND v(dout1_60) AT=995.025n

* CHECK dout1_61 Vdout1_61ck198 = 0.9 time = 995
.meas tran vdout1_61ck198 FIND v(dout1_61) AT=995.025n

* CHECK dout1_62 Vdout1_62ck198 = 0 time = 995
.meas tran vdout1_62ck198 FIND v(dout1_62) AT=995.025n

* CHECK dout1_63 Vdout1_63ck198 = 0.9 time = 995
.meas tran vdout1_63ck198 FIND v(dout1_63) AT=995.025n

* CHECK dout1_64 Vdout1_64ck198 = 0.9 time = 995
.meas tran vdout1_64ck198 FIND v(dout1_64) AT=995.025n

* CHECK dout1_65 Vdout1_65ck198 = 0 time = 995
.meas tran vdout1_65ck198 FIND v(dout1_65) AT=995.025n

* CHECK dout1_66 Vdout1_66ck198 = 0.9 time = 995
.meas tran vdout1_66ck198 FIND v(dout1_66) AT=995.025n

* CHECK dout1_67 Vdout1_67ck198 = 0.9 time = 995
.meas tran vdout1_67ck198 FIND v(dout1_67) AT=995.025n

* CHECK dout1_68 Vdout1_68ck198 = 0.9 time = 995
.meas tran vdout1_68ck198 FIND v(dout1_68) AT=995.025n

* CHECK dout1_69 Vdout1_69ck198 = 0.9 time = 995
.meas tran vdout1_69ck198 FIND v(dout1_69) AT=995.025n

* CHECK dout1_70 Vdout1_70ck198 = 0 time = 995
.meas tran vdout1_70ck198 FIND v(dout1_70) AT=995.025n

* CHECK dout1_71 Vdout1_71ck198 = 0.9 time = 995
.meas tran vdout1_71ck198 FIND v(dout1_71) AT=995.025n

* CHECK dout1_72 Vdout1_72ck198 = 0 time = 995
.meas tran vdout1_72ck198 FIND v(dout1_72) AT=995.025n

* CHECK dout1_73 Vdout1_73ck198 = 0 time = 995
.meas tran vdout1_73ck198 FIND v(dout1_73) AT=995.025n

* CHECK dout1_74 Vdout1_74ck198 = 0 time = 995
.meas tran vdout1_74ck198 FIND v(dout1_74) AT=995.025n

* CHECK dout1_75 Vdout1_75ck198 = 0 time = 995
.meas tran vdout1_75ck198 FIND v(dout1_75) AT=995.025n

* CHECK dout1_76 Vdout1_76ck198 = 0 time = 995
.meas tran vdout1_76ck198 FIND v(dout1_76) AT=995.025n

* CHECK dout1_77 Vdout1_77ck198 = 0 time = 995
.meas tran vdout1_77ck198 FIND v(dout1_77) AT=995.025n

* CHECK dout1_78 Vdout1_78ck198 = 0 time = 995
.meas tran vdout1_78ck198 FIND v(dout1_78) AT=995.025n

* CHECK dout1_79 Vdout1_79ck198 = 0 time = 995
.meas tran vdout1_79ck198 FIND v(dout1_79) AT=995.025n

* CHECK dout1_80 Vdout1_80ck198 = 0.9 time = 995
.meas tran vdout1_80ck198 FIND v(dout1_80) AT=995.025n

* CHECK dout1_81 Vdout1_81ck198 = 0.9 time = 995
.meas tran vdout1_81ck198 FIND v(dout1_81) AT=995.025n

* CHECK dout1_82 Vdout1_82ck198 = 0 time = 995
.meas tran vdout1_82ck198 FIND v(dout1_82) AT=995.025n

* CHECK dout1_83 Vdout1_83ck198 = 0 time = 995
.meas tran vdout1_83ck198 FIND v(dout1_83) AT=995.025n

* CHECK dout1_84 Vdout1_84ck198 = 0.9 time = 995
.meas tran vdout1_84ck198 FIND v(dout1_84) AT=995.025n

* CHECK dout1_85 Vdout1_85ck198 = 0 time = 995
.meas tran vdout1_85ck198 FIND v(dout1_85) AT=995.025n

* CHECK dout1_86 Vdout1_86ck198 = 0 time = 995
.meas tran vdout1_86ck198 FIND v(dout1_86) AT=995.025n

* CHECK dout1_87 Vdout1_87ck198 = 0.9 time = 995
.meas tran vdout1_87ck198 FIND v(dout1_87) AT=995.025n

* CHECK dout1_88 Vdout1_88ck198 = 0 time = 995
.meas tran vdout1_88ck198 FIND v(dout1_88) AT=995.025n

* CHECK dout1_89 Vdout1_89ck198 = 0 time = 995
.meas tran vdout1_89ck198 FIND v(dout1_89) AT=995.025n

* CHECK dout1_90 Vdout1_90ck198 = 0.9 time = 995
.meas tran vdout1_90ck198 FIND v(dout1_90) AT=995.025n

* CHECK dout1_91 Vdout1_91ck198 = 0 time = 995
.meas tran vdout1_91ck198 FIND v(dout1_91) AT=995.025n

* CHECK dout1_92 Vdout1_92ck198 = 0 time = 995
.meas tran vdout1_92ck198 FIND v(dout1_92) AT=995.025n

* CHECK dout1_93 Vdout1_93ck198 = 0 time = 995
.meas tran vdout1_93ck198 FIND v(dout1_93) AT=995.025n

* CHECK dout1_94 Vdout1_94ck198 = 0.9 time = 995
.meas tran vdout1_94ck198 FIND v(dout1_94) AT=995.025n

* CHECK dout1_95 Vdout1_95ck198 = 0.9 time = 995
.meas tran vdout1_95ck198 FIND v(dout1_95) AT=995.025n

* CHECK dout1_96 Vdout1_96ck198 = 0.9 time = 995
.meas tran vdout1_96ck198 FIND v(dout1_96) AT=995.025n

* CHECK dout1_97 Vdout1_97ck198 = 0 time = 995
.meas tran vdout1_97ck198 FIND v(dout1_97) AT=995.025n

* CHECK dout1_98 Vdout1_98ck198 = 0 time = 995
.meas tran vdout1_98ck198 FIND v(dout1_98) AT=995.025n

* CHECK dout1_99 Vdout1_99ck198 = 0.9 time = 995
.meas tran vdout1_99ck198 FIND v(dout1_99) AT=995.025n

* CHECK dout1_100 Vdout1_100ck198 = 0 time = 995
.meas tran vdout1_100ck198 FIND v(dout1_100) AT=995.025n

* CHECK dout1_101 Vdout1_101ck198 = 0.9 time = 995
.meas tran vdout1_101ck198 FIND v(dout1_101) AT=995.025n

* CHECK dout1_102 Vdout1_102ck198 = 0.9 time = 995
.meas tran vdout1_102ck198 FIND v(dout1_102) AT=995.025n

* CHECK dout1_103 Vdout1_103ck198 = 0.9 time = 995
.meas tran vdout1_103ck198 FIND v(dout1_103) AT=995.025n

* CHECK dout1_104 Vdout1_104ck198 = 0 time = 995
.meas tran vdout1_104ck198 FIND v(dout1_104) AT=995.025n

* CHECK dout1_105 Vdout1_105ck198 = 0.9 time = 995
.meas tran vdout1_105ck198 FIND v(dout1_105) AT=995.025n

* CHECK dout1_106 Vdout1_106ck198 = 0 time = 995
.meas tran vdout1_106ck198 FIND v(dout1_106) AT=995.025n

* CHECK dout1_107 Vdout1_107ck198 = 0 time = 995
.meas tran vdout1_107ck198 FIND v(dout1_107) AT=995.025n

* CHECK dout1_108 Vdout1_108ck198 = 0.9 time = 995
.meas tran vdout1_108ck198 FIND v(dout1_108) AT=995.025n

* CHECK dout1_109 Vdout1_109ck198 = 0 time = 995
.meas tran vdout1_109ck198 FIND v(dout1_109) AT=995.025n

* CHECK dout1_110 Vdout1_110ck198 = 0.9 time = 995
.meas tran vdout1_110ck198 FIND v(dout1_110) AT=995.025n

* CHECK dout1_111 Vdout1_111ck198 = 0 time = 995
.meas tran vdout1_111ck198 FIND v(dout1_111) AT=995.025n

* CHECK dout1_112 Vdout1_112ck198 = 0.9 time = 995
.meas tran vdout1_112ck198 FIND v(dout1_112) AT=995.025n

* CHECK dout1_113 Vdout1_113ck198 = 0 time = 995
.meas tran vdout1_113ck198 FIND v(dout1_113) AT=995.025n

* CHECK dout1_114 Vdout1_114ck198 = 0 time = 995
.meas tran vdout1_114ck198 FIND v(dout1_114) AT=995.025n

* CHECK dout1_115 Vdout1_115ck198 = 0 time = 995
.meas tran vdout1_115ck198 FIND v(dout1_115) AT=995.025n

* CHECK dout1_116 Vdout1_116ck198 = 0.9 time = 995
.meas tran vdout1_116ck198 FIND v(dout1_116) AT=995.025n

* CHECK dout1_117 Vdout1_117ck198 = 0 time = 995
.meas tran vdout1_117ck198 FIND v(dout1_117) AT=995.025n

* CHECK dout1_118 Vdout1_118ck198 = 0 time = 995
.meas tran vdout1_118ck198 FIND v(dout1_118) AT=995.025n

* CHECK dout1_119 Vdout1_119ck198 = 0 time = 995
.meas tran vdout1_119ck198 FIND v(dout1_119) AT=995.025n

* CHECK dout1_0 Vdout1_0ck201 = 0 time = 1010
.meas tran vdout1_0ck201 FIND v(dout1_0) AT=1010.025n

* CHECK dout1_1 Vdout1_1ck201 = 0.9 time = 1010
.meas tran vdout1_1ck201 FIND v(dout1_1) AT=1010.025n

* CHECK dout1_2 Vdout1_2ck201 = 0 time = 1010
.meas tran vdout1_2ck201 FIND v(dout1_2) AT=1010.025n

* CHECK dout1_3 Vdout1_3ck201 = 0.9 time = 1010
.meas tran vdout1_3ck201 FIND v(dout1_3) AT=1010.025n

* CHECK dout1_4 Vdout1_4ck201 = 0 time = 1010
.meas tran vdout1_4ck201 FIND v(dout1_4) AT=1010.025n

* CHECK dout1_5 Vdout1_5ck201 = 0 time = 1010
.meas tran vdout1_5ck201 FIND v(dout1_5) AT=1010.025n

* CHECK dout1_6 Vdout1_6ck201 = 0.9 time = 1010
.meas tran vdout1_6ck201 FIND v(dout1_6) AT=1010.025n

* CHECK dout1_7 Vdout1_7ck201 = 0 time = 1010
.meas tran vdout1_7ck201 FIND v(dout1_7) AT=1010.025n

* CHECK dout1_8 Vdout1_8ck201 = 0 time = 1010
.meas tran vdout1_8ck201 FIND v(dout1_8) AT=1010.025n

* CHECK dout1_9 Vdout1_9ck201 = 0 time = 1010
.meas tran vdout1_9ck201 FIND v(dout1_9) AT=1010.025n

* CHECK dout1_10 Vdout1_10ck201 = 0 time = 1010
.meas tran vdout1_10ck201 FIND v(dout1_10) AT=1010.025n

* CHECK dout1_11 Vdout1_11ck201 = 0.9 time = 1010
.meas tran vdout1_11ck201 FIND v(dout1_11) AT=1010.025n

* CHECK dout1_12 Vdout1_12ck201 = 0.9 time = 1010
.meas tran vdout1_12ck201 FIND v(dout1_12) AT=1010.025n

* CHECK dout1_13 Vdout1_13ck201 = 0.9 time = 1010
.meas tran vdout1_13ck201 FIND v(dout1_13) AT=1010.025n

* CHECK dout1_14 Vdout1_14ck201 = 0 time = 1010
.meas tran vdout1_14ck201 FIND v(dout1_14) AT=1010.025n

* CHECK dout1_15 Vdout1_15ck201 = 0.9 time = 1010
.meas tran vdout1_15ck201 FIND v(dout1_15) AT=1010.025n

* CHECK dout1_16 Vdout1_16ck201 = 0.9 time = 1010
.meas tran vdout1_16ck201 FIND v(dout1_16) AT=1010.025n

* CHECK dout1_17 Vdout1_17ck201 = 0.9 time = 1010
.meas tran vdout1_17ck201 FIND v(dout1_17) AT=1010.025n

* CHECK dout1_18 Vdout1_18ck201 = 0 time = 1010
.meas tran vdout1_18ck201 FIND v(dout1_18) AT=1010.025n

* CHECK dout1_19 Vdout1_19ck201 = 0.9 time = 1010
.meas tran vdout1_19ck201 FIND v(dout1_19) AT=1010.025n

* CHECK dout1_20 Vdout1_20ck201 = 0.9 time = 1010
.meas tran vdout1_20ck201 FIND v(dout1_20) AT=1010.025n

* CHECK dout1_21 Vdout1_21ck201 = 0 time = 1010
.meas tran vdout1_21ck201 FIND v(dout1_21) AT=1010.025n

* CHECK dout1_22 Vdout1_22ck201 = 0.9 time = 1010
.meas tran vdout1_22ck201 FIND v(dout1_22) AT=1010.025n

* CHECK dout1_23 Vdout1_23ck201 = 0.9 time = 1010
.meas tran vdout1_23ck201 FIND v(dout1_23) AT=1010.025n

* CHECK dout1_24 Vdout1_24ck201 = 0 time = 1010
.meas tran vdout1_24ck201 FIND v(dout1_24) AT=1010.025n

* CHECK dout1_25 Vdout1_25ck201 = 0.9 time = 1010
.meas tran vdout1_25ck201 FIND v(dout1_25) AT=1010.025n

* CHECK dout1_26 Vdout1_26ck201 = 0 time = 1010
.meas tran vdout1_26ck201 FIND v(dout1_26) AT=1010.025n

* CHECK dout1_27 Vdout1_27ck201 = 0 time = 1010
.meas tran vdout1_27ck201 FIND v(dout1_27) AT=1010.025n

* CHECK dout1_28 Vdout1_28ck201 = 0 time = 1010
.meas tran vdout1_28ck201 FIND v(dout1_28) AT=1010.025n

* CHECK dout1_29 Vdout1_29ck201 = 0 time = 1010
.meas tran vdout1_29ck201 FIND v(dout1_29) AT=1010.025n

* CHECK dout1_30 Vdout1_30ck201 = 0.9 time = 1010
.meas tran vdout1_30ck201 FIND v(dout1_30) AT=1010.025n

* CHECK dout1_31 Vdout1_31ck201 = 0.9 time = 1010
.meas tran vdout1_31ck201 FIND v(dout1_31) AT=1010.025n

* CHECK dout1_32 Vdout1_32ck201 = 0.9 time = 1010
.meas tran vdout1_32ck201 FIND v(dout1_32) AT=1010.025n

* CHECK dout1_33 Vdout1_33ck201 = 0 time = 1010
.meas tran vdout1_33ck201 FIND v(dout1_33) AT=1010.025n

* CHECK dout1_34 Vdout1_34ck201 = 0 time = 1010
.meas tran vdout1_34ck201 FIND v(dout1_34) AT=1010.025n

* CHECK dout1_35 Vdout1_35ck201 = 0.9 time = 1010
.meas tran vdout1_35ck201 FIND v(dout1_35) AT=1010.025n

* CHECK dout1_36 Vdout1_36ck201 = 0 time = 1010
.meas tran vdout1_36ck201 FIND v(dout1_36) AT=1010.025n

* CHECK dout1_37 Vdout1_37ck201 = 0.9 time = 1010
.meas tran vdout1_37ck201 FIND v(dout1_37) AT=1010.025n

* CHECK dout1_38 Vdout1_38ck201 = 0.9 time = 1010
.meas tran vdout1_38ck201 FIND v(dout1_38) AT=1010.025n

* CHECK dout1_39 Vdout1_39ck201 = 0 time = 1010
.meas tran vdout1_39ck201 FIND v(dout1_39) AT=1010.025n

* CHECK dout1_40 Vdout1_40ck201 = 0.9 time = 1010
.meas tran vdout1_40ck201 FIND v(dout1_40) AT=1010.025n

* CHECK dout1_41 Vdout1_41ck201 = 0.9 time = 1010
.meas tran vdout1_41ck201 FIND v(dout1_41) AT=1010.025n

* CHECK dout1_42 Vdout1_42ck201 = 0.9 time = 1010
.meas tran vdout1_42ck201 FIND v(dout1_42) AT=1010.025n

* CHECK dout1_43 Vdout1_43ck201 = 0.9 time = 1010
.meas tran vdout1_43ck201 FIND v(dout1_43) AT=1010.025n

* CHECK dout1_44 Vdout1_44ck201 = 0.9 time = 1010
.meas tran vdout1_44ck201 FIND v(dout1_44) AT=1010.025n

* CHECK dout1_45 Vdout1_45ck201 = 0.9 time = 1010
.meas tran vdout1_45ck201 FIND v(dout1_45) AT=1010.025n

* CHECK dout1_46 Vdout1_46ck201 = 0 time = 1010
.meas tran vdout1_46ck201 FIND v(dout1_46) AT=1010.025n

* CHECK dout1_47 Vdout1_47ck201 = 0.9 time = 1010
.meas tran vdout1_47ck201 FIND v(dout1_47) AT=1010.025n

* CHECK dout1_48 Vdout1_48ck201 = 0 time = 1010
.meas tran vdout1_48ck201 FIND v(dout1_48) AT=1010.025n

* CHECK dout1_49 Vdout1_49ck201 = 0.9 time = 1010
.meas tran vdout1_49ck201 FIND v(dout1_49) AT=1010.025n

* CHECK dout1_50 Vdout1_50ck201 = 0.9 time = 1010
.meas tran vdout1_50ck201 FIND v(dout1_50) AT=1010.025n

* CHECK dout1_51 Vdout1_51ck201 = 0 time = 1010
.meas tran vdout1_51ck201 FIND v(dout1_51) AT=1010.025n

* CHECK dout1_52 Vdout1_52ck201 = 0.9 time = 1010
.meas tran vdout1_52ck201 FIND v(dout1_52) AT=1010.025n

* CHECK dout1_53 Vdout1_53ck201 = 0.9 time = 1010
.meas tran vdout1_53ck201 FIND v(dout1_53) AT=1010.025n

* CHECK dout1_54 Vdout1_54ck201 = 0.9 time = 1010
.meas tran vdout1_54ck201 FIND v(dout1_54) AT=1010.025n

* CHECK dout1_55 Vdout1_55ck201 = 0.9 time = 1010
.meas tran vdout1_55ck201 FIND v(dout1_55) AT=1010.025n

* CHECK dout1_56 Vdout1_56ck201 = 0 time = 1010
.meas tran vdout1_56ck201 FIND v(dout1_56) AT=1010.025n

* CHECK dout1_57 Vdout1_57ck201 = 0.9 time = 1010
.meas tran vdout1_57ck201 FIND v(dout1_57) AT=1010.025n

* CHECK dout1_58 Vdout1_58ck201 = 0.9 time = 1010
.meas tran vdout1_58ck201 FIND v(dout1_58) AT=1010.025n

* CHECK dout1_59 Vdout1_59ck201 = 0 time = 1010
.meas tran vdout1_59ck201 FIND v(dout1_59) AT=1010.025n

* CHECK dout1_60 Vdout1_60ck201 = 0.9 time = 1010
.meas tran vdout1_60ck201 FIND v(dout1_60) AT=1010.025n

* CHECK dout1_61 Vdout1_61ck201 = 0.9 time = 1010
.meas tran vdout1_61ck201 FIND v(dout1_61) AT=1010.025n

* CHECK dout1_62 Vdout1_62ck201 = 0 time = 1010
.meas tran vdout1_62ck201 FIND v(dout1_62) AT=1010.025n

* CHECK dout1_63 Vdout1_63ck201 = 0.9 time = 1010
.meas tran vdout1_63ck201 FIND v(dout1_63) AT=1010.025n

* CHECK dout1_64 Vdout1_64ck201 = 0.9 time = 1010
.meas tran vdout1_64ck201 FIND v(dout1_64) AT=1010.025n

* CHECK dout1_65 Vdout1_65ck201 = 0 time = 1010
.meas tran vdout1_65ck201 FIND v(dout1_65) AT=1010.025n

* CHECK dout1_66 Vdout1_66ck201 = 0.9 time = 1010
.meas tran vdout1_66ck201 FIND v(dout1_66) AT=1010.025n

* CHECK dout1_67 Vdout1_67ck201 = 0.9 time = 1010
.meas tran vdout1_67ck201 FIND v(dout1_67) AT=1010.025n

* CHECK dout1_68 Vdout1_68ck201 = 0.9 time = 1010
.meas tran vdout1_68ck201 FIND v(dout1_68) AT=1010.025n

* CHECK dout1_69 Vdout1_69ck201 = 0.9 time = 1010
.meas tran vdout1_69ck201 FIND v(dout1_69) AT=1010.025n

* CHECK dout1_70 Vdout1_70ck201 = 0 time = 1010
.meas tran vdout1_70ck201 FIND v(dout1_70) AT=1010.025n

* CHECK dout1_71 Vdout1_71ck201 = 0.9 time = 1010
.meas tran vdout1_71ck201 FIND v(dout1_71) AT=1010.025n

* CHECK dout1_72 Vdout1_72ck201 = 0 time = 1010
.meas tran vdout1_72ck201 FIND v(dout1_72) AT=1010.025n

* CHECK dout1_73 Vdout1_73ck201 = 0 time = 1010
.meas tran vdout1_73ck201 FIND v(dout1_73) AT=1010.025n

* CHECK dout1_74 Vdout1_74ck201 = 0 time = 1010
.meas tran vdout1_74ck201 FIND v(dout1_74) AT=1010.025n

* CHECK dout1_75 Vdout1_75ck201 = 0 time = 1010
.meas tran vdout1_75ck201 FIND v(dout1_75) AT=1010.025n

* CHECK dout1_76 Vdout1_76ck201 = 0 time = 1010
.meas tran vdout1_76ck201 FIND v(dout1_76) AT=1010.025n

* CHECK dout1_77 Vdout1_77ck201 = 0 time = 1010
.meas tran vdout1_77ck201 FIND v(dout1_77) AT=1010.025n

* CHECK dout1_78 Vdout1_78ck201 = 0 time = 1010
.meas tran vdout1_78ck201 FIND v(dout1_78) AT=1010.025n

* CHECK dout1_79 Vdout1_79ck201 = 0 time = 1010
.meas tran vdout1_79ck201 FIND v(dout1_79) AT=1010.025n

* CHECK dout1_80 Vdout1_80ck201 = 0.9 time = 1010
.meas tran vdout1_80ck201 FIND v(dout1_80) AT=1010.025n

* CHECK dout1_81 Vdout1_81ck201 = 0.9 time = 1010
.meas tran vdout1_81ck201 FIND v(dout1_81) AT=1010.025n

* CHECK dout1_82 Vdout1_82ck201 = 0 time = 1010
.meas tran vdout1_82ck201 FIND v(dout1_82) AT=1010.025n

* CHECK dout1_83 Vdout1_83ck201 = 0 time = 1010
.meas tran vdout1_83ck201 FIND v(dout1_83) AT=1010.025n

* CHECK dout1_84 Vdout1_84ck201 = 0.9 time = 1010
.meas tran vdout1_84ck201 FIND v(dout1_84) AT=1010.025n

* CHECK dout1_85 Vdout1_85ck201 = 0 time = 1010
.meas tran vdout1_85ck201 FIND v(dout1_85) AT=1010.025n

* CHECK dout1_86 Vdout1_86ck201 = 0 time = 1010
.meas tran vdout1_86ck201 FIND v(dout1_86) AT=1010.025n

* CHECK dout1_87 Vdout1_87ck201 = 0.9 time = 1010
.meas tran vdout1_87ck201 FIND v(dout1_87) AT=1010.025n

* CHECK dout1_88 Vdout1_88ck201 = 0 time = 1010
.meas tran vdout1_88ck201 FIND v(dout1_88) AT=1010.025n

* CHECK dout1_89 Vdout1_89ck201 = 0 time = 1010
.meas tran vdout1_89ck201 FIND v(dout1_89) AT=1010.025n

* CHECK dout1_90 Vdout1_90ck201 = 0.9 time = 1010
.meas tran vdout1_90ck201 FIND v(dout1_90) AT=1010.025n

* CHECK dout1_91 Vdout1_91ck201 = 0 time = 1010
.meas tran vdout1_91ck201 FIND v(dout1_91) AT=1010.025n

* CHECK dout1_92 Vdout1_92ck201 = 0 time = 1010
.meas tran vdout1_92ck201 FIND v(dout1_92) AT=1010.025n

* CHECK dout1_93 Vdout1_93ck201 = 0 time = 1010
.meas tran vdout1_93ck201 FIND v(dout1_93) AT=1010.025n

* CHECK dout1_94 Vdout1_94ck201 = 0.9 time = 1010
.meas tran vdout1_94ck201 FIND v(dout1_94) AT=1010.025n

* CHECK dout1_95 Vdout1_95ck201 = 0.9 time = 1010
.meas tran vdout1_95ck201 FIND v(dout1_95) AT=1010.025n

* CHECK dout1_96 Vdout1_96ck201 = 0.9 time = 1010
.meas tran vdout1_96ck201 FIND v(dout1_96) AT=1010.025n

* CHECK dout1_97 Vdout1_97ck201 = 0 time = 1010
.meas tran vdout1_97ck201 FIND v(dout1_97) AT=1010.025n

* CHECK dout1_98 Vdout1_98ck201 = 0 time = 1010
.meas tran vdout1_98ck201 FIND v(dout1_98) AT=1010.025n

* CHECK dout1_99 Vdout1_99ck201 = 0.9 time = 1010
.meas tran vdout1_99ck201 FIND v(dout1_99) AT=1010.025n

* CHECK dout1_100 Vdout1_100ck201 = 0 time = 1010
.meas tran vdout1_100ck201 FIND v(dout1_100) AT=1010.025n

* CHECK dout1_101 Vdout1_101ck201 = 0.9 time = 1010
.meas tran vdout1_101ck201 FIND v(dout1_101) AT=1010.025n

* CHECK dout1_102 Vdout1_102ck201 = 0.9 time = 1010
.meas tran vdout1_102ck201 FIND v(dout1_102) AT=1010.025n

* CHECK dout1_103 Vdout1_103ck201 = 0.9 time = 1010
.meas tran vdout1_103ck201 FIND v(dout1_103) AT=1010.025n

* CHECK dout1_104 Vdout1_104ck201 = 0 time = 1010
.meas tran vdout1_104ck201 FIND v(dout1_104) AT=1010.025n

* CHECK dout1_105 Vdout1_105ck201 = 0.9 time = 1010
.meas tran vdout1_105ck201 FIND v(dout1_105) AT=1010.025n

* CHECK dout1_106 Vdout1_106ck201 = 0 time = 1010
.meas tran vdout1_106ck201 FIND v(dout1_106) AT=1010.025n

* CHECK dout1_107 Vdout1_107ck201 = 0 time = 1010
.meas tran vdout1_107ck201 FIND v(dout1_107) AT=1010.025n

* CHECK dout1_108 Vdout1_108ck201 = 0.9 time = 1010
.meas tran vdout1_108ck201 FIND v(dout1_108) AT=1010.025n

* CHECK dout1_109 Vdout1_109ck201 = 0 time = 1010
.meas tran vdout1_109ck201 FIND v(dout1_109) AT=1010.025n

* CHECK dout1_110 Vdout1_110ck201 = 0.9 time = 1010
.meas tran vdout1_110ck201 FIND v(dout1_110) AT=1010.025n

* CHECK dout1_111 Vdout1_111ck201 = 0 time = 1010
.meas tran vdout1_111ck201 FIND v(dout1_111) AT=1010.025n

* CHECK dout1_112 Vdout1_112ck201 = 0.9 time = 1010
.meas tran vdout1_112ck201 FIND v(dout1_112) AT=1010.025n

* CHECK dout1_113 Vdout1_113ck201 = 0 time = 1010
.meas tran vdout1_113ck201 FIND v(dout1_113) AT=1010.025n

* CHECK dout1_114 Vdout1_114ck201 = 0 time = 1010
.meas tran vdout1_114ck201 FIND v(dout1_114) AT=1010.025n

* CHECK dout1_115 Vdout1_115ck201 = 0 time = 1010
.meas tran vdout1_115ck201 FIND v(dout1_115) AT=1010.025n

* CHECK dout1_116 Vdout1_116ck201 = 0.9 time = 1010
.meas tran vdout1_116ck201 FIND v(dout1_116) AT=1010.025n

* CHECK dout1_117 Vdout1_117ck201 = 0 time = 1010
.meas tran vdout1_117ck201 FIND v(dout1_117) AT=1010.025n

* CHECK dout1_118 Vdout1_118ck201 = 0 time = 1010
.meas tran vdout1_118ck201 FIND v(dout1_118) AT=1010.025n

* CHECK dout1_119 Vdout1_119ck201 = 0 time = 1010
.meas tran vdout1_119ck201 FIND v(dout1_119) AT=1010.025n

* CHECK dout1_0 Vdout1_0ck202 = 0 time = 1015
.meas tran vdout1_0ck202 FIND v(dout1_0) AT=1015.025n

* CHECK dout1_1 Vdout1_1ck202 = 0.9 time = 1015
.meas tran vdout1_1ck202 FIND v(dout1_1) AT=1015.025n

* CHECK dout1_2 Vdout1_2ck202 = 0 time = 1015
.meas tran vdout1_2ck202 FIND v(dout1_2) AT=1015.025n

* CHECK dout1_3 Vdout1_3ck202 = 0.9 time = 1015
.meas tran vdout1_3ck202 FIND v(dout1_3) AT=1015.025n

* CHECK dout1_4 Vdout1_4ck202 = 0 time = 1015
.meas tran vdout1_4ck202 FIND v(dout1_4) AT=1015.025n

* CHECK dout1_5 Vdout1_5ck202 = 0.9 time = 1015
.meas tran vdout1_5ck202 FIND v(dout1_5) AT=1015.025n

* CHECK dout1_6 Vdout1_6ck202 = 0.9 time = 1015
.meas tran vdout1_6ck202 FIND v(dout1_6) AT=1015.025n

* CHECK dout1_7 Vdout1_7ck202 = 0.9 time = 1015
.meas tran vdout1_7ck202 FIND v(dout1_7) AT=1015.025n

* CHECK dout1_8 Vdout1_8ck202 = 0.9 time = 1015
.meas tran vdout1_8ck202 FIND v(dout1_8) AT=1015.025n

* CHECK dout1_9 Vdout1_9ck202 = 0 time = 1015
.meas tran vdout1_9ck202 FIND v(dout1_9) AT=1015.025n

* CHECK dout1_10 Vdout1_10ck202 = 0 time = 1015
.meas tran vdout1_10ck202 FIND v(dout1_10) AT=1015.025n

* CHECK dout1_11 Vdout1_11ck202 = 0 time = 1015
.meas tran vdout1_11ck202 FIND v(dout1_11) AT=1015.025n

* CHECK dout1_12 Vdout1_12ck202 = 0.9 time = 1015
.meas tran vdout1_12ck202 FIND v(dout1_12) AT=1015.025n

* CHECK dout1_13 Vdout1_13ck202 = 0 time = 1015
.meas tran vdout1_13ck202 FIND v(dout1_13) AT=1015.025n

* CHECK dout1_14 Vdout1_14ck202 = 0 time = 1015
.meas tran vdout1_14ck202 FIND v(dout1_14) AT=1015.025n

* CHECK dout1_15 Vdout1_15ck202 = 0.9 time = 1015
.meas tran vdout1_15ck202 FIND v(dout1_15) AT=1015.025n

* CHECK dout1_16 Vdout1_16ck202 = 0 time = 1015
.meas tran vdout1_16ck202 FIND v(dout1_16) AT=1015.025n

* CHECK dout1_17 Vdout1_17ck202 = 0.9 time = 1015
.meas tran vdout1_17ck202 FIND v(dout1_17) AT=1015.025n

* CHECK dout1_18 Vdout1_18ck202 = 0 time = 1015
.meas tran vdout1_18ck202 FIND v(dout1_18) AT=1015.025n

* CHECK dout1_19 Vdout1_19ck202 = 0 time = 1015
.meas tran vdout1_19ck202 FIND v(dout1_19) AT=1015.025n

* CHECK dout1_20 Vdout1_20ck202 = 0 time = 1015
.meas tran vdout1_20ck202 FIND v(dout1_20) AT=1015.025n

* CHECK dout1_21 Vdout1_21ck202 = 0 time = 1015
.meas tran vdout1_21ck202 FIND v(dout1_21) AT=1015.025n

* CHECK dout1_22 Vdout1_22ck202 = 0.9 time = 1015
.meas tran vdout1_22ck202 FIND v(dout1_22) AT=1015.025n

* CHECK dout1_23 Vdout1_23ck202 = 0 time = 1015
.meas tran vdout1_23ck202 FIND v(dout1_23) AT=1015.025n

* CHECK dout1_24 Vdout1_24ck202 = 0.9 time = 1015
.meas tran vdout1_24ck202 FIND v(dout1_24) AT=1015.025n

* CHECK dout1_25 Vdout1_25ck202 = 0 time = 1015
.meas tran vdout1_25ck202 FIND v(dout1_25) AT=1015.025n

* CHECK dout1_26 Vdout1_26ck202 = 0.9 time = 1015
.meas tran vdout1_26ck202 FIND v(dout1_26) AT=1015.025n

* CHECK dout1_27 Vdout1_27ck202 = 0.9 time = 1015
.meas tran vdout1_27ck202 FIND v(dout1_27) AT=1015.025n

* CHECK dout1_28 Vdout1_28ck202 = 0 time = 1015
.meas tran vdout1_28ck202 FIND v(dout1_28) AT=1015.025n

* CHECK dout1_29 Vdout1_29ck202 = 0 time = 1015
.meas tran vdout1_29ck202 FIND v(dout1_29) AT=1015.025n

* CHECK dout1_30 Vdout1_30ck202 = 0 time = 1015
.meas tran vdout1_30ck202 FIND v(dout1_30) AT=1015.025n

* CHECK dout1_31 Vdout1_31ck202 = 0.9 time = 1015
.meas tran vdout1_31ck202 FIND v(dout1_31) AT=1015.025n

* CHECK dout1_32 Vdout1_32ck202 = 0 time = 1015
.meas tran vdout1_32ck202 FIND v(dout1_32) AT=1015.025n

* CHECK dout1_33 Vdout1_33ck202 = 0 time = 1015
.meas tran vdout1_33ck202 FIND v(dout1_33) AT=1015.025n

* CHECK dout1_34 Vdout1_34ck202 = 0.9 time = 1015
.meas tran vdout1_34ck202 FIND v(dout1_34) AT=1015.025n

* CHECK dout1_35 Vdout1_35ck202 = 0 time = 1015
.meas tran vdout1_35ck202 FIND v(dout1_35) AT=1015.025n

* CHECK dout1_36 Vdout1_36ck202 = 0 time = 1015
.meas tran vdout1_36ck202 FIND v(dout1_36) AT=1015.025n

* CHECK dout1_37 Vdout1_37ck202 = 0 time = 1015
.meas tran vdout1_37ck202 FIND v(dout1_37) AT=1015.025n

* CHECK dout1_38 Vdout1_38ck202 = 0.9 time = 1015
.meas tran vdout1_38ck202 FIND v(dout1_38) AT=1015.025n

* CHECK dout1_39 Vdout1_39ck202 = 0.9 time = 1015
.meas tran vdout1_39ck202 FIND v(dout1_39) AT=1015.025n

* CHECK dout1_40 Vdout1_40ck202 = 0.9 time = 1015
.meas tran vdout1_40ck202 FIND v(dout1_40) AT=1015.025n

* CHECK dout1_41 Vdout1_41ck202 = 0 time = 1015
.meas tran vdout1_41ck202 FIND v(dout1_41) AT=1015.025n

* CHECK dout1_42 Vdout1_42ck202 = 0.9 time = 1015
.meas tran vdout1_42ck202 FIND v(dout1_42) AT=1015.025n

* CHECK dout1_43 Vdout1_43ck202 = 0.9 time = 1015
.meas tran vdout1_43ck202 FIND v(dout1_43) AT=1015.025n

* CHECK dout1_44 Vdout1_44ck202 = 0.9 time = 1015
.meas tran vdout1_44ck202 FIND v(dout1_44) AT=1015.025n

* CHECK dout1_45 Vdout1_45ck202 = 0 time = 1015
.meas tran vdout1_45ck202 FIND v(dout1_45) AT=1015.025n

* CHECK dout1_46 Vdout1_46ck202 = 0 time = 1015
.meas tran vdout1_46ck202 FIND v(dout1_46) AT=1015.025n

* CHECK dout1_47 Vdout1_47ck202 = 0.9 time = 1015
.meas tran vdout1_47ck202 FIND v(dout1_47) AT=1015.025n

* CHECK dout1_48 Vdout1_48ck202 = 0 time = 1015
.meas tran vdout1_48ck202 FIND v(dout1_48) AT=1015.025n

* CHECK dout1_49 Vdout1_49ck202 = 0 time = 1015
.meas tran vdout1_49ck202 FIND v(dout1_49) AT=1015.025n

* CHECK dout1_50 Vdout1_50ck202 = 0 time = 1015
.meas tran vdout1_50ck202 FIND v(dout1_50) AT=1015.025n

* CHECK dout1_51 Vdout1_51ck202 = 0 time = 1015
.meas tran vdout1_51ck202 FIND v(dout1_51) AT=1015.025n

* CHECK dout1_52 Vdout1_52ck202 = 0.9 time = 1015
.meas tran vdout1_52ck202 FIND v(dout1_52) AT=1015.025n

* CHECK dout1_53 Vdout1_53ck202 = 0 time = 1015
.meas tran vdout1_53ck202 FIND v(dout1_53) AT=1015.025n

* CHECK dout1_54 Vdout1_54ck202 = 0 time = 1015
.meas tran vdout1_54ck202 FIND v(dout1_54) AT=1015.025n

* CHECK dout1_55 Vdout1_55ck202 = 0 time = 1015
.meas tran vdout1_55ck202 FIND v(dout1_55) AT=1015.025n

* CHECK dout1_56 Vdout1_56ck202 = 0 time = 1015
.meas tran vdout1_56ck202 FIND v(dout1_56) AT=1015.025n

* CHECK dout1_57 Vdout1_57ck202 = 0 time = 1015
.meas tran vdout1_57ck202 FIND v(dout1_57) AT=1015.025n

* CHECK dout1_58 Vdout1_58ck202 = 0 time = 1015
.meas tran vdout1_58ck202 FIND v(dout1_58) AT=1015.025n

* CHECK dout1_59 Vdout1_59ck202 = 0.9 time = 1015
.meas tran vdout1_59ck202 FIND v(dout1_59) AT=1015.025n

* CHECK dout1_60 Vdout1_60ck202 = 0.9 time = 1015
.meas tran vdout1_60ck202 FIND v(dout1_60) AT=1015.025n

* CHECK dout1_61 Vdout1_61ck202 = 0 time = 1015
.meas tran vdout1_61ck202 FIND v(dout1_61) AT=1015.025n

* CHECK dout1_62 Vdout1_62ck202 = 0.9 time = 1015
.meas tran vdout1_62ck202 FIND v(dout1_62) AT=1015.025n

* CHECK dout1_63 Vdout1_63ck202 = 0.9 time = 1015
.meas tran vdout1_63ck202 FIND v(dout1_63) AT=1015.025n

* CHECK dout1_64 Vdout1_64ck202 = 0.9 time = 1015
.meas tran vdout1_64ck202 FIND v(dout1_64) AT=1015.025n

* CHECK dout1_65 Vdout1_65ck202 = 0.9 time = 1015
.meas tran vdout1_65ck202 FIND v(dout1_65) AT=1015.025n

* CHECK dout1_66 Vdout1_66ck202 = 0.9 time = 1015
.meas tran vdout1_66ck202 FIND v(dout1_66) AT=1015.025n

* CHECK dout1_67 Vdout1_67ck202 = 0.9 time = 1015
.meas tran vdout1_67ck202 FIND v(dout1_67) AT=1015.025n

* CHECK dout1_68 Vdout1_68ck202 = 0.9 time = 1015
.meas tran vdout1_68ck202 FIND v(dout1_68) AT=1015.025n

* CHECK dout1_69 Vdout1_69ck202 = 0 time = 1015
.meas tran vdout1_69ck202 FIND v(dout1_69) AT=1015.025n

* CHECK dout1_70 Vdout1_70ck202 = 0.9 time = 1015
.meas tran vdout1_70ck202 FIND v(dout1_70) AT=1015.025n

* CHECK dout1_71 Vdout1_71ck202 = 0.9 time = 1015
.meas tran vdout1_71ck202 FIND v(dout1_71) AT=1015.025n

* CHECK dout1_72 Vdout1_72ck202 = 0 time = 1015
.meas tran vdout1_72ck202 FIND v(dout1_72) AT=1015.025n

* CHECK dout1_73 Vdout1_73ck202 = 0 time = 1015
.meas tran vdout1_73ck202 FIND v(dout1_73) AT=1015.025n

* CHECK dout1_74 Vdout1_74ck202 = 0.9 time = 1015
.meas tran vdout1_74ck202 FIND v(dout1_74) AT=1015.025n

* CHECK dout1_75 Vdout1_75ck202 = 0.9 time = 1015
.meas tran vdout1_75ck202 FIND v(dout1_75) AT=1015.025n

* CHECK dout1_76 Vdout1_76ck202 = 0.9 time = 1015
.meas tran vdout1_76ck202 FIND v(dout1_76) AT=1015.025n

* CHECK dout1_77 Vdout1_77ck202 = 0.9 time = 1015
.meas tran vdout1_77ck202 FIND v(dout1_77) AT=1015.025n

* CHECK dout1_78 Vdout1_78ck202 = 0.9 time = 1015
.meas tran vdout1_78ck202 FIND v(dout1_78) AT=1015.025n

* CHECK dout1_79 Vdout1_79ck202 = 0 time = 1015
.meas tran vdout1_79ck202 FIND v(dout1_79) AT=1015.025n

* CHECK dout1_80 Vdout1_80ck202 = 0 time = 1015
.meas tran vdout1_80ck202 FIND v(dout1_80) AT=1015.025n

* CHECK dout1_81 Vdout1_81ck202 = 0.9 time = 1015
.meas tran vdout1_81ck202 FIND v(dout1_81) AT=1015.025n

* CHECK dout1_82 Vdout1_82ck202 = 0.9 time = 1015
.meas tran vdout1_82ck202 FIND v(dout1_82) AT=1015.025n

* CHECK dout1_83 Vdout1_83ck202 = 0.9 time = 1015
.meas tran vdout1_83ck202 FIND v(dout1_83) AT=1015.025n

* CHECK dout1_84 Vdout1_84ck202 = 0.9 time = 1015
.meas tran vdout1_84ck202 FIND v(dout1_84) AT=1015.025n

* CHECK dout1_85 Vdout1_85ck202 = 0.9 time = 1015
.meas tran vdout1_85ck202 FIND v(dout1_85) AT=1015.025n

* CHECK dout1_86 Vdout1_86ck202 = 0 time = 1015
.meas tran vdout1_86ck202 FIND v(dout1_86) AT=1015.025n

* CHECK dout1_87 Vdout1_87ck202 = 0 time = 1015
.meas tran vdout1_87ck202 FIND v(dout1_87) AT=1015.025n

* CHECK dout1_88 Vdout1_88ck202 = 0.9 time = 1015
.meas tran vdout1_88ck202 FIND v(dout1_88) AT=1015.025n

* CHECK dout1_89 Vdout1_89ck202 = 0 time = 1015
.meas tran vdout1_89ck202 FIND v(dout1_89) AT=1015.025n

* CHECK dout1_90 Vdout1_90ck202 = 0.9 time = 1015
.meas tran vdout1_90ck202 FIND v(dout1_90) AT=1015.025n

* CHECK dout1_91 Vdout1_91ck202 = 0.9 time = 1015
.meas tran vdout1_91ck202 FIND v(dout1_91) AT=1015.025n

* CHECK dout1_92 Vdout1_92ck202 = 0 time = 1015
.meas tran vdout1_92ck202 FIND v(dout1_92) AT=1015.025n

* CHECK dout1_93 Vdout1_93ck202 = 0.9 time = 1015
.meas tran vdout1_93ck202 FIND v(dout1_93) AT=1015.025n

* CHECK dout1_94 Vdout1_94ck202 = 0 time = 1015
.meas tran vdout1_94ck202 FIND v(dout1_94) AT=1015.025n

* CHECK dout1_95 Vdout1_95ck202 = 0 time = 1015
.meas tran vdout1_95ck202 FIND v(dout1_95) AT=1015.025n

* CHECK dout1_96 Vdout1_96ck202 = 0.9 time = 1015
.meas tran vdout1_96ck202 FIND v(dout1_96) AT=1015.025n

* CHECK dout1_97 Vdout1_97ck202 = 0.9 time = 1015
.meas tran vdout1_97ck202 FIND v(dout1_97) AT=1015.025n

* CHECK dout1_98 Vdout1_98ck202 = 0.9 time = 1015
.meas tran vdout1_98ck202 FIND v(dout1_98) AT=1015.025n

* CHECK dout1_99 Vdout1_99ck202 = 0.9 time = 1015
.meas tran vdout1_99ck202 FIND v(dout1_99) AT=1015.025n

* CHECK dout1_100 Vdout1_100ck202 = 0 time = 1015
.meas tran vdout1_100ck202 FIND v(dout1_100) AT=1015.025n

* CHECK dout1_101 Vdout1_101ck202 = 0 time = 1015
.meas tran vdout1_101ck202 FIND v(dout1_101) AT=1015.025n

* CHECK dout1_102 Vdout1_102ck202 = 0.9 time = 1015
.meas tran vdout1_102ck202 FIND v(dout1_102) AT=1015.025n

* CHECK dout1_103 Vdout1_103ck202 = 0.9 time = 1015
.meas tran vdout1_103ck202 FIND v(dout1_103) AT=1015.025n

* CHECK dout1_104 Vdout1_104ck202 = 0 time = 1015
.meas tran vdout1_104ck202 FIND v(dout1_104) AT=1015.025n

* CHECK dout1_105 Vdout1_105ck202 = 0.9 time = 1015
.meas tran vdout1_105ck202 FIND v(dout1_105) AT=1015.025n

* CHECK dout1_106 Vdout1_106ck202 = 0.9 time = 1015
.meas tran vdout1_106ck202 FIND v(dout1_106) AT=1015.025n

* CHECK dout1_107 Vdout1_107ck202 = 0 time = 1015
.meas tran vdout1_107ck202 FIND v(dout1_107) AT=1015.025n

* CHECK dout1_108 Vdout1_108ck202 = 0 time = 1015
.meas tran vdout1_108ck202 FIND v(dout1_108) AT=1015.025n

* CHECK dout1_109 Vdout1_109ck202 = 0 time = 1015
.meas tran vdout1_109ck202 FIND v(dout1_109) AT=1015.025n

* CHECK dout1_110 Vdout1_110ck202 = 0.9 time = 1015
.meas tran vdout1_110ck202 FIND v(dout1_110) AT=1015.025n

* CHECK dout1_111 Vdout1_111ck202 = 0 time = 1015
.meas tran vdout1_111ck202 FIND v(dout1_111) AT=1015.025n

* CHECK dout1_112 Vdout1_112ck202 = 0.9 time = 1015
.meas tran vdout1_112ck202 FIND v(dout1_112) AT=1015.025n

* CHECK dout1_113 Vdout1_113ck202 = 0 time = 1015
.meas tran vdout1_113ck202 FIND v(dout1_113) AT=1015.025n

* CHECK dout1_114 Vdout1_114ck202 = 0 time = 1015
.meas tran vdout1_114ck202 FIND v(dout1_114) AT=1015.025n

* CHECK dout1_115 Vdout1_115ck202 = 0 time = 1015
.meas tran vdout1_115ck202 FIND v(dout1_115) AT=1015.025n

* CHECK dout1_116 Vdout1_116ck202 = 0.9 time = 1015
.meas tran vdout1_116ck202 FIND v(dout1_116) AT=1015.025n

* CHECK dout1_117 Vdout1_117ck202 = 0 time = 1015
.meas tran vdout1_117ck202 FIND v(dout1_117) AT=1015.025n

* CHECK dout1_118 Vdout1_118ck202 = 0 time = 1015
.meas tran vdout1_118ck202 FIND v(dout1_118) AT=1015.025n

* CHECK dout1_119 Vdout1_119ck202 = 0 time = 1015
.meas tran vdout1_119ck202 FIND v(dout1_119) AT=1015.025n

* CHECK dout1_0 Vdout1_0ck204 = 0.9 time = 1025
.meas tran vdout1_0ck204 FIND v(dout1_0) AT=1025.025n

* CHECK dout1_1 Vdout1_1ck204 = 0 time = 1025
.meas tran vdout1_1ck204 FIND v(dout1_1) AT=1025.025n

* CHECK dout1_2 Vdout1_2ck204 = 0 time = 1025
.meas tran vdout1_2ck204 FIND v(dout1_2) AT=1025.025n

* CHECK dout1_3 Vdout1_3ck204 = 0.9 time = 1025
.meas tran vdout1_3ck204 FIND v(dout1_3) AT=1025.025n

* CHECK dout1_4 Vdout1_4ck204 = 0 time = 1025
.meas tran vdout1_4ck204 FIND v(dout1_4) AT=1025.025n

* CHECK dout1_5 Vdout1_5ck204 = 0 time = 1025
.meas tran vdout1_5ck204 FIND v(dout1_5) AT=1025.025n

* CHECK dout1_6 Vdout1_6ck204 = 0 time = 1025
.meas tran vdout1_6ck204 FIND v(dout1_6) AT=1025.025n

* CHECK dout1_7 Vdout1_7ck204 = 0 time = 1025
.meas tran vdout1_7ck204 FIND v(dout1_7) AT=1025.025n

* CHECK dout1_8 Vdout1_8ck204 = 0 time = 1025
.meas tran vdout1_8ck204 FIND v(dout1_8) AT=1025.025n

* CHECK dout1_9 Vdout1_9ck204 = 0.9 time = 1025
.meas tran vdout1_9ck204 FIND v(dout1_9) AT=1025.025n

* CHECK dout1_10 Vdout1_10ck204 = 0.9 time = 1025
.meas tran vdout1_10ck204 FIND v(dout1_10) AT=1025.025n

* CHECK dout1_11 Vdout1_11ck204 = 0.9 time = 1025
.meas tran vdout1_11ck204 FIND v(dout1_11) AT=1025.025n

* CHECK dout1_12 Vdout1_12ck204 = 0.9 time = 1025
.meas tran vdout1_12ck204 FIND v(dout1_12) AT=1025.025n

* CHECK dout1_13 Vdout1_13ck204 = 0.9 time = 1025
.meas tran vdout1_13ck204 FIND v(dout1_13) AT=1025.025n

* CHECK dout1_14 Vdout1_14ck204 = 0 time = 1025
.meas tran vdout1_14ck204 FIND v(dout1_14) AT=1025.025n

* CHECK dout1_15 Vdout1_15ck204 = 0 time = 1025
.meas tran vdout1_15ck204 FIND v(dout1_15) AT=1025.025n

* CHECK dout1_16 Vdout1_16ck204 = 0.9 time = 1025
.meas tran vdout1_16ck204 FIND v(dout1_16) AT=1025.025n

* CHECK dout1_17 Vdout1_17ck204 = 0 time = 1025
.meas tran vdout1_17ck204 FIND v(dout1_17) AT=1025.025n

* CHECK dout1_18 Vdout1_18ck204 = 0.9 time = 1025
.meas tran vdout1_18ck204 FIND v(dout1_18) AT=1025.025n

* CHECK dout1_19 Vdout1_19ck204 = 0.9 time = 1025
.meas tran vdout1_19ck204 FIND v(dout1_19) AT=1025.025n

* CHECK dout1_20 Vdout1_20ck204 = 0 time = 1025
.meas tran vdout1_20ck204 FIND v(dout1_20) AT=1025.025n

* CHECK dout1_21 Vdout1_21ck204 = 0.9 time = 1025
.meas tran vdout1_21ck204 FIND v(dout1_21) AT=1025.025n

* CHECK dout1_22 Vdout1_22ck204 = 0.9 time = 1025
.meas tran vdout1_22ck204 FIND v(dout1_22) AT=1025.025n

* CHECK dout1_23 Vdout1_23ck204 = 0.9 time = 1025
.meas tran vdout1_23ck204 FIND v(dout1_23) AT=1025.025n

* CHECK dout1_24 Vdout1_24ck204 = 0.9 time = 1025
.meas tran vdout1_24ck204 FIND v(dout1_24) AT=1025.025n

* CHECK dout1_25 Vdout1_25ck204 = 0.9 time = 1025
.meas tran vdout1_25ck204 FIND v(dout1_25) AT=1025.025n

* CHECK dout1_26 Vdout1_26ck204 = 0.9 time = 1025
.meas tran vdout1_26ck204 FIND v(dout1_26) AT=1025.025n

* CHECK dout1_27 Vdout1_27ck204 = 0.9 time = 1025
.meas tran vdout1_27ck204 FIND v(dout1_27) AT=1025.025n

* CHECK dout1_28 Vdout1_28ck204 = 0.9 time = 1025
.meas tran vdout1_28ck204 FIND v(dout1_28) AT=1025.025n

* CHECK dout1_29 Vdout1_29ck204 = 0 time = 1025
.meas tran vdout1_29ck204 FIND v(dout1_29) AT=1025.025n

* CHECK dout1_30 Vdout1_30ck204 = 0 time = 1025
.meas tran vdout1_30ck204 FIND v(dout1_30) AT=1025.025n

* CHECK dout1_31 Vdout1_31ck204 = 0 time = 1025
.meas tran vdout1_31ck204 FIND v(dout1_31) AT=1025.025n

* CHECK dout1_32 Vdout1_32ck204 = 0.9 time = 1025
.meas tran vdout1_32ck204 FIND v(dout1_32) AT=1025.025n

* CHECK dout1_33 Vdout1_33ck204 = 0 time = 1025
.meas tran vdout1_33ck204 FIND v(dout1_33) AT=1025.025n

* CHECK dout1_34 Vdout1_34ck204 = 0 time = 1025
.meas tran vdout1_34ck204 FIND v(dout1_34) AT=1025.025n

* CHECK dout1_35 Vdout1_35ck204 = 0.9 time = 1025
.meas tran vdout1_35ck204 FIND v(dout1_35) AT=1025.025n

* CHECK dout1_36 Vdout1_36ck204 = 0 time = 1025
.meas tran vdout1_36ck204 FIND v(dout1_36) AT=1025.025n

* CHECK dout1_37 Vdout1_37ck204 = 0 time = 1025
.meas tran vdout1_37ck204 FIND v(dout1_37) AT=1025.025n

* CHECK dout1_38 Vdout1_38ck204 = 0.9 time = 1025
.meas tran vdout1_38ck204 FIND v(dout1_38) AT=1025.025n

* CHECK dout1_39 Vdout1_39ck204 = 0 time = 1025
.meas tran vdout1_39ck204 FIND v(dout1_39) AT=1025.025n

* CHECK dout1_40 Vdout1_40ck204 = 0.9 time = 1025
.meas tran vdout1_40ck204 FIND v(dout1_40) AT=1025.025n

* CHECK dout1_41 Vdout1_41ck204 = 0 time = 1025
.meas tran vdout1_41ck204 FIND v(dout1_41) AT=1025.025n

* CHECK dout1_42 Vdout1_42ck204 = 0.9 time = 1025
.meas tran vdout1_42ck204 FIND v(dout1_42) AT=1025.025n

* CHECK dout1_43 Vdout1_43ck204 = 0 time = 1025
.meas tran vdout1_43ck204 FIND v(dout1_43) AT=1025.025n

* CHECK dout1_44 Vdout1_44ck204 = 0.9 time = 1025
.meas tran vdout1_44ck204 FIND v(dout1_44) AT=1025.025n

* CHECK dout1_45 Vdout1_45ck204 = 0 time = 1025
.meas tran vdout1_45ck204 FIND v(dout1_45) AT=1025.025n

* CHECK dout1_46 Vdout1_46ck204 = 0.9 time = 1025
.meas tran vdout1_46ck204 FIND v(dout1_46) AT=1025.025n

* CHECK dout1_47 Vdout1_47ck204 = 0.9 time = 1025
.meas tran vdout1_47ck204 FIND v(dout1_47) AT=1025.025n

* CHECK dout1_48 Vdout1_48ck204 = 0 time = 1025
.meas tran vdout1_48ck204 FIND v(dout1_48) AT=1025.025n

* CHECK dout1_49 Vdout1_49ck204 = 0.9 time = 1025
.meas tran vdout1_49ck204 FIND v(dout1_49) AT=1025.025n

* CHECK dout1_50 Vdout1_50ck204 = 0.9 time = 1025
.meas tran vdout1_50ck204 FIND v(dout1_50) AT=1025.025n

* CHECK dout1_51 Vdout1_51ck204 = 0.9 time = 1025
.meas tran vdout1_51ck204 FIND v(dout1_51) AT=1025.025n

* CHECK dout1_52 Vdout1_52ck204 = 0.9 time = 1025
.meas tran vdout1_52ck204 FIND v(dout1_52) AT=1025.025n

* CHECK dout1_53 Vdout1_53ck204 = 0 time = 1025
.meas tran vdout1_53ck204 FIND v(dout1_53) AT=1025.025n

* CHECK dout1_54 Vdout1_54ck204 = 0.9 time = 1025
.meas tran vdout1_54ck204 FIND v(dout1_54) AT=1025.025n

* CHECK dout1_55 Vdout1_55ck204 = 0.9 time = 1025
.meas tran vdout1_55ck204 FIND v(dout1_55) AT=1025.025n

* CHECK dout1_56 Vdout1_56ck204 = 0.9 time = 1025
.meas tran vdout1_56ck204 FIND v(dout1_56) AT=1025.025n

* CHECK dout1_57 Vdout1_57ck204 = 0.9 time = 1025
.meas tran vdout1_57ck204 FIND v(dout1_57) AT=1025.025n

* CHECK dout1_58 Vdout1_58ck204 = 0 time = 1025
.meas tran vdout1_58ck204 FIND v(dout1_58) AT=1025.025n

* CHECK dout1_59 Vdout1_59ck204 = 0.9 time = 1025
.meas tran vdout1_59ck204 FIND v(dout1_59) AT=1025.025n

* CHECK dout1_60 Vdout1_60ck204 = 0.9 time = 1025
.meas tran vdout1_60ck204 FIND v(dout1_60) AT=1025.025n

* CHECK dout1_61 Vdout1_61ck204 = 0 time = 1025
.meas tran vdout1_61ck204 FIND v(dout1_61) AT=1025.025n

* CHECK dout1_62 Vdout1_62ck204 = 0 time = 1025
.meas tran vdout1_62ck204 FIND v(dout1_62) AT=1025.025n

* CHECK dout1_63 Vdout1_63ck204 = 0.9 time = 1025
.meas tran vdout1_63ck204 FIND v(dout1_63) AT=1025.025n

* CHECK dout1_64 Vdout1_64ck204 = 0 time = 1025
.meas tran vdout1_64ck204 FIND v(dout1_64) AT=1025.025n

* CHECK dout1_65 Vdout1_65ck204 = 0 time = 1025
.meas tran vdout1_65ck204 FIND v(dout1_65) AT=1025.025n

* CHECK dout1_66 Vdout1_66ck204 = 0.9 time = 1025
.meas tran vdout1_66ck204 FIND v(dout1_66) AT=1025.025n

* CHECK dout1_67 Vdout1_67ck204 = 0 time = 1025
.meas tran vdout1_67ck204 FIND v(dout1_67) AT=1025.025n

* CHECK dout1_68 Vdout1_68ck204 = 0 time = 1025
.meas tran vdout1_68ck204 FIND v(dout1_68) AT=1025.025n

* CHECK dout1_69 Vdout1_69ck204 = 0 time = 1025
.meas tran vdout1_69ck204 FIND v(dout1_69) AT=1025.025n

* CHECK dout1_70 Vdout1_70ck204 = 0.9 time = 1025
.meas tran vdout1_70ck204 FIND v(dout1_70) AT=1025.025n

* CHECK dout1_71 Vdout1_71ck204 = 0 time = 1025
.meas tran vdout1_71ck204 FIND v(dout1_71) AT=1025.025n

* CHECK dout1_72 Vdout1_72ck204 = 0 time = 1025
.meas tran vdout1_72ck204 FIND v(dout1_72) AT=1025.025n

* CHECK dout1_73 Vdout1_73ck204 = 0.9 time = 1025
.meas tran vdout1_73ck204 FIND v(dout1_73) AT=1025.025n

* CHECK dout1_74 Vdout1_74ck204 = 0 time = 1025
.meas tran vdout1_74ck204 FIND v(dout1_74) AT=1025.025n

* CHECK dout1_75 Vdout1_75ck204 = 0 time = 1025
.meas tran vdout1_75ck204 FIND v(dout1_75) AT=1025.025n

* CHECK dout1_76 Vdout1_76ck204 = 0.9 time = 1025
.meas tran vdout1_76ck204 FIND v(dout1_76) AT=1025.025n

* CHECK dout1_77 Vdout1_77ck204 = 0.9 time = 1025
.meas tran vdout1_77ck204 FIND v(dout1_77) AT=1025.025n

* CHECK dout1_78 Vdout1_78ck204 = 0.9 time = 1025
.meas tran vdout1_78ck204 FIND v(dout1_78) AT=1025.025n

* CHECK dout1_79 Vdout1_79ck204 = 0.9 time = 1025
.meas tran vdout1_79ck204 FIND v(dout1_79) AT=1025.025n

* CHECK dout1_80 Vdout1_80ck204 = 0 time = 1025
.meas tran vdout1_80ck204 FIND v(dout1_80) AT=1025.025n

* CHECK dout1_81 Vdout1_81ck204 = 0 time = 1025
.meas tran vdout1_81ck204 FIND v(dout1_81) AT=1025.025n

* CHECK dout1_82 Vdout1_82ck204 = 0 time = 1025
.meas tran vdout1_82ck204 FIND v(dout1_82) AT=1025.025n

* CHECK dout1_83 Vdout1_83ck204 = 0 time = 1025
.meas tran vdout1_83ck204 FIND v(dout1_83) AT=1025.025n

* CHECK dout1_84 Vdout1_84ck204 = 0 time = 1025
.meas tran vdout1_84ck204 FIND v(dout1_84) AT=1025.025n

* CHECK dout1_85 Vdout1_85ck204 = 0 time = 1025
.meas tran vdout1_85ck204 FIND v(dout1_85) AT=1025.025n

* CHECK dout1_86 Vdout1_86ck204 = 0 time = 1025
.meas tran vdout1_86ck204 FIND v(dout1_86) AT=1025.025n

* CHECK dout1_87 Vdout1_87ck204 = 0 time = 1025
.meas tran vdout1_87ck204 FIND v(dout1_87) AT=1025.025n

* CHECK dout1_88 Vdout1_88ck204 = 0 time = 1025
.meas tran vdout1_88ck204 FIND v(dout1_88) AT=1025.025n

* CHECK dout1_89 Vdout1_89ck204 = 0 time = 1025
.meas tran vdout1_89ck204 FIND v(dout1_89) AT=1025.025n

* CHECK dout1_90 Vdout1_90ck204 = 0.9 time = 1025
.meas tran vdout1_90ck204 FIND v(dout1_90) AT=1025.025n

* CHECK dout1_91 Vdout1_91ck204 = 0 time = 1025
.meas tran vdout1_91ck204 FIND v(dout1_91) AT=1025.025n

* CHECK dout1_92 Vdout1_92ck204 = 0 time = 1025
.meas tran vdout1_92ck204 FIND v(dout1_92) AT=1025.025n

* CHECK dout1_93 Vdout1_93ck204 = 0.9 time = 1025
.meas tran vdout1_93ck204 FIND v(dout1_93) AT=1025.025n

* CHECK dout1_94 Vdout1_94ck204 = 0.9 time = 1025
.meas tran vdout1_94ck204 FIND v(dout1_94) AT=1025.025n

* CHECK dout1_95 Vdout1_95ck204 = 0 time = 1025
.meas tran vdout1_95ck204 FIND v(dout1_95) AT=1025.025n

* CHECK dout1_96 Vdout1_96ck204 = 0 time = 1025
.meas tran vdout1_96ck204 FIND v(dout1_96) AT=1025.025n

* CHECK dout1_97 Vdout1_97ck204 = 0.9 time = 1025
.meas tran vdout1_97ck204 FIND v(dout1_97) AT=1025.025n

* CHECK dout1_98 Vdout1_98ck204 = 0 time = 1025
.meas tran vdout1_98ck204 FIND v(dout1_98) AT=1025.025n

* CHECK dout1_99 Vdout1_99ck204 = 0.9 time = 1025
.meas tran vdout1_99ck204 FIND v(dout1_99) AT=1025.025n

* CHECK dout1_100 Vdout1_100ck204 = 0.9 time = 1025
.meas tran vdout1_100ck204 FIND v(dout1_100) AT=1025.025n

* CHECK dout1_101 Vdout1_101ck204 = 0 time = 1025
.meas tran vdout1_101ck204 FIND v(dout1_101) AT=1025.025n

* CHECK dout1_102 Vdout1_102ck204 = 0.9 time = 1025
.meas tran vdout1_102ck204 FIND v(dout1_102) AT=1025.025n

* CHECK dout1_103 Vdout1_103ck204 = 0 time = 1025
.meas tran vdout1_103ck204 FIND v(dout1_103) AT=1025.025n

* CHECK dout1_104 Vdout1_104ck204 = 0.9 time = 1025
.meas tran vdout1_104ck204 FIND v(dout1_104) AT=1025.025n

* CHECK dout1_105 Vdout1_105ck204 = 0 time = 1025
.meas tran vdout1_105ck204 FIND v(dout1_105) AT=1025.025n

* CHECK dout1_106 Vdout1_106ck204 = 0 time = 1025
.meas tran vdout1_106ck204 FIND v(dout1_106) AT=1025.025n

* CHECK dout1_107 Vdout1_107ck204 = 0.9 time = 1025
.meas tran vdout1_107ck204 FIND v(dout1_107) AT=1025.025n

* CHECK dout1_108 Vdout1_108ck204 = 0.9 time = 1025
.meas tran vdout1_108ck204 FIND v(dout1_108) AT=1025.025n

* CHECK dout1_109 Vdout1_109ck204 = 0 time = 1025
.meas tran vdout1_109ck204 FIND v(dout1_109) AT=1025.025n

* CHECK dout1_110 Vdout1_110ck204 = 0.9 time = 1025
.meas tran vdout1_110ck204 FIND v(dout1_110) AT=1025.025n

* CHECK dout1_111 Vdout1_111ck204 = 0 time = 1025
.meas tran vdout1_111ck204 FIND v(dout1_111) AT=1025.025n

* CHECK dout1_112 Vdout1_112ck204 = 0.9 time = 1025
.meas tran vdout1_112ck204 FIND v(dout1_112) AT=1025.025n

* CHECK dout1_113 Vdout1_113ck204 = 0.9 time = 1025
.meas tran vdout1_113ck204 FIND v(dout1_113) AT=1025.025n

* CHECK dout1_114 Vdout1_114ck204 = 0 time = 1025
.meas tran vdout1_114ck204 FIND v(dout1_114) AT=1025.025n

* CHECK dout1_115 Vdout1_115ck204 = 0 time = 1025
.meas tran vdout1_115ck204 FIND v(dout1_115) AT=1025.025n

* CHECK dout1_116 Vdout1_116ck204 = 0.9 time = 1025
.meas tran vdout1_116ck204 FIND v(dout1_116) AT=1025.025n

* CHECK dout1_117 Vdout1_117ck204 = 0 time = 1025
.meas tran vdout1_117ck204 FIND v(dout1_117) AT=1025.025n

* CHECK dout1_118 Vdout1_118ck204 = 0 time = 1025
.meas tran vdout1_118ck204 FIND v(dout1_118) AT=1025.025n

* CHECK dout1_119 Vdout1_119ck204 = 0 time = 1025
.meas tran vdout1_119ck204 FIND v(dout1_119) AT=1025.025n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
