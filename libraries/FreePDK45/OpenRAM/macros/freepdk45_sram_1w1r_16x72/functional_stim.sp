* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "freepdk45_sram_1w1r_16x72.sp"

* Global Power Supplies
Vvdd vdd 0 0.9

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xfreepdk45_sram_1w1r_16x72 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 din0_40 din0_41 din0_42 din0_43 din0_44 din0_45 din0_46 din0_47 din0_48 din0_49 din0_50 din0_51 din0_52 din0_53 din0_54 din0_55 din0_56 din0_57 din0_58 din0_59 din0_60 din0_61 din0_62 din0_63 din0_64 din0_65 din0_66 din0_67 din0_68 din0_69 din0_70 din0_71 a0_0 a0_1 a0_2 a0_3 a1_0 a1_1 a1_2 a1_3 CSB0 CSB1 clk0 clk1 dout1_0 dout1_1 dout1_2 dout1_3 dout1_4 dout1_5 dout1_6 dout1_7 dout1_8 dout1_9 dout1_10 dout1_11 dout1_12 dout1_13 dout1_14 dout1_15 dout1_16 dout1_17 dout1_18 dout1_19 dout1_20 dout1_21 dout1_22 dout1_23 dout1_24 dout1_25 dout1_26 dout1_27 dout1_28 dout1_29 dout1_30 dout1_31 dout1_32 dout1_33 dout1_34 dout1_35 dout1_36 dout1_37 dout1_38 dout1_39 dout1_40 dout1_41 dout1_42 dout1_43 dout1_44 dout1_45 dout1_46 dout1_47 dout1_48 dout1_49 dout1_50 dout1_51 dout1_52 dout1_53 dout1_54 dout1_55 dout1_56 dout1_57 dout1_58 dout1_59 dout1_60 dout1_61 dout1_62 dout1_63 dout1_64 dout1_65 dout1_66 dout1_67 dout1_68 dout1_69 dout1_70 dout1_71 vdd gnd freepdk45_sram_1w1r_16x72

* SRAM output loads
CD10 dout1_0  0 0.8364f
CD11 dout1_1  0 0.8364f
CD12 dout1_2  0 0.8364f
CD13 dout1_3  0 0.8364f
CD14 dout1_4  0 0.8364f
CD15 dout1_5  0 0.8364f
CD16 dout1_6  0 0.8364f
CD17 dout1_7  0 0.8364f
CD18 dout1_8  0 0.8364f
CD19 dout1_9  0 0.8364f
CD110 dout1_10  0 0.8364f
CD111 dout1_11  0 0.8364f
CD112 dout1_12  0 0.8364f
CD113 dout1_13  0 0.8364f
CD114 dout1_14  0 0.8364f
CD115 dout1_15  0 0.8364f
CD116 dout1_16  0 0.8364f
CD117 dout1_17  0 0.8364f
CD118 dout1_18  0 0.8364f
CD119 dout1_19  0 0.8364f
CD120 dout1_20  0 0.8364f
CD121 dout1_21  0 0.8364f
CD122 dout1_22  0 0.8364f
CD123 dout1_23  0 0.8364f
CD124 dout1_24  0 0.8364f
CD125 dout1_25  0 0.8364f
CD126 dout1_26  0 0.8364f
CD127 dout1_27  0 0.8364f
CD128 dout1_28  0 0.8364f
CD129 dout1_29  0 0.8364f
CD130 dout1_30  0 0.8364f
CD131 dout1_31  0 0.8364f
CD132 dout1_32  0 0.8364f
CD133 dout1_33  0 0.8364f
CD134 dout1_34  0 0.8364f
CD135 dout1_35  0 0.8364f
CD136 dout1_36  0 0.8364f
CD137 dout1_37  0 0.8364f
CD138 dout1_38  0 0.8364f
CD139 dout1_39  0 0.8364f
CD140 dout1_40  0 0.8364f
CD141 dout1_41  0 0.8364f
CD142 dout1_42  0 0.8364f
CD143 dout1_43  0 0.8364f
CD144 dout1_44  0 0.8364f
CD145 dout1_45  0 0.8364f
CD146 dout1_46  0 0.8364f
CD147 dout1_47  0 0.8364f
CD148 dout1_48  0 0.8364f
CD149 dout1_49  0 0.8364f
CD150 dout1_50  0 0.8364f
CD151 dout1_51  0 0.8364f
CD152 dout1_52  0 0.8364f
CD153 dout1_53  0 0.8364f
CD154 dout1_54  0 0.8364f
CD155 dout1_55  0 0.8364f
CD156 dout1_56  0 0.8364f
CD157 dout1_57  0 0.8364f
CD158 dout1_58  0 0.8364f
CD159 dout1_59  0 0.8364f
CD160 dout1_60  0 0.8364f
CD161 dout1_61  0 0.8364f
CD162 dout1_62  0 0.8364f
CD163 dout1_63  0 0.8364f
CD164 dout1_64  0 0.8364f
CD165 dout1_65  0 0.8364f
CD166 dout1_66  0 0.8364f
CD167 dout1_67  0 0.8364f
CD168 dout1_68  0 0.8364f
CD169 dout1_69  0 0.8364f
CD170 dout1_70  0 0.8364f
CD171 dout1_71  0 0.8364f

* Important signals for debug
* bl:	xfreepdk45_sram_1w1r_16x72.xbank0.bl_1_0
* br:	xfreepdk45_sram_1w1r_16x72.xbank0.br_1_0
* s_en:	xfreepdk45_sram_1w1r_16x72.s_en
* q:	xfreepdk45_sram_1w1r_16x72.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xfreepdk45_sram_1w1r_16x72.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 100110110111110010100110100000000011110111111110001011011101101011010010  to  address 0000 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 000010000010100000001110100110000101010111110001010001010001101100010110  to  address 0000 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 101101010110001100110111001101000110110101100001100010010001111100100111  to  address 1110 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 101101010110001100110111001101000110110101100001100010010001111100100111 from address 1110 (from port 1) during cycle 4 (20ns - 25ns)
*	Writing 011101001100100010000000011110110000001100111001000110000010111011101000  to  address 0000 (from port 0) during cycle 5 (25ns - 30ns)
*	Reading 101101010110001100110111001101000110110101100001100010010001111100100111 from address 1110 (from port 1) during cycle 5 (25ns - 30ns)
*	Reading 101101010110001100110111001101000110110101100001100010010001111100100111 from address 1110 (from port 1) during cycle 6 (30ns - 35ns)
*	Writing 001100010110000001000101100101001110101101110011100010100011011000101010  to  address 1110 (from port 0) during cycle 7 (35ns - 40ns)
*	Writing 001010010110111111110110010011010111100011001110100001111011110011000110  to  address 0000 (from port 0) during cycle 10 (50ns - 55ns)
*	Writing 001100110010001010100000100110111110011010001001111101010010000000010110  to  address 0000 (from port 0) during cycle 14 (70ns - 75ns)
*	Writing 100110000110111100011110101100111100100001010001011000011101000000111001  to  address 1110 (from port 0) during cycle 15 (75ns - 80ns)
*	Writing 001101011010111000000000000110001010110101001011010011111001100011010111  to  address 0000 (from port 0) during cycle 16 (80ns - 85ns)
*	Reading 001101011010111000000000000110001010110101001011010011111001100011010111 from address 0000 (from port 1) during cycle 18 (90ns - 95ns)
*	Reading 001101011010111000000000000110001010110101001011010011111001100011010111 from address 0000 (from port 1) during cycle 20 (100ns - 105ns)
*	Writing 010001011000000011111101010111100110011000010000011000001100111001111000  to  address 0000 (from port 0) during cycle 21 (105ns - 110ns)
*	Reading 100110000110111100011110101100111100100001010001011000011101000000111001 from address 1110 (from port 1) during cycle 21 (105ns - 110ns)
*	Writing 011000001001001110011010011000000100010010111110111001000000100001000010  to  address 1110 (from port 0) during cycle 22 (110ns - 115ns)
*	Writing 111001001000101101101001110000001001010110001111011001100111110001100101  to  address 0000 (from port 0) during cycle 23 (115ns - 120ns)
*	Writing 100111110111100111001110000001110010101100100010011000000001010001110010  to  address 1110 (from port 0) during cycle 24 (120ns - 125ns)
*	Reading 111001001000101101101001110000001001010110001111011001100111110001100101 from address 0000 (from port 1) during cycle 24 (120ns - 125ns)
*	Writing 001111010100000010110001000011010100110000110110101001110001011011000011  to  address 1110 (from port 0) during cycle 25 (125ns - 130ns)
*	Writing 001000011001110001100011011110100001001100011010111000010011100111011101  to  address 0000 (from port 0) during cycle 26 (130ns - 135ns)
*	Writing 101010110101101111000111001011100110010110100000010010011111110010010110  to  address 1110 (from port 0) during cycle 27 (135ns - 140ns)
*	Reading 001000011001110001100011011110100001001100011010111000010011100111011101 from address 0000 (from port 1) during cycle 29 (145ns - 150ns)
*	Writing 100101001011000110111001011011011010010111100010111010011010000111110001  to  address 0000 (from port 0) during cycle 30 (150ns - 155ns)
*	Writing 011011101001110000111111100011100111100000010111101100011000101001010110  to  address 0000 (from port 0) during cycle 31 (155ns - 160ns)
*	Reading 101010110101101111000111001011100110010110100000010010011111110010010110 from address 1110 (from port 1) during cycle 31 (155ns - 160ns)
*	Reading 011011101001110000111111100011100111100000010111101100011000101001010110 from address 0000 (from port 1) during cycle 32 (160ns - 165ns)
*	Writing 110100100001001010110111010001000001000010111101011000100011100111011110  to  address 0000 (from port 0) during cycle 34 (170ns - 175ns)
*	Writing 100110111101111100100100010000000100110110101011101001101100101001010100  to  address 1110 (from port 0) during cycle 35 (175ns - 180ns)
*	Writing 011010100011111111010011100100111001110001101001010101111010100100101100  to  address 0000 (from port 0) during cycle 37 (185ns - 190ns)
*	Writing 111111001111100111010100000000100111100111110101101100110011111000101110  to  address 1110 (from port 0) during cycle 40 (200ns - 205ns)
*	Reading 011010100011111111010011100100111001110001101001010101111010100100101100 from address 0000 (from port 1) during cycle 44 (220ns - 225ns)
*	Writing 000001100011011110100110110011100010100110001101111001101000010001101100  to  address 0000 (from port 0) during cycle 45 (225ns - 230ns)
*	Writing 001100100010010100000111101010100001000011001101000111110110000100100100  to  address 0000 (from port 0) during cycle 46 (230ns - 235ns)
*	Reading 001100100010010100000111101010100001000011001101000111110110000100100100 from address 0000 (from port 1) during cycle 48 (240ns - 245ns)
*	Writing 001010110101101010001111001111011000111110010000011110010010001110011000  to  address 1110 (from port 0) during cycle 49 (245ns - 250ns)
*	Writing 010110100000011001100010010110001010001011001010110011100011011011000000  to  address 1110 (from port 0) during cycle 50 (250ns - 255ns)
*	Writing 010010010111001100111000011011101101110100010110101000001001001010011110  to  address 0000 (from port 0) during cycle 51 (255ns - 260ns)
*	Reading 010110100000011001100010010110001010001011001010110011100011011011000000 from address 1110 (from port 1) during cycle 51 (255ns - 260ns)
*	Writing 111111001110101011101110011000101011000110011110101110010110110001111101  to  address 1110 (from port 0) during cycle 52 (260ns - 265ns)
*	Reading 010010010111001100111000011011101101110100010110101000001001001010011110 from address 0000 (from port 1) during cycle 52 (260ns - 265ns)
*	Writing 101110111010010111100100010100001000110001101101001001110011110010100001  to  address 0000 (from port 0) during cycle 53 (265ns - 270ns)
*	Writing 001011110010000111100010001100000001001100001101011111000111101000000000  to  address 1110 (from port 0) during cycle 54 (270ns - 275ns)
*	Writing 010110111000110100011011010000100011000010000010000011001011010001101101  to  address 1110 (from port 0) during cycle 55 (275ns - 280ns)
*	Writing 000011110111100110001100001011101000111111001110001001010101010101010001  to  address 0000 (from port 0) during cycle 56 (280ns - 285ns)
*	Reading 010110111000110100011011010000100011000010000010000011001011010001101101 from address 1110 (from port 1) during cycle 56 (280ns - 285ns)
*	Writing 011101110101011001101011101111000001100000001000110101011110011000001011  to  address 1110 (from port 0) during cycle 57 (285ns - 290ns)
*	Reading 011101110101011001101011101111000001100000001000110101011110011000001011 from address 1110 (from port 1) during cycle 60 (300ns - 305ns)
*	Writing 010001111100111110010001100010000111111000100000001000000010110110101110  to  address 0000 (from port 0) during cycle 61 (305ns - 310ns)
*	Reading 011101110101011001101011101111000001100000001000110101011110011000001011 from address 1110 (from port 1) during cycle 63 (315ns - 320ns)
*	Reading 010001111100111110010001100010000111111000100000001000000010110110101110 from address 0000 (from port 1) during cycle 64 (320ns - 325ns)
*	Writing 010111100000010010101000110100101101010001000110100111000110000001100010  to  address 0000 (from port 0) during cycle 66 (330ns - 335ns)
*	Writing 010011010111101000000000111100011010000110001011100100011010000010110011  to  address 1110 (from port 0) during cycle 67 (335ns - 340ns)
*	Writing 100101111010001100000010001100010001101100101010110110001010100110001001  to  address 0000 (from port 0) during cycle 68 (340ns - 345ns)
*	Writing 001111000111001001110111001011011100001110001001001101010100100000101010  to  address 1110 (from port 0) during cycle 73 (365ns - 370ns)
*	Writing 001010111101010010000111010111000000000001010101011000110100000000001000  to  address 0000 (from port 0) during cycle 74 (370ns - 375ns)
*	Reading 001111000111001001110111001011011100001110001001001101010100100000101010 from address 1110 (from port 1) during cycle 75 (375ns - 380ns)
*	Writing 011110010101010110111111000101000001000001001001110100000000000111101010  to  address 0000 (from port 0) during cycle 76 (380ns - 385ns)
*	Reading 011110010101010110111111000101000001000001001001110100000000000111101010 from address 0000 (from port 1) during cycle 77 (385ns - 390ns)
*	Writing 001000011011000011001101100111010000111000101010001101101000001111000000  to  address 1110 (from port 0) during cycle 79 (395ns - 400ns)
*	Reading 001000011011000011001101100111010000111000101010001101101000001111000000 from address 1110 (from port 1) during cycle 81 (405ns - 410ns)
*	Writing 100110100100101011000110110001101010110110100001011100101101000110101001  to  address 1110 (from port 0) during cycle 82 (410ns - 415ns)
*	Writing 011111101001111001000000001111010000010011101011100011111001110000100100  to  address 0000 (from port 0) during cycle 83 (415ns - 420ns)
*	Reading 100110100100101011000110110001101010110110100001011100101101000110101001 from address 1110 (from port 1) during cycle 83 (415ns - 420ns)
*	Writing 010101011011111011010110010001011100000110111100011100111000110111110100  to  address 0000 (from port 0) during cycle 84 (420ns - 425ns)
*	Writing 001000000101001101100101001010110101101110011001001111001001011000010101  to  address 1110 (from port 0) during cycle 85 (425ns - 430ns)
*	Writing 010100011111000111101010111011000011101011101011011101000110100000000100  to  address 0000 (from port 0) during cycle 86 (430ns - 435ns)
*	Reading 001000000101001101100101001010110101101110011001001111001001011000010101 from address 1110 (from port 1) during cycle 88 (440ns - 445ns)
*	Reading 010100011111000111101010111011000011101011101011011101000110100000000100 from address 0000 (from port 1) during cycle 91 (455ns - 460ns)
*	Reading 001000000101001101100101001010110101101110011001001111001001011000010101 from address 1110 (from port 1) during cycle 92 (460ns - 465ns)
*	Writing 110000001101011010010000001110001110101010000110001110001010101010110001  to  address 1110 (from port 0) during cycle 93 (465ns - 470ns)
*	Reading 010100011111000111101010111011000011101011101011011101000110100000000100 from address 0000 (from port 1) during cycle 94 (470ns - 475ns)
*	Writing 110100100100010000010101011010110100001010111100111010110000111110110111  to  address 0000 (from port 0) during cycle 96 (480ns - 485ns)
*	Reading 110000001101011010010000001110001110101010000110001110001010101010110001 from address 1110 (from port 1) during cycle 96 (480ns - 485ns)
*	Writing 100001111010010011101000100000101101110000010111010101101011100011011011  to  address 1110 (from port 0) during cycle 97 (485ns - 490ns)
*	Reading 100001111010010011101000100000101101110000010111010101101011100011011011 from address 1110 (from port 1) during cycle 98 (490ns - 495ns)
*	Reading 110100100100010000010101011010110100001010111100111010110000111110110111 from address 0000 (from port 1) during cycle 99 (495ns - 500ns)
*	Writing 010110000111111000110001110011011010101110011001010000000001110010100001  to  address 1110 (from port 0) during cycle 100 (500ns - 505ns)
*	Writing 111001111110001101100000111111001000111000111101111011100101000100100100  to  address 0000 (from port 0) during cycle 101 (505ns - 510ns)
*	Reading 111001111110001101100000111111001000111000111101111011100101000100100100 from address 0000 (from port 1) during cycle 102 (510ns - 515ns)
*	Writing 010011000001100010111111110011000011001100010000110001010111011000100010  to  address 1110 (from port 0) during cycle 104 (520ns - 525ns)
*	Writing 000101111011000111101000001101111101010101000000101101001110010001000101  to  address 1110 (from port 0) during cycle 105 (525ns - 530ns)
*	Writing 011010010111110011100010000000110010110010001001010010001011101101001011  to  address 1110 (from port 0) during cycle 106 (530ns - 535ns)
*	Reading 111001111110001101100000111111001000111000111101111011100101000100100100 from address 0000 (from port 1) during cycle 107 (535ns - 540ns)
*	Writing 011101000101001011101100010010100001011000101100011111111000110000110011  to  address 0000 (from port 0) during cycle 108 (540ns - 545ns)
*	Reading 011010010111110011100010000000110010110010001001010010001011101101001011 from address 1110 (from port 1) during cycle 108 (540ns - 545ns)
*	Writing 101010011011000111011111000011101001101100010010010111001010101110110110  to  address 1110 (from port 0) during cycle 109 (545ns - 550ns)
*	Reading 011101000101001011101100010010100001011000101100011111111000110000110011 from address 0000 (from port 1) during cycle 109 (545ns - 550ns)
*	Writing 001010001000101100000111010100110111100101000100010110111101010111001111  to  address 0000 (from port 0) during cycle 111 (555ns - 560ns)
*	Reading 101010011011000111011111000011101001101100010010010111001010101110110110 from address 1110 (from port 1) during cycle 111 (555ns - 560ns)
*	Reading 001010001000101100000111010100110111100101000100010110111101010111001111 from address 0000 (from port 1) during cycle 112 (560ns - 565ns)
*	Writing 110100010001001011010111000000010011110010110110100110000101001010100101  to  address 0000 (from port 0) during cycle 114 (570ns - 575ns)
*	Reading 101010011011000111011111000011101001101100010010010111001010101110110110 from address 1110 (from port 1) during cycle 114 (570ns - 575ns)
*	Writing 000010000111111110001101100010010001101001011000011101011111100010010100  to  address 0000 (from port 0) during cycle 118 (590ns - 595ns)
*	Reading 101010011011000111011111000011101001101100010010010111001010101110110110 from address 1110 (from port 1) during cycle 119 (595ns - 600ns)
*	Reading 000010000111111110001101100010010001101001011000011101011111100010010100 from address 0000 (from port 1) during cycle 123 (615ns - 620ns)
*	Writing 110101111100100000110011101101111100100100111010000000100011100101001101  to  address 1110 (from port 0) during cycle 124 (620ns - 625ns)
*	Reading 110101111100100000110011101101111100100100111010000000100011100101001101 from address 1110 (from port 1) during cycle 126 (630ns - 635ns)
*	Writing 111110101000101111111001000101101110101000100010101110111101100001101110  to  address 0000 (from port 0) during cycle 127 (635ns - 640ns)
*	Writing 010110100010001011010111000100000111101111011011101000011100001011110101  to  address 1110 (from port 0) during cycle 128 (640ns - 645ns)
*	Writing 001110001010000010001001001100111000001001100011011100011111110010010101  to  address 0000 (from port 0) during cycle 129 (645ns - 650ns)
*	Reading 010110100010001011010111000100000111101111011011101000011100001011110101 from address 1110 (from port 1) during cycle 129 (645ns - 650ns)
*	Writing 101001010000011010000001110100010001000010000010001011100011110001111100  to  address 1110 (from port 0) during cycle 130 (650ns - 655ns)
*	Writing 000100101101110000011111011110101111110101101000110010001111011001011000  to  address 1110 (from port 0) during cycle 131 (655ns - 660ns)
*	Reading 001110001010000010001001001100111000001001100011011100011111110010010101 from address 0000 (from port 1) during cycle 133 (665ns - 670ns)
*	Writing 011001011101010010111111110010111101010000101000111011111110010111110000  to  address 1110 (from port 0) during cycle 134 (670ns - 675ns)
*	Writing 111001100101110010001001000100100010100001011110000100000111111100100100  to  address 1110 (from port 0) during cycle 135 (675ns - 680ns)
*	Writing 100010001000001001111101001011110101110100011100001001011101100101000010  to  address 1110 (from port 0) during cycle 136 (680ns - 685ns)
*	Reading 001110001010000010001001001100111000001001100011011100011111110010010101 from address 0000 (from port 1) during cycle 136 (680ns - 685ns)
*	Writing 011000000111111111001110011011110011001101110101111001110101111110100110  to  address 1110 (from port 0) during cycle 139 (695ns - 700ns)
*	Writing 100101100010001100111101011100101101110010110010001110100000000111011100  to  address 0000 (from port 0) during cycle 140 (700ns - 705ns)
*	Reading 011000000111111111001110011011110011001101110101111001110101111110100110 from address 1110 (from port 1) during cycle 141 (705ns - 710ns)
*	Writing 110101001110100101110111011011110100001010101000111000110110011010110100  to  address 0000 (from port 0) during cycle 142 (710ns - 715ns)
*	Writing 101000110101101101110100101110011010111001010110001110010001011011011111  to  address 1110 (from port 0) during cycle 143 (715ns - 720ns)
*	Reading 110101001110100101110111011011110100001010101000111000110110011010110100 from address 0000 (from port 1) during cycle 146 (730ns - 735ns)
*	Writing 100100101011011001000100000110000111010110001100010010001010011000010001  to  address 1110 (from port 0) during cycle 147 (735ns - 740ns)
*	Reading 110101001110100101110111011011110100001010101000111000110110011010110100 from address 0000 (from port 1) during cycle 147 (735ns - 740ns)
*	Writing 110111010001101110010001010010011000100000110010001001111100100111001100  to  address 1110 (from port 0) during cycle 148 (740ns - 745ns)
*	Writing 111011011100010000001100000111010101011011101000011000110011110110010100  to  address 0000 (from port 0) during cycle 150 (750ns - 755ns)
*	Reading 110111010001101110010001010010011000100000110010001001111100100111001100 from address 1110 (from port 1) during cycle 152 (760ns - 765ns)
*	Reading 111011011100010000001100000111010101011011101000011000110011110110010100 from address 0000 (from port 1) during cycle 153 (765ns - 770ns)
*	Reading 111011011100010000001100000111010101011011101000011000110011110110010100 from address 0000 (from port 1) during cycle 155 (775ns - 780ns)
*	Reading 111011011100010000001100000111010101011011101000011000110011110110010100 from address 0000 (from port 1) during cycle 156 (780ns - 785ns)
*	Writing 100000110111011100110111110010001000100111110011110000100010001001010110  to  address 0000 (from port 0) during cycle 157 (785ns - 790ns)
*	Reading 110111010001101110010001010010011000100000110010001001111100100111001100 from address 1110 (from port 1) during cycle 157 (785ns - 790ns)
*	Writing 010011001011110100100110111001010111010000010100001111101101001010101000  to  address 0000 (from port 0) during cycle 158 (790ns - 795ns)
*	Writing 011011111011011010100100111011100000100001101100110111101011110110001101  to  address 1110 (from port 0) during cycle 159 (795ns - 800ns)
*	Reading 010011001011110100100110111001010111010000010100001111101101001010101000 from address 0000 (from port 1) during cycle 162 (810ns - 815ns)
*	Reading 011011111011011010100100111011100000100001101100110111101011110110001101 from address 1110 (from port 1) during cycle 163 (815ns - 820ns)
*	Writing 010010010001000111101010111011010110111001010100010011110111011100110101  to  address 0000 (from port 0) during cycle 164 (820ns - 825ns)
*	Reading 011011111011011010100100111011100000100001101100110111101011110110001101 from address 1110 (from port 1) during cycle 164 (820ns - 825ns)
*	Reading 010010010001000111101010111011010110111001010100010011110111011100110101 from address 0000 (from port 1) during cycle 165 (825ns - 830ns)
*	Writing 110100100101010001110010110100111100011101001110111000000101110011100001  to  address 0000 (from port 0) during cycle 166 (830ns - 835ns)
*	Reading 011011111011011010100100111011100000100001101100110111101011110110001101 from address 1110 (from port 1) during cycle 167 (835ns - 840ns)
*	Reading 011011111011011010100100111011100000100001101100110111101011110110001101 from address 1110 (from port 1) during cycle 168 (840ns - 845ns)
*	Reading 110100100101010001110010110100111100011101001110111000000101110011100001 from address 0000 (from port 1) during cycle 169 (845ns - 850ns)
*	Writing 101011000010000010000000110110111000101001001000010100010001110110001000  to  address 1110 (from port 0) during cycle 170 (850ns - 855ns)
*	Reading 110100100101010001110010110100111100011101001110111000000101110011100001 from address 0000 (from port 1) during cycle 170 (850ns - 855ns)
*	Writing 011010010011100010010010011101000101110000111100100011110001101000001010  to  address 0000 (from port 0) during cycle 172 (860ns - 865ns)
*	Reading 101011000010000010000000110110111000101001001000010100010001110110001000 from address 1110 (from port 1) during cycle 172 (860ns - 865ns)
*	Reading 011010010011100010010010011101000101110000111100100011110001101000001010 from address 0000 (from port 1) during cycle 173 (865ns - 870ns)
*	Reading 011010010011100010010010011101000101110000111100100011110001101000001010 from address 0000 (from port 1) during cycle 174 (870ns - 875ns)
*	Writing 101110010100101111110111110100001110110110101100001011110111100111110001  to  address 1110 (from port 0) during cycle 175 (875ns - 880ns)
*	Writing 001001111011100011000100101101110110010100101010110001001001110010010101  to  address 0000 (from port 0) during cycle 176 (880ns - 885ns)
*	Writing 011101000011110101000000100000110111101011000011101101000010000110110101  to  address 1110 (from port 0) during cycle 177 (885ns - 890ns)
*	Writing 011111111011101010011100100100001011100111011110000011001010000101001100  to  address 1110 (from port 0) during cycle 178 (890ns - 895ns)
*	Reading 001001111011100011000100101101110110010100101010110001001001110010010101 from address 0000 (from port 1) during cycle 178 (890ns - 895ns)
*	Reading 001001111011100011000100101101110110010100101010110001001001110010010101 from address 0000 (from port 1) during cycle 179 (895ns - 900ns)
*	Reading 011111111011101010011100100100001011100111011110000011001010000101001100 from address 1110 (from port 1) during cycle 180 (900ns - 905ns)
*	Writing 001011011010101011011011010100101011111110001101001100100110001110100010  to  address 0000 (from port 0) during cycle 181 (905ns - 910ns)
*	Writing 100011010000110101100101001001000100111010110110101110000000101110011100  to  address 1110 (from port 0) during cycle 182 (910ns - 915ns)
*	Writing 001100101011010111100111001100101010000101101011000111010010111010111100  to  address 1110 (from port 0) during cycle 183 (915ns - 920ns)
*	Writing 000100000010011000001001101001100101100010101001100000010000111110011110  to  address 1110 (from port 0) during cycle 184 (920ns - 925ns)
*	Writing 100010000101010010100001010110001010010001001001101100100011111001111000  to  address 0000 (from port 0) during cycle 188 (940ns - 945ns)
*	Reading 100010000101010010100001010110001010010001001001101100100011111001111000 from address 0000 (from port 1) during cycle 190 (950ns - 955ns)
*	Writing 110101100100010010110100101110100100110101011011000101101111000010111101  to  address 1110 (from port 0) during cycle 191 (955ns - 960ns)
*	Writing 000111010111111101100111101001001100101010100100110001001100110110100100  to  address 1110 (from port 0) during cycle 192 (960ns - 965ns)
*	Reading 100010000101010010100001010110001010010001001001101100100011111001111000 from address 0000 (from port 1) during cycle 193 (965ns - 970ns)
*	Writing 000000100111010110001011001100010100001011000111010111101001111101111000  to  address 1110 (from port 0) during cycle 194 (970ns - 975ns)
*	Reading 000000100111010110001011001100010100001011000111010111101001111101111000 from address 1110 (from port 1) during cycle 196 (980ns - 985ns)
*	Writing 110101000111111010001100011110000101011000010100001001111100000100010111  to  address 1110 (from port 0) during cycle 197 (985ns - 990ns)
*	Reading 110101000111111010001100011110000101011000010100001001111100000100010111 from address 1110 (from port 1) during cycle 198 (990ns - 995ns)
*	Reading 110101000111111010001100011110000101011000010100001001111100000100010111 from address 1110 (from port 1) during cycle 199 (995ns - 1000ns)
*	Writing 000000101000001010011001110000001100111001000111100010101011100011011000  to  address 0000 (from port 0) during cycle 200 (1000ns - 1005ns)
*	Writing 000110001110111000000111110011101100101010000010110101000001110010011101  to  address 1110 (from port 0) during cycle 201 (1005ns - 1010ns)
*	Writing 110111001000101110101111001100110001011000000001010110010010100100110010  to  address 1110 (from port 0) during cycle 203 (1015ns - 1020ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 0), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 1), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 0), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 0), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 0), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 0), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 1), (265, 0), (270, 1), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 1), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 0), (260, 1), (265, 0), (270, 0), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_40  din0_40  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 1), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_41  din0_41  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_42  din0_42  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_43  din0_43  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_44  din0_44  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 0), (270, 1), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_45  din0_45  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_46  din0_46  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_47  din0_47  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_48  din0_48  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_49  din0_49  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_50  din0_50  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 0), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_51  din0_51  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_52  din0_52  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 0), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_53  din0_53  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_54  din0_54  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_55  din0_55  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_56  din0_56  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_57  din0_57  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 0), (260, 0), (265, 1), (270, 0), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_58  din0_58  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_59  din0_59  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_60  din0_60  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_61  din0_61  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_62  din0_62  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_63  din0_63  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_64  din0_64  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_65  din0_65  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_66  din0_66  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_67  din0_67  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_68  din0_68  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_69  din0_69  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_70  din0_70  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_71  din0_71  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va1_0  a1_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va1_1  a1_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va1_2  a1_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va1_3  a1_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 0), (30, 1), (35, 0), (40, 1), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 0), (175, 0), (180, 1), (185, 0), (190, 1), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 0), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 1), (840, 1), (845, 1), (850, 0), (855, 1), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 1), (970, 0), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 1), (5, 1), (10, 1), (15, 1), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 1), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 0), (460, 0), (465, 1), (470, 0), (475, 1), (480, 0), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 0), (970, 1), (975, 1), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VCSB1 CSB1 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)
* PULSE: period=5
Vclk1 clk1 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout1_0 Vdout1_0ck4 = 0.9 time = 25
.meas tran vdout1_0ck4 FIND v(dout1_0) AT=25.025n

* CHECK dout1_1 Vdout1_1ck4 = 0.9 time = 25
.meas tran vdout1_1ck4 FIND v(dout1_1) AT=25.025n

* CHECK dout1_2 Vdout1_2ck4 = 0.9 time = 25
.meas tran vdout1_2ck4 FIND v(dout1_2) AT=25.025n

* CHECK dout1_3 Vdout1_3ck4 = 0 time = 25
.meas tran vdout1_3ck4 FIND v(dout1_3) AT=25.025n

* CHECK dout1_4 Vdout1_4ck4 = 0 time = 25
.meas tran vdout1_4ck4 FIND v(dout1_4) AT=25.025n

* CHECK dout1_5 Vdout1_5ck4 = 0.9 time = 25
.meas tran vdout1_5ck4 FIND v(dout1_5) AT=25.025n

* CHECK dout1_6 Vdout1_6ck4 = 0 time = 25
.meas tran vdout1_6ck4 FIND v(dout1_6) AT=25.025n

* CHECK dout1_7 Vdout1_7ck4 = 0 time = 25
.meas tran vdout1_7ck4 FIND v(dout1_7) AT=25.025n

* CHECK dout1_8 Vdout1_8ck4 = 0.9 time = 25
.meas tran vdout1_8ck4 FIND v(dout1_8) AT=25.025n

* CHECK dout1_9 Vdout1_9ck4 = 0.9 time = 25
.meas tran vdout1_9ck4 FIND v(dout1_9) AT=25.025n

* CHECK dout1_10 Vdout1_10ck4 = 0.9 time = 25
.meas tran vdout1_10ck4 FIND v(dout1_10) AT=25.025n

* CHECK dout1_11 Vdout1_11ck4 = 0.9 time = 25
.meas tran vdout1_11ck4 FIND v(dout1_11) AT=25.025n

* CHECK dout1_12 Vdout1_12ck4 = 0.9 time = 25
.meas tran vdout1_12ck4 FIND v(dout1_12) AT=25.025n

* CHECK dout1_13 Vdout1_13ck4 = 0 time = 25
.meas tran vdout1_13ck4 FIND v(dout1_13) AT=25.025n

* CHECK dout1_14 Vdout1_14ck4 = 0 time = 25
.meas tran vdout1_14ck4 FIND v(dout1_14) AT=25.025n

* CHECK dout1_15 Vdout1_15ck4 = 0 time = 25
.meas tran vdout1_15ck4 FIND v(dout1_15) AT=25.025n

* CHECK dout1_16 Vdout1_16ck4 = 0.9 time = 25
.meas tran vdout1_16ck4 FIND v(dout1_16) AT=25.025n

* CHECK dout1_17 Vdout1_17ck4 = 0 time = 25
.meas tran vdout1_17ck4 FIND v(dout1_17) AT=25.025n

* CHECK dout1_18 Vdout1_18ck4 = 0 time = 25
.meas tran vdout1_18ck4 FIND v(dout1_18) AT=25.025n

* CHECK dout1_19 Vdout1_19ck4 = 0.9 time = 25
.meas tran vdout1_19ck4 FIND v(dout1_19) AT=25.025n

* CHECK dout1_20 Vdout1_20ck4 = 0 time = 25
.meas tran vdout1_20ck4 FIND v(dout1_20) AT=25.025n

* CHECK dout1_21 Vdout1_21ck4 = 0 time = 25
.meas tran vdout1_21ck4 FIND v(dout1_21) AT=25.025n

* CHECK dout1_22 Vdout1_22ck4 = 0 time = 25
.meas tran vdout1_22ck4 FIND v(dout1_22) AT=25.025n

* CHECK dout1_23 Vdout1_23ck4 = 0.9 time = 25
.meas tran vdout1_23ck4 FIND v(dout1_23) AT=25.025n

* CHECK dout1_24 Vdout1_24ck4 = 0.9 time = 25
.meas tran vdout1_24ck4 FIND v(dout1_24) AT=25.025n

* CHECK dout1_25 Vdout1_25ck4 = 0 time = 25
.meas tran vdout1_25ck4 FIND v(dout1_25) AT=25.025n

* CHECK dout1_26 Vdout1_26ck4 = 0 time = 25
.meas tran vdout1_26ck4 FIND v(dout1_26) AT=25.025n

* CHECK dout1_27 Vdout1_27ck4 = 0 time = 25
.meas tran vdout1_27ck4 FIND v(dout1_27) AT=25.025n

* CHECK dout1_28 Vdout1_28ck4 = 0 time = 25
.meas tran vdout1_28ck4 FIND v(dout1_28) AT=25.025n

* CHECK dout1_29 Vdout1_29ck4 = 0.9 time = 25
.meas tran vdout1_29ck4 FIND v(dout1_29) AT=25.025n

* CHECK dout1_30 Vdout1_30ck4 = 0.9 time = 25
.meas tran vdout1_30ck4 FIND v(dout1_30) AT=25.025n

* CHECK dout1_31 Vdout1_31ck4 = 0 time = 25
.meas tran vdout1_31ck4 FIND v(dout1_31) AT=25.025n

* CHECK dout1_32 Vdout1_32ck4 = 0.9 time = 25
.meas tran vdout1_32ck4 FIND v(dout1_32) AT=25.025n

* CHECK dout1_33 Vdout1_33ck4 = 0 time = 25
.meas tran vdout1_33ck4 FIND v(dout1_33) AT=25.025n

* CHECK dout1_34 Vdout1_34ck4 = 0.9 time = 25
.meas tran vdout1_34ck4 FIND v(dout1_34) AT=25.025n

* CHECK dout1_35 Vdout1_35ck4 = 0.9 time = 25
.meas tran vdout1_35ck4 FIND v(dout1_35) AT=25.025n

* CHECK dout1_36 Vdout1_36ck4 = 0 time = 25
.meas tran vdout1_36ck4 FIND v(dout1_36) AT=25.025n

* CHECK dout1_37 Vdout1_37ck4 = 0.9 time = 25
.meas tran vdout1_37ck4 FIND v(dout1_37) AT=25.025n

* CHECK dout1_38 Vdout1_38ck4 = 0.9 time = 25
.meas tran vdout1_38ck4 FIND v(dout1_38) AT=25.025n

* CHECK dout1_39 Vdout1_39ck4 = 0 time = 25
.meas tran vdout1_39ck4 FIND v(dout1_39) AT=25.025n

* CHECK dout1_40 Vdout1_40ck4 = 0 time = 25
.meas tran vdout1_40ck4 FIND v(dout1_40) AT=25.025n

* CHECK dout1_41 Vdout1_41ck4 = 0 time = 25
.meas tran vdout1_41ck4 FIND v(dout1_41) AT=25.025n

* CHECK dout1_42 Vdout1_42ck4 = 0.9 time = 25
.meas tran vdout1_42ck4 FIND v(dout1_42) AT=25.025n

* CHECK dout1_43 Vdout1_43ck4 = 0 time = 25
.meas tran vdout1_43ck4 FIND v(dout1_43) AT=25.025n

* CHECK dout1_44 Vdout1_44ck4 = 0.9 time = 25
.meas tran vdout1_44ck4 FIND v(dout1_44) AT=25.025n

* CHECK dout1_45 Vdout1_45ck4 = 0.9 time = 25
.meas tran vdout1_45ck4 FIND v(dout1_45) AT=25.025n

* CHECK dout1_46 Vdout1_46ck4 = 0 time = 25
.meas tran vdout1_46ck4 FIND v(dout1_46) AT=25.025n

* CHECK dout1_47 Vdout1_47ck4 = 0 time = 25
.meas tran vdout1_47ck4 FIND v(dout1_47) AT=25.025n

* CHECK dout1_48 Vdout1_48ck4 = 0.9 time = 25
.meas tran vdout1_48ck4 FIND v(dout1_48) AT=25.025n

* CHECK dout1_49 Vdout1_49ck4 = 0.9 time = 25
.meas tran vdout1_49ck4 FIND v(dout1_49) AT=25.025n

* CHECK dout1_50 Vdout1_50ck4 = 0.9 time = 25
.meas tran vdout1_50ck4 FIND v(dout1_50) AT=25.025n

* CHECK dout1_51 Vdout1_51ck4 = 0 time = 25
.meas tran vdout1_51ck4 FIND v(dout1_51) AT=25.025n

* CHECK dout1_52 Vdout1_52ck4 = 0.9 time = 25
.meas tran vdout1_52ck4 FIND v(dout1_52) AT=25.025n

* CHECK dout1_53 Vdout1_53ck4 = 0.9 time = 25
.meas tran vdout1_53ck4 FIND v(dout1_53) AT=25.025n

* CHECK dout1_54 Vdout1_54ck4 = 0 time = 25
.meas tran vdout1_54ck4 FIND v(dout1_54) AT=25.025n

* CHECK dout1_55 Vdout1_55ck4 = 0 time = 25
.meas tran vdout1_55ck4 FIND v(dout1_55) AT=25.025n

* CHECK dout1_56 Vdout1_56ck4 = 0.9 time = 25
.meas tran vdout1_56ck4 FIND v(dout1_56) AT=25.025n

* CHECK dout1_57 Vdout1_57ck4 = 0.9 time = 25
.meas tran vdout1_57ck4 FIND v(dout1_57) AT=25.025n

* CHECK dout1_58 Vdout1_58ck4 = 0 time = 25
.meas tran vdout1_58ck4 FIND v(dout1_58) AT=25.025n

* CHECK dout1_59 Vdout1_59ck4 = 0 time = 25
.meas tran vdout1_59ck4 FIND v(dout1_59) AT=25.025n

* CHECK dout1_60 Vdout1_60ck4 = 0 time = 25
.meas tran vdout1_60ck4 FIND v(dout1_60) AT=25.025n

* CHECK dout1_61 Vdout1_61ck4 = 0.9 time = 25
.meas tran vdout1_61ck4 FIND v(dout1_61) AT=25.025n

* CHECK dout1_62 Vdout1_62ck4 = 0.9 time = 25
.meas tran vdout1_62ck4 FIND v(dout1_62) AT=25.025n

* CHECK dout1_63 Vdout1_63ck4 = 0 time = 25
.meas tran vdout1_63ck4 FIND v(dout1_63) AT=25.025n

* CHECK dout1_64 Vdout1_64ck4 = 0.9 time = 25
.meas tran vdout1_64ck4 FIND v(dout1_64) AT=25.025n

* CHECK dout1_65 Vdout1_65ck4 = 0 time = 25
.meas tran vdout1_65ck4 FIND v(dout1_65) AT=25.025n

* CHECK dout1_66 Vdout1_66ck4 = 0.9 time = 25
.meas tran vdout1_66ck4 FIND v(dout1_66) AT=25.025n

* CHECK dout1_67 Vdout1_67ck4 = 0 time = 25
.meas tran vdout1_67ck4 FIND v(dout1_67) AT=25.025n

* CHECK dout1_68 Vdout1_68ck4 = 0.9 time = 25
.meas tran vdout1_68ck4 FIND v(dout1_68) AT=25.025n

* CHECK dout1_69 Vdout1_69ck4 = 0.9 time = 25
.meas tran vdout1_69ck4 FIND v(dout1_69) AT=25.025n

* CHECK dout1_70 Vdout1_70ck4 = 0 time = 25
.meas tran vdout1_70ck4 FIND v(dout1_70) AT=25.025n

* CHECK dout1_71 Vdout1_71ck4 = 0.9 time = 25
.meas tran vdout1_71ck4 FIND v(dout1_71) AT=25.025n

* CHECK dout1_0 Vdout1_0ck5 = 0.9 time = 30
.meas tran vdout1_0ck5 FIND v(dout1_0) AT=30.025n

* CHECK dout1_1 Vdout1_1ck5 = 0.9 time = 30
.meas tran vdout1_1ck5 FIND v(dout1_1) AT=30.025n

* CHECK dout1_2 Vdout1_2ck5 = 0.9 time = 30
.meas tran vdout1_2ck5 FIND v(dout1_2) AT=30.025n

* CHECK dout1_3 Vdout1_3ck5 = 0 time = 30
.meas tran vdout1_3ck5 FIND v(dout1_3) AT=30.025n

* CHECK dout1_4 Vdout1_4ck5 = 0 time = 30
.meas tran vdout1_4ck5 FIND v(dout1_4) AT=30.025n

* CHECK dout1_5 Vdout1_5ck5 = 0.9 time = 30
.meas tran vdout1_5ck5 FIND v(dout1_5) AT=30.025n

* CHECK dout1_6 Vdout1_6ck5 = 0 time = 30
.meas tran vdout1_6ck5 FIND v(dout1_6) AT=30.025n

* CHECK dout1_7 Vdout1_7ck5 = 0 time = 30
.meas tran vdout1_7ck5 FIND v(dout1_7) AT=30.025n

* CHECK dout1_8 Vdout1_8ck5 = 0.9 time = 30
.meas tran vdout1_8ck5 FIND v(dout1_8) AT=30.025n

* CHECK dout1_9 Vdout1_9ck5 = 0.9 time = 30
.meas tran vdout1_9ck5 FIND v(dout1_9) AT=30.025n

* CHECK dout1_10 Vdout1_10ck5 = 0.9 time = 30
.meas tran vdout1_10ck5 FIND v(dout1_10) AT=30.025n

* CHECK dout1_11 Vdout1_11ck5 = 0.9 time = 30
.meas tran vdout1_11ck5 FIND v(dout1_11) AT=30.025n

* CHECK dout1_12 Vdout1_12ck5 = 0.9 time = 30
.meas tran vdout1_12ck5 FIND v(dout1_12) AT=30.025n

* CHECK dout1_13 Vdout1_13ck5 = 0 time = 30
.meas tran vdout1_13ck5 FIND v(dout1_13) AT=30.025n

* CHECK dout1_14 Vdout1_14ck5 = 0 time = 30
.meas tran vdout1_14ck5 FIND v(dout1_14) AT=30.025n

* CHECK dout1_15 Vdout1_15ck5 = 0 time = 30
.meas tran vdout1_15ck5 FIND v(dout1_15) AT=30.025n

* CHECK dout1_16 Vdout1_16ck5 = 0.9 time = 30
.meas tran vdout1_16ck5 FIND v(dout1_16) AT=30.025n

* CHECK dout1_17 Vdout1_17ck5 = 0 time = 30
.meas tran vdout1_17ck5 FIND v(dout1_17) AT=30.025n

* CHECK dout1_18 Vdout1_18ck5 = 0 time = 30
.meas tran vdout1_18ck5 FIND v(dout1_18) AT=30.025n

* CHECK dout1_19 Vdout1_19ck5 = 0.9 time = 30
.meas tran vdout1_19ck5 FIND v(dout1_19) AT=30.025n

* CHECK dout1_20 Vdout1_20ck5 = 0 time = 30
.meas tran vdout1_20ck5 FIND v(dout1_20) AT=30.025n

* CHECK dout1_21 Vdout1_21ck5 = 0 time = 30
.meas tran vdout1_21ck5 FIND v(dout1_21) AT=30.025n

* CHECK dout1_22 Vdout1_22ck5 = 0 time = 30
.meas tran vdout1_22ck5 FIND v(dout1_22) AT=30.025n

* CHECK dout1_23 Vdout1_23ck5 = 0.9 time = 30
.meas tran vdout1_23ck5 FIND v(dout1_23) AT=30.025n

* CHECK dout1_24 Vdout1_24ck5 = 0.9 time = 30
.meas tran vdout1_24ck5 FIND v(dout1_24) AT=30.025n

* CHECK dout1_25 Vdout1_25ck5 = 0 time = 30
.meas tran vdout1_25ck5 FIND v(dout1_25) AT=30.025n

* CHECK dout1_26 Vdout1_26ck5 = 0 time = 30
.meas tran vdout1_26ck5 FIND v(dout1_26) AT=30.025n

* CHECK dout1_27 Vdout1_27ck5 = 0 time = 30
.meas tran vdout1_27ck5 FIND v(dout1_27) AT=30.025n

* CHECK dout1_28 Vdout1_28ck5 = 0 time = 30
.meas tran vdout1_28ck5 FIND v(dout1_28) AT=30.025n

* CHECK dout1_29 Vdout1_29ck5 = 0.9 time = 30
.meas tran vdout1_29ck5 FIND v(dout1_29) AT=30.025n

* CHECK dout1_30 Vdout1_30ck5 = 0.9 time = 30
.meas tran vdout1_30ck5 FIND v(dout1_30) AT=30.025n

* CHECK dout1_31 Vdout1_31ck5 = 0 time = 30
.meas tran vdout1_31ck5 FIND v(dout1_31) AT=30.025n

* CHECK dout1_32 Vdout1_32ck5 = 0.9 time = 30
.meas tran vdout1_32ck5 FIND v(dout1_32) AT=30.025n

* CHECK dout1_33 Vdout1_33ck5 = 0 time = 30
.meas tran vdout1_33ck5 FIND v(dout1_33) AT=30.025n

* CHECK dout1_34 Vdout1_34ck5 = 0.9 time = 30
.meas tran vdout1_34ck5 FIND v(dout1_34) AT=30.025n

* CHECK dout1_35 Vdout1_35ck5 = 0.9 time = 30
.meas tran vdout1_35ck5 FIND v(dout1_35) AT=30.025n

* CHECK dout1_36 Vdout1_36ck5 = 0 time = 30
.meas tran vdout1_36ck5 FIND v(dout1_36) AT=30.025n

* CHECK dout1_37 Vdout1_37ck5 = 0.9 time = 30
.meas tran vdout1_37ck5 FIND v(dout1_37) AT=30.025n

* CHECK dout1_38 Vdout1_38ck5 = 0.9 time = 30
.meas tran vdout1_38ck5 FIND v(dout1_38) AT=30.025n

* CHECK dout1_39 Vdout1_39ck5 = 0 time = 30
.meas tran vdout1_39ck5 FIND v(dout1_39) AT=30.025n

* CHECK dout1_40 Vdout1_40ck5 = 0 time = 30
.meas tran vdout1_40ck5 FIND v(dout1_40) AT=30.025n

* CHECK dout1_41 Vdout1_41ck5 = 0 time = 30
.meas tran vdout1_41ck5 FIND v(dout1_41) AT=30.025n

* CHECK dout1_42 Vdout1_42ck5 = 0.9 time = 30
.meas tran vdout1_42ck5 FIND v(dout1_42) AT=30.025n

* CHECK dout1_43 Vdout1_43ck5 = 0 time = 30
.meas tran vdout1_43ck5 FIND v(dout1_43) AT=30.025n

* CHECK dout1_44 Vdout1_44ck5 = 0.9 time = 30
.meas tran vdout1_44ck5 FIND v(dout1_44) AT=30.025n

* CHECK dout1_45 Vdout1_45ck5 = 0.9 time = 30
.meas tran vdout1_45ck5 FIND v(dout1_45) AT=30.025n

* CHECK dout1_46 Vdout1_46ck5 = 0 time = 30
.meas tran vdout1_46ck5 FIND v(dout1_46) AT=30.025n

* CHECK dout1_47 Vdout1_47ck5 = 0 time = 30
.meas tran vdout1_47ck5 FIND v(dout1_47) AT=30.025n

* CHECK dout1_48 Vdout1_48ck5 = 0.9 time = 30
.meas tran vdout1_48ck5 FIND v(dout1_48) AT=30.025n

* CHECK dout1_49 Vdout1_49ck5 = 0.9 time = 30
.meas tran vdout1_49ck5 FIND v(dout1_49) AT=30.025n

* CHECK dout1_50 Vdout1_50ck5 = 0.9 time = 30
.meas tran vdout1_50ck5 FIND v(dout1_50) AT=30.025n

* CHECK dout1_51 Vdout1_51ck5 = 0 time = 30
.meas tran vdout1_51ck5 FIND v(dout1_51) AT=30.025n

* CHECK dout1_52 Vdout1_52ck5 = 0.9 time = 30
.meas tran vdout1_52ck5 FIND v(dout1_52) AT=30.025n

* CHECK dout1_53 Vdout1_53ck5 = 0.9 time = 30
.meas tran vdout1_53ck5 FIND v(dout1_53) AT=30.025n

* CHECK dout1_54 Vdout1_54ck5 = 0 time = 30
.meas tran vdout1_54ck5 FIND v(dout1_54) AT=30.025n

* CHECK dout1_55 Vdout1_55ck5 = 0 time = 30
.meas tran vdout1_55ck5 FIND v(dout1_55) AT=30.025n

* CHECK dout1_56 Vdout1_56ck5 = 0.9 time = 30
.meas tran vdout1_56ck5 FIND v(dout1_56) AT=30.025n

* CHECK dout1_57 Vdout1_57ck5 = 0.9 time = 30
.meas tran vdout1_57ck5 FIND v(dout1_57) AT=30.025n

* CHECK dout1_58 Vdout1_58ck5 = 0 time = 30
.meas tran vdout1_58ck5 FIND v(dout1_58) AT=30.025n

* CHECK dout1_59 Vdout1_59ck5 = 0 time = 30
.meas tran vdout1_59ck5 FIND v(dout1_59) AT=30.025n

* CHECK dout1_60 Vdout1_60ck5 = 0 time = 30
.meas tran vdout1_60ck5 FIND v(dout1_60) AT=30.025n

* CHECK dout1_61 Vdout1_61ck5 = 0.9 time = 30
.meas tran vdout1_61ck5 FIND v(dout1_61) AT=30.025n

* CHECK dout1_62 Vdout1_62ck5 = 0.9 time = 30
.meas tran vdout1_62ck5 FIND v(dout1_62) AT=30.025n

* CHECK dout1_63 Vdout1_63ck5 = 0 time = 30
.meas tran vdout1_63ck5 FIND v(dout1_63) AT=30.025n

* CHECK dout1_64 Vdout1_64ck5 = 0.9 time = 30
.meas tran vdout1_64ck5 FIND v(dout1_64) AT=30.025n

* CHECK dout1_65 Vdout1_65ck5 = 0 time = 30
.meas tran vdout1_65ck5 FIND v(dout1_65) AT=30.025n

* CHECK dout1_66 Vdout1_66ck5 = 0.9 time = 30
.meas tran vdout1_66ck5 FIND v(dout1_66) AT=30.025n

* CHECK dout1_67 Vdout1_67ck5 = 0 time = 30
.meas tran vdout1_67ck5 FIND v(dout1_67) AT=30.025n

* CHECK dout1_68 Vdout1_68ck5 = 0.9 time = 30
.meas tran vdout1_68ck5 FIND v(dout1_68) AT=30.025n

* CHECK dout1_69 Vdout1_69ck5 = 0.9 time = 30
.meas tran vdout1_69ck5 FIND v(dout1_69) AT=30.025n

* CHECK dout1_70 Vdout1_70ck5 = 0 time = 30
.meas tran vdout1_70ck5 FIND v(dout1_70) AT=30.025n

* CHECK dout1_71 Vdout1_71ck5 = 0.9 time = 30
.meas tran vdout1_71ck5 FIND v(dout1_71) AT=30.025n

* CHECK dout1_0 Vdout1_0ck6 = 0.9 time = 35
.meas tran vdout1_0ck6 FIND v(dout1_0) AT=35.025n

* CHECK dout1_1 Vdout1_1ck6 = 0.9 time = 35
.meas tran vdout1_1ck6 FIND v(dout1_1) AT=35.025n

* CHECK dout1_2 Vdout1_2ck6 = 0.9 time = 35
.meas tran vdout1_2ck6 FIND v(dout1_2) AT=35.025n

* CHECK dout1_3 Vdout1_3ck6 = 0 time = 35
.meas tran vdout1_3ck6 FIND v(dout1_3) AT=35.025n

* CHECK dout1_4 Vdout1_4ck6 = 0 time = 35
.meas tran vdout1_4ck6 FIND v(dout1_4) AT=35.025n

* CHECK dout1_5 Vdout1_5ck6 = 0.9 time = 35
.meas tran vdout1_5ck6 FIND v(dout1_5) AT=35.025n

* CHECK dout1_6 Vdout1_6ck6 = 0 time = 35
.meas tran vdout1_6ck6 FIND v(dout1_6) AT=35.025n

* CHECK dout1_7 Vdout1_7ck6 = 0 time = 35
.meas tran vdout1_7ck6 FIND v(dout1_7) AT=35.025n

* CHECK dout1_8 Vdout1_8ck6 = 0.9 time = 35
.meas tran vdout1_8ck6 FIND v(dout1_8) AT=35.025n

* CHECK dout1_9 Vdout1_9ck6 = 0.9 time = 35
.meas tran vdout1_9ck6 FIND v(dout1_9) AT=35.025n

* CHECK dout1_10 Vdout1_10ck6 = 0.9 time = 35
.meas tran vdout1_10ck6 FIND v(dout1_10) AT=35.025n

* CHECK dout1_11 Vdout1_11ck6 = 0.9 time = 35
.meas tran vdout1_11ck6 FIND v(dout1_11) AT=35.025n

* CHECK dout1_12 Vdout1_12ck6 = 0.9 time = 35
.meas tran vdout1_12ck6 FIND v(dout1_12) AT=35.025n

* CHECK dout1_13 Vdout1_13ck6 = 0 time = 35
.meas tran vdout1_13ck6 FIND v(dout1_13) AT=35.025n

* CHECK dout1_14 Vdout1_14ck6 = 0 time = 35
.meas tran vdout1_14ck6 FIND v(dout1_14) AT=35.025n

* CHECK dout1_15 Vdout1_15ck6 = 0 time = 35
.meas tran vdout1_15ck6 FIND v(dout1_15) AT=35.025n

* CHECK dout1_16 Vdout1_16ck6 = 0.9 time = 35
.meas tran vdout1_16ck6 FIND v(dout1_16) AT=35.025n

* CHECK dout1_17 Vdout1_17ck6 = 0 time = 35
.meas tran vdout1_17ck6 FIND v(dout1_17) AT=35.025n

* CHECK dout1_18 Vdout1_18ck6 = 0 time = 35
.meas tran vdout1_18ck6 FIND v(dout1_18) AT=35.025n

* CHECK dout1_19 Vdout1_19ck6 = 0.9 time = 35
.meas tran vdout1_19ck6 FIND v(dout1_19) AT=35.025n

* CHECK dout1_20 Vdout1_20ck6 = 0 time = 35
.meas tran vdout1_20ck6 FIND v(dout1_20) AT=35.025n

* CHECK dout1_21 Vdout1_21ck6 = 0 time = 35
.meas tran vdout1_21ck6 FIND v(dout1_21) AT=35.025n

* CHECK dout1_22 Vdout1_22ck6 = 0 time = 35
.meas tran vdout1_22ck6 FIND v(dout1_22) AT=35.025n

* CHECK dout1_23 Vdout1_23ck6 = 0.9 time = 35
.meas tran vdout1_23ck6 FIND v(dout1_23) AT=35.025n

* CHECK dout1_24 Vdout1_24ck6 = 0.9 time = 35
.meas tran vdout1_24ck6 FIND v(dout1_24) AT=35.025n

* CHECK dout1_25 Vdout1_25ck6 = 0 time = 35
.meas tran vdout1_25ck6 FIND v(dout1_25) AT=35.025n

* CHECK dout1_26 Vdout1_26ck6 = 0 time = 35
.meas tran vdout1_26ck6 FIND v(dout1_26) AT=35.025n

* CHECK dout1_27 Vdout1_27ck6 = 0 time = 35
.meas tran vdout1_27ck6 FIND v(dout1_27) AT=35.025n

* CHECK dout1_28 Vdout1_28ck6 = 0 time = 35
.meas tran vdout1_28ck6 FIND v(dout1_28) AT=35.025n

* CHECK dout1_29 Vdout1_29ck6 = 0.9 time = 35
.meas tran vdout1_29ck6 FIND v(dout1_29) AT=35.025n

* CHECK dout1_30 Vdout1_30ck6 = 0.9 time = 35
.meas tran vdout1_30ck6 FIND v(dout1_30) AT=35.025n

* CHECK dout1_31 Vdout1_31ck6 = 0 time = 35
.meas tran vdout1_31ck6 FIND v(dout1_31) AT=35.025n

* CHECK dout1_32 Vdout1_32ck6 = 0.9 time = 35
.meas tran vdout1_32ck6 FIND v(dout1_32) AT=35.025n

* CHECK dout1_33 Vdout1_33ck6 = 0 time = 35
.meas tran vdout1_33ck6 FIND v(dout1_33) AT=35.025n

* CHECK dout1_34 Vdout1_34ck6 = 0.9 time = 35
.meas tran vdout1_34ck6 FIND v(dout1_34) AT=35.025n

* CHECK dout1_35 Vdout1_35ck6 = 0.9 time = 35
.meas tran vdout1_35ck6 FIND v(dout1_35) AT=35.025n

* CHECK dout1_36 Vdout1_36ck6 = 0 time = 35
.meas tran vdout1_36ck6 FIND v(dout1_36) AT=35.025n

* CHECK dout1_37 Vdout1_37ck6 = 0.9 time = 35
.meas tran vdout1_37ck6 FIND v(dout1_37) AT=35.025n

* CHECK dout1_38 Vdout1_38ck6 = 0.9 time = 35
.meas tran vdout1_38ck6 FIND v(dout1_38) AT=35.025n

* CHECK dout1_39 Vdout1_39ck6 = 0 time = 35
.meas tran vdout1_39ck6 FIND v(dout1_39) AT=35.025n

* CHECK dout1_40 Vdout1_40ck6 = 0 time = 35
.meas tran vdout1_40ck6 FIND v(dout1_40) AT=35.025n

* CHECK dout1_41 Vdout1_41ck6 = 0 time = 35
.meas tran vdout1_41ck6 FIND v(dout1_41) AT=35.025n

* CHECK dout1_42 Vdout1_42ck6 = 0.9 time = 35
.meas tran vdout1_42ck6 FIND v(dout1_42) AT=35.025n

* CHECK dout1_43 Vdout1_43ck6 = 0 time = 35
.meas tran vdout1_43ck6 FIND v(dout1_43) AT=35.025n

* CHECK dout1_44 Vdout1_44ck6 = 0.9 time = 35
.meas tran vdout1_44ck6 FIND v(dout1_44) AT=35.025n

* CHECK dout1_45 Vdout1_45ck6 = 0.9 time = 35
.meas tran vdout1_45ck6 FIND v(dout1_45) AT=35.025n

* CHECK dout1_46 Vdout1_46ck6 = 0 time = 35
.meas tran vdout1_46ck6 FIND v(dout1_46) AT=35.025n

* CHECK dout1_47 Vdout1_47ck6 = 0 time = 35
.meas tran vdout1_47ck6 FIND v(dout1_47) AT=35.025n

* CHECK dout1_48 Vdout1_48ck6 = 0.9 time = 35
.meas tran vdout1_48ck6 FIND v(dout1_48) AT=35.025n

* CHECK dout1_49 Vdout1_49ck6 = 0.9 time = 35
.meas tran vdout1_49ck6 FIND v(dout1_49) AT=35.025n

* CHECK dout1_50 Vdout1_50ck6 = 0.9 time = 35
.meas tran vdout1_50ck6 FIND v(dout1_50) AT=35.025n

* CHECK dout1_51 Vdout1_51ck6 = 0 time = 35
.meas tran vdout1_51ck6 FIND v(dout1_51) AT=35.025n

* CHECK dout1_52 Vdout1_52ck6 = 0.9 time = 35
.meas tran vdout1_52ck6 FIND v(dout1_52) AT=35.025n

* CHECK dout1_53 Vdout1_53ck6 = 0.9 time = 35
.meas tran vdout1_53ck6 FIND v(dout1_53) AT=35.025n

* CHECK dout1_54 Vdout1_54ck6 = 0 time = 35
.meas tran vdout1_54ck6 FIND v(dout1_54) AT=35.025n

* CHECK dout1_55 Vdout1_55ck6 = 0 time = 35
.meas tran vdout1_55ck6 FIND v(dout1_55) AT=35.025n

* CHECK dout1_56 Vdout1_56ck6 = 0.9 time = 35
.meas tran vdout1_56ck6 FIND v(dout1_56) AT=35.025n

* CHECK dout1_57 Vdout1_57ck6 = 0.9 time = 35
.meas tran vdout1_57ck6 FIND v(dout1_57) AT=35.025n

* CHECK dout1_58 Vdout1_58ck6 = 0 time = 35
.meas tran vdout1_58ck6 FIND v(dout1_58) AT=35.025n

* CHECK dout1_59 Vdout1_59ck6 = 0 time = 35
.meas tran vdout1_59ck6 FIND v(dout1_59) AT=35.025n

* CHECK dout1_60 Vdout1_60ck6 = 0 time = 35
.meas tran vdout1_60ck6 FIND v(dout1_60) AT=35.025n

* CHECK dout1_61 Vdout1_61ck6 = 0.9 time = 35
.meas tran vdout1_61ck6 FIND v(dout1_61) AT=35.025n

* CHECK dout1_62 Vdout1_62ck6 = 0.9 time = 35
.meas tran vdout1_62ck6 FIND v(dout1_62) AT=35.025n

* CHECK dout1_63 Vdout1_63ck6 = 0 time = 35
.meas tran vdout1_63ck6 FIND v(dout1_63) AT=35.025n

* CHECK dout1_64 Vdout1_64ck6 = 0.9 time = 35
.meas tran vdout1_64ck6 FIND v(dout1_64) AT=35.025n

* CHECK dout1_65 Vdout1_65ck6 = 0 time = 35
.meas tran vdout1_65ck6 FIND v(dout1_65) AT=35.025n

* CHECK dout1_66 Vdout1_66ck6 = 0.9 time = 35
.meas tran vdout1_66ck6 FIND v(dout1_66) AT=35.025n

* CHECK dout1_67 Vdout1_67ck6 = 0 time = 35
.meas tran vdout1_67ck6 FIND v(dout1_67) AT=35.025n

* CHECK dout1_68 Vdout1_68ck6 = 0.9 time = 35
.meas tran vdout1_68ck6 FIND v(dout1_68) AT=35.025n

* CHECK dout1_69 Vdout1_69ck6 = 0.9 time = 35
.meas tran vdout1_69ck6 FIND v(dout1_69) AT=35.025n

* CHECK dout1_70 Vdout1_70ck6 = 0 time = 35
.meas tran vdout1_70ck6 FIND v(dout1_70) AT=35.025n

* CHECK dout1_71 Vdout1_71ck6 = 0.9 time = 35
.meas tran vdout1_71ck6 FIND v(dout1_71) AT=35.025n

* CHECK dout1_0 Vdout1_0ck18 = 0.9 time = 95
.meas tran vdout1_0ck18 FIND v(dout1_0) AT=95.025n

* CHECK dout1_1 Vdout1_1ck18 = 0.9 time = 95
.meas tran vdout1_1ck18 FIND v(dout1_1) AT=95.025n

* CHECK dout1_2 Vdout1_2ck18 = 0.9 time = 95
.meas tran vdout1_2ck18 FIND v(dout1_2) AT=95.025n

* CHECK dout1_3 Vdout1_3ck18 = 0 time = 95
.meas tran vdout1_3ck18 FIND v(dout1_3) AT=95.025n

* CHECK dout1_4 Vdout1_4ck18 = 0.9 time = 95
.meas tran vdout1_4ck18 FIND v(dout1_4) AT=95.025n

* CHECK dout1_5 Vdout1_5ck18 = 0 time = 95
.meas tran vdout1_5ck18 FIND v(dout1_5) AT=95.025n

* CHECK dout1_6 Vdout1_6ck18 = 0.9 time = 95
.meas tran vdout1_6ck18 FIND v(dout1_6) AT=95.025n

* CHECK dout1_7 Vdout1_7ck18 = 0.9 time = 95
.meas tran vdout1_7ck18 FIND v(dout1_7) AT=95.025n

* CHECK dout1_8 Vdout1_8ck18 = 0 time = 95
.meas tran vdout1_8ck18 FIND v(dout1_8) AT=95.025n

* CHECK dout1_9 Vdout1_9ck18 = 0 time = 95
.meas tran vdout1_9ck18 FIND v(dout1_9) AT=95.025n

* CHECK dout1_10 Vdout1_10ck18 = 0 time = 95
.meas tran vdout1_10ck18 FIND v(dout1_10) AT=95.025n

* CHECK dout1_11 Vdout1_11ck18 = 0.9 time = 95
.meas tran vdout1_11ck18 FIND v(dout1_11) AT=95.025n

* CHECK dout1_12 Vdout1_12ck18 = 0.9 time = 95
.meas tran vdout1_12ck18 FIND v(dout1_12) AT=95.025n

* CHECK dout1_13 Vdout1_13ck18 = 0 time = 95
.meas tran vdout1_13ck18 FIND v(dout1_13) AT=95.025n

* CHECK dout1_14 Vdout1_14ck18 = 0 time = 95
.meas tran vdout1_14ck18 FIND v(dout1_14) AT=95.025n

* CHECK dout1_15 Vdout1_15ck18 = 0.9 time = 95
.meas tran vdout1_15ck18 FIND v(dout1_15) AT=95.025n

* CHECK dout1_16 Vdout1_16ck18 = 0.9 time = 95
.meas tran vdout1_16ck18 FIND v(dout1_16) AT=95.025n

* CHECK dout1_17 Vdout1_17ck18 = 0.9 time = 95
.meas tran vdout1_17ck18 FIND v(dout1_17) AT=95.025n

* CHECK dout1_18 Vdout1_18ck18 = 0.9 time = 95
.meas tran vdout1_18ck18 FIND v(dout1_18) AT=95.025n

* CHECK dout1_19 Vdout1_19ck18 = 0.9 time = 95
.meas tran vdout1_19ck18 FIND v(dout1_19) AT=95.025n

* CHECK dout1_20 Vdout1_20ck18 = 0 time = 95
.meas tran vdout1_20ck18 FIND v(dout1_20) AT=95.025n

* CHECK dout1_21 Vdout1_21ck18 = 0 time = 95
.meas tran vdout1_21ck18 FIND v(dout1_21) AT=95.025n

* CHECK dout1_22 Vdout1_22ck18 = 0.9 time = 95
.meas tran vdout1_22ck18 FIND v(dout1_22) AT=95.025n

* CHECK dout1_23 Vdout1_23ck18 = 0 time = 95
.meas tran vdout1_23ck18 FIND v(dout1_23) AT=95.025n

* CHECK dout1_24 Vdout1_24ck18 = 0.9 time = 95
.meas tran vdout1_24ck18 FIND v(dout1_24) AT=95.025n

* CHECK dout1_25 Vdout1_25ck18 = 0.9 time = 95
.meas tran vdout1_25ck18 FIND v(dout1_25) AT=95.025n

* CHECK dout1_26 Vdout1_26ck18 = 0 time = 95
.meas tran vdout1_26ck18 FIND v(dout1_26) AT=95.025n

* CHECK dout1_27 Vdout1_27ck18 = 0.9 time = 95
.meas tran vdout1_27ck18 FIND v(dout1_27) AT=95.025n

* CHECK dout1_28 Vdout1_28ck18 = 0 time = 95
.meas tran vdout1_28ck18 FIND v(dout1_28) AT=95.025n

* CHECK dout1_29 Vdout1_29ck18 = 0 time = 95
.meas tran vdout1_29ck18 FIND v(dout1_29) AT=95.025n

* CHECK dout1_30 Vdout1_30ck18 = 0.9 time = 95
.meas tran vdout1_30ck18 FIND v(dout1_30) AT=95.025n

* CHECK dout1_31 Vdout1_31ck18 = 0 time = 95
.meas tran vdout1_31ck18 FIND v(dout1_31) AT=95.025n

* CHECK dout1_32 Vdout1_32ck18 = 0.9 time = 95
.meas tran vdout1_32ck18 FIND v(dout1_32) AT=95.025n

* CHECK dout1_33 Vdout1_33ck18 = 0 time = 95
.meas tran vdout1_33ck18 FIND v(dout1_33) AT=95.025n

* CHECK dout1_34 Vdout1_34ck18 = 0.9 time = 95
.meas tran vdout1_34ck18 FIND v(dout1_34) AT=95.025n

* CHECK dout1_35 Vdout1_35ck18 = 0.9 time = 95
.meas tran vdout1_35ck18 FIND v(dout1_35) AT=95.025n

* CHECK dout1_36 Vdout1_36ck18 = 0 time = 95
.meas tran vdout1_36ck18 FIND v(dout1_36) AT=95.025n

* CHECK dout1_37 Vdout1_37ck18 = 0.9 time = 95
.meas tran vdout1_37ck18 FIND v(dout1_37) AT=95.025n

* CHECK dout1_38 Vdout1_38ck18 = 0 time = 95
.meas tran vdout1_38ck18 FIND v(dout1_38) AT=95.025n

* CHECK dout1_39 Vdout1_39ck18 = 0.9 time = 95
.meas tran vdout1_39ck18 FIND v(dout1_39) AT=95.025n

* CHECK dout1_40 Vdout1_40ck18 = 0 time = 95
.meas tran vdout1_40ck18 FIND v(dout1_40) AT=95.025n

* CHECK dout1_41 Vdout1_41ck18 = 0 time = 95
.meas tran vdout1_41ck18 FIND v(dout1_41) AT=95.025n

* CHECK dout1_42 Vdout1_42ck18 = 0 time = 95
.meas tran vdout1_42ck18 FIND v(dout1_42) AT=95.025n

* CHECK dout1_43 Vdout1_43ck18 = 0.9 time = 95
.meas tran vdout1_43ck18 FIND v(dout1_43) AT=95.025n

* CHECK dout1_44 Vdout1_44ck18 = 0.9 time = 95
.meas tran vdout1_44ck18 FIND v(dout1_44) AT=95.025n

* CHECK dout1_45 Vdout1_45ck18 = 0 time = 95
.meas tran vdout1_45ck18 FIND v(dout1_45) AT=95.025n

* CHECK dout1_46 Vdout1_46ck18 = 0 time = 95
.meas tran vdout1_46ck18 FIND v(dout1_46) AT=95.025n

* CHECK dout1_47 Vdout1_47ck18 = 0 time = 95
.meas tran vdout1_47ck18 FIND v(dout1_47) AT=95.025n

* CHECK dout1_48 Vdout1_48ck18 = 0 time = 95
.meas tran vdout1_48ck18 FIND v(dout1_48) AT=95.025n

* CHECK dout1_49 Vdout1_49ck18 = 0 time = 95
.meas tran vdout1_49ck18 FIND v(dout1_49) AT=95.025n

* CHECK dout1_50 Vdout1_50ck18 = 0 time = 95
.meas tran vdout1_50ck18 FIND v(dout1_50) AT=95.025n

* CHECK dout1_51 Vdout1_51ck18 = 0 time = 95
.meas tran vdout1_51ck18 FIND v(dout1_51) AT=95.025n

* CHECK dout1_52 Vdout1_52ck18 = 0 time = 95
.meas tran vdout1_52ck18 FIND v(dout1_52) AT=95.025n

* CHECK dout1_53 Vdout1_53ck18 = 0 time = 95
.meas tran vdout1_53ck18 FIND v(dout1_53) AT=95.025n

* CHECK dout1_54 Vdout1_54ck18 = 0 time = 95
.meas tran vdout1_54ck18 FIND v(dout1_54) AT=95.025n

* CHECK dout1_55 Vdout1_55ck18 = 0 time = 95
.meas tran vdout1_55ck18 FIND v(dout1_55) AT=95.025n

* CHECK dout1_56 Vdout1_56ck18 = 0 time = 95
.meas tran vdout1_56ck18 FIND v(dout1_56) AT=95.025n

* CHECK dout1_57 Vdout1_57ck18 = 0.9 time = 95
.meas tran vdout1_57ck18 FIND v(dout1_57) AT=95.025n

* CHECK dout1_58 Vdout1_58ck18 = 0.9 time = 95
.meas tran vdout1_58ck18 FIND v(dout1_58) AT=95.025n

* CHECK dout1_59 Vdout1_59ck18 = 0.9 time = 95
.meas tran vdout1_59ck18 FIND v(dout1_59) AT=95.025n

* CHECK dout1_60 Vdout1_60ck18 = 0 time = 95
.meas tran vdout1_60ck18 FIND v(dout1_60) AT=95.025n

* CHECK dout1_61 Vdout1_61ck18 = 0.9 time = 95
.meas tran vdout1_61ck18 FIND v(dout1_61) AT=95.025n

* CHECK dout1_62 Vdout1_62ck18 = 0 time = 95
.meas tran vdout1_62ck18 FIND v(dout1_62) AT=95.025n

* CHECK dout1_63 Vdout1_63ck18 = 0.9 time = 95
.meas tran vdout1_63ck18 FIND v(dout1_63) AT=95.025n

* CHECK dout1_64 Vdout1_64ck18 = 0.9 time = 95
.meas tran vdout1_64ck18 FIND v(dout1_64) AT=95.025n

* CHECK dout1_65 Vdout1_65ck18 = 0 time = 95
.meas tran vdout1_65ck18 FIND v(dout1_65) AT=95.025n

* CHECK dout1_66 Vdout1_66ck18 = 0.9 time = 95
.meas tran vdout1_66ck18 FIND v(dout1_66) AT=95.025n

* CHECK dout1_67 Vdout1_67ck18 = 0 time = 95
.meas tran vdout1_67ck18 FIND v(dout1_67) AT=95.025n

* CHECK dout1_68 Vdout1_68ck18 = 0.9 time = 95
.meas tran vdout1_68ck18 FIND v(dout1_68) AT=95.025n

* CHECK dout1_69 Vdout1_69ck18 = 0.9 time = 95
.meas tran vdout1_69ck18 FIND v(dout1_69) AT=95.025n

* CHECK dout1_70 Vdout1_70ck18 = 0 time = 95
.meas tran vdout1_70ck18 FIND v(dout1_70) AT=95.025n

* CHECK dout1_71 Vdout1_71ck18 = 0 time = 95
.meas tran vdout1_71ck18 FIND v(dout1_71) AT=95.025n

* CHECK dout1_0 Vdout1_0ck20 = 0.9 time = 105
.meas tran vdout1_0ck20 FIND v(dout1_0) AT=105.025n

* CHECK dout1_1 Vdout1_1ck20 = 0.9 time = 105
.meas tran vdout1_1ck20 FIND v(dout1_1) AT=105.025n

* CHECK dout1_2 Vdout1_2ck20 = 0.9 time = 105
.meas tran vdout1_2ck20 FIND v(dout1_2) AT=105.025n

* CHECK dout1_3 Vdout1_3ck20 = 0 time = 105
.meas tran vdout1_3ck20 FIND v(dout1_3) AT=105.025n

* CHECK dout1_4 Vdout1_4ck20 = 0.9 time = 105
.meas tran vdout1_4ck20 FIND v(dout1_4) AT=105.025n

* CHECK dout1_5 Vdout1_5ck20 = 0 time = 105
.meas tran vdout1_5ck20 FIND v(dout1_5) AT=105.025n

* CHECK dout1_6 Vdout1_6ck20 = 0.9 time = 105
.meas tran vdout1_6ck20 FIND v(dout1_6) AT=105.025n

* CHECK dout1_7 Vdout1_7ck20 = 0.9 time = 105
.meas tran vdout1_7ck20 FIND v(dout1_7) AT=105.025n

* CHECK dout1_8 Vdout1_8ck20 = 0 time = 105
.meas tran vdout1_8ck20 FIND v(dout1_8) AT=105.025n

* CHECK dout1_9 Vdout1_9ck20 = 0 time = 105
.meas tran vdout1_9ck20 FIND v(dout1_9) AT=105.025n

* CHECK dout1_10 Vdout1_10ck20 = 0 time = 105
.meas tran vdout1_10ck20 FIND v(dout1_10) AT=105.025n

* CHECK dout1_11 Vdout1_11ck20 = 0.9 time = 105
.meas tran vdout1_11ck20 FIND v(dout1_11) AT=105.025n

* CHECK dout1_12 Vdout1_12ck20 = 0.9 time = 105
.meas tran vdout1_12ck20 FIND v(dout1_12) AT=105.025n

* CHECK dout1_13 Vdout1_13ck20 = 0 time = 105
.meas tran vdout1_13ck20 FIND v(dout1_13) AT=105.025n

* CHECK dout1_14 Vdout1_14ck20 = 0 time = 105
.meas tran vdout1_14ck20 FIND v(dout1_14) AT=105.025n

* CHECK dout1_15 Vdout1_15ck20 = 0.9 time = 105
.meas tran vdout1_15ck20 FIND v(dout1_15) AT=105.025n

* CHECK dout1_16 Vdout1_16ck20 = 0.9 time = 105
.meas tran vdout1_16ck20 FIND v(dout1_16) AT=105.025n

* CHECK dout1_17 Vdout1_17ck20 = 0.9 time = 105
.meas tran vdout1_17ck20 FIND v(dout1_17) AT=105.025n

* CHECK dout1_18 Vdout1_18ck20 = 0.9 time = 105
.meas tran vdout1_18ck20 FIND v(dout1_18) AT=105.025n

* CHECK dout1_19 Vdout1_19ck20 = 0.9 time = 105
.meas tran vdout1_19ck20 FIND v(dout1_19) AT=105.025n

* CHECK dout1_20 Vdout1_20ck20 = 0 time = 105
.meas tran vdout1_20ck20 FIND v(dout1_20) AT=105.025n

* CHECK dout1_21 Vdout1_21ck20 = 0 time = 105
.meas tran vdout1_21ck20 FIND v(dout1_21) AT=105.025n

* CHECK dout1_22 Vdout1_22ck20 = 0.9 time = 105
.meas tran vdout1_22ck20 FIND v(dout1_22) AT=105.025n

* CHECK dout1_23 Vdout1_23ck20 = 0 time = 105
.meas tran vdout1_23ck20 FIND v(dout1_23) AT=105.025n

* CHECK dout1_24 Vdout1_24ck20 = 0.9 time = 105
.meas tran vdout1_24ck20 FIND v(dout1_24) AT=105.025n

* CHECK dout1_25 Vdout1_25ck20 = 0.9 time = 105
.meas tran vdout1_25ck20 FIND v(dout1_25) AT=105.025n

* CHECK dout1_26 Vdout1_26ck20 = 0 time = 105
.meas tran vdout1_26ck20 FIND v(dout1_26) AT=105.025n

* CHECK dout1_27 Vdout1_27ck20 = 0.9 time = 105
.meas tran vdout1_27ck20 FIND v(dout1_27) AT=105.025n

* CHECK dout1_28 Vdout1_28ck20 = 0 time = 105
.meas tran vdout1_28ck20 FIND v(dout1_28) AT=105.025n

* CHECK dout1_29 Vdout1_29ck20 = 0 time = 105
.meas tran vdout1_29ck20 FIND v(dout1_29) AT=105.025n

* CHECK dout1_30 Vdout1_30ck20 = 0.9 time = 105
.meas tran vdout1_30ck20 FIND v(dout1_30) AT=105.025n

* CHECK dout1_31 Vdout1_31ck20 = 0 time = 105
.meas tran vdout1_31ck20 FIND v(dout1_31) AT=105.025n

* CHECK dout1_32 Vdout1_32ck20 = 0.9 time = 105
.meas tran vdout1_32ck20 FIND v(dout1_32) AT=105.025n

* CHECK dout1_33 Vdout1_33ck20 = 0 time = 105
.meas tran vdout1_33ck20 FIND v(dout1_33) AT=105.025n

* CHECK dout1_34 Vdout1_34ck20 = 0.9 time = 105
.meas tran vdout1_34ck20 FIND v(dout1_34) AT=105.025n

* CHECK dout1_35 Vdout1_35ck20 = 0.9 time = 105
.meas tran vdout1_35ck20 FIND v(dout1_35) AT=105.025n

* CHECK dout1_36 Vdout1_36ck20 = 0 time = 105
.meas tran vdout1_36ck20 FIND v(dout1_36) AT=105.025n

* CHECK dout1_37 Vdout1_37ck20 = 0.9 time = 105
.meas tran vdout1_37ck20 FIND v(dout1_37) AT=105.025n

* CHECK dout1_38 Vdout1_38ck20 = 0 time = 105
.meas tran vdout1_38ck20 FIND v(dout1_38) AT=105.025n

* CHECK dout1_39 Vdout1_39ck20 = 0.9 time = 105
.meas tran vdout1_39ck20 FIND v(dout1_39) AT=105.025n

* CHECK dout1_40 Vdout1_40ck20 = 0 time = 105
.meas tran vdout1_40ck20 FIND v(dout1_40) AT=105.025n

* CHECK dout1_41 Vdout1_41ck20 = 0 time = 105
.meas tran vdout1_41ck20 FIND v(dout1_41) AT=105.025n

* CHECK dout1_42 Vdout1_42ck20 = 0 time = 105
.meas tran vdout1_42ck20 FIND v(dout1_42) AT=105.025n

* CHECK dout1_43 Vdout1_43ck20 = 0.9 time = 105
.meas tran vdout1_43ck20 FIND v(dout1_43) AT=105.025n

* CHECK dout1_44 Vdout1_44ck20 = 0.9 time = 105
.meas tran vdout1_44ck20 FIND v(dout1_44) AT=105.025n

* CHECK dout1_45 Vdout1_45ck20 = 0 time = 105
.meas tran vdout1_45ck20 FIND v(dout1_45) AT=105.025n

* CHECK dout1_46 Vdout1_46ck20 = 0 time = 105
.meas tran vdout1_46ck20 FIND v(dout1_46) AT=105.025n

* CHECK dout1_47 Vdout1_47ck20 = 0 time = 105
.meas tran vdout1_47ck20 FIND v(dout1_47) AT=105.025n

* CHECK dout1_48 Vdout1_48ck20 = 0 time = 105
.meas tran vdout1_48ck20 FIND v(dout1_48) AT=105.025n

* CHECK dout1_49 Vdout1_49ck20 = 0 time = 105
.meas tran vdout1_49ck20 FIND v(dout1_49) AT=105.025n

* CHECK dout1_50 Vdout1_50ck20 = 0 time = 105
.meas tran vdout1_50ck20 FIND v(dout1_50) AT=105.025n

* CHECK dout1_51 Vdout1_51ck20 = 0 time = 105
.meas tran vdout1_51ck20 FIND v(dout1_51) AT=105.025n

* CHECK dout1_52 Vdout1_52ck20 = 0 time = 105
.meas tran vdout1_52ck20 FIND v(dout1_52) AT=105.025n

* CHECK dout1_53 Vdout1_53ck20 = 0 time = 105
.meas tran vdout1_53ck20 FIND v(dout1_53) AT=105.025n

* CHECK dout1_54 Vdout1_54ck20 = 0 time = 105
.meas tran vdout1_54ck20 FIND v(dout1_54) AT=105.025n

* CHECK dout1_55 Vdout1_55ck20 = 0 time = 105
.meas tran vdout1_55ck20 FIND v(dout1_55) AT=105.025n

* CHECK dout1_56 Vdout1_56ck20 = 0 time = 105
.meas tran vdout1_56ck20 FIND v(dout1_56) AT=105.025n

* CHECK dout1_57 Vdout1_57ck20 = 0.9 time = 105
.meas tran vdout1_57ck20 FIND v(dout1_57) AT=105.025n

* CHECK dout1_58 Vdout1_58ck20 = 0.9 time = 105
.meas tran vdout1_58ck20 FIND v(dout1_58) AT=105.025n

* CHECK dout1_59 Vdout1_59ck20 = 0.9 time = 105
.meas tran vdout1_59ck20 FIND v(dout1_59) AT=105.025n

* CHECK dout1_60 Vdout1_60ck20 = 0 time = 105
.meas tran vdout1_60ck20 FIND v(dout1_60) AT=105.025n

* CHECK dout1_61 Vdout1_61ck20 = 0.9 time = 105
.meas tran vdout1_61ck20 FIND v(dout1_61) AT=105.025n

* CHECK dout1_62 Vdout1_62ck20 = 0 time = 105
.meas tran vdout1_62ck20 FIND v(dout1_62) AT=105.025n

* CHECK dout1_63 Vdout1_63ck20 = 0.9 time = 105
.meas tran vdout1_63ck20 FIND v(dout1_63) AT=105.025n

* CHECK dout1_64 Vdout1_64ck20 = 0.9 time = 105
.meas tran vdout1_64ck20 FIND v(dout1_64) AT=105.025n

* CHECK dout1_65 Vdout1_65ck20 = 0 time = 105
.meas tran vdout1_65ck20 FIND v(dout1_65) AT=105.025n

* CHECK dout1_66 Vdout1_66ck20 = 0.9 time = 105
.meas tran vdout1_66ck20 FIND v(dout1_66) AT=105.025n

* CHECK dout1_67 Vdout1_67ck20 = 0 time = 105
.meas tran vdout1_67ck20 FIND v(dout1_67) AT=105.025n

* CHECK dout1_68 Vdout1_68ck20 = 0.9 time = 105
.meas tran vdout1_68ck20 FIND v(dout1_68) AT=105.025n

* CHECK dout1_69 Vdout1_69ck20 = 0.9 time = 105
.meas tran vdout1_69ck20 FIND v(dout1_69) AT=105.025n

* CHECK dout1_70 Vdout1_70ck20 = 0 time = 105
.meas tran vdout1_70ck20 FIND v(dout1_70) AT=105.025n

* CHECK dout1_71 Vdout1_71ck20 = 0 time = 105
.meas tran vdout1_71ck20 FIND v(dout1_71) AT=105.025n

* CHECK dout1_0 Vdout1_0ck21 = 0.9 time = 110
.meas tran vdout1_0ck21 FIND v(dout1_0) AT=110.025n

* CHECK dout1_1 Vdout1_1ck21 = 0 time = 110
.meas tran vdout1_1ck21 FIND v(dout1_1) AT=110.025n

* CHECK dout1_2 Vdout1_2ck21 = 0 time = 110
.meas tran vdout1_2ck21 FIND v(dout1_2) AT=110.025n

* CHECK dout1_3 Vdout1_3ck21 = 0.9 time = 110
.meas tran vdout1_3ck21 FIND v(dout1_3) AT=110.025n

* CHECK dout1_4 Vdout1_4ck21 = 0.9 time = 110
.meas tran vdout1_4ck21 FIND v(dout1_4) AT=110.025n

* CHECK dout1_5 Vdout1_5ck21 = 0.9 time = 110
.meas tran vdout1_5ck21 FIND v(dout1_5) AT=110.025n

* CHECK dout1_6 Vdout1_6ck21 = 0 time = 110
.meas tran vdout1_6ck21 FIND v(dout1_6) AT=110.025n

* CHECK dout1_7 Vdout1_7ck21 = 0 time = 110
.meas tran vdout1_7ck21 FIND v(dout1_7) AT=110.025n

* CHECK dout1_8 Vdout1_8ck21 = 0 time = 110
.meas tran vdout1_8ck21 FIND v(dout1_8) AT=110.025n

* CHECK dout1_9 Vdout1_9ck21 = 0 time = 110
.meas tran vdout1_9ck21 FIND v(dout1_9) AT=110.025n

* CHECK dout1_10 Vdout1_10ck21 = 0 time = 110
.meas tran vdout1_10ck21 FIND v(dout1_10) AT=110.025n

* CHECK dout1_11 Vdout1_11ck21 = 0 time = 110
.meas tran vdout1_11ck21 FIND v(dout1_11) AT=110.025n

* CHECK dout1_12 Vdout1_12ck21 = 0.9 time = 110
.meas tran vdout1_12ck21 FIND v(dout1_12) AT=110.025n

* CHECK dout1_13 Vdout1_13ck21 = 0 time = 110
.meas tran vdout1_13ck21 FIND v(dout1_13) AT=110.025n

* CHECK dout1_14 Vdout1_14ck21 = 0.9 time = 110
.meas tran vdout1_14ck21 FIND v(dout1_14) AT=110.025n

* CHECK dout1_15 Vdout1_15ck21 = 0.9 time = 110
.meas tran vdout1_15ck21 FIND v(dout1_15) AT=110.025n

* CHECK dout1_16 Vdout1_16ck21 = 0.9 time = 110
.meas tran vdout1_16ck21 FIND v(dout1_16) AT=110.025n

* CHECK dout1_17 Vdout1_17ck21 = 0 time = 110
.meas tran vdout1_17ck21 FIND v(dout1_17) AT=110.025n

* CHECK dout1_18 Vdout1_18ck21 = 0 time = 110
.meas tran vdout1_18ck21 FIND v(dout1_18) AT=110.025n

* CHECK dout1_19 Vdout1_19ck21 = 0 time = 110
.meas tran vdout1_19ck21 FIND v(dout1_19) AT=110.025n

* CHECK dout1_20 Vdout1_20ck21 = 0 time = 110
.meas tran vdout1_20ck21 FIND v(dout1_20) AT=110.025n

* CHECK dout1_21 Vdout1_21ck21 = 0.9 time = 110
.meas tran vdout1_21ck21 FIND v(dout1_21) AT=110.025n

* CHECK dout1_22 Vdout1_22ck21 = 0.9 time = 110
.meas tran vdout1_22ck21 FIND v(dout1_22) AT=110.025n

* CHECK dout1_23 Vdout1_23ck21 = 0 time = 110
.meas tran vdout1_23ck21 FIND v(dout1_23) AT=110.025n

* CHECK dout1_24 Vdout1_24ck21 = 0.9 time = 110
.meas tran vdout1_24ck21 FIND v(dout1_24) AT=110.025n

* CHECK dout1_25 Vdout1_25ck21 = 0 time = 110
.meas tran vdout1_25ck21 FIND v(dout1_25) AT=110.025n

* CHECK dout1_26 Vdout1_26ck21 = 0 time = 110
.meas tran vdout1_26ck21 FIND v(dout1_26) AT=110.025n

* CHECK dout1_27 Vdout1_27ck21 = 0 time = 110
.meas tran vdout1_27ck21 FIND v(dout1_27) AT=110.025n

* CHECK dout1_28 Vdout1_28ck21 = 0.9 time = 110
.meas tran vdout1_28ck21 FIND v(dout1_28) AT=110.025n

* CHECK dout1_29 Vdout1_29ck21 = 0 time = 110
.meas tran vdout1_29ck21 FIND v(dout1_29) AT=110.025n

* CHECK dout1_30 Vdout1_30ck21 = 0.9 time = 110
.meas tran vdout1_30ck21 FIND v(dout1_30) AT=110.025n

* CHECK dout1_31 Vdout1_31ck21 = 0 time = 110
.meas tran vdout1_31ck21 FIND v(dout1_31) AT=110.025n

* CHECK dout1_32 Vdout1_32ck21 = 0 time = 110
.meas tran vdout1_32ck21 FIND v(dout1_32) AT=110.025n

* CHECK dout1_33 Vdout1_33ck21 = 0 time = 110
.meas tran vdout1_33ck21 FIND v(dout1_33) AT=110.025n

* CHECK dout1_34 Vdout1_34ck21 = 0 time = 110
.meas tran vdout1_34ck21 FIND v(dout1_34) AT=110.025n

* CHECK dout1_35 Vdout1_35ck21 = 0.9 time = 110
.meas tran vdout1_35ck21 FIND v(dout1_35) AT=110.025n

* CHECK dout1_36 Vdout1_36ck21 = 0 time = 110
.meas tran vdout1_36ck21 FIND v(dout1_36) AT=110.025n

* CHECK dout1_37 Vdout1_37ck21 = 0 time = 110
.meas tran vdout1_37ck21 FIND v(dout1_37) AT=110.025n

* CHECK dout1_38 Vdout1_38ck21 = 0.9 time = 110
.meas tran vdout1_38ck21 FIND v(dout1_38) AT=110.025n

* CHECK dout1_39 Vdout1_39ck21 = 0.9 time = 110
.meas tran vdout1_39ck21 FIND v(dout1_39) AT=110.025n

* CHECK dout1_40 Vdout1_40ck21 = 0.9 time = 110
.meas tran vdout1_40ck21 FIND v(dout1_40) AT=110.025n

* CHECK dout1_41 Vdout1_41ck21 = 0.9 time = 110
.meas tran vdout1_41ck21 FIND v(dout1_41) AT=110.025n

* CHECK dout1_42 Vdout1_42ck21 = 0 time = 110
.meas tran vdout1_42ck21 FIND v(dout1_42) AT=110.025n

* CHECK dout1_43 Vdout1_43ck21 = 0 time = 110
.meas tran vdout1_43ck21 FIND v(dout1_43) AT=110.025n

* CHECK dout1_44 Vdout1_44ck21 = 0.9 time = 110
.meas tran vdout1_44ck21 FIND v(dout1_44) AT=110.025n

* CHECK dout1_45 Vdout1_45ck21 = 0.9 time = 110
.meas tran vdout1_45ck21 FIND v(dout1_45) AT=110.025n

* CHECK dout1_46 Vdout1_46ck21 = 0 time = 110
.meas tran vdout1_46ck21 FIND v(dout1_46) AT=110.025n

* CHECK dout1_47 Vdout1_47ck21 = 0.9 time = 110
.meas tran vdout1_47ck21 FIND v(dout1_47) AT=110.025n

* CHECK dout1_48 Vdout1_48ck21 = 0 time = 110
.meas tran vdout1_48ck21 FIND v(dout1_48) AT=110.025n

* CHECK dout1_49 Vdout1_49ck21 = 0.9 time = 110
.meas tran vdout1_49ck21 FIND v(dout1_49) AT=110.025n

* CHECK dout1_50 Vdout1_50ck21 = 0.9 time = 110
.meas tran vdout1_50ck21 FIND v(dout1_50) AT=110.025n

* CHECK dout1_51 Vdout1_51ck21 = 0.9 time = 110
.meas tran vdout1_51ck21 FIND v(dout1_51) AT=110.025n

* CHECK dout1_52 Vdout1_52ck21 = 0.9 time = 110
.meas tran vdout1_52ck21 FIND v(dout1_52) AT=110.025n

* CHECK dout1_53 Vdout1_53ck21 = 0 time = 110
.meas tran vdout1_53ck21 FIND v(dout1_53) AT=110.025n

* CHECK dout1_54 Vdout1_54ck21 = 0 time = 110
.meas tran vdout1_54ck21 FIND v(dout1_54) AT=110.025n

* CHECK dout1_55 Vdout1_55ck21 = 0 time = 110
.meas tran vdout1_55ck21 FIND v(dout1_55) AT=110.025n

* CHECK dout1_56 Vdout1_56ck21 = 0.9 time = 110
.meas tran vdout1_56ck21 FIND v(dout1_56) AT=110.025n

* CHECK dout1_57 Vdout1_57ck21 = 0.9 time = 110
.meas tran vdout1_57ck21 FIND v(dout1_57) AT=110.025n

* CHECK dout1_58 Vdout1_58ck21 = 0.9 time = 110
.meas tran vdout1_58ck21 FIND v(dout1_58) AT=110.025n

* CHECK dout1_59 Vdout1_59ck21 = 0.9 time = 110
.meas tran vdout1_59ck21 FIND v(dout1_59) AT=110.025n

* CHECK dout1_60 Vdout1_60ck21 = 0 time = 110
.meas tran vdout1_60ck21 FIND v(dout1_60) AT=110.025n

* CHECK dout1_61 Vdout1_61ck21 = 0.9 time = 110
.meas tran vdout1_61ck21 FIND v(dout1_61) AT=110.025n

* CHECK dout1_62 Vdout1_62ck21 = 0.9 time = 110
.meas tran vdout1_62ck21 FIND v(dout1_62) AT=110.025n

* CHECK dout1_63 Vdout1_63ck21 = 0 time = 110
.meas tran vdout1_63ck21 FIND v(dout1_63) AT=110.025n

* CHECK dout1_64 Vdout1_64ck21 = 0 time = 110
.meas tran vdout1_64ck21 FIND v(dout1_64) AT=110.025n

* CHECK dout1_65 Vdout1_65ck21 = 0 time = 110
.meas tran vdout1_65ck21 FIND v(dout1_65) AT=110.025n

* CHECK dout1_66 Vdout1_66ck21 = 0 time = 110
.meas tran vdout1_66ck21 FIND v(dout1_66) AT=110.025n

* CHECK dout1_67 Vdout1_67ck21 = 0.9 time = 110
.meas tran vdout1_67ck21 FIND v(dout1_67) AT=110.025n

* CHECK dout1_68 Vdout1_68ck21 = 0.9 time = 110
.meas tran vdout1_68ck21 FIND v(dout1_68) AT=110.025n

* CHECK dout1_69 Vdout1_69ck21 = 0 time = 110
.meas tran vdout1_69ck21 FIND v(dout1_69) AT=110.025n

* CHECK dout1_70 Vdout1_70ck21 = 0 time = 110
.meas tran vdout1_70ck21 FIND v(dout1_70) AT=110.025n

* CHECK dout1_71 Vdout1_71ck21 = 0.9 time = 110
.meas tran vdout1_71ck21 FIND v(dout1_71) AT=110.025n

* CHECK dout1_0 Vdout1_0ck24 = 0.9 time = 125
.meas tran vdout1_0ck24 FIND v(dout1_0) AT=125.025n

* CHECK dout1_1 Vdout1_1ck24 = 0 time = 125
.meas tran vdout1_1ck24 FIND v(dout1_1) AT=125.025n

* CHECK dout1_2 Vdout1_2ck24 = 0.9 time = 125
.meas tran vdout1_2ck24 FIND v(dout1_2) AT=125.025n

* CHECK dout1_3 Vdout1_3ck24 = 0 time = 125
.meas tran vdout1_3ck24 FIND v(dout1_3) AT=125.025n

* CHECK dout1_4 Vdout1_4ck24 = 0 time = 125
.meas tran vdout1_4ck24 FIND v(dout1_4) AT=125.025n

* CHECK dout1_5 Vdout1_5ck24 = 0.9 time = 125
.meas tran vdout1_5ck24 FIND v(dout1_5) AT=125.025n

* CHECK dout1_6 Vdout1_6ck24 = 0.9 time = 125
.meas tran vdout1_6ck24 FIND v(dout1_6) AT=125.025n

* CHECK dout1_7 Vdout1_7ck24 = 0 time = 125
.meas tran vdout1_7ck24 FIND v(dout1_7) AT=125.025n

* CHECK dout1_8 Vdout1_8ck24 = 0 time = 125
.meas tran vdout1_8ck24 FIND v(dout1_8) AT=125.025n

* CHECK dout1_9 Vdout1_9ck24 = 0 time = 125
.meas tran vdout1_9ck24 FIND v(dout1_9) AT=125.025n

* CHECK dout1_10 Vdout1_10ck24 = 0.9 time = 125
.meas tran vdout1_10ck24 FIND v(dout1_10) AT=125.025n

* CHECK dout1_11 Vdout1_11ck24 = 0.9 time = 125
.meas tran vdout1_11ck24 FIND v(dout1_11) AT=125.025n

* CHECK dout1_12 Vdout1_12ck24 = 0.9 time = 125
.meas tran vdout1_12ck24 FIND v(dout1_12) AT=125.025n

* CHECK dout1_13 Vdout1_13ck24 = 0.9 time = 125
.meas tran vdout1_13ck24 FIND v(dout1_13) AT=125.025n

* CHECK dout1_14 Vdout1_14ck24 = 0.9 time = 125
.meas tran vdout1_14ck24 FIND v(dout1_14) AT=125.025n

* CHECK dout1_15 Vdout1_15ck24 = 0 time = 125
.meas tran vdout1_15ck24 FIND v(dout1_15) AT=125.025n

* CHECK dout1_16 Vdout1_16ck24 = 0 time = 125
.meas tran vdout1_16ck24 FIND v(dout1_16) AT=125.025n

* CHECK dout1_17 Vdout1_17ck24 = 0.9 time = 125
.meas tran vdout1_17ck24 FIND v(dout1_17) AT=125.025n

* CHECK dout1_18 Vdout1_18ck24 = 0.9 time = 125
.meas tran vdout1_18ck24 FIND v(dout1_18) AT=125.025n

* CHECK dout1_19 Vdout1_19ck24 = 0 time = 125
.meas tran vdout1_19ck24 FIND v(dout1_19) AT=125.025n

* CHECK dout1_20 Vdout1_20ck24 = 0 time = 125
.meas tran vdout1_20ck24 FIND v(dout1_20) AT=125.025n

* CHECK dout1_21 Vdout1_21ck24 = 0.9 time = 125
.meas tran vdout1_21ck24 FIND v(dout1_21) AT=125.025n

* CHECK dout1_22 Vdout1_22ck24 = 0.9 time = 125
.meas tran vdout1_22ck24 FIND v(dout1_22) AT=125.025n

* CHECK dout1_23 Vdout1_23ck24 = 0 time = 125
.meas tran vdout1_23ck24 FIND v(dout1_23) AT=125.025n

* CHECK dout1_24 Vdout1_24ck24 = 0.9 time = 125
.meas tran vdout1_24ck24 FIND v(dout1_24) AT=125.025n

* CHECK dout1_25 Vdout1_25ck24 = 0.9 time = 125
.meas tran vdout1_25ck24 FIND v(dout1_25) AT=125.025n

* CHECK dout1_26 Vdout1_26ck24 = 0.9 time = 125
.meas tran vdout1_26ck24 FIND v(dout1_26) AT=125.025n

* CHECK dout1_27 Vdout1_27ck24 = 0.9 time = 125
.meas tran vdout1_27ck24 FIND v(dout1_27) AT=125.025n

* CHECK dout1_28 Vdout1_28ck24 = 0 time = 125
.meas tran vdout1_28ck24 FIND v(dout1_28) AT=125.025n

* CHECK dout1_29 Vdout1_29ck24 = 0 time = 125
.meas tran vdout1_29ck24 FIND v(dout1_29) AT=125.025n

* CHECK dout1_30 Vdout1_30ck24 = 0 time = 125
.meas tran vdout1_30ck24 FIND v(dout1_30) AT=125.025n

* CHECK dout1_31 Vdout1_31ck24 = 0.9 time = 125
.meas tran vdout1_31ck24 FIND v(dout1_31) AT=125.025n

* CHECK dout1_32 Vdout1_32ck24 = 0.9 time = 125
.meas tran vdout1_32ck24 FIND v(dout1_32) AT=125.025n

* CHECK dout1_33 Vdout1_33ck24 = 0 time = 125
.meas tran vdout1_33ck24 FIND v(dout1_33) AT=125.025n

* CHECK dout1_34 Vdout1_34ck24 = 0.9 time = 125
.meas tran vdout1_34ck24 FIND v(dout1_34) AT=125.025n

* CHECK dout1_35 Vdout1_35ck24 = 0 time = 125
.meas tran vdout1_35ck24 FIND v(dout1_35) AT=125.025n

* CHECK dout1_36 Vdout1_36ck24 = 0.9 time = 125
.meas tran vdout1_36ck24 FIND v(dout1_36) AT=125.025n

* CHECK dout1_37 Vdout1_37ck24 = 0 time = 125
.meas tran vdout1_37ck24 FIND v(dout1_37) AT=125.025n

* CHECK dout1_38 Vdout1_38ck24 = 0 time = 125
.meas tran vdout1_38ck24 FIND v(dout1_38) AT=125.025n

* CHECK dout1_39 Vdout1_39ck24 = 0.9 time = 125
.meas tran vdout1_39ck24 FIND v(dout1_39) AT=125.025n

* CHECK dout1_40 Vdout1_40ck24 = 0 time = 125
.meas tran vdout1_40ck24 FIND v(dout1_40) AT=125.025n

* CHECK dout1_41 Vdout1_41ck24 = 0 time = 125
.meas tran vdout1_41ck24 FIND v(dout1_41) AT=125.025n

* CHECK dout1_42 Vdout1_42ck24 = 0 time = 125
.meas tran vdout1_42ck24 FIND v(dout1_42) AT=125.025n

* CHECK dout1_43 Vdout1_43ck24 = 0 time = 125
.meas tran vdout1_43ck24 FIND v(dout1_43) AT=125.025n

* CHECK dout1_44 Vdout1_44ck24 = 0 time = 125
.meas tran vdout1_44ck24 FIND v(dout1_44) AT=125.025n

* CHECK dout1_45 Vdout1_45ck24 = 0 time = 125
.meas tran vdout1_45ck24 FIND v(dout1_45) AT=125.025n

* CHECK dout1_46 Vdout1_46ck24 = 0.9 time = 125
.meas tran vdout1_46ck24 FIND v(dout1_46) AT=125.025n

* CHECK dout1_47 Vdout1_47ck24 = 0.9 time = 125
.meas tran vdout1_47ck24 FIND v(dout1_47) AT=125.025n

* CHECK dout1_48 Vdout1_48ck24 = 0.9 time = 125
.meas tran vdout1_48ck24 FIND v(dout1_48) AT=125.025n

* CHECK dout1_49 Vdout1_49ck24 = 0 time = 125
.meas tran vdout1_49ck24 FIND v(dout1_49) AT=125.025n

* CHECK dout1_50 Vdout1_50ck24 = 0 time = 125
.meas tran vdout1_50ck24 FIND v(dout1_50) AT=125.025n

* CHECK dout1_51 Vdout1_51ck24 = 0.9 time = 125
.meas tran vdout1_51ck24 FIND v(dout1_51) AT=125.025n

* CHECK dout1_52 Vdout1_52ck24 = 0 time = 125
.meas tran vdout1_52ck24 FIND v(dout1_52) AT=125.025n

* CHECK dout1_53 Vdout1_53ck24 = 0.9 time = 125
.meas tran vdout1_53ck24 FIND v(dout1_53) AT=125.025n

* CHECK dout1_54 Vdout1_54ck24 = 0.9 time = 125
.meas tran vdout1_54ck24 FIND v(dout1_54) AT=125.025n

* CHECK dout1_55 Vdout1_55ck24 = 0 time = 125
.meas tran vdout1_55ck24 FIND v(dout1_55) AT=125.025n

* CHECK dout1_56 Vdout1_56ck24 = 0.9 time = 125
.meas tran vdout1_56ck24 FIND v(dout1_56) AT=125.025n

* CHECK dout1_57 Vdout1_57ck24 = 0.9 time = 125
.meas tran vdout1_57ck24 FIND v(dout1_57) AT=125.025n

* CHECK dout1_58 Vdout1_58ck24 = 0 time = 125
.meas tran vdout1_58ck24 FIND v(dout1_58) AT=125.025n

* CHECK dout1_59 Vdout1_59ck24 = 0.9 time = 125
.meas tran vdout1_59ck24 FIND v(dout1_59) AT=125.025n

* CHECK dout1_60 Vdout1_60ck24 = 0 time = 125
.meas tran vdout1_60ck24 FIND v(dout1_60) AT=125.025n

* CHECK dout1_61 Vdout1_61ck24 = 0 time = 125
.meas tran vdout1_61ck24 FIND v(dout1_61) AT=125.025n

* CHECK dout1_62 Vdout1_62ck24 = 0 time = 125
.meas tran vdout1_62ck24 FIND v(dout1_62) AT=125.025n

* CHECK dout1_63 Vdout1_63ck24 = 0.9 time = 125
.meas tran vdout1_63ck24 FIND v(dout1_63) AT=125.025n

* CHECK dout1_64 Vdout1_64ck24 = 0 time = 125
.meas tran vdout1_64ck24 FIND v(dout1_64) AT=125.025n

* CHECK dout1_65 Vdout1_65ck24 = 0 time = 125
.meas tran vdout1_65ck24 FIND v(dout1_65) AT=125.025n

* CHECK dout1_66 Vdout1_66ck24 = 0.9 time = 125
.meas tran vdout1_66ck24 FIND v(dout1_66) AT=125.025n

* CHECK dout1_67 Vdout1_67ck24 = 0 time = 125
.meas tran vdout1_67ck24 FIND v(dout1_67) AT=125.025n

* CHECK dout1_68 Vdout1_68ck24 = 0 time = 125
.meas tran vdout1_68ck24 FIND v(dout1_68) AT=125.025n

* CHECK dout1_69 Vdout1_69ck24 = 0.9 time = 125
.meas tran vdout1_69ck24 FIND v(dout1_69) AT=125.025n

* CHECK dout1_70 Vdout1_70ck24 = 0.9 time = 125
.meas tran vdout1_70ck24 FIND v(dout1_70) AT=125.025n

* CHECK dout1_71 Vdout1_71ck24 = 0.9 time = 125
.meas tran vdout1_71ck24 FIND v(dout1_71) AT=125.025n

* CHECK dout1_0 Vdout1_0ck29 = 0.9 time = 150
.meas tran vdout1_0ck29 FIND v(dout1_0) AT=150.025n

* CHECK dout1_1 Vdout1_1ck29 = 0 time = 150
.meas tran vdout1_1ck29 FIND v(dout1_1) AT=150.025n

* CHECK dout1_2 Vdout1_2ck29 = 0.9 time = 150
.meas tran vdout1_2ck29 FIND v(dout1_2) AT=150.025n

* CHECK dout1_3 Vdout1_3ck29 = 0.9 time = 150
.meas tran vdout1_3ck29 FIND v(dout1_3) AT=150.025n

* CHECK dout1_4 Vdout1_4ck29 = 0.9 time = 150
.meas tran vdout1_4ck29 FIND v(dout1_4) AT=150.025n

* CHECK dout1_5 Vdout1_5ck29 = 0 time = 150
.meas tran vdout1_5ck29 FIND v(dout1_5) AT=150.025n

* CHECK dout1_6 Vdout1_6ck29 = 0.9 time = 150
.meas tran vdout1_6ck29 FIND v(dout1_6) AT=150.025n

* CHECK dout1_7 Vdout1_7ck29 = 0.9 time = 150
.meas tran vdout1_7ck29 FIND v(dout1_7) AT=150.025n

* CHECK dout1_8 Vdout1_8ck29 = 0.9 time = 150
.meas tran vdout1_8ck29 FIND v(dout1_8) AT=150.025n

* CHECK dout1_9 Vdout1_9ck29 = 0 time = 150
.meas tran vdout1_9ck29 FIND v(dout1_9) AT=150.025n

* CHECK dout1_10 Vdout1_10ck29 = 0 time = 150
.meas tran vdout1_10ck29 FIND v(dout1_10) AT=150.025n

* CHECK dout1_11 Vdout1_11ck29 = 0.9 time = 150
.meas tran vdout1_11ck29 FIND v(dout1_11) AT=150.025n

* CHECK dout1_12 Vdout1_12ck29 = 0.9 time = 150
.meas tran vdout1_12ck29 FIND v(dout1_12) AT=150.025n

* CHECK dout1_13 Vdout1_13ck29 = 0.9 time = 150
.meas tran vdout1_13ck29 FIND v(dout1_13) AT=150.025n

* CHECK dout1_14 Vdout1_14ck29 = 0 time = 150
.meas tran vdout1_14ck29 FIND v(dout1_14) AT=150.025n

* CHECK dout1_15 Vdout1_15ck29 = 0 time = 150
.meas tran vdout1_15ck29 FIND v(dout1_15) AT=150.025n

* CHECK dout1_16 Vdout1_16ck29 = 0.9 time = 150
.meas tran vdout1_16ck29 FIND v(dout1_16) AT=150.025n

* CHECK dout1_17 Vdout1_17ck29 = 0 time = 150
.meas tran vdout1_17ck29 FIND v(dout1_17) AT=150.025n

* CHECK dout1_18 Vdout1_18ck29 = 0 time = 150
.meas tran vdout1_18ck29 FIND v(dout1_18) AT=150.025n

* CHECK dout1_19 Vdout1_19ck29 = 0 time = 150
.meas tran vdout1_19ck29 FIND v(dout1_19) AT=150.025n

* CHECK dout1_20 Vdout1_20ck29 = 0 time = 150
.meas tran vdout1_20ck29 FIND v(dout1_20) AT=150.025n

* CHECK dout1_21 Vdout1_21ck29 = 0.9 time = 150
.meas tran vdout1_21ck29 FIND v(dout1_21) AT=150.025n

* CHECK dout1_22 Vdout1_22ck29 = 0.9 time = 150
.meas tran vdout1_22ck29 FIND v(dout1_22) AT=150.025n

* CHECK dout1_23 Vdout1_23ck29 = 0.9 time = 150
.meas tran vdout1_23ck29 FIND v(dout1_23) AT=150.025n

* CHECK dout1_24 Vdout1_24ck29 = 0 time = 150
.meas tran vdout1_24ck29 FIND v(dout1_24) AT=150.025n

* CHECK dout1_25 Vdout1_25ck29 = 0.9 time = 150
.meas tran vdout1_25ck29 FIND v(dout1_25) AT=150.025n

* CHECK dout1_26 Vdout1_26ck29 = 0 time = 150
.meas tran vdout1_26ck29 FIND v(dout1_26) AT=150.025n

* CHECK dout1_27 Vdout1_27ck29 = 0.9 time = 150
.meas tran vdout1_27ck29 FIND v(dout1_27) AT=150.025n

* CHECK dout1_28 Vdout1_28ck29 = 0.9 time = 150
.meas tran vdout1_28ck29 FIND v(dout1_28) AT=150.025n

* CHECK dout1_29 Vdout1_29ck29 = 0 time = 150
.meas tran vdout1_29ck29 FIND v(dout1_29) AT=150.025n

* CHECK dout1_30 Vdout1_30ck29 = 0 time = 150
.meas tran vdout1_30ck29 FIND v(dout1_30) AT=150.025n

* CHECK dout1_31 Vdout1_31ck29 = 0 time = 150
.meas tran vdout1_31ck29 FIND v(dout1_31) AT=150.025n

* CHECK dout1_32 Vdout1_32ck29 = 0.9 time = 150
.meas tran vdout1_32ck29 FIND v(dout1_32) AT=150.025n

* CHECK dout1_33 Vdout1_33ck29 = 0.9 time = 150
.meas tran vdout1_33ck29 FIND v(dout1_33) AT=150.025n

* CHECK dout1_34 Vdout1_34ck29 = 0 time = 150
.meas tran vdout1_34ck29 FIND v(dout1_34) AT=150.025n

* CHECK dout1_35 Vdout1_35ck29 = 0 time = 150
.meas tran vdout1_35ck29 FIND v(dout1_35) AT=150.025n

* CHECK dout1_36 Vdout1_36ck29 = 0.9 time = 150
.meas tran vdout1_36ck29 FIND v(dout1_36) AT=150.025n

* CHECK dout1_37 Vdout1_37ck29 = 0 time = 150
.meas tran vdout1_37ck29 FIND v(dout1_37) AT=150.025n

* CHECK dout1_38 Vdout1_38ck29 = 0 time = 150
.meas tran vdout1_38ck29 FIND v(dout1_38) AT=150.025n

* CHECK dout1_39 Vdout1_39ck29 = 0 time = 150
.meas tran vdout1_39ck29 FIND v(dout1_39) AT=150.025n

* CHECK dout1_40 Vdout1_40ck29 = 0 time = 150
.meas tran vdout1_40ck29 FIND v(dout1_40) AT=150.025n

* CHECK dout1_41 Vdout1_41ck29 = 0.9 time = 150
.meas tran vdout1_41ck29 FIND v(dout1_41) AT=150.025n

* CHECK dout1_42 Vdout1_42ck29 = 0 time = 150
.meas tran vdout1_42ck29 FIND v(dout1_42) AT=150.025n

* CHECK dout1_43 Vdout1_43ck29 = 0.9 time = 150
.meas tran vdout1_43ck29 FIND v(dout1_43) AT=150.025n

* CHECK dout1_44 Vdout1_44ck29 = 0.9 time = 150
.meas tran vdout1_44ck29 FIND v(dout1_44) AT=150.025n

* CHECK dout1_45 Vdout1_45ck29 = 0.9 time = 150
.meas tran vdout1_45ck29 FIND v(dout1_45) AT=150.025n

* CHECK dout1_46 Vdout1_46ck29 = 0.9 time = 150
.meas tran vdout1_46ck29 FIND v(dout1_46) AT=150.025n

* CHECK dout1_47 Vdout1_47ck29 = 0 time = 150
.meas tran vdout1_47ck29 FIND v(dout1_47) AT=150.025n

* CHECK dout1_48 Vdout1_48ck29 = 0.9 time = 150
.meas tran vdout1_48ck29 FIND v(dout1_48) AT=150.025n

* CHECK dout1_49 Vdout1_49ck29 = 0.9 time = 150
.meas tran vdout1_49ck29 FIND v(dout1_49) AT=150.025n

* CHECK dout1_50 Vdout1_50ck29 = 0 time = 150
.meas tran vdout1_50ck29 FIND v(dout1_50) AT=150.025n

* CHECK dout1_51 Vdout1_51ck29 = 0 time = 150
.meas tran vdout1_51ck29 FIND v(dout1_51) AT=150.025n

* CHECK dout1_52 Vdout1_52ck29 = 0 time = 150
.meas tran vdout1_52ck29 FIND v(dout1_52) AT=150.025n

* CHECK dout1_53 Vdout1_53ck29 = 0.9 time = 150
.meas tran vdout1_53ck29 FIND v(dout1_53) AT=150.025n

* CHECK dout1_54 Vdout1_54ck29 = 0.9 time = 150
.meas tran vdout1_54ck29 FIND v(dout1_54) AT=150.025n

* CHECK dout1_55 Vdout1_55ck29 = 0 time = 150
.meas tran vdout1_55ck29 FIND v(dout1_55) AT=150.025n

* CHECK dout1_56 Vdout1_56ck29 = 0 time = 150
.meas tran vdout1_56ck29 FIND v(dout1_56) AT=150.025n

* CHECK dout1_57 Vdout1_57ck29 = 0 time = 150
.meas tran vdout1_57ck29 FIND v(dout1_57) AT=150.025n

* CHECK dout1_58 Vdout1_58ck29 = 0.9 time = 150
.meas tran vdout1_58ck29 FIND v(dout1_58) AT=150.025n

* CHECK dout1_59 Vdout1_59ck29 = 0.9 time = 150
.meas tran vdout1_59ck29 FIND v(dout1_59) AT=150.025n

* CHECK dout1_60 Vdout1_60ck29 = 0.9 time = 150
.meas tran vdout1_60ck29 FIND v(dout1_60) AT=150.025n

* CHECK dout1_61 Vdout1_61ck29 = 0 time = 150
.meas tran vdout1_61ck29 FIND v(dout1_61) AT=150.025n

* CHECK dout1_62 Vdout1_62ck29 = 0 time = 150
.meas tran vdout1_62ck29 FIND v(dout1_62) AT=150.025n

* CHECK dout1_63 Vdout1_63ck29 = 0.9 time = 150
.meas tran vdout1_63ck29 FIND v(dout1_63) AT=150.025n

* CHECK dout1_64 Vdout1_64ck29 = 0.9 time = 150
.meas tran vdout1_64ck29 FIND v(dout1_64) AT=150.025n

* CHECK dout1_65 Vdout1_65ck29 = 0 time = 150
.meas tran vdout1_65ck29 FIND v(dout1_65) AT=150.025n

* CHECK dout1_66 Vdout1_66ck29 = 0 time = 150
.meas tran vdout1_66ck29 FIND v(dout1_66) AT=150.025n

* CHECK dout1_67 Vdout1_67ck29 = 0 time = 150
.meas tran vdout1_67ck29 FIND v(dout1_67) AT=150.025n

* CHECK dout1_68 Vdout1_68ck29 = 0 time = 150
.meas tran vdout1_68ck29 FIND v(dout1_68) AT=150.025n

* CHECK dout1_69 Vdout1_69ck29 = 0.9 time = 150
.meas tran vdout1_69ck29 FIND v(dout1_69) AT=150.025n

* CHECK dout1_70 Vdout1_70ck29 = 0 time = 150
.meas tran vdout1_70ck29 FIND v(dout1_70) AT=150.025n

* CHECK dout1_71 Vdout1_71ck29 = 0 time = 150
.meas tran vdout1_71ck29 FIND v(dout1_71) AT=150.025n

* CHECK dout1_0 Vdout1_0ck31 = 0 time = 160
.meas tran vdout1_0ck31 FIND v(dout1_0) AT=160.025n

* CHECK dout1_1 Vdout1_1ck31 = 0.9 time = 160
.meas tran vdout1_1ck31 FIND v(dout1_1) AT=160.025n

* CHECK dout1_2 Vdout1_2ck31 = 0.9 time = 160
.meas tran vdout1_2ck31 FIND v(dout1_2) AT=160.025n

* CHECK dout1_3 Vdout1_3ck31 = 0 time = 160
.meas tran vdout1_3ck31 FIND v(dout1_3) AT=160.025n

* CHECK dout1_4 Vdout1_4ck31 = 0.9 time = 160
.meas tran vdout1_4ck31 FIND v(dout1_4) AT=160.025n

* CHECK dout1_5 Vdout1_5ck31 = 0 time = 160
.meas tran vdout1_5ck31 FIND v(dout1_5) AT=160.025n

* CHECK dout1_6 Vdout1_6ck31 = 0 time = 160
.meas tran vdout1_6ck31 FIND v(dout1_6) AT=160.025n

* CHECK dout1_7 Vdout1_7ck31 = 0.9 time = 160
.meas tran vdout1_7ck31 FIND v(dout1_7) AT=160.025n

* CHECK dout1_8 Vdout1_8ck31 = 0 time = 160
.meas tran vdout1_8ck31 FIND v(dout1_8) AT=160.025n

* CHECK dout1_9 Vdout1_9ck31 = 0 time = 160
.meas tran vdout1_9ck31 FIND v(dout1_9) AT=160.025n

* CHECK dout1_10 Vdout1_10ck31 = 0.9 time = 160
.meas tran vdout1_10ck31 FIND v(dout1_10) AT=160.025n

* CHECK dout1_11 Vdout1_11ck31 = 0.9 time = 160
.meas tran vdout1_11ck31 FIND v(dout1_11) AT=160.025n

* CHECK dout1_12 Vdout1_12ck31 = 0.9 time = 160
.meas tran vdout1_12ck31 FIND v(dout1_12) AT=160.025n

* CHECK dout1_13 Vdout1_13ck31 = 0.9 time = 160
.meas tran vdout1_13ck31 FIND v(dout1_13) AT=160.025n

* CHECK dout1_14 Vdout1_14ck31 = 0.9 time = 160
.meas tran vdout1_14ck31 FIND v(dout1_14) AT=160.025n

* CHECK dout1_15 Vdout1_15ck31 = 0.9 time = 160
.meas tran vdout1_15ck31 FIND v(dout1_15) AT=160.025n

* CHECK dout1_16 Vdout1_16ck31 = 0.9 time = 160
.meas tran vdout1_16ck31 FIND v(dout1_16) AT=160.025n

* CHECK dout1_17 Vdout1_17ck31 = 0 time = 160
.meas tran vdout1_17ck31 FIND v(dout1_17) AT=160.025n

* CHECK dout1_18 Vdout1_18ck31 = 0 time = 160
.meas tran vdout1_18ck31 FIND v(dout1_18) AT=160.025n

* CHECK dout1_19 Vdout1_19ck31 = 0.9 time = 160
.meas tran vdout1_19ck31 FIND v(dout1_19) AT=160.025n

* CHECK dout1_20 Vdout1_20ck31 = 0 time = 160
.meas tran vdout1_20ck31 FIND v(dout1_20) AT=160.025n

* CHECK dout1_21 Vdout1_21ck31 = 0 time = 160
.meas tran vdout1_21ck31 FIND v(dout1_21) AT=160.025n

* CHECK dout1_22 Vdout1_22ck31 = 0.9 time = 160
.meas tran vdout1_22ck31 FIND v(dout1_22) AT=160.025n

* CHECK dout1_23 Vdout1_23ck31 = 0 time = 160
.meas tran vdout1_23ck31 FIND v(dout1_23) AT=160.025n

* CHECK dout1_24 Vdout1_24ck31 = 0 time = 160
.meas tran vdout1_24ck31 FIND v(dout1_24) AT=160.025n

* CHECK dout1_25 Vdout1_25ck31 = 0 time = 160
.meas tran vdout1_25ck31 FIND v(dout1_25) AT=160.025n

* CHECK dout1_26 Vdout1_26ck31 = 0 time = 160
.meas tran vdout1_26ck31 FIND v(dout1_26) AT=160.025n

* CHECK dout1_27 Vdout1_27ck31 = 0 time = 160
.meas tran vdout1_27ck31 FIND v(dout1_27) AT=160.025n

* CHECK dout1_28 Vdout1_28ck31 = 0 time = 160
.meas tran vdout1_28ck31 FIND v(dout1_28) AT=160.025n

* CHECK dout1_29 Vdout1_29ck31 = 0.9 time = 160
.meas tran vdout1_29ck31 FIND v(dout1_29) AT=160.025n

* CHECK dout1_30 Vdout1_30ck31 = 0 time = 160
.meas tran vdout1_30ck31 FIND v(dout1_30) AT=160.025n

* CHECK dout1_31 Vdout1_31ck31 = 0.9 time = 160
.meas tran vdout1_31ck31 FIND v(dout1_31) AT=160.025n

* CHECK dout1_32 Vdout1_32ck31 = 0.9 time = 160
.meas tran vdout1_32ck31 FIND v(dout1_32) AT=160.025n

* CHECK dout1_33 Vdout1_33ck31 = 0 time = 160
.meas tran vdout1_33ck31 FIND v(dout1_33) AT=160.025n

* CHECK dout1_34 Vdout1_34ck31 = 0.9 time = 160
.meas tran vdout1_34ck31 FIND v(dout1_34) AT=160.025n

* CHECK dout1_35 Vdout1_35ck31 = 0 time = 160
.meas tran vdout1_35ck31 FIND v(dout1_35) AT=160.025n

* CHECK dout1_36 Vdout1_36ck31 = 0 time = 160
.meas tran vdout1_36ck31 FIND v(dout1_36) AT=160.025n

* CHECK dout1_37 Vdout1_37ck31 = 0.9 time = 160
.meas tran vdout1_37ck31 FIND v(dout1_37) AT=160.025n

* CHECK dout1_38 Vdout1_38ck31 = 0.9 time = 160
.meas tran vdout1_38ck31 FIND v(dout1_38) AT=160.025n

* CHECK dout1_39 Vdout1_39ck31 = 0 time = 160
.meas tran vdout1_39ck31 FIND v(dout1_39) AT=160.025n

* CHECK dout1_40 Vdout1_40ck31 = 0 time = 160
.meas tran vdout1_40ck31 FIND v(dout1_40) AT=160.025n

* CHECK dout1_41 Vdout1_41ck31 = 0.9 time = 160
.meas tran vdout1_41ck31 FIND v(dout1_41) AT=160.025n

* CHECK dout1_42 Vdout1_42ck31 = 0.9 time = 160
.meas tran vdout1_42ck31 FIND v(dout1_42) AT=160.025n

* CHECK dout1_43 Vdout1_43ck31 = 0.9 time = 160
.meas tran vdout1_43ck31 FIND v(dout1_43) AT=160.025n

* CHECK dout1_44 Vdout1_44ck31 = 0 time = 160
.meas tran vdout1_44ck31 FIND v(dout1_44) AT=160.025n

* CHECK dout1_45 Vdout1_45ck31 = 0.9 time = 160
.meas tran vdout1_45ck31 FIND v(dout1_45) AT=160.025n

* CHECK dout1_46 Vdout1_46ck31 = 0 time = 160
.meas tran vdout1_46ck31 FIND v(dout1_46) AT=160.025n

* CHECK dout1_47 Vdout1_47ck31 = 0 time = 160
.meas tran vdout1_47ck31 FIND v(dout1_47) AT=160.025n

* CHECK dout1_48 Vdout1_48ck31 = 0.9 time = 160
.meas tran vdout1_48ck31 FIND v(dout1_48) AT=160.025n

* CHECK dout1_49 Vdout1_49ck31 = 0.9 time = 160
.meas tran vdout1_49ck31 FIND v(dout1_49) AT=160.025n

* CHECK dout1_50 Vdout1_50ck31 = 0.9 time = 160
.meas tran vdout1_50ck31 FIND v(dout1_50) AT=160.025n

* CHECK dout1_51 Vdout1_51ck31 = 0 time = 160
.meas tran vdout1_51ck31 FIND v(dout1_51) AT=160.025n

* CHECK dout1_52 Vdout1_52ck31 = 0 time = 160
.meas tran vdout1_52ck31 FIND v(dout1_52) AT=160.025n

* CHECK dout1_53 Vdout1_53ck31 = 0 time = 160
.meas tran vdout1_53ck31 FIND v(dout1_53) AT=160.025n

* CHECK dout1_54 Vdout1_54ck31 = 0.9 time = 160
.meas tran vdout1_54ck31 FIND v(dout1_54) AT=160.025n

* CHECK dout1_55 Vdout1_55ck31 = 0.9 time = 160
.meas tran vdout1_55ck31 FIND v(dout1_55) AT=160.025n

* CHECK dout1_56 Vdout1_56ck31 = 0.9 time = 160
.meas tran vdout1_56ck31 FIND v(dout1_56) AT=160.025n

* CHECK dout1_57 Vdout1_57ck31 = 0.9 time = 160
.meas tran vdout1_57ck31 FIND v(dout1_57) AT=160.025n

* CHECK dout1_58 Vdout1_58ck31 = 0 time = 160
.meas tran vdout1_58ck31 FIND v(dout1_58) AT=160.025n

* CHECK dout1_59 Vdout1_59ck31 = 0.9 time = 160
.meas tran vdout1_59ck31 FIND v(dout1_59) AT=160.025n

* CHECK dout1_60 Vdout1_60ck31 = 0.9 time = 160
.meas tran vdout1_60ck31 FIND v(dout1_60) AT=160.025n

* CHECK dout1_61 Vdout1_61ck31 = 0 time = 160
.meas tran vdout1_61ck31 FIND v(dout1_61) AT=160.025n

* CHECK dout1_62 Vdout1_62ck31 = 0.9 time = 160
.meas tran vdout1_62ck31 FIND v(dout1_62) AT=160.025n

* CHECK dout1_63 Vdout1_63ck31 = 0 time = 160
.meas tran vdout1_63ck31 FIND v(dout1_63) AT=160.025n

* CHECK dout1_64 Vdout1_64ck31 = 0.9 time = 160
.meas tran vdout1_64ck31 FIND v(dout1_64) AT=160.025n

* CHECK dout1_65 Vdout1_65ck31 = 0.9 time = 160
.meas tran vdout1_65ck31 FIND v(dout1_65) AT=160.025n

* CHECK dout1_66 Vdout1_66ck31 = 0 time = 160
.meas tran vdout1_66ck31 FIND v(dout1_66) AT=160.025n

* CHECK dout1_67 Vdout1_67ck31 = 0.9 time = 160
.meas tran vdout1_67ck31 FIND v(dout1_67) AT=160.025n

* CHECK dout1_68 Vdout1_68ck31 = 0 time = 160
.meas tran vdout1_68ck31 FIND v(dout1_68) AT=160.025n

* CHECK dout1_69 Vdout1_69ck31 = 0.9 time = 160
.meas tran vdout1_69ck31 FIND v(dout1_69) AT=160.025n

* CHECK dout1_70 Vdout1_70ck31 = 0 time = 160
.meas tran vdout1_70ck31 FIND v(dout1_70) AT=160.025n

* CHECK dout1_71 Vdout1_71ck31 = 0.9 time = 160
.meas tran vdout1_71ck31 FIND v(dout1_71) AT=160.025n

* CHECK dout1_0 Vdout1_0ck32 = 0 time = 165
.meas tran vdout1_0ck32 FIND v(dout1_0) AT=165.025n

* CHECK dout1_1 Vdout1_1ck32 = 0.9 time = 165
.meas tran vdout1_1ck32 FIND v(dout1_1) AT=165.025n

* CHECK dout1_2 Vdout1_2ck32 = 0.9 time = 165
.meas tran vdout1_2ck32 FIND v(dout1_2) AT=165.025n

* CHECK dout1_3 Vdout1_3ck32 = 0 time = 165
.meas tran vdout1_3ck32 FIND v(dout1_3) AT=165.025n

* CHECK dout1_4 Vdout1_4ck32 = 0.9 time = 165
.meas tran vdout1_4ck32 FIND v(dout1_4) AT=165.025n

* CHECK dout1_5 Vdout1_5ck32 = 0 time = 165
.meas tran vdout1_5ck32 FIND v(dout1_5) AT=165.025n

* CHECK dout1_6 Vdout1_6ck32 = 0.9 time = 165
.meas tran vdout1_6ck32 FIND v(dout1_6) AT=165.025n

* CHECK dout1_7 Vdout1_7ck32 = 0 time = 165
.meas tran vdout1_7ck32 FIND v(dout1_7) AT=165.025n

* CHECK dout1_8 Vdout1_8ck32 = 0 time = 165
.meas tran vdout1_8ck32 FIND v(dout1_8) AT=165.025n

* CHECK dout1_9 Vdout1_9ck32 = 0.9 time = 165
.meas tran vdout1_9ck32 FIND v(dout1_9) AT=165.025n

* CHECK dout1_10 Vdout1_10ck32 = 0 time = 165
.meas tran vdout1_10ck32 FIND v(dout1_10) AT=165.025n

* CHECK dout1_11 Vdout1_11ck32 = 0.9 time = 165
.meas tran vdout1_11ck32 FIND v(dout1_11) AT=165.025n

* CHECK dout1_12 Vdout1_12ck32 = 0 time = 165
.meas tran vdout1_12ck32 FIND v(dout1_12) AT=165.025n

* CHECK dout1_13 Vdout1_13ck32 = 0 time = 165
.meas tran vdout1_13ck32 FIND v(dout1_13) AT=165.025n

* CHECK dout1_14 Vdout1_14ck32 = 0 time = 165
.meas tran vdout1_14ck32 FIND v(dout1_14) AT=165.025n

* CHECK dout1_15 Vdout1_15ck32 = 0.9 time = 165
.meas tran vdout1_15ck32 FIND v(dout1_15) AT=165.025n

* CHECK dout1_16 Vdout1_16ck32 = 0.9 time = 165
.meas tran vdout1_16ck32 FIND v(dout1_16) AT=165.025n

* CHECK dout1_17 Vdout1_17ck32 = 0 time = 165
.meas tran vdout1_17ck32 FIND v(dout1_17) AT=165.025n

* CHECK dout1_18 Vdout1_18ck32 = 0 time = 165
.meas tran vdout1_18ck32 FIND v(dout1_18) AT=165.025n

* CHECK dout1_19 Vdout1_19ck32 = 0 time = 165
.meas tran vdout1_19ck32 FIND v(dout1_19) AT=165.025n

* CHECK dout1_20 Vdout1_20ck32 = 0.9 time = 165
.meas tran vdout1_20ck32 FIND v(dout1_20) AT=165.025n

* CHECK dout1_21 Vdout1_21ck32 = 0.9 time = 165
.meas tran vdout1_21ck32 FIND v(dout1_21) AT=165.025n

* CHECK dout1_22 Vdout1_22ck32 = 0 time = 165
.meas tran vdout1_22ck32 FIND v(dout1_22) AT=165.025n

* CHECK dout1_23 Vdout1_23ck32 = 0.9 time = 165
.meas tran vdout1_23ck32 FIND v(dout1_23) AT=165.025n

* CHECK dout1_24 Vdout1_24ck32 = 0.9 time = 165
.meas tran vdout1_24ck32 FIND v(dout1_24) AT=165.025n

* CHECK dout1_25 Vdout1_25ck32 = 0.9 time = 165
.meas tran vdout1_25ck32 FIND v(dout1_25) AT=165.025n

* CHECK dout1_26 Vdout1_26ck32 = 0.9 time = 165
.meas tran vdout1_26ck32 FIND v(dout1_26) AT=165.025n

* CHECK dout1_27 Vdout1_27ck32 = 0 time = 165
.meas tran vdout1_27ck32 FIND v(dout1_27) AT=165.025n

* CHECK dout1_28 Vdout1_28ck32 = 0.9 time = 165
.meas tran vdout1_28ck32 FIND v(dout1_28) AT=165.025n

* CHECK dout1_29 Vdout1_29ck32 = 0 time = 165
.meas tran vdout1_29ck32 FIND v(dout1_29) AT=165.025n

* CHECK dout1_30 Vdout1_30ck32 = 0 time = 165
.meas tran vdout1_30ck32 FIND v(dout1_30) AT=165.025n

* CHECK dout1_31 Vdout1_31ck32 = 0 time = 165
.meas tran vdout1_31ck32 FIND v(dout1_31) AT=165.025n

* CHECK dout1_32 Vdout1_32ck32 = 0 time = 165
.meas tran vdout1_32ck32 FIND v(dout1_32) AT=165.025n

* CHECK dout1_33 Vdout1_33ck32 = 0 time = 165
.meas tran vdout1_33ck32 FIND v(dout1_33) AT=165.025n

* CHECK dout1_34 Vdout1_34ck32 = 0 time = 165
.meas tran vdout1_34ck32 FIND v(dout1_34) AT=165.025n

* CHECK dout1_35 Vdout1_35ck32 = 0.9 time = 165
.meas tran vdout1_35ck32 FIND v(dout1_35) AT=165.025n

* CHECK dout1_36 Vdout1_36ck32 = 0.9 time = 165
.meas tran vdout1_36ck32 FIND v(dout1_36) AT=165.025n

* CHECK dout1_37 Vdout1_37ck32 = 0.9 time = 165
.meas tran vdout1_37ck32 FIND v(dout1_37) AT=165.025n

* CHECK dout1_38 Vdout1_38ck32 = 0.9 time = 165
.meas tran vdout1_38ck32 FIND v(dout1_38) AT=165.025n

* CHECK dout1_39 Vdout1_39ck32 = 0 time = 165
.meas tran vdout1_39ck32 FIND v(dout1_39) AT=165.025n

* CHECK dout1_40 Vdout1_40ck32 = 0 time = 165
.meas tran vdout1_40ck32 FIND v(dout1_40) AT=165.025n

* CHECK dout1_41 Vdout1_41ck32 = 0.9 time = 165
.meas tran vdout1_41ck32 FIND v(dout1_41) AT=165.025n

* CHECK dout1_42 Vdout1_42ck32 = 0.9 time = 165
.meas tran vdout1_42ck32 FIND v(dout1_42) AT=165.025n

* CHECK dout1_43 Vdout1_43ck32 = 0.9 time = 165
.meas tran vdout1_43ck32 FIND v(dout1_43) AT=165.025n

* CHECK dout1_44 Vdout1_44ck32 = 0 time = 165
.meas tran vdout1_44ck32 FIND v(dout1_44) AT=165.025n

* CHECK dout1_45 Vdout1_45ck32 = 0 time = 165
.meas tran vdout1_45ck32 FIND v(dout1_45) AT=165.025n

* CHECK dout1_46 Vdout1_46ck32 = 0 time = 165
.meas tran vdout1_46ck32 FIND v(dout1_46) AT=165.025n

* CHECK dout1_47 Vdout1_47ck32 = 0.9 time = 165
.meas tran vdout1_47ck32 FIND v(dout1_47) AT=165.025n

* CHECK dout1_48 Vdout1_48ck32 = 0.9 time = 165
.meas tran vdout1_48ck32 FIND v(dout1_48) AT=165.025n

* CHECK dout1_49 Vdout1_49ck32 = 0.9 time = 165
.meas tran vdout1_49ck32 FIND v(dout1_49) AT=165.025n

* CHECK dout1_50 Vdout1_50ck32 = 0.9 time = 165
.meas tran vdout1_50ck32 FIND v(dout1_50) AT=165.025n

* CHECK dout1_51 Vdout1_51ck32 = 0.9 time = 165
.meas tran vdout1_51ck32 FIND v(dout1_51) AT=165.025n

* CHECK dout1_52 Vdout1_52ck32 = 0.9 time = 165
.meas tran vdout1_52ck32 FIND v(dout1_52) AT=165.025n

* CHECK dout1_53 Vdout1_53ck32 = 0.9 time = 165
.meas tran vdout1_53ck32 FIND v(dout1_53) AT=165.025n

* CHECK dout1_54 Vdout1_54ck32 = 0 time = 165
.meas tran vdout1_54ck32 FIND v(dout1_54) AT=165.025n

* CHECK dout1_55 Vdout1_55ck32 = 0 time = 165
.meas tran vdout1_55ck32 FIND v(dout1_55) AT=165.025n

* CHECK dout1_56 Vdout1_56ck32 = 0 time = 165
.meas tran vdout1_56ck32 FIND v(dout1_56) AT=165.025n

* CHECK dout1_57 Vdout1_57ck32 = 0 time = 165
.meas tran vdout1_57ck32 FIND v(dout1_57) AT=165.025n

* CHECK dout1_58 Vdout1_58ck32 = 0.9 time = 165
.meas tran vdout1_58ck32 FIND v(dout1_58) AT=165.025n

* CHECK dout1_59 Vdout1_59ck32 = 0.9 time = 165
.meas tran vdout1_59ck32 FIND v(dout1_59) AT=165.025n

* CHECK dout1_60 Vdout1_60ck32 = 0.9 time = 165
.meas tran vdout1_60ck32 FIND v(dout1_60) AT=165.025n

* CHECK dout1_61 Vdout1_61ck32 = 0 time = 165
.meas tran vdout1_61ck32 FIND v(dout1_61) AT=165.025n

* CHECK dout1_62 Vdout1_62ck32 = 0 time = 165
.meas tran vdout1_62ck32 FIND v(dout1_62) AT=165.025n

* CHECK dout1_63 Vdout1_63ck32 = 0.9 time = 165
.meas tran vdout1_63ck32 FIND v(dout1_63) AT=165.025n

* CHECK dout1_64 Vdout1_64ck32 = 0 time = 165
.meas tran vdout1_64ck32 FIND v(dout1_64) AT=165.025n

* CHECK dout1_65 Vdout1_65ck32 = 0.9 time = 165
.meas tran vdout1_65ck32 FIND v(dout1_65) AT=165.025n

* CHECK dout1_66 Vdout1_66ck32 = 0.9 time = 165
.meas tran vdout1_66ck32 FIND v(dout1_66) AT=165.025n

* CHECK dout1_67 Vdout1_67ck32 = 0.9 time = 165
.meas tran vdout1_67ck32 FIND v(dout1_67) AT=165.025n

* CHECK dout1_68 Vdout1_68ck32 = 0 time = 165
.meas tran vdout1_68ck32 FIND v(dout1_68) AT=165.025n

* CHECK dout1_69 Vdout1_69ck32 = 0.9 time = 165
.meas tran vdout1_69ck32 FIND v(dout1_69) AT=165.025n

* CHECK dout1_70 Vdout1_70ck32 = 0.9 time = 165
.meas tran vdout1_70ck32 FIND v(dout1_70) AT=165.025n

* CHECK dout1_71 Vdout1_71ck32 = 0 time = 165
.meas tran vdout1_71ck32 FIND v(dout1_71) AT=165.025n

* CHECK dout1_0 Vdout1_0ck44 = 0 time = 225
.meas tran vdout1_0ck44 FIND v(dout1_0) AT=225.025n

* CHECK dout1_1 Vdout1_1ck44 = 0 time = 225
.meas tran vdout1_1ck44 FIND v(dout1_1) AT=225.025n

* CHECK dout1_2 Vdout1_2ck44 = 0.9 time = 225
.meas tran vdout1_2ck44 FIND v(dout1_2) AT=225.025n

* CHECK dout1_3 Vdout1_3ck44 = 0.9 time = 225
.meas tran vdout1_3ck44 FIND v(dout1_3) AT=225.025n

* CHECK dout1_4 Vdout1_4ck44 = 0 time = 225
.meas tran vdout1_4ck44 FIND v(dout1_4) AT=225.025n

* CHECK dout1_5 Vdout1_5ck44 = 0.9 time = 225
.meas tran vdout1_5ck44 FIND v(dout1_5) AT=225.025n

* CHECK dout1_6 Vdout1_6ck44 = 0 time = 225
.meas tran vdout1_6ck44 FIND v(dout1_6) AT=225.025n

* CHECK dout1_7 Vdout1_7ck44 = 0 time = 225
.meas tran vdout1_7ck44 FIND v(dout1_7) AT=225.025n

* CHECK dout1_8 Vdout1_8ck44 = 0.9 time = 225
.meas tran vdout1_8ck44 FIND v(dout1_8) AT=225.025n

* CHECK dout1_9 Vdout1_9ck44 = 0 time = 225
.meas tran vdout1_9ck44 FIND v(dout1_9) AT=225.025n

* CHECK dout1_10 Vdout1_10ck44 = 0 time = 225
.meas tran vdout1_10ck44 FIND v(dout1_10) AT=225.025n

* CHECK dout1_11 Vdout1_11ck44 = 0.9 time = 225
.meas tran vdout1_11ck44 FIND v(dout1_11) AT=225.025n

* CHECK dout1_12 Vdout1_12ck44 = 0 time = 225
.meas tran vdout1_12ck44 FIND v(dout1_12) AT=225.025n

* CHECK dout1_13 Vdout1_13ck44 = 0.9 time = 225
.meas tran vdout1_13ck44 FIND v(dout1_13) AT=225.025n

* CHECK dout1_14 Vdout1_14ck44 = 0 time = 225
.meas tran vdout1_14ck44 FIND v(dout1_14) AT=225.025n

* CHECK dout1_15 Vdout1_15ck44 = 0.9 time = 225
.meas tran vdout1_15ck44 FIND v(dout1_15) AT=225.025n

* CHECK dout1_16 Vdout1_16ck44 = 0.9 time = 225
.meas tran vdout1_16ck44 FIND v(dout1_16) AT=225.025n

* CHECK dout1_17 Vdout1_17ck44 = 0.9 time = 225
.meas tran vdout1_17ck44 FIND v(dout1_17) AT=225.025n

* CHECK dout1_18 Vdout1_18ck44 = 0.9 time = 225
.meas tran vdout1_18ck44 FIND v(dout1_18) AT=225.025n

* CHECK dout1_19 Vdout1_19ck44 = 0 time = 225
.meas tran vdout1_19ck44 FIND v(dout1_19) AT=225.025n

* CHECK dout1_20 Vdout1_20ck44 = 0.9 time = 225
.meas tran vdout1_20ck44 FIND v(dout1_20) AT=225.025n

* CHECK dout1_21 Vdout1_21ck44 = 0 time = 225
.meas tran vdout1_21ck44 FIND v(dout1_21) AT=225.025n

* CHECK dout1_22 Vdout1_22ck44 = 0.9 time = 225
.meas tran vdout1_22ck44 FIND v(dout1_22) AT=225.025n

* CHECK dout1_23 Vdout1_23ck44 = 0 time = 225
.meas tran vdout1_23ck44 FIND v(dout1_23) AT=225.025n

* CHECK dout1_24 Vdout1_24ck44 = 0.9 time = 225
.meas tran vdout1_24ck44 FIND v(dout1_24) AT=225.025n

* CHECK dout1_25 Vdout1_25ck44 = 0 time = 225
.meas tran vdout1_25ck44 FIND v(dout1_25) AT=225.025n

* CHECK dout1_26 Vdout1_26ck44 = 0 time = 225
.meas tran vdout1_26ck44 FIND v(dout1_26) AT=225.025n

* CHECK dout1_27 Vdout1_27ck44 = 0.9 time = 225
.meas tran vdout1_27ck44 FIND v(dout1_27) AT=225.025n

* CHECK dout1_28 Vdout1_28ck44 = 0 time = 225
.meas tran vdout1_28ck44 FIND v(dout1_28) AT=225.025n

* CHECK dout1_29 Vdout1_29ck44 = 0.9 time = 225
.meas tran vdout1_29ck44 FIND v(dout1_29) AT=225.025n

* CHECK dout1_30 Vdout1_30ck44 = 0.9 time = 225
.meas tran vdout1_30ck44 FIND v(dout1_30) AT=225.025n

* CHECK dout1_31 Vdout1_31ck44 = 0 time = 225
.meas tran vdout1_31ck44 FIND v(dout1_31) AT=225.025n

* CHECK dout1_32 Vdout1_32ck44 = 0 time = 225
.meas tran vdout1_32ck44 FIND v(dout1_32) AT=225.025n

* CHECK dout1_33 Vdout1_33ck44 = 0 time = 225
.meas tran vdout1_33ck44 FIND v(dout1_33) AT=225.025n

* CHECK dout1_34 Vdout1_34ck44 = 0.9 time = 225
.meas tran vdout1_34ck44 FIND v(dout1_34) AT=225.025n

* CHECK dout1_35 Vdout1_35ck44 = 0.9 time = 225
.meas tran vdout1_35ck44 FIND v(dout1_35) AT=225.025n

* CHECK dout1_36 Vdout1_36ck44 = 0.9 time = 225
.meas tran vdout1_36ck44 FIND v(dout1_36) AT=225.025n

* CHECK dout1_37 Vdout1_37ck44 = 0 time = 225
.meas tran vdout1_37ck44 FIND v(dout1_37) AT=225.025n

* CHECK dout1_38 Vdout1_38ck44 = 0 time = 225
.meas tran vdout1_38ck44 FIND v(dout1_38) AT=225.025n

* CHECK dout1_39 Vdout1_39ck44 = 0.9 time = 225
.meas tran vdout1_39ck44 FIND v(dout1_39) AT=225.025n

* CHECK dout1_40 Vdout1_40ck44 = 0.9 time = 225
.meas tran vdout1_40ck44 FIND v(dout1_40) AT=225.025n

* CHECK dout1_41 Vdout1_41ck44 = 0.9 time = 225
.meas tran vdout1_41ck44 FIND v(dout1_41) AT=225.025n

* CHECK dout1_42 Vdout1_42ck44 = 0 time = 225
.meas tran vdout1_42ck44 FIND v(dout1_42) AT=225.025n

* CHECK dout1_43 Vdout1_43ck44 = 0 time = 225
.meas tran vdout1_43ck44 FIND v(dout1_43) AT=225.025n

* CHECK dout1_44 Vdout1_44ck44 = 0.9 time = 225
.meas tran vdout1_44ck44 FIND v(dout1_44) AT=225.025n

* CHECK dout1_45 Vdout1_45ck44 = 0 time = 225
.meas tran vdout1_45ck44 FIND v(dout1_45) AT=225.025n

* CHECK dout1_46 Vdout1_46ck44 = 0 time = 225
.meas tran vdout1_46ck44 FIND v(dout1_46) AT=225.025n

* CHECK dout1_47 Vdout1_47ck44 = 0.9 time = 225
.meas tran vdout1_47ck44 FIND v(dout1_47) AT=225.025n

* CHECK dout1_48 Vdout1_48ck44 = 0.9 time = 225
.meas tran vdout1_48ck44 FIND v(dout1_48) AT=225.025n

* CHECK dout1_49 Vdout1_49ck44 = 0.9 time = 225
.meas tran vdout1_49ck44 FIND v(dout1_49) AT=225.025n

* CHECK dout1_50 Vdout1_50ck44 = 0 time = 225
.meas tran vdout1_50ck44 FIND v(dout1_50) AT=225.025n

* CHECK dout1_51 Vdout1_51ck44 = 0 time = 225
.meas tran vdout1_51ck44 FIND v(dout1_51) AT=225.025n

* CHECK dout1_52 Vdout1_52ck44 = 0.9 time = 225
.meas tran vdout1_52ck44 FIND v(dout1_52) AT=225.025n

* CHECK dout1_53 Vdout1_53ck44 = 0 time = 225
.meas tran vdout1_53ck44 FIND v(dout1_53) AT=225.025n

* CHECK dout1_54 Vdout1_54ck44 = 0.9 time = 225
.meas tran vdout1_54ck44 FIND v(dout1_54) AT=225.025n

* CHECK dout1_55 Vdout1_55ck44 = 0.9 time = 225
.meas tran vdout1_55ck44 FIND v(dout1_55) AT=225.025n

* CHECK dout1_56 Vdout1_56ck44 = 0.9 time = 225
.meas tran vdout1_56ck44 FIND v(dout1_56) AT=225.025n

* CHECK dout1_57 Vdout1_57ck44 = 0.9 time = 225
.meas tran vdout1_57ck44 FIND v(dout1_57) AT=225.025n

* CHECK dout1_58 Vdout1_58ck44 = 0.9 time = 225
.meas tran vdout1_58ck44 FIND v(dout1_58) AT=225.025n

* CHECK dout1_59 Vdout1_59ck44 = 0.9 time = 225
.meas tran vdout1_59ck44 FIND v(dout1_59) AT=225.025n

* CHECK dout1_60 Vdout1_60ck44 = 0.9 time = 225
.meas tran vdout1_60ck44 FIND v(dout1_60) AT=225.025n

* CHECK dout1_61 Vdout1_61ck44 = 0.9 time = 225
.meas tran vdout1_61ck44 FIND v(dout1_61) AT=225.025n

* CHECK dout1_62 Vdout1_62ck44 = 0 time = 225
.meas tran vdout1_62ck44 FIND v(dout1_62) AT=225.025n

* CHECK dout1_63 Vdout1_63ck44 = 0 time = 225
.meas tran vdout1_63ck44 FIND v(dout1_63) AT=225.025n

* CHECK dout1_64 Vdout1_64ck44 = 0 time = 225
.meas tran vdout1_64ck44 FIND v(dout1_64) AT=225.025n

* CHECK dout1_65 Vdout1_65ck44 = 0.9 time = 225
.meas tran vdout1_65ck44 FIND v(dout1_65) AT=225.025n

* CHECK dout1_66 Vdout1_66ck44 = 0 time = 225
.meas tran vdout1_66ck44 FIND v(dout1_66) AT=225.025n

* CHECK dout1_67 Vdout1_67ck44 = 0.9 time = 225
.meas tran vdout1_67ck44 FIND v(dout1_67) AT=225.025n

* CHECK dout1_68 Vdout1_68ck44 = 0 time = 225
.meas tran vdout1_68ck44 FIND v(dout1_68) AT=225.025n

* CHECK dout1_69 Vdout1_69ck44 = 0.9 time = 225
.meas tran vdout1_69ck44 FIND v(dout1_69) AT=225.025n

* CHECK dout1_70 Vdout1_70ck44 = 0.9 time = 225
.meas tran vdout1_70ck44 FIND v(dout1_70) AT=225.025n

* CHECK dout1_71 Vdout1_71ck44 = 0 time = 225
.meas tran vdout1_71ck44 FIND v(dout1_71) AT=225.025n

* CHECK dout1_0 Vdout1_0ck48 = 0 time = 245
.meas tran vdout1_0ck48 FIND v(dout1_0) AT=245.025n

* CHECK dout1_1 Vdout1_1ck48 = 0 time = 245
.meas tran vdout1_1ck48 FIND v(dout1_1) AT=245.025n

* CHECK dout1_2 Vdout1_2ck48 = 0.9 time = 245
.meas tran vdout1_2ck48 FIND v(dout1_2) AT=245.025n

* CHECK dout1_3 Vdout1_3ck48 = 0 time = 245
.meas tran vdout1_3ck48 FIND v(dout1_3) AT=245.025n

* CHECK dout1_4 Vdout1_4ck48 = 0 time = 245
.meas tran vdout1_4ck48 FIND v(dout1_4) AT=245.025n

* CHECK dout1_5 Vdout1_5ck48 = 0.9 time = 245
.meas tran vdout1_5ck48 FIND v(dout1_5) AT=245.025n

* CHECK dout1_6 Vdout1_6ck48 = 0 time = 245
.meas tran vdout1_6ck48 FIND v(dout1_6) AT=245.025n

* CHECK dout1_7 Vdout1_7ck48 = 0 time = 245
.meas tran vdout1_7ck48 FIND v(dout1_7) AT=245.025n

* CHECK dout1_8 Vdout1_8ck48 = 0.9 time = 245
.meas tran vdout1_8ck48 FIND v(dout1_8) AT=245.025n

* CHECK dout1_9 Vdout1_9ck48 = 0 time = 245
.meas tran vdout1_9ck48 FIND v(dout1_9) AT=245.025n

* CHECK dout1_10 Vdout1_10ck48 = 0 time = 245
.meas tran vdout1_10ck48 FIND v(dout1_10) AT=245.025n

* CHECK dout1_11 Vdout1_11ck48 = 0 time = 245
.meas tran vdout1_11ck48 FIND v(dout1_11) AT=245.025n

* CHECK dout1_12 Vdout1_12ck48 = 0 time = 245
.meas tran vdout1_12ck48 FIND v(dout1_12) AT=245.025n

* CHECK dout1_13 Vdout1_13ck48 = 0.9 time = 245
.meas tran vdout1_13ck48 FIND v(dout1_13) AT=245.025n

* CHECK dout1_14 Vdout1_14ck48 = 0.9 time = 245
.meas tran vdout1_14ck48 FIND v(dout1_14) AT=245.025n

* CHECK dout1_15 Vdout1_15ck48 = 0 time = 245
.meas tran vdout1_15ck48 FIND v(dout1_15) AT=245.025n

* CHECK dout1_16 Vdout1_16ck48 = 0.9 time = 245
.meas tran vdout1_16ck48 FIND v(dout1_16) AT=245.025n

* CHECK dout1_17 Vdout1_17ck48 = 0.9 time = 245
.meas tran vdout1_17ck48 FIND v(dout1_17) AT=245.025n

* CHECK dout1_18 Vdout1_18ck48 = 0.9 time = 245
.meas tran vdout1_18ck48 FIND v(dout1_18) AT=245.025n

* CHECK dout1_19 Vdout1_19ck48 = 0.9 time = 245
.meas tran vdout1_19ck48 FIND v(dout1_19) AT=245.025n

* CHECK dout1_20 Vdout1_20ck48 = 0.9 time = 245
.meas tran vdout1_20ck48 FIND v(dout1_20) AT=245.025n

* CHECK dout1_21 Vdout1_21ck48 = 0 time = 245
.meas tran vdout1_21ck48 FIND v(dout1_21) AT=245.025n

* CHECK dout1_22 Vdout1_22ck48 = 0 time = 245
.meas tran vdout1_22ck48 FIND v(dout1_22) AT=245.025n

* CHECK dout1_23 Vdout1_23ck48 = 0 time = 245
.meas tran vdout1_23ck48 FIND v(dout1_23) AT=245.025n

* CHECK dout1_24 Vdout1_24ck48 = 0.9 time = 245
.meas tran vdout1_24ck48 FIND v(dout1_24) AT=245.025n

* CHECK dout1_25 Vdout1_25ck48 = 0 time = 245
.meas tran vdout1_25ck48 FIND v(dout1_25) AT=245.025n

* CHECK dout1_26 Vdout1_26ck48 = 0.9 time = 245
.meas tran vdout1_26ck48 FIND v(dout1_26) AT=245.025n

* CHECK dout1_27 Vdout1_27ck48 = 0.9 time = 245
.meas tran vdout1_27ck48 FIND v(dout1_27) AT=245.025n

* CHECK dout1_28 Vdout1_28ck48 = 0 time = 245
.meas tran vdout1_28ck48 FIND v(dout1_28) AT=245.025n

* CHECK dout1_29 Vdout1_29ck48 = 0 time = 245
.meas tran vdout1_29ck48 FIND v(dout1_29) AT=245.025n

* CHECK dout1_30 Vdout1_30ck48 = 0.9 time = 245
.meas tran vdout1_30ck48 FIND v(dout1_30) AT=245.025n

* CHECK dout1_31 Vdout1_31ck48 = 0.9 time = 245
.meas tran vdout1_31ck48 FIND v(dout1_31) AT=245.025n

* CHECK dout1_32 Vdout1_32ck48 = 0 time = 245
.meas tran vdout1_32ck48 FIND v(dout1_32) AT=245.025n

* CHECK dout1_33 Vdout1_33ck48 = 0 time = 245
.meas tran vdout1_33ck48 FIND v(dout1_33) AT=245.025n

* CHECK dout1_34 Vdout1_34ck48 = 0 time = 245
.meas tran vdout1_34ck48 FIND v(dout1_34) AT=245.025n

* CHECK dout1_35 Vdout1_35ck48 = 0 time = 245
.meas tran vdout1_35ck48 FIND v(dout1_35) AT=245.025n

* CHECK dout1_36 Vdout1_36ck48 = 0.9 time = 245
.meas tran vdout1_36ck48 FIND v(dout1_36) AT=245.025n

* CHECK dout1_37 Vdout1_37ck48 = 0 time = 245
.meas tran vdout1_37ck48 FIND v(dout1_37) AT=245.025n

* CHECK dout1_38 Vdout1_38ck48 = 0 time = 245
.meas tran vdout1_38ck48 FIND v(dout1_38) AT=245.025n

* CHECK dout1_39 Vdout1_39ck48 = 0 time = 245
.meas tran vdout1_39ck48 FIND v(dout1_39) AT=245.025n

* CHECK dout1_40 Vdout1_40ck48 = 0 time = 245
.meas tran vdout1_40ck48 FIND v(dout1_40) AT=245.025n

* CHECK dout1_41 Vdout1_41ck48 = 0.9 time = 245
.meas tran vdout1_41ck48 FIND v(dout1_41) AT=245.025n

* CHECK dout1_42 Vdout1_42ck48 = 0 time = 245
.meas tran vdout1_42ck48 FIND v(dout1_42) AT=245.025n

* CHECK dout1_43 Vdout1_43ck48 = 0.9 time = 245
.meas tran vdout1_43ck48 FIND v(dout1_43) AT=245.025n

* CHECK dout1_44 Vdout1_44ck48 = 0 time = 245
.meas tran vdout1_44ck48 FIND v(dout1_44) AT=245.025n

* CHECK dout1_45 Vdout1_45ck48 = 0.9 time = 245
.meas tran vdout1_45ck48 FIND v(dout1_45) AT=245.025n

* CHECK dout1_46 Vdout1_46ck48 = 0 time = 245
.meas tran vdout1_46ck48 FIND v(dout1_46) AT=245.025n

* CHECK dout1_47 Vdout1_47ck48 = 0.9 time = 245
.meas tran vdout1_47ck48 FIND v(dout1_47) AT=245.025n

* CHECK dout1_48 Vdout1_48ck48 = 0.9 time = 245
.meas tran vdout1_48ck48 FIND v(dout1_48) AT=245.025n

* CHECK dout1_49 Vdout1_49ck48 = 0.9 time = 245
.meas tran vdout1_49ck48 FIND v(dout1_49) AT=245.025n

* CHECK dout1_50 Vdout1_50ck48 = 0.9 time = 245
.meas tran vdout1_50ck48 FIND v(dout1_50) AT=245.025n

* CHECK dout1_51 Vdout1_51ck48 = 0 time = 245
.meas tran vdout1_51ck48 FIND v(dout1_51) AT=245.025n

* CHECK dout1_52 Vdout1_52ck48 = 0 time = 245
.meas tran vdout1_52ck48 FIND v(dout1_52) AT=245.025n

* CHECK dout1_53 Vdout1_53ck48 = 0 time = 245
.meas tran vdout1_53ck48 FIND v(dout1_53) AT=245.025n

* CHECK dout1_54 Vdout1_54ck48 = 0 time = 245
.meas tran vdout1_54ck48 FIND v(dout1_54) AT=245.025n

* CHECK dout1_55 Vdout1_55ck48 = 0 time = 245
.meas tran vdout1_55ck48 FIND v(dout1_55) AT=245.025n

* CHECK dout1_56 Vdout1_56ck48 = 0.9 time = 245
.meas tran vdout1_56ck48 FIND v(dout1_56) AT=245.025n

* CHECK dout1_57 Vdout1_57ck48 = 0 time = 245
.meas tran vdout1_57ck48 FIND v(dout1_57) AT=245.025n

* CHECK dout1_58 Vdout1_58ck48 = 0.9 time = 245
.meas tran vdout1_58ck48 FIND v(dout1_58) AT=245.025n

* CHECK dout1_59 Vdout1_59ck48 = 0 time = 245
.meas tran vdout1_59ck48 FIND v(dout1_59) AT=245.025n

* CHECK dout1_60 Vdout1_60ck48 = 0 time = 245
.meas tran vdout1_60ck48 FIND v(dout1_60) AT=245.025n

* CHECK dout1_61 Vdout1_61ck48 = 0.9 time = 245
.meas tran vdout1_61ck48 FIND v(dout1_61) AT=245.025n

* CHECK dout1_62 Vdout1_62ck48 = 0 time = 245
.meas tran vdout1_62ck48 FIND v(dout1_62) AT=245.025n

* CHECK dout1_63 Vdout1_63ck48 = 0 time = 245
.meas tran vdout1_63ck48 FIND v(dout1_63) AT=245.025n

* CHECK dout1_64 Vdout1_64ck48 = 0 time = 245
.meas tran vdout1_64ck48 FIND v(dout1_64) AT=245.025n

* CHECK dout1_65 Vdout1_65ck48 = 0.9 time = 245
.meas tran vdout1_65ck48 FIND v(dout1_65) AT=245.025n

* CHECK dout1_66 Vdout1_66ck48 = 0 time = 245
.meas tran vdout1_66ck48 FIND v(dout1_66) AT=245.025n

* CHECK dout1_67 Vdout1_67ck48 = 0 time = 245
.meas tran vdout1_67ck48 FIND v(dout1_67) AT=245.025n

* CHECK dout1_68 Vdout1_68ck48 = 0.9 time = 245
.meas tran vdout1_68ck48 FIND v(dout1_68) AT=245.025n

* CHECK dout1_69 Vdout1_69ck48 = 0.9 time = 245
.meas tran vdout1_69ck48 FIND v(dout1_69) AT=245.025n

* CHECK dout1_70 Vdout1_70ck48 = 0 time = 245
.meas tran vdout1_70ck48 FIND v(dout1_70) AT=245.025n

* CHECK dout1_71 Vdout1_71ck48 = 0 time = 245
.meas tran vdout1_71ck48 FIND v(dout1_71) AT=245.025n

* CHECK dout1_0 Vdout1_0ck51 = 0 time = 260
.meas tran vdout1_0ck51 FIND v(dout1_0) AT=260.025n

* CHECK dout1_1 Vdout1_1ck51 = 0 time = 260
.meas tran vdout1_1ck51 FIND v(dout1_1) AT=260.025n

* CHECK dout1_2 Vdout1_2ck51 = 0 time = 260
.meas tran vdout1_2ck51 FIND v(dout1_2) AT=260.025n

* CHECK dout1_3 Vdout1_3ck51 = 0 time = 260
.meas tran vdout1_3ck51 FIND v(dout1_3) AT=260.025n

* CHECK dout1_4 Vdout1_4ck51 = 0 time = 260
.meas tran vdout1_4ck51 FIND v(dout1_4) AT=260.025n

* CHECK dout1_5 Vdout1_5ck51 = 0 time = 260
.meas tran vdout1_5ck51 FIND v(dout1_5) AT=260.025n

* CHECK dout1_6 Vdout1_6ck51 = 0.9 time = 260
.meas tran vdout1_6ck51 FIND v(dout1_6) AT=260.025n

* CHECK dout1_7 Vdout1_7ck51 = 0.9 time = 260
.meas tran vdout1_7ck51 FIND v(dout1_7) AT=260.025n

* CHECK dout1_8 Vdout1_8ck51 = 0 time = 260
.meas tran vdout1_8ck51 FIND v(dout1_8) AT=260.025n

* CHECK dout1_9 Vdout1_9ck51 = 0.9 time = 260
.meas tran vdout1_9ck51 FIND v(dout1_9) AT=260.025n

* CHECK dout1_10 Vdout1_10ck51 = 0.9 time = 260
.meas tran vdout1_10ck51 FIND v(dout1_10) AT=260.025n

* CHECK dout1_11 Vdout1_11ck51 = 0 time = 260
.meas tran vdout1_11ck51 FIND v(dout1_11) AT=260.025n

* CHECK dout1_12 Vdout1_12ck51 = 0.9 time = 260
.meas tran vdout1_12ck51 FIND v(dout1_12) AT=260.025n

* CHECK dout1_13 Vdout1_13ck51 = 0.9 time = 260
.meas tran vdout1_13ck51 FIND v(dout1_13) AT=260.025n

* CHECK dout1_14 Vdout1_14ck51 = 0 time = 260
.meas tran vdout1_14ck51 FIND v(dout1_14) AT=260.025n

* CHECK dout1_15 Vdout1_15ck51 = 0 time = 260
.meas tran vdout1_15ck51 FIND v(dout1_15) AT=260.025n

* CHECK dout1_16 Vdout1_16ck51 = 0 time = 260
.meas tran vdout1_16ck51 FIND v(dout1_16) AT=260.025n

* CHECK dout1_17 Vdout1_17ck51 = 0.9 time = 260
.meas tran vdout1_17ck51 FIND v(dout1_17) AT=260.025n

* CHECK dout1_18 Vdout1_18ck51 = 0.9 time = 260
.meas tran vdout1_18ck51 FIND v(dout1_18) AT=260.025n

* CHECK dout1_19 Vdout1_19ck51 = 0.9 time = 260
.meas tran vdout1_19ck51 FIND v(dout1_19) AT=260.025n

* CHECK dout1_20 Vdout1_20ck51 = 0 time = 260
.meas tran vdout1_20ck51 FIND v(dout1_20) AT=260.025n

* CHECK dout1_21 Vdout1_21ck51 = 0 time = 260
.meas tran vdout1_21ck51 FIND v(dout1_21) AT=260.025n

* CHECK dout1_22 Vdout1_22ck51 = 0.9 time = 260
.meas tran vdout1_22ck51 FIND v(dout1_22) AT=260.025n

* CHECK dout1_23 Vdout1_23ck51 = 0.9 time = 260
.meas tran vdout1_23ck51 FIND v(dout1_23) AT=260.025n

* CHECK dout1_24 Vdout1_24ck51 = 0 time = 260
.meas tran vdout1_24ck51 FIND v(dout1_24) AT=260.025n

* CHECK dout1_25 Vdout1_25ck51 = 0.9 time = 260
.meas tran vdout1_25ck51 FIND v(dout1_25) AT=260.025n

* CHECK dout1_26 Vdout1_26ck51 = 0 time = 260
.meas tran vdout1_26ck51 FIND v(dout1_26) AT=260.025n

* CHECK dout1_27 Vdout1_27ck51 = 0.9 time = 260
.meas tran vdout1_27ck51 FIND v(dout1_27) AT=260.025n

* CHECK dout1_28 Vdout1_28ck51 = 0 time = 260
.meas tran vdout1_28ck51 FIND v(dout1_28) AT=260.025n

* CHECK dout1_29 Vdout1_29ck51 = 0 time = 260
.meas tran vdout1_29ck51 FIND v(dout1_29) AT=260.025n

* CHECK dout1_30 Vdout1_30ck51 = 0.9 time = 260
.meas tran vdout1_30ck51 FIND v(dout1_30) AT=260.025n

* CHECK dout1_31 Vdout1_31ck51 = 0.9 time = 260
.meas tran vdout1_31ck51 FIND v(dout1_31) AT=260.025n

* CHECK dout1_32 Vdout1_32ck51 = 0 time = 260
.meas tran vdout1_32ck51 FIND v(dout1_32) AT=260.025n

* CHECK dout1_33 Vdout1_33ck51 = 0.9 time = 260
.meas tran vdout1_33ck51 FIND v(dout1_33) AT=260.025n

* CHECK dout1_34 Vdout1_34ck51 = 0 time = 260
.meas tran vdout1_34ck51 FIND v(dout1_34) AT=260.025n

* CHECK dout1_35 Vdout1_35ck51 = 0 time = 260
.meas tran vdout1_35ck51 FIND v(dout1_35) AT=260.025n

* CHECK dout1_36 Vdout1_36ck51 = 0 time = 260
.meas tran vdout1_36ck51 FIND v(dout1_36) AT=260.025n

* CHECK dout1_37 Vdout1_37ck51 = 0.9 time = 260
.meas tran vdout1_37ck51 FIND v(dout1_37) AT=260.025n

* CHECK dout1_38 Vdout1_38ck51 = 0 time = 260
.meas tran vdout1_38ck51 FIND v(dout1_38) AT=260.025n

* CHECK dout1_39 Vdout1_39ck51 = 0.9 time = 260
.meas tran vdout1_39ck51 FIND v(dout1_39) AT=260.025n

* CHECK dout1_40 Vdout1_40ck51 = 0 time = 260
.meas tran vdout1_40ck51 FIND v(dout1_40) AT=260.025n

* CHECK dout1_41 Vdout1_41ck51 = 0 time = 260
.meas tran vdout1_41ck51 FIND v(dout1_41) AT=260.025n

* CHECK dout1_42 Vdout1_42ck51 = 0 time = 260
.meas tran vdout1_42ck51 FIND v(dout1_42) AT=260.025n

* CHECK dout1_43 Vdout1_43ck51 = 0.9 time = 260
.meas tran vdout1_43ck51 FIND v(dout1_43) AT=260.025n

* CHECK dout1_44 Vdout1_44ck51 = 0.9 time = 260
.meas tran vdout1_44ck51 FIND v(dout1_44) AT=260.025n

* CHECK dout1_45 Vdout1_45ck51 = 0 time = 260
.meas tran vdout1_45ck51 FIND v(dout1_45) AT=260.025n

* CHECK dout1_46 Vdout1_46ck51 = 0.9 time = 260
.meas tran vdout1_46ck51 FIND v(dout1_46) AT=260.025n

* CHECK dout1_47 Vdout1_47ck51 = 0 time = 260
.meas tran vdout1_47ck51 FIND v(dout1_47) AT=260.025n

* CHECK dout1_48 Vdout1_48ck51 = 0 time = 260
.meas tran vdout1_48ck51 FIND v(dout1_48) AT=260.025n

* CHECK dout1_49 Vdout1_49ck51 = 0.9 time = 260
.meas tran vdout1_49ck51 FIND v(dout1_49) AT=260.025n

* CHECK dout1_50 Vdout1_50ck51 = 0 time = 260
.meas tran vdout1_50ck51 FIND v(dout1_50) AT=260.025n

* CHECK dout1_51 Vdout1_51ck51 = 0 time = 260
.meas tran vdout1_51ck51 FIND v(dout1_51) AT=260.025n

* CHECK dout1_52 Vdout1_52ck51 = 0 time = 260
.meas tran vdout1_52ck51 FIND v(dout1_52) AT=260.025n

* CHECK dout1_53 Vdout1_53ck51 = 0.9 time = 260
.meas tran vdout1_53ck51 FIND v(dout1_53) AT=260.025n

* CHECK dout1_54 Vdout1_54ck51 = 0.9 time = 260
.meas tran vdout1_54ck51 FIND v(dout1_54) AT=260.025n

* CHECK dout1_55 Vdout1_55ck51 = 0 time = 260
.meas tran vdout1_55ck51 FIND v(dout1_55) AT=260.025n

* CHECK dout1_56 Vdout1_56ck51 = 0 time = 260
.meas tran vdout1_56ck51 FIND v(dout1_56) AT=260.025n

* CHECK dout1_57 Vdout1_57ck51 = 0.9 time = 260
.meas tran vdout1_57ck51 FIND v(dout1_57) AT=260.025n

* CHECK dout1_58 Vdout1_58ck51 = 0.9 time = 260
.meas tran vdout1_58ck51 FIND v(dout1_58) AT=260.025n

* CHECK dout1_59 Vdout1_59ck51 = 0 time = 260
.meas tran vdout1_59ck51 FIND v(dout1_59) AT=260.025n

* CHECK dout1_60 Vdout1_60ck51 = 0 time = 260
.meas tran vdout1_60ck51 FIND v(dout1_60) AT=260.025n

* CHECK dout1_61 Vdout1_61ck51 = 0 time = 260
.meas tran vdout1_61ck51 FIND v(dout1_61) AT=260.025n

* CHECK dout1_62 Vdout1_62ck51 = 0 time = 260
.meas tran vdout1_62ck51 FIND v(dout1_62) AT=260.025n

* CHECK dout1_63 Vdout1_63ck51 = 0 time = 260
.meas tran vdout1_63ck51 FIND v(dout1_63) AT=260.025n

* CHECK dout1_64 Vdout1_64ck51 = 0 time = 260
.meas tran vdout1_64ck51 FIND v(dout1_64) AT=260.025n

* CHECK dout1_65 Vdout1_65ck51 = 0.9 time = 260
.meas tran vdout1_65ck51 FIND v(dout1_65) AT=260.025n

* CHECK dout1_66 Vdout1_66ck51 = 0 time = 260
.meas tran vdout1_66ck51 FIND v(dout1_66) AT=260.025n

* CHECK dout1_67 Vdout1_67ck51 = 0.9 time = 260
.meas tran vdout1_67ck51 FIND v(dout1_67) AT=260.025n

* CHECK dout1_68 Vdout1_68ck51 = 0.9 time = 260
.meas tran vdout1_68ck51 FIND v(dout1_68) AT=260.025n

* CHECK dout1_69 Vdout1_69ck51 = 0 time = 260
.meas tran vdout1_69ck51 FIND v(dout1_69) AT=260.025n

* CHECK dout1_70 Vdout1_70ck51 = 0.9 time = 260
.meas tran vdout1_70ck51 FIND v(dout1_70) AT=260.025n

* CHECK dout1_71 Vdout1_71ck51 = 0 time = 260
.meas tran vdout1_71ck51 FIND v(dout1_71) AT=260.025n

* CHECK dout1_0 Vdout1_0ck52 = 0 time = 265
.meas tran vdout1_0ck52 FIND v(dout1_0) AT=265.025n

* CHECK dout1_1 Vdout1_1ck52 = 0.9 time = 265
.meas tran vdout1_1ck52 FIND v(dout1_1) AT=265.025n

* CHECK dout1_2 Vdout1_2ck52 = 0.9 time = 265
.meas tran vdout1_2ck52 FIND v(dout1_2) AT=265.025n

* CHECK dout1_3 Vdout1_3ck52 = 0.9 time = 265
.meas tran vdout1_3ck52 FIND v(dout1_3) AT=265.025n

* CHECK dout1_4 Vdout1_4ck52 = 0.9 time = 265
.meas tran vdout1_4ck52 FIND v(dout1_4) AT=265.025n

* CHECK dout1_5 Vdout1_5ck52 = 0 time = 265
.meas tran vdout1_5ck52 FIND v(dout1_5) AT=265.025n

* CHECK dout1_6 Vdout1_6ck52 = 0 time = 265
.meas tran vdout1_6ck52 FIND v(dout1_6) AT=265.025n

* CHECK dout1_7 Vdout1_7ck52 = 0.9 time = 265
.meas tran vdout1_7ck52 FIND v(dout1_7) AT=265.025n

* CHECK dout1_8 Vdout1_8ck52 = 0 time = 265
.meas tran vdout1_8ck52 FIND v(dout1_8) AT=265.025n

* CHECK dout1_9 Vdout1_9ck52 = 0.9 time = 265
.meas tran vdout1_9ck52 FIND v(dout1_9) AT=265.025n

* CHECK dout1_10 Vdout1_10ck52 = 0 time = 265
.meas tran vdout1_10ck52 FIND v(dout1_10) AT=265.025n

* CHECK dout1_11 Vdout1_11ck52 = 0 time = 265
.meas tran vdout1_11ck52 FIND v(dout1_11) AT=265.025n

* CHECK dout1_12 Vdout1_12ck52 = 0.9 time = 265
.meas tran vdout1_12ck52 FIND v(dout1_12) AT=265.025n

* CHECK dout1_13 Vdout1_13ck52 = 0 time = 265
.meas tran vdout1_13ck52 FIND v(dout1_13) AT=265.025n

* CHECK dout1_14 Vdout1_14ck52 = 0 time = 265
.meas tran vdout1_14ck52 FIND v(dout1_14) AT=265.025n

* CHECK dout1_15 Vdout1_15ck52 = 0.9 time = 265
.meas tran vdout1_15ck52 FIND v(dout1_15) AT=265.025n

* CHECK dout1_16 Vdout1_16ck52 = 0 time = 265
.meas tran vdout1_16ck52 FIND v(dout1_16) AT=265.025n

* CHECK dout1_17 Vdout1_17ck52 = 0 time = 265
.meas tran vdout1_17ck52 FIND v(dout1_17) AT=265.025n

* CHECK dout1_18 Vdout1_18ck52 = 0 time = 265
.meas tran vdout1_18ck52 FIND v(dout1_18) AT=265.025n

* CHECK dout1_19 Vdout1_19ck52 = 0 time = 265
.meas tran vdout1_19ck52 FIND v(dout1_19) AT=265.025n

* CHECK dout1_20 Vdout1_20ck52 = 0 time = 265
.meas tran vdout1_20ck52 FIND v(dout1_20) AT=265.025n

* CHECK dout1_21 Vdout1_21ck52 = 0.9 time = 265
.meas tran vdout1_21ck52 FIND v(dout1_21) AT=265.025n

* CHECK dout1_22 Vdout1_22ck52 = 0 time = 265
.meas tran vdout1_22ck52 FIND v(dout1_22) AT=265.025n

* CHECK dout1_23 Vdout1_23ck52 = 0.9 time = 265
.meas tran vdout1_23ck52 FIND v(dout1_23) AT=265.025n

* CHECK dout1_24 Vdout1_24ck52 = 0 time = 265
.meas tran vdout1_24ck52 FIND v(dout1_24) AT=265.025n

* CHECK dout1_25 Vdout1_25ck52 = 0.9 time = 265
.meas tran vdout1_25ck52 FIND v(dout1_25) AT=265.025n

* CHECK dout1_26 Vdout1_26ck52 = 0.9 time = 265
.meas tran vdout1_26ck52 FIND v(dout1_26) AT=265.025n

* CHECK dout1_27 Vdout1_27ck52 = 0 time = 265
.meas tran vdout1_27ck52 FIND v(dout1_27) AT=265.025n

* CHECK dout1_28 Vdout1_28ck52 = 0.9 time = 265
.meas tran vdout1_28ck52 FIND v(dout1_28) AT=265.025n

* CHECK dout1_29 Vdout1_29ck52 = 0 time = 265
.meas tran vdout1_29ck52 FIND v(dout1_29) AT=265.025n

* CHECK dout1_30 Vdout1_30ck52 = 0 time = 265
.meas tran vdout1_30ck52 FIND v(dout1_30) AT=265.025n

* CHECK dout1_31 Vdout1_31ck52 = 0 time = 265
.meas tran vdout1_31ck52 FIND v(dout1_31) AT=265.025n

* CHECK dout1_32 Vdout1_32ck52 = 0.9 time = 265
.meas tran vdout1_32ck52 FIND v(dout1_32) AT=265.025n

* CHECK dout1_33 Vdout1_33ck52 = 0 time = 265
.meas tran vdout1_33ck52 FIND v(dout1_33) AT=265.025n

* CHECK dout1_34 Vdout1_34ck52 = 0.9 time = 265
.meas tran vdout1_34ck52 FIND v(dout1_34) AT=265.025n

* CHECK dout1_35 Vdout1_35ck52 = 0.9 time = 265
.meas tran vdout1_35ck52 FIND v(dout1_35) AT=265.025n

* CHECK dout1_36 Vdout1_36ck52 = 0.9 time = 265
.meas tran vdout1_36ck52 FIND v(dout1_36) AT=265.025n

* CHECK dout1_37 Vdout1_37ck52 = 0 time = 265
.meas tran vdout1_37ck52 FIND v(dout1_37) AT=265.025n

* CHECK dout1_38 Vdout1_38ck52 = 0.9 time = 265
.meas tran vdout1_38ck52 FIND v(dout1_38) AT=265.025n

* CHECK dout1_39 Vdout1_39ck52 = 0.9 time = 265
.meas tran vdout1_39ck52 FIND v(dout1_39) AT=265.025n

* CHECK dout1_40 Vdout1_40ck52 = 0 time = 265
.meas tran vdout1_40ck52 FIND v(dout1_40) AT=265.025n

* CHECK dout1_41 Vdout1_41ck52 = 0.9 time = 265
.meas tran vdout1_41ck52 FIND v(dout1_41) AT=265.025n

* CHECK dout1_42 Vdout1_42ck52 = 0.9 time = 265
.meas tran vdout1_42ck52 FIND v(dout1_42) AT=265.025n

* CHECK dout1_43 Vdout1_43ck52 = 0.9 time = 265
.meas tran vdout1_43ck52 FIND v(dout1_43) AT=265.025n

* CHECK dout1_44 Vdout1_44ck52 = 0 time = 265
.meas tran vdout1_44ck52 FIND v(dout1_44) AT=265.025n

* CHECK dout1_45 Vdout1_45ck52 = 0.9 time = 265
.meas tran vdout1_45ck52 FIND v(dout1_45) AT=265.025n

* CHECK dout1_46 Vdout1_46ck52 = 0.9 time = 265
.meas tran vdout1_46ck52 FIND v(dout1_46) AT=265.025n

* CHECK dout1_47 Vdout1_47ck52 = 0 time = 265
.meas tran vdout1_47ck52 FIND v(dout1_47) AT=265.025n

* CHECK dout1_48 Vdout1_48ck52 = 0 time = 265
.meas tran vdout1_48ck52 FIND v(dout1_48) AT=265.025n

* CHECK dout1_49 Vdout1_49ck52 = 0 time = 265
.meas tran vdout1_49ck52 FIND v(dout1_49) AT=265.025n

* CHECK dout1_50 Vdout1_50ck52 = 0 time = 265
.meas tran vdout1_50ck52 FIND v(dout1_50) AT=265.025n

* CHECK dout1_51 Vdout1_51ck52 = 0.9 time = 265
.meas tran vdout1_51ck52 FIND v(dout1_51) AT=265.025n

* CHECK dout1_52 Vdout1_52ck52 = 0.9 time = 265
.meas tran vdout1_52ck52 FIND v(dout1_52) AT=265.025n

* CHECK dout1_53 Vdout1_53ck52 = 0.9 time = 265
.meas tran vdout1_53ck52 FIND v(dout1_53) AT=265.025n

* CHECK dout1_54 Vdout1_54ck52 = 0 time = 265
.meas tran vdout1_54ck52 FIND v(dout1_54) AT=265.025n

* CHECK dout1_55 Vdout1_55ck52 = 0 time = 265
.meas tran vdout1_55ck52 FIND v(dout1_55) AT=265.025n

* CHECK dout1_56 Vdout1_56ck52 = 0.9 time = 265
.meas tran vdout1_56ck52 FIND v(dout1_56) AT=265.025n

* CHECK dout1_57 Vdout1_57ck52 = 0.9 time = 265
.meas tran vdout1_57ck52 FIND v(dout1_57) AT=265.025n

* CHECK dout1_58 Vdout1_58ck52 = 0 time = 265
.meas tran vdout1_58ck52 FIND v(dout1_58) AT=265.025n

* CHECK dout1_59 Vdout1_59ck52 = 0 time = 265
.meas tran vdout1_59ck52 FIND v(dout1_59) AT=265.025n

* CHECK dout1_60 Vdout1_60ck52 = 0.9 time = 265
.meas tran vdout1_60ck52 FIND v(dout1_60) AT=265.025n

* CHECK dout1_61 Vdout1_61ck52 = 0.9 time = 265
.meas tran vdout1_61ck52 FIND v(dout1_61) AT=265.025n

* CHECK dout1_62 Vdout1_62ck52 = 0.9 time = 265
.meas tran vdout1_62ck52 FIND v(dout1_62) AT=265.025n

* CHECK dout1_63 Vdout1_63ck52 = 0 time = 265
.meas tran vdout1_63ck52 FIND v(dout1_63) AT=265.025n

* CHECK dout1_64 Vdout1_64ck52 = 0.9 time = 265
.meas tran vdout1_64ck52 FIND v(dout1_64) AT=265.025n

* CHECK dout1_65 Vdout1_65ck52 = 0 time = 265
.meas tran vdout1_65ck52 FIND v(dout1_65) AT=265.025n

* CHECK dout1_66 Vdout1_66ck52 = 0 time = 265
.meas tran vdout1_66ck52 FIND v(dout1_66) AT=265.025n

* CHECK dout1_67 Vdout1_67ck52 = 0.9 time = 265
.meas tran vdout1_67ck52 FIND v(dout1_67) AT=265.025n

* CHECK dout1_68 Vdout1_68ck52 = 0 time = 265
.meas tran vdout1_68ck52 FIND v(dout1_68) AT=265.025n

* CHECK dout1_69 Vdout1_69ck52 = 0 time = 265
.meas tran vdout1_69ck52 FIND v(dout1_69) AT=265.025n

* CHECK dout1_70 Vdout1_70ck52 = 0.9 time = 265
.meas tran vdout1_70ck52 FIND v(dout1_70) AT=265.025n

* CHECK dout1_71 Vdout1_71ck52 = 0 time = 265
.meas tran vdout1_71ck52 FIND v(dout1_71) AT=265.025n

* CHECK dout1_0 Vdout1_0ck56 = 0.9 time = 285
.meas tran vdout1_0ck56 FIND v(dout1_0) AT=285.025n

* CHECK dout1_1 Vdout1_1ck56 = 0 time = 285
.meas tran vdout1_1ck56 FIND v(dout1_1) AT=285.025n

* CHECK dout1_2 Vdout1_2ck56 = 0.9 time = 285
.meas tran vdout1_2ck56 FIND v(dout1_2) AT=285.025n

* CHECK dout1_3 Vdout1_3ck56 = 0.9 time = 285
.meas tran vdout1_3ck56 FIND v(dout1_3) AT=285.025n

* CHECK dout1_4 Vdout1_4ck56 = 0 time = 285
.meas tran vdout1_4ck56 FIND v(dout1_4) AT=285.025n

* CHECK dout1_5 Vdout1_5ck56 = 0.9 time = 285
.meas tran vdout1_5ck56 FIND v(dout1_5) AT=285.025n

* CHECK dout1_6 Vdout1_6ck56 = 0.9 time = 285
.meas tran vdout1_6ck56 FIND v(dout1_6) AT=285.025n

* CHECK dout1_7 Vdout1_7ck56 = 0 time = 285
.meas tran vdout1_7ck56 FIND v(dout1_7) AT=285.025n

* CHECK dout1_8 Vdout1_8ck56 = 0 time = 285
.meas tran vdout1_8ck56 FIND v(dout1_8) AT=285.025n

* CHECK dout1_9 Vdout1_9ck56 = 0 time = 285
.meas tran vdout1_9ck56 FIND v(dout1_9) AT=285.025n

* CHECK dout1_10 Vdout1_10ck56 = 0.9 time = 285
.meas tran vdout1_10ck56 FIND v(dout1_10) AT=285.025n

* CHECK dout1_11 Vdout1_11ck56 = 0 time = 285
.meas tran vdout1_11ck56 FIND v(dout1_11) AT=285.025n

* CHECK dout1_12 Vdout1_12ck56 = 0.9 time = 285
.meas tran vdout1_12ck56 FIND v(dout1_12) AT=285.025n

* CHECK dout1_13 Vdout1_13ck56 = 0.9 time = 285
.meas tran vdout1_13ck56 FIND v(dout1_13) AT=285.025n

* CHECK dout1_14 Vdout1_14ck56 = 0 time = 285
.meas tran vdout1_14ck56 FIND v(dout1_14) AT=285.025n

* CHECK dout1_15 Vdout1_15ck56 = 0.9 time = 285
.meas tran vdout1_15ck56 FIND v(dout1_15) AT=285.025n

* CHECK dout1_16 Vdout1_16ck56 = 0 time = 285
.meas tran vdout1_16ck56 FIND v(dout1_16) AT=285.025n

* CHECK dout1_17 Vdout1_17ck56 = 0 time = 285
.meas tran vdout1_17ck56 FIND v(dout1_17) AT=285.025n

* CHECK dout1_18 Vdout1_18ck56 = 0.9 time = 285
.meas tran vdout1_18ck56 FIND v(dout1_18) AT=285.025n

* CHECK dout1_19 Vdout1_19ck56 = 0.9 time = 285
.meas tran vdout1_19ck56 FIND v(dout1_19) AT=285.025n

* CHECK dout1_20 Vdout1_20ck56 = 0 time = 285
.meas tran vdout1_20ck56 FIND v(dout1_20) AT=285.025n

* CHECK dout1_21 Vdout1_21ck56 = 0 time = 285
.meas tran vdout1_21ck56 FIND v(dout1_21) AT=285.025n

* CHECK dout1_22 Vdout1_22ck56 = 0 time = 285
.meas tran vdout1_22ck56 FIND v(dout1_22) AT=285.025n

* CHECK dout1_23 Vdout1_23ck56 = 0 time = 285
.meas tran vdout1_23ck56 FIND v(dout1_23) AT=285.025n

* CHECK dout1_24 Vdout1_24ck56 = 0 time = 285
.meas tran vdout1_24ck56 FIND v(dout1_24) AT=285.025n

* CHECK dout1_25 Vdout1_25ck56 = 0.9 time = 285
.meas tran vdout1_25ck56 FIND v(dout1_25) AT=285.025n

* CHECK dout1_26 Vdout1_26ck56 = 0 time = 285
.meas tran vdout1_26ck56 FIND v(dout1_26) AT=285.025n

* CHECK dout1_27 Vdout1_27ck56 = 0 time = 285
.meas tran vdout1_27ck56 FIND v(dout1_27) AT=285.025n

* CHECK dout1_28 Vdout1_28ck56 = 0 time = 285
.meas tran vdout1_28ck56 FIND v(dout1_28) AT=285.025n

* CHECK dout1_29 Vdout1_29ck56 = 0 time = 285
.meas tran vdout1_29ck56 FIND v(dout1_29) AT=285.025n

* CHECK dout1_30 Vdout1_30ck56 = 0 time = 285
.meas tran vdout1_30ck56 FIND v(dout1_30) AT=285.025n

* CHECK dout1_31 Vdout1_31ck56 = 0.9 time = 285
.meas tran vdout1_31ck56 FIND v(dout1_31) AT=285.025n

* CHECK dout1_32 Vdout1_32ck56 = 0 time = 285
.meas tran vdout1_32ck56 FIND v(dout1_32) AT=285.025n

* CHECK dout1_33 Vdout1_33ck56 = 0 time = 285
.meas tran vdout1_33ck56 FIND v(dout1_33) AT=285.025n

* CHECK dout1_34 Vdout1_34ck56 = 0 time = 285
.meas tran vdout1_34ck56 FIND v(dout1_34) AT=285.025n

* CHECK dout1_35 Vdout1_35ck56 = 0 time = 285
.meas tran vdout1_35ck56 FIND v(dout1_35) AT=285.025n

* CHECK dout1_36 Vdout1_36ck56 = 0.9 time = 285
.meas tran vdout1_36ck56 FIND v(dout1_36) AT=285.025n

* CHECK dout1_37 Vdout1_37ck56 = 0.9 time = 285
.meas tran vdout1_37ck56 FIND v(dout1_37) AT=285.025n

* CHECK dout1_38 Vdout1_38ck56 = 0 time = 285
.meas tran vdout1_38ck56 FIND v(dout1_38) AT=285.025n

* CHECK dout1_39 Vdout1_39ck56 = 0 time = 285
.meas tran vdout1_39ck56 FIND v(dout1_39) AT=285.025n

* CHECK dout1_40 Vdout1_40ck56 = 0 time = 285
.meas tran vdout1_40ck56 FIND v(dout1_40) AT=285.025n

* CHECK dout1_41 Vdout1_41ck56 = 0.9 time = 285
.meas tran vdout1_41ck56 FIND v(dout1_41) AT=285.025n

* CHECK dout1_42 Vdout1_42ck56 = 0 time = 285
.meas tran vdout1_42ck56 FIND v(dout1_42) AT=285.025n

* CHECK dout1_43 Vdout1_43ck56 = 0 time = 285
.meas tran vdout1_43ck56 FIND v(dout1_43) AT=285.025n

* CHECK dout1_44 Vdout1_44ck56 = 0 time = 285
.meas tran vdout1_44ck56 FIND v(dout1_44) AT=285.025n

* CHECK dout1_45 Vdout1_45ck56 = 0 time = 285
.meas tran vdout1_45ck56 FIND v(dout1_45) AT=285.025n

* CHECK dout1_46 Vdout1_46ck56 = 0.9 time = 285
.meas tran vdout1_46ck56 FIND v(dout1_46) AT=285.025n

* CHECK dout1_47 Vdout1_47ck56 = 0 time = 285
.meas tran vdout1_47ck56 FIND v(dout1_47) AT=285.025n

* CHECK dout1_48 Vdout1_48ck56 = 0.9 time = 285
.meas tran vdout1_48ck56 FIND v(dout1_48) AT=285.025n

* CHECK dout1_49 Vdout1_49ck56 = 0.9 time = 285
.meas tran vdout1_49ck56 FIND v(dout1_49) AT=285.025n

* CHECK dout1_50 Vdout1_50ck56 = 0 time = 285
.meas tran vdout1_50ck56 FIND v(dout1_50) AT=285.025n

* CHECK dout1_51 Vdout1_51ck56 = 0.9 time = 285
.meas tran vdout1_51ck56 FIND v(dout1_51) AT=285.025n

* CHECK dout1_52 Vdout1_52ck56 = 0.9 time = 285
.meas tran vdout1_52ck56 FIND v(dout1_52) AT=285.025n

* CHECK dout1_53 Vdout1_53ck56 = 0 time = 285
.meas tran vdout1_53ck56 FIND v(dout1_53) AT=285.025n

* CHECK dout1_54 Vdout1_54ck56 = 0 time = 285
.meas tran vdout1_54ck56 FIND v(dout1_54) AT=285.025n

* CHECK dout1_55 Vdout1_55ck56 = 0 time = 285
.meas tran vdout1_55ck56 FIND v(dout1_55) AT=285.025n

* CHECK dout1_56 Vdout1_56ck56 = 0.9 time = 285
.meas tran vdout1_56ck56 FIND v(dout1_56) AT=285.025n

* CHECK dout1_57 Vdout1_57ck56 = 0 time = 285
.meas tran vdout1_57ck56 FIND v(dout1_57) AT=285.025n

* CHECK dout1_58 Vdout1_58ck56 = 0.9 time = 285
.meas tran vdout1_58ck56 FIND v(dout1_58) AT=285.025n

* CHECK dout1_59 Vdout1_59ck56 = 0.9 time = 285
.meas tran vdout1_59ck56 FIND v(dout1_59) AT=285.025n

* CHECK dout1_60 Vdout1_60ck56 = 0 time = 285
.meas tran vdout1_60ck56 FIND v(dout1_60) AT=285.025n

* CHECK dout1_61 Vdout1_61ck56 = 0 time = 285
.meas tran vdout1_61ck56 FIND v(dout1_61) AT=285.025n

* CHECK dout1_62 Vdout1_62ck56 = 0 time = 285
.meas tran vdout1_62ck56 FIND v(dout1_62) AT=285.025n

* CHECK dout1_63 Vdout1_63ck56 = 0.9 time = 285
.meas tran vdout1_63ck56 FIND v(dout1_63) AT=285.025n

* CHECK dout1_64 Vdout1_64ck56 = 0.9 time = 285
.meas tran vdout1_64ck56 FIND v(dout1_64) AT=285.025n

* CHECK dout1_65 Vdout1_65ck56 = 0.9 time = 285
.meas tran vdout1_65ck56 FIND v(dout1_65) AT=285.025n

* CHECK dout1_66 Vdout1_66ck56 = 0 time = 285
.meas tran vdout1_66ck56 FIND v(dout1_66) AT=285.025n

* CHECK dout1_67 Vdout1_67ck56 = 0.9 time = 285
.meas tran vdout1_67ck56 FIND v(dout1_67) AT=285.025n

* CHECK dout1_68 Vdout1_68ck56 = 0.9 time = 285
.meas tran vdout1_68ck56 FIND v(dout1_68) AT=285.025n

* CHECK dout1_69 Vdout1_69ck56 = 0 time = 285
.meas tran vdout1_69ck56 FIND v(dout1_69) AT=285.025n

* CHECK dout1_70 Vdout1_70ck56 = 0.9 time = 285
.meas tran vdout1_70ck56 FIND v(dout1_70) AT=285.025n

* CHECK dout1_71 Vdout1_71ck56 = 0 time = 285
.meas tran vdout1_71ck56 FIND v(dout1_71) AT=285.025n

* CHECK dout1_0 Vdout1_0ck60 = 0.9 time = 305
.meas tran vdout1_0ck60 FIND v(dout1_0) AT=305.025n

* CHECK dout1_1 Vdout1_1ck60 = 0.9 time = 305
.meas tran vdout1_1ck60 FIND v(dout1_1) AT=305.025n

* CHECK dout1_2 Vdout1_2ck60 = 0 time = 305
.meas tran vdout1_2ck60 FIND v(dout1_2) AT=305.025n

* CHECK dout1_3 Vdout1_3ck60 = 0.9 time = 305
.meas tran vdout1_3ck60 FIND v(dout1_3) AT=305.025n

* CHECK dout1_4 Vdout1_4ck60 = 0 time = 305
.meas tran vdout1_4ck60 FIND v(dout1_4) AT=305.025n

* CHECK dout1_5 Vdout1_5ck60 = 0 time = 305
.meas tran vdout1_5ck60 FIND v(dout1_5) AT=305.025n

* CHECK dout1_6 Vdout1_6ck60 = 0 time = 305
.meas tran vdout1_6ck60 FIND v(dout1_6) AT=305.025n

* CHECK dout1_7 Vdout1_7ck60 = 0 time = 305
.meas tran vdout1_7ck60 FIND v(dout1_7) AT=305.025n

* CHECK dout1_8 Vdout1_8ck60 = 0 time = 305
.meas tran vdout1_8ck60 FIND v(dout1_8) AT=305.025n

* CHECK dout1_9 Vdout1_9ck60 = 0.9 time = 305
.meas tran vdout1_9ck60 FIND v(dout1_9) AT=305.025n

* CHECK dout1_10 Vdout1_10ck60 = 0.9 time = 305
.meas tran vdout1_10ck60 FIND v(dout1_10) AT=305.025n

* CHECK dout1_11 Vdout1_11ck60 = 0 time = 305
.meas tran vdout1_11ck60 FIND v(dout1_11) AT=305.025n

* CHECK dout1_12 Vdout1_12ck60 = 0 time = 305
.meas tran vdout1_12ck60 FIND v(dout1_12) AT=305.025n

* CHECK dout1_13 Vdout1_13ck60 = 0.9 time = 305
.meas tran vdout1_13ck60 FIND v(dout1_13) AT=305.025n

* CHECK dout1_14 Vdout1_14ck60 = 0.9 time = 305
.meas tran vdout1_14ck60 FIND v(dout1_14) AT=305.025n

* CHECK dout1_15 Vdout1_15ck60 = 0.9 time = 305
.meas tran vdout1_15ck60 FIND v(dout1_15) AT=305.025n

* CHECK dout1_16 Vdout1_16ck60 = 0.9 time = 305
.meas tran vdout1_16ck60 FIND v(dout1_16) AT=305.025n

* CHECK dout1_17 Vdout1_17ck60 = 0 time = 305
.meas tran vdout1_17ck60 FIND v(dout1_17) AT=305.025n

* CHECK dout1_18 Vdout1_18ck60 = 0.9 time = 305
.meas tran vdout1_18ck60 FIND v(dout1_18) AT=305.025n

* CHECK dout1_19 Vdout1_19ck60 = 0 time = 305
.meas tran vdout1_19ck60 FIND v(dout1_19) AT=305.025n

* CHECK dout1_20 Vdout1_20ck60 = 0.9 time = 305
.meas tran vdout1_20ck60 FIND v(dout1_20) AT=305.025n

* CHECK dout1_21 Vdout1_21ck60 = 0 time = 305
.meas tran vdout1_21ck60 FIND v(dout1_21) AT=305.025n

* CHECK dout1_22 Vdout1_22ck60 = 0.9 time = 305
.meas tran vdout1_22ck60 FIND v(dout1_22) AT=305.025n

* CHECK dout1_23 Vdout1_23ck60 = 0.9 time = 305
.meas tran vdout1_23ck60 FIND v(dout1_23) AT=305.025n

* CHECK dout1_24 Vdout1_24ck60 = 0 time = 305
.meas tran vdout1_24ck60 FIND v(dout1_24) AT=305.025n

* CHECK dout1_25 Vdout1_25ck60 = 0 time = 305
.meas tran vdout1_25ck60 FIND v(dout1_25) AT=305.025n

* CHECK dout1_26 Vdout1_26ck60 = 0 time = 305
.meas tran vdout1_26ck60 FIND v(dout1_26) AT=305.025n

* CHECK dout1_27 Vdout1_27ck60 = 0.9 time = 305
.meas tran vdout1_27ck60 FIND v(dout1_27) AT=305.025n

* CHECK dout1_28 Vdout1_28ck60 = 0 time = 305
.meas tran vdout1_28ck60 FIND v(dout1_28) AT=305.025n

* CHECK dout1_29 Vdout1_29ck60 = 0 time = 305
.meas tran vdout1_29ck60 FIND v(dout1_29) AT=305.025n

* CHECK dout1_30 Vdout1_30ck60 = 0 time = 305
.meas tran vdout1_30ck60 FIND v(dout1_30) AT=305.025n

* CHECK dout1_31 Vdout1_31ck60 = 0 time = 305
.meas tran vdout1_31ck60 FIND v(dout1_31) AT=305.025n

* CHECK dout1_32 Vdout1_32ck60 = 0 time = 305
.meas tran vdout1_32ck60 FIND v(dout1_32) AT=305.025n

* CHECK dout1_33 Vdout1_33ck60 = 0 time = 305
.meas tran vdout1_33ck60 FIND v(dout1_33) AT=305.025n

* CHECK dout1_34 Vdout1_34ck60 = 0 time = 305
.meas tran vdout1_34ck60 FIND v(dout1_34) AT=305.025n

* CHECK dout1_35 Vdout1_35ck60 = 0.9 time = 305
.meas tran vdout1_35ck60 FIND v(dout1_35) AT=305.025n

* CHECK dout1_36 Vdout1_36ck60 = 0.9 time = 305
.meas tran vdout1_36ck60 FIND v(dout1_36) AT=305.025n

* CHECK dout1_37 Vdout1_37ck60 = 0 time = 305
.meas tran vdout1_37ck60 FIND v(dout1_37) AT=305.025n

* CHECK dout1_38 Vdout1_38ck60 = 0 time = 305
.meas tran vdout1_38ck60 FIND v(dout1_38) AT=305.025n

* CHECK dout1_39 Vdout1_39ck60 = 0 time = 305
.meas tran vdout1_39ck60 FIND v(dout1_39) AT=305.025n

* CHECK dout1_40 Vdout1_40ck60 = 0 time = 305
.meas tran vdout1_40ck60 FIND v(dout1_40) AT=305.025n

* CHECK dout1_41 Vdout1_41ck60 = 0 time = 305
.meas tran vdout1_41ck60 FIND v(dout1_41) AT=305.025n

* CHECK dout1_42 Vdout1_42ck60 = 0.9 time = 305
.meas tran vdout1_42ck60 FIND v(dout1_42) AT=305.025n

* CHECK dout1_43 Vdout1_43ck60 = 0.9 time = 305
.meas tran vdout1_43ck60 FIND v(dout1_43) AT=305.025n

* CHECK dout1_44 Vdout1_44ck60 = 0.9 time = 305
.meas tran vdout1_44ck60 FIND v(dout1_44) AT=305.025n

* CHECK dout1_45 Vdout1_45ck60 = 0.9 time = 305
.meas tran vdout1_45ck60 FIND v(dout1_45) AT=305.025n

* CHECK dout1_46 Vdout1_46ck60 = 0 time = 305
.meas tran vdout1_46ck60 FIND v(dout1_46) AT=305.025n

* CHECK dout1_47 Vdout1_47ck60 = 0.9 time = 305
.meas tran vdout1_47ck60 FIND v(dout1_47) AT=305.025n

* CHECK dout1_48 Vdout1_48ck60 = 0.9 time = 305
.meas tran vdout1_48ck60 FIND v(dout1_48) AT=305.025n

* CHECK dout1_49 Vdout1_49ck60 = 0.9 time = 305
.meas tran vdout1_49ck60 FIND v(dout1_49) AT=305.025n

* CHECK dout1_50 Vdout1_50ck60 = 0 time = 305
.meas tran vdout1_50ck60 FIND v(dout1_50) AT=305.025n

* CHECK dout1_51 Vdout1_51ck60 = 0.9 time = 305
.meas tran vdout1_51ck60 FIND v(dout1_51) AT=305.025n

* CHECK dout1_52 Vdout1_52ck60 = 0 time = 305
.meas tran vdout1_52ck60 FIND v(dout1_52) AT=305.025n

* CHECK dout1_53 Vdout1_53ck60 = 0.9 time = 305
.meas tran vdout1_53ck60 FIND v(dout1_53) AT=305.025n

* CHECK dout1_54 Vdout1_54ck60 = 0.9 time = 305
.meas tran vdout1_54ck60 FIND v(dout1_54) AT=305.025n

* CHECK dout1_55 Vdout1_55ck60 = 0 time = 305
.meas tran vdout1_55ck60 FIND v(dout1_55) AT=305.025n

* CHECK dout1_56 Vdout1_56ck60 = 0 time = 305
.meas tran vdout1_56ck60 FIND v(dout1_56) AT=305.025n

* CHECK dout1_57 Vdout1_57ck60 = 0.9 time = 305
.meas tran vdout1_57ck60 FIND v(dout1_57) AT=305.025n

* CHECK dout1_58 Vdout1_58ck60 = 0.9 time = 305
.meas tran vdout1_58ck60 FIND v(dout1_58) AT=305.025n

* CHECK dout1_59 Vdout1_59ck60 = 0 time = 305
.meas tran vdout1_59ck60 FIND v(dout1_59) AT=305.025n

* CHECK dout1_60 Vdout1_60ck60 = 0.9 time = 305
.meas tran vdout1_60ck60 FIND v(dout1_60) AT=305.025n

* CHECK dout1_61 Vdout1_61ck60 = 0 time = 305
.meas tran vdout1_61ck60 FIND v(dout1_61) AT=305.025n

* CHECK dout1_62 Vdout1_62ck60 = 0.9 time = 305
.meas tran vdout1_62ck60 FIND v(dout1_62) AT=305.025n

* CHECK dout1_63 Vdout1_63ck60 = 0 time = 305
.meas tran vdout1_63ck60 FIND v(dout1_63) AT=305.025n

* CHECK dout1_64 Vdout1_64ck60 = 0.9 time = 305
.meas tran vdout1_64ck60 FIND v(dout1_64) AT=305.025n

* CHECK dout1_65 Vdout1_65ck60 = 0.9 time = 305
.meas tran vdout1_65ck60 FIND v(dout1_65) AT=305.025n

* CHECK dout1_66 Vdout1_66ck60 = 0.9 time = 305
.meas tran vdout1_66ck60 FIND v(dout1_66) AT=305.025n

* CHECK dout1_67 Vdout1_67ck60 = 0 time = 305
.meas tran vdout1_67ck60 FIND v(dout1_67) AT=305.025n

* CHECK dout1_68 Vdout1_68ck60 = 0.9 time = 305
.meas tran vdout1_68ck60 FIND v(dout1_68) AT=305.025n

* CHECK dout1_69 Vdout1_69ck60 = 0.9 time = 305
.meas tran vdout1_69ck60 FIND v(dout1_69) AT=305.025n

* CHECK dout1_70 Vdout1_70ck60 = 0.9 time = 305
.meas tran vdout1_70ck60 FIND v(dout1_70) AT=305.025n

* CHECK dout1_71 Vdout1_71ck60 = 0 time = 305
.meas tran vdout1_71ck60 FIND v(dout1_71) AT=305.025n

* CHECK dout1_0 Vdout1_0ck63 = 0.9 time = 320
.meas tran vdout1_0ck63 FIND v(dout1_0) AT=320.025n

* CHECK dout1_1 Vdout1_1ck63 = 0.9 time = 320
.meas tran vdout1_1ck63 FIND v(dout1_1) AT=320.025n

* CHECK dout1_2 Vdout1_2ck63 = 0 time = 320
.meas tran vdout1_2ck63 FIND v(dout1_2) AT=320.025n

* CHECK dout1_3 Vdout1_3ck63 = 0.9 time = 320
.meas tran vdout1_3ck63 FIND v(dout1_3) AT=320.025n

* CHECK dout1_4 Vdout1_4ck63 = 0 time = 320
.meas tran vdout1_4ck63 FIND v(dout1_4) AT=320.025n

* CHECK dout1_5 Vdout1_5ck63 = 0 time = 320
.meas tran vdout1_5ck63 FIND v(dout1_5) AT=320.025n

* CHECK dout1_6 Vdout1_6ck63 = 0 time = 320
.meas tran vdout1_6ck63 FIND v(dout1_6) AT=320.025n

* CHECK dout1_7 Vdout1_7ck63 = 0 time = 320
.meas tran vdout1_7ck63 FIND v(dout1_7) AT=320.025n

* CHECK dout1_8 Vdout1_8ck63 = 0 time = 320
.meas tran vdout1_8ck63 FIND v(dout1_8) AT=320.025n

* CHECK dout1_9 Vdout1_9ck63 = 0.9 time = 320
.meas tran vdout1_9ck63 FIND v(dout1_9) AT=320.025n

* CHECK dout1_10 Vdout1_10ck63 = 0.9 time = 320
.meas tran vdout1_10ck63 FIND v(dout1_10) AT=320.025n

* CHECK dout1_11 Vdout1_11ck63 = 0 time = 320
.meas tran vdout1_11ck63 FIND v(dout1_11) AT=320.025n

* CHECK dout1_12 Vdout1_12ck63 = 0 time = 320
.meas tran vdout1_12ck63 FIND v(dout1_12) AT=320.025n

* CHECK dout1_13 Vdout1_13ck63 = 0.9 time = 320
.meas tran vdout1_13ck63 FIND v(dout1_13) AT=320.025n

* CHECK dout1_14 Vdout1_14ck63 = 0.9 time = 320
.meas tran vdout1_14ck63 FIND v(dout1_14) AT=320.025n

* CHECK dout1_15 Vdout1_15ck63 = 0.9 time = 320
.meas tran vdout1_15ck63 FIND v(dout1_15) AT=320.025n

* CHECK dout1_16 Vdout1_16ck63 = 0.9 time = 320
.meas tran vdout1_16ck63 FIND v(dout1_16) AT=320.025n

* CHECK dout1_17 Vdout1_17ck63 = 0 time = 320
.meas tran vdout1_17ck63 FIND v(dout1_17) AT=320.025n

* CHECK dout1_18 Vdout1_18ck63 = 0.9 time = 320
.meas tran vdout1_18ck63 FIND v(dout1_18) AT=320.025n

* CHECK dout1_19 Vdout1_19ck63 = 0 time = 320
.meas tran vdout1_19ck63 FIND v(dout1_19) AT=320.025n

* CHECK dout1_20 Vdout1_20ck63 = 0.9 time = 320
.meas tran vdout1_20ck63 FIND v(dout1_20) AT=320.025n

* CHECK dout1_21 Vdout1_21ck63 = 0 time = 320
.meas tran vdout1_21ck63 FIND v(dout1_21) AT=320.025n

* CHECK dout1_22 Vdout1_22ck63 = 0.9 time = 320
.meas tran vdout1_22ck63 FIND v(dout1_22) AT=320.025n

* CHECK dout1_23 Vdout1_23ck63 = 0.9 time = 320
.meas tran vdout1_23ck63 FIND v(dout1_23) AT=320.025n

* CHECK dout1_24 Vdout1_24ck63 = 0 time = 320
.meas tran vdout1_24ck63 FIND v(dout1_24) AT=320.025n

* CHECK dout1_25 Vdout1_25ck63 = 0 time = 320
.meas tran vdout1_25ck63 FIND v(dout1_25) AT=320.025n

* CHECK dout1_26 Vdout1_26ck63 = 0 time = 320
.meas tran vdout1_26ck63 FIND v(dout1_26) AT=320.025n

* CHECK dout1_27 Vdout1_27ck63 = 0.9 time = 320
.meas tran vdout1_27ck63 FIND v(dout1_27) AT=320.025n

* CHECK dout1_28 Vdout1_28ck63 = 0 time = 320
.meas tran vdout1_28ck63 FIND v(dout1_28) AT=320.025n

* CHECK dout1_29 Vdout1_29ck63 = 0 time = 320
.meas tran vdout1_29ck63 FIND v(dout1_29) AT=320.025n

* CHECK dout1_30 Vdout1_30ck63 = 0 time = 320
.meas tran vdout1_30ck63 FIND v(dout1_30) AT=320.025n

* CHECK dout1_31 Vdout1_31ck63 = 0 time = 320
.meas tran vdout1_31ck63 FIND v(dout1_31) AT=320.025n

* CHECK dout1_32 Vdout1_32ck63 = 0 time = 320
.meas tran vdout1_32ck63 FIND v(dout1_32) AT=320.025n

* CHECK dout1_33 Vdout1_33ck63 = 0 time = 320
.meas tran vdout1_33ck63 FIND v(dout1_33) AT=320.025n

* CHECK dout1_34 Vdout1_34ck63 = 0 time = 320
.meas tran vdout1_34ck63 FIND v(dout1_34) AT=320.025n

* CHECK dout1_35 Vdout1_35ck63 = 0.9 time = 320
.meas tran vdout1_35ck63 FIND v(dout1_35) AT=320.025n

* CHECK dout1_36 Vdout1_36ck63 = 0.9 time = 320
.meas tran vdout1_36ck63 FIND v(dout1_36) AT=320.025n

* CHECK dout1_37 Vdout1_37ck63 = 0 time = 320
.meas tran vdout1_37ck63 FIND v(dout1_37) AT=320.025n

* CHECK dout1_38 Vdout1_38ck63 = 0 time = 320
.meas tran vdout1_38ck63 FIND v(dout1_38) AT=320.025n

* CHECK dout1_39 Vdout1_39ck63 = 0 time = 320
.meas tran vdout1_39ck63 FIND v(dout1_39) AT=320.025n

* CHECK dout1_40 Vdout1_40ck63 = 0 time = 320
.meas tran vdout1_40ck63 FIND v(dout1_40) AT=320.025n

* CHECK dout1_41 Vdout1_41ck63 = 0 time = 320
.meas tran vdout1_41ck63 FIND v(dout1_41) AT=320.025n

* CHECK dout1_42 Vdout1_42ck63 = 0.9 time = 320
.meas tran vdout1_42ck63 FIND v(dout1_42) AT=320.025n

* CHECK dout1_43 Vdout1_43ck63 = 0.9 time = 320
.meas tran vdout1_43ck63 FIND v(dout1_43) AT=320.025n

* CHECK dout1_44 Vdout1_44ck63 = 0.9 time = 320
.meas tran vdout1_44ck63 FIND v(dout1_44) AT=320.025n

* CHECK dout1_45 Vdout1_45ck63 = 0.9 time = 320
.meas tran vdout1_45ck63 FIND v(dout1_45) AT=320.025n

* CHECK dout1_46 Vdout1_46ck63 = 0 time = 320
.meas tran vdout1_46ck63 FIND v(dout1_46) AT=320.025n

* CHECK dout1_47 Vdout1_47ck63 = 0.9 time = 320
.meas tran vdout1_47ck63 FIND v(dout1_47) AT=320.025n

* CHECK dout1_48 Vdout1_48ck63 = 0.9 time = 320
.meas tran vdout1_48ck63 FIND v(dout1_48) AT=320.025n

* CHECK dout1_49 Vdout1_49ck63 = 0.9 time = 320
.meas tran vdout1_49ck63 FIND v(dout1_49) AT=320.025n

* CHECK dout1_50 Vdout1_50ck63 = 0 time = 320
.meas tran vdout1_50ck63 FIND v(dout1_50) AT=320.025n

* CHECK dout1_51 Vdout1_51ck63 = 0.9 time = 320
.meas tran vdout1_51ck63 FIND v(dout1_51) AT=320.025n

* CHECK dout1_52 Vdout1_52ck63 = 0 time = 320
.meas tran vdout1_52ck63 FIND v(dout1_52) AT=320.025n

* CHECK dout1_53 Vdout1_53ck63 = 0.9 time = 320
.meas tran vdout1_53ck63 FIND v(dout1_53) AT=320.025n

* CHECK dout1_54 Vdout1_54ck63 = 0.9 time = 320
.meas tran vdout1_54ck63 FIND v(dout1_54) AT=320.025n

* CHECK dout1_55 Vdout1_55ck63 = 0 time = 320
.meas tran vdout1_55ck63 FIND v(dout1_55) AT=320.025n

* CHECK dout1_56 Vdout1_56ck63 = 0 time = 320
.meas tran vdout1_56ck63 FIND v(dout1_56) AT=320.025n

* CHECK dout1_57 Vdout1_57ck63 = 0.9 time = 320
.meas tran vdout1_57ck63 FIND v(dout1_57) AT=320.025n

* CHECK dout1_58 Vdout1_58ck63 = 0.9 time = 320
.meas tran vdout1_58ck63 FIND v(dout1_58) AT=320.025n

* CHECK dout1_59 Vdout1_59ck63 = 0 time = 320
.meas tran vdout1_59ck63 FIND v(dout1_59) AT=320.025n

* CHECK dout1_60 Vdout1_60ck63 = 0.9 time = 320
.meas tran vdout1_60ck63 FIND v(dout1_60) AT=320.025n

* CHECK dout1_61 Vdout1_61ck63 = 0 time = 320
.meas tran vdout1_61ck63 FIND v(dout1_61) AT=320.025n

* CHECK dout1_62 Vdout1_62ck63 = 0.9 time = 320
.meas tran vdout1_62ck63 FIND v(dout1_62) AT=320.025n

* CHECK dout1_63 Vdout1_63ck63 = 0 time = 320
.meas tran vdout1_63ck63 FIND v(dout1_63) AT=320.025n

* CHECK dout1_64 Vdout1_64ck63 = 0.9 time = 320
.meas tran vdout1_64ck63 FIND v(dout1_64) AT=320.025n

* CHECK dout1_65 Vdout1_65ck63 = 0.9 time = 320
.meas tran vdout1_65ck63 FIND v(dout1_65) AT=320.025n

* CHECK dout1_66 Vdout1_66ck63 = 0.9 time = 320
.meas tran vdout1_66ck63 FIND v(dout1_66) AT=320.025n

* CHECK dout1_67 Vdout1_67ck63 = 0 time = 320
.meas tran vdout1_67ck63 FIND v(dout1_67) AT=320.025n

* CHECK dout1_68 Vdout1_68ck63 = 0.9 time = 320
.meas tran vdout1_68ck63 FIND v(dout1_68) AT=320.025n

* CHECK dout1_69 Vdout1_69ck63 = 0.9 time = 320
.meas tran vdout1_69ck63 FIND v(dout1_69) AT=320.025n

* CHECK dout1_70 Vdout1_70ck63 = 0.9 time = 320
.meas tran vdout1_70ck63 FIND v(dout1_70) AT=320.025n

* CHECK dout1_71 Vdout1_71ck63 = 0 time = 320
.meas tran vdout1_71ck63 FIND v(dout1_71) AT=320.025n

* CHECK dout1_0 Vdout1_0ck64 = 0 time = 325
.meas tran vdout1_0ck64 FIND v(dout1_0) AT=325.025n

* CHECK dout1_1 Vdout1_1ck64 = 0.9 time = 325
.meas tran vdout1_1ck64 FIND v(dout1_1) AT=325.025n

* CHECK dout1_2 Vdout1_2ck64 = 0.9 time = 325
.meas tran vdout1_2ck64 FIND v(dout1_2) AT=325.025n

* CHECK dout1_3 Vdout1_3ck64 = 0.9 time = 325
.meas tran vdout1_3ck64 FIND v(dout1_3) AT=325.025n

* CHECK dout1_4 Vdout1_4ck64 = 0 time = 325
.meas tran vdout1_4ck64 FIND v(dout1_4) AT=325.025n

* CHECK dout1_5 Vdout1_5ck64 = 0.9 time = 325
.meas tran vdout1_5ck64 FIND v(dout1_5) AT=325.025n

* CHECK dout1_6 Vdout1_6ck64 = 0 time = 325
.meas tran vdout1_6ck64 FIND v(dout1_6) AT=325.025n

* CHECK dout1_7 Vdout1_7ck64 = 0.9 time = 325
.meas tran vdout1_7ck64 FIND v(dout1_7) AT=325.025n

* CHECK dout1_8 Vdout1_8ck64 = 0.9 time = 325
.meas tran vdout1_8ck64 FIND v(dout1_8) AT=325.025n

* CHECK dout1_9 Vdout1_9ck64 = 0 time = 325
.meas tran vdout1_9ck64 FIND v(dout1_9) AT=325.025n

* CHECK dout1_10 Vdout1_10ck64 = 0.9 time = 325
.meas tran vdout1_10ck64 FIND v(dout1_10) AT=325.025n

* CHECK dout1_11 Vdout1_11ck64 = 0.9 time = 325
.meas tran vdout1_11ck64 FIND v(dout1_11) AT=325.025n

* CHECK dout1_12 Vdout1_12ck64 = 0 time = 325
.meas tran vdout1_12ck64 FIND v(dout1_12) AT=325.025n

* CHECK dout1_13 Vdout1_13ck64 = 0.9 time = 325
.meas tran vdout1_13ck64 FIND v(dout1_13) AT=325.025n

* CHECK dout1_14 Vdout1_14ck64 = 0 time = 325
.meas tran vdout1_14ck64 FIND v(dout1_14) AT=325.025n

* CHECK dout1_15 Vdout1_15ck64 = 0 time = 325
.meas tran vdout1_15ck64 FIND v(dout1_15) AT=325.025n

* CHECK dout1_16 Vdout1_16ck64 = 0 time = 325
.meas tran vdout1_16ck64 FIND v(dout1_16) AT=325.025n

* CHECK dout1_17 Vdout1_17ck64 = 0 time = 325
.meas tran vdout1_17ck64 FIND v(dout1_17) AT=325.025n

* CHECK dout1_18 Vdout1_18ck64 = 0 time = 325
.meas tran vdout1_18ck64 FIND v(dout1_18) AT=325.025n

* CHECK dout1_19 Vdout1_19ck64 = 0 time = 325
.meas tran vdout1_19ck64 FIND v(dout1_19) AT=325.025n

* CHECK dout1_20 Vdout1_20ck64 = 0 time = 325
.meas tran vdout1_20ck64 FIND v(dout1_20) AT=325.025n

* CHECK dout1_21 Vdout1_21ck64 = 0.9 time = 325
.meas tran vdout1_21ck64 FIND v(dout1_21) AT=325.025n

* CHECK dout1_22 Vdout1_22ck64 = 0 time = 325
.meas tran vdout1_22ck64 FIND v(dout1_22) AT=325.025n

* CHECK dout1_23 Vdout1_23ck64 = 0 time = 325
.meas tran vdout1_23ck64 FIND v(dout1_23) AT=325.025n

* CHECK dout1_24 Vdout1_24ck64 = 0 time = 325
.meas tran vdout1_24ck64 FIND v(dout1_24) AT=325.025n

* CHECK dout1_25 Vdout1_25ck64 = 0 time = 325
.meas tran vdout1_25ck64 FIND v(dout1_25) AT=325.025n

* CHECK dout1_26 Vdout1_26ck64 = 0 time = 325
.meas tran vdout1_26ck64 FIND v(dout1_26) AT=325.025n

* CHECK dout1_27 Vdout1_27ck64 = 0 time = 325
.meas tran vdout1_27ck64 FIND v(dout1_27) AT=325.025n

* CHECK dout1_28 Vdout1_28ck64 = 0 time = 325
.meas tran vdout1_28ck64 FIND v(dout1_28) AT=325.025n

* CHECK dout1_29 Vdout1_29ck64 = 0.9 time = 325
.meas tran vdout1_29ck64 FIND v(dout1_29) AT=325.025n

* CHECK dout1_30 Vdout1_30ck64 = 0 time = 325
.meas tran vdout1_30ck64 FIND v(dout1_30) AT=325.025n

* CHECK dout1_31 Vdout1_31ck64 = 0 time = 325
.meas tran vdout1_31ck64 FIND v(dout1_31) AT=325.025n

* CHECK dout1_32 Vdout1_32ck64 = 0 time = 325
.meas tran vdout1_32ck64 FIND v(dout1_32) AT=325.025n

* CHECK dout1_33 Vdout1_33ck64 = 0.9 time = 325
.meas tran vdout1_33ck64 FIND v(dout1_33) AT=325.025n

* CHECK dout1_34 Vdout1_34ck64 = 0.9 time = 325
.meas tran vdout1_34ck64 FIND v(dout1_34) AT=325.025n

* CHECK dout1_35 Vdout1_35ck64 = 0.9 time = 325
.meas tran vdout1_35ck64 FIND v(dout1_35) AT=325.025n

* CHECK dout1_36 Vdout1_36ck64 = 0.9 time = 325
.meas tran vdout1_36ck64 FIND v(dout1_36) AT=325.025n

* CHECK dout1_37 Vdout1_37ck64 = 0.9 time = 325
.meas tran vdout1_37ck64 FIND v(dout1_37) AT=325.025n

* CHECK dout1_38 Vdout1_38ck64 = 0.9 time = 325
.meas tran vdout1_38ck64 FIND v(dout1_38) AT=325.025n

* CHECK dout1_39 Vdout1_39ck64 = 0 time = 325
.meas tran vdout1_39ck64 FIND v(dout1_39) AT=325.025n

* CHECK dout1_40 Vdout1_40ck64 = 0 time = 325
.meas tran vdout1_40ck64 FIND v(dout1_40) AT=325.025n

* CHECK dout1_41 Vdout1_41ck64 = 0 time = 325
.meas tran vdout1_41ck64 FIND v(dout1_41) AT=325.025n

* CHECK dout1_42 Vdout1_42ck64 = 0 time = 325
.meas tran vdout1_42ck64 FIND v(dout1_42) AT=325.025n

* CHECK dout1_43 Vdout1_43ck64 = 0.9 time = 325
.meas tran vdout1_43ck64 FIND v(dout1_43) AT=325.025n

* CHECK dout1_44 Vdout1_44ck64 = 0 time = 325
.meas tran vdout1_44ck64 FIND v(dout1_44) AT=325.025n

* CHECK dout1_45 Vdout1_45ck64 = 0 time = 325
.meas tran vdout1_45ck64 FIND v(dout1_45) AT=325.025n

* CHECK dout1_46 Vdout1_46ck64 = 0 time = 325
.meas tran vdout1_46ck64 FIND v(dout1_46) AT=325.025n

* CHECK dout1_47 Vdout1_47ck64 = 0.9 time = 325
.meas tran vdout1_47ck64 FIND v(dout1_47) AT=325.025n

* CHECK dout1_48 Vdout1_48ck64 = 0.9 time = 325
.meas tran vdout1_48ck64 FIND v(dout1_48) AT=325.025n

* CHECK dout1_49 Vdout1_49ck64 = 0 time = 325
.meas tran vdout1_49ck64 FIND v(dout1_49) AT=325.025n

* CHECK dout1_50 Vdout1_50ck64 = 0 time = 325
.meas tran vdout1_50ck64 FIND v(dout1_50) AT=325.025n

* CHECK dout1_51 Vdout1_51ck64 = 0 time = 325
.meas tran vdout1_51ck64 FIND v(dout1_51) AT=325.025n

* CHECK dout1_52 Vdout1_52ck64 = 0.9 time = 325
.meas tran vdout1_52ck64 FIND v(dout1_52) AT=325.025n

* CHECK dout1_53 Vdout1_53ck64 = 0 time = 325
.meas tran vdout1_53ck64 FIND v(dout1_53) AT=325.025n

* CHECK dout1_54 Vdout1_54ck64 = 0 time = 325
.meas tran vdout1_54ck64 FIND v(dout1_54) AT=325.025n

* CHECK dout1_55 Vdout1_55ck64 = 0.9 time = 325
.meas tran vdout1_55ck64 FIND v(dout1_55) AT=325.025n

* CHECK dout1_56 Vdout1_56ck64 = 0.9 time = 325
.meas tran vdout1_56ck64 FIND v(dout1_56) AT=325.025n

* CHECK dout1_57 Vdout1_57ck64 = 0.9 time = 325
.meas tran vdout1_57ck64 FIND v(dout1_57) AT=325.025n

* CHECK dout1_58 Vdout1_58ck64 = 0.9 time = 325
.meas tran vdout1_58ck64 FIND v(dout1_58) AT=325.025n

* CHECK dout1_59 Vdout1_59ck64 = 0.9 time = 325
.meas tran vdout1_59ck64 FIND v(dout1_59) AT=325.025n

* CHECK dout1_60 Vdout1_60ck64 = 0 time = 325
.meas tran vdout1_60ck64 FIND v(dout1_60) AT=325.025n

* CHECK dout1_61 Vdout1_61ck64 = 0 time = 325
.meas tran vdout1_61ck64 FIND v(dout1_61) AT=325.025n

* CHECK dout1_62 Vdout1_62ck64 = 0.9 time = 325
.meas tran vdout1_62ck64 FIND v(dout1_62) AT=325.025n

* CHECK dout1_63 Vdout1_63ck64 = 0.9 time = 325
.meas tran vdout1_63ck64 FIND v(dout1_63) AT=325.025n

* CHECK dout1_64 Vdout1_64ck64 = 0.9 time = 325
.meas tran vdout1_64ck64 FIND v(dout1_64) AT=325.025n

* CHECK dout1_65 Vdout1_65ck64 = 0.9 time = 325
.meas tran vdout1_65ck64 FIND v(dout1_65) AT=325.025n

* CHECK dout1_66 Vdout1_66ck64 = 0.9 time = 325
.meas tran vdout1_66ck64 FIND v(dout1_66) AT=325.025n

* CHECK dout1_67 Vdout1_67ck64 = 0 time = 325
.meas tran vdout1_67ck64 FIND v(dout1_67) AT=325.025n

* CHECK dout1_68 Vdout1_68ck64 = 0 time = 325
.meas tran vdout1_68ck64 FIND v(dout1_68) AT=325.025n

* CHECK dout1_69 Vdout1_69ck64 = 0 time = 325
.meas tran vdout1_69ck64 FIND v(dout1_69) AT=325.025n

* CHECK dout1_70 Vdout1_70ck64 = 0.9 time = 325
.meas tran vdout1_70ck64 FIND v(dout1_70) AT=325.025n

* CHECK dout1_71 Vdout1_71ck64 = 0 time = 325
.meas tran vdout1_71ck64 FIND v(dout1_71) AT=325.025n

* CHECK dout1_0 Vdout1_0ck75 = 0 time = 380
.meas tran vdout1_0ck75 FIND v(dout1_0) AT=380.025n

* CHECK dout1_1 Vdout1_1ck75 = 0.9 time = 380
.meas tran vdout1_1ck75 FIND v(dout1_1) AT=380.025n

* CHECK dout1_2 Vdout1_2ck75 = 0 time = 380
.meas tran vdout1_2ck75 FIND v(dout1_2) AT=380.025n

* CHECK dout1_3 Vdout1_3ck75 = 0.9 time = 380
.meas tran vdout1_3ck75 FIND v(dout1_3) AT=380.025n

* CHECK dout1_4 Vdout1_4ck75 = 0 time = 380
.meas tran vdout1_4ck75 FIND v(dout1_4) AT=380.025n

* CHECK dout1_5 Vdout1_5ck75 = 0.9 time = 380
.meas tran vdout1_5ck75 FIND v(dout1_5) AT=380.025n

* CHECK dout1_6 Vdout1_6ck75 = 0 time = 380
.meas tran vdout1_6ck75 FIND v(dout1_6) AT=380.025n

* CHECK dout1_7 Vdout1_7ck75 = 0 time = 380
.meas tran vdout1_7ck75 FIND v(dout1_7) AT=380.025n

* CHECK dout1_8 Vdout1_8ck75 = 0 time = 380
.meas tran vdout1_8ck75 FIND v(dout1_8) AT=380.025n

* CHECK dout1_9 Vdout1_9ck75 = 0 time = 380
.meas tran vdout1_9ck75 FIND v(dout1_9) AT=380.025n

* CHECK dout1_10 Vdout1_10ck75 = 0 time = 380
.meas tran vdout1_10ck75 FIND v(dout1_10) AT=380.025n

* CHECK dout1_11 Vdout1_11ck75 = 0.9 time = 380
.meas tran vdout1_11ck75 FIND v(dout1_11) AT=380.025n

* CHECK dout1_12 Vdout1_12ck75 = 0 time = 380
.meas tran vdout1_12ck75 FIND v(dout1_12) AT=380.025n

* CHECK dout1_13 Vdout1_13ck75 = 0 time = 380
.meas tran vdout1_13ck75 FIND v(dout1_13) AT=380.025n

* CHECK dout1_14 Vdout1_14ck75 = 0.9 time = 380
.meas tran vdout1_14ck75 FIND v(dout1_14) AT=380.025n

* CHECK dout1_15 Vdout1_15ck75 = 0 time = 380
.meas tran vdout1_15ck75 FIND v(dout1_15) AT=380.025n

* CHECK dout1_16 Vdout1_16ck75 = 0.9 time = 380
.meas tran vdout1_16ck75 FIND v(dout1_16) AT=380.025n

* CHECK dout1_17 Vdout1_17ck75 = 0 time = 380
.meas tran vdout1_17ck75 FIND v(dout1_17) AT=380.025n

* CHECK dout1_18 Vdout1_18ck75 = 0.9 time = 380
.meas tran vdout1_18ck75 FIND v(dout1_18) AT=380.025n

* CHECK dout1_19 Vdout1_19ck75 = 0 time = 380
.meas tran vdout1_19ck75 FIND v(dout1_19) AT=380.025n

* CHECK dout1_20 Vdout1_20ck75 = 0.9 time = 380
.meas tran vdout1_20ck75 FIND v(dout1_20) AT=380.025n

* CHECK dout1_21 Vdout1_21ck75 = 0.9 time = 380
.meas tran vdout1_21ck75 FIND v(dout1_21) AT=380.025n

* CHECK dout1_22 Vdout1_22ck75 = 0 time = 380
.meas tran vdout1_22ck75 FIND v(dout1_22) AT=380.025n

* CHECK dout1_23 Vdout1_23ck75 = 0 time = 380
.meas tran vdout1_23ck75 FIND v(dout1_23) AT=380.025n

* CHECK dout1_24 Vdout1_24ck75 = 0.9 time = 380
.meas tran vdout1_24ck75 FIND v(dout1_24) AT=380.025n

* CHECK dout1_25 Vdout1_25ck75 = 0 time = 380
.meas tran vdout1_25ck75 FIND v(dout1_25) AT=380.025n

* CHECK dout1_26 Vdout1_26ck75 = 0 time = 380
.meas tran vdout1_26ck75 FIND v(dout1_26) AT=380.025n

* CHECK dout1_27 Vdout1_27ck75 = 0.9 time = 380
.meas tran vdout1_27ck75 FIND v(dout1_27) AT=380.025n

* CHECK dout1_28 Vdout1_28ck75 = 0 time = 380
.meas tran vdout1_28ck75 FIND v(dout1_28) AT=380.025n

* CHECK dout1_29 Vdout1_29ck75 = 0 time = 380
.meas tran vdout1_29ck75 FIND v(dout1_29) AT=380.025n

* CHECK dout1_30 Vdout1_30ck75 = 0 time = 380
.meas tran vdout1_30ck75 FIND v(dout1_30) AT=380.025n

* CHECK dout1_31 Vdout1_31ck75 = 0.9 time = 380
.meas tran vdout1_31ck75 FIND v(dout1_31) AT=380.025n

* CHECK dout1_32 Vdout1_32ck75 = 0.9 time = 380
.meas tran vdout1_32ck75 FIND v(dout1_32) AT=380.025n

* CHECK dout1_33 Vdout1_33ck75 = 0.9 time = 380
.meas tran vdout1_33ck75 FIND v(dout1_33) AT=380.025n

* CHECK dout1_34 Vdout1_34ck75 = 0 time = 380
.meas tran vdout1_34ck75 FIND v(dout1_34) AT=380.025n

* CHECK dout1_35 Vdout1_35ck75 = 0 time = 380
.meas tran vdout1_35ck75 FIND v(dout1_35) AT=380.025n

* CHECK dout1_36 Vdout1_36ck75 = 0 time = 380
.meas tran vdout1_36ck75 FIND v(dout1_36) AT=380.025n

* CHECK dout1_37 Vdout1_37ck75 = 0 time = 380
.meas tran vdout1_37ck75 FIND v(dout1_37) AT=380.025n

* CHECK dout1_38 Vdout1_38ck75 = 0.9 time = 380
.meas tran vdout1_38ck75 FIND v(dout1_38) AT=380.025n

* CHECK dout1_39 Vdout1_39ck75 = 0.9 time = 380
.meas tran vdout1_39ck75 FIND v(dout1_39) AT=380.025n

* CHECK dout1_40 Vdout1_40ck75 = 0.9 time = 380
.meas tran vdout1_40ck75 FIND v(dout1_40) AT=380.025n

* CHECK dout1_41 Vdout1_41ck75 = 0 time = 380
.meas tran vdout1_41ck75 FIND v(dout1_41) AT=380.025n

* CHECK dout1_42 Vdout1_42ck75 = 0.9 time = 380
.meas tran vdout1_42ck75 FIND v(dout1_42) AT=380.025n

* CHECK dout1_43 Vdout1_43ck75 = 0.9 time = 380
.meas tran vdout1_43ck75 FIND v(dout1_43) AT=380.025n

* CHECK dout1_44 Vdout1_44ck75 = 0 time = 380
.meas tran vdout1_44ck75 FIND v(dout1_44) AT=380.025n

* CHECK dout1_45 Vdout1_45ck75 = 0.9 time = 380
.meas tran vdout1_45ck75 FIND v(dout1_45) AT=380.025n

* CHECK dout1_46 Vdout1_46ck75 = 0 time = 380
.meas tran vdout1_46ck75 FIND v(dout1_46) AT=380.025n

* CHECK dout1_47 Vdout1_47ck75 = 0 time = 380
.meas tran vdout1_47ck75 FIND v(dout1_47) AT=380.025n

* CHECK dout1_48 Vdout1_48ck75 = 0.9 time = 380
.meas tran vdout1_48ck75 FIND v(dout1_48) AT=380.025n

* CHECK dout1_49 Vdout1_49ck75 = 0.9 time = 380
.meas tran vdout1_49ck75 FIND v(dout1_49) AT=380.025n

* CHECK dout1_50 Vdout1_50ck75 = 0.9 time = 380
.meas tran vdout1_50ck75 FIND v(dout1_50) AT=380.025n

* CHECK dout1_51 Vdout1_51ck75 = 0 time = 380
.meas tran vdout1_51ck75 FIND v(dout1_51) AT=380.025n

* CHECK dout1_52 Vdout1_52ck75 = 0.9 time = 380
.meas tran vdout1_52ck75 FIND v(dout1_52) AT=380.025n

* CHECK dout1_53 Vdout1_53ck75 = 0.9 time = 380
.meas tran vdout1_53ck75 FIND v(dout1_53) AT=380.025n

* CHECK dout1_54 Vdout1_54ck75 = 0.9 time = 380
.meas tran vdout1_54ck75 FIND v(dout1_54) AT=380.025n

* CHECK dout1_55 Vdout1_55ck75 = 0 time = 380
.meas tran vdout1_55ck75 FIND v(dout1_55) AT=380.025n

* CHECK dout1_56 Vdout1_56ck75 = 0 time = 380
.meas tran vdout1_56ck75 FIND v(dout1_56) AT=380.025n

* CHECK dout1_57 Vdout1_57ck75 = 0.9 time = 380
.meas tran vdout1_57ck75 FIND v(dout1_57) AT=380.025n

* CHECK dout1_58 Vdout1_58ck75 = 0 time = 380
.meas tran vdout1_58ck75 FIND v(dout1_58) AT=380.025n

* CHECK dout1_59 Vdout1_59ck75 = 0 time = 380
.meas tran vdout1_59ck75 FIND v(dout1_59) AT=380.025n

* CHECK dout1_60 Vdout1_60ck75 = 0.9 time = 380
.meas tran vdout1_60ck75 FIND v(dout1_60) AT=380.025n

* CHECK dout1_61 Vdout1_61ck75 = 0.9 time = 380
.meas tran vdout1_61ck75 FIND v(dout1_61) AT=380.025n

* CHECK dout1_62 Vdout1_62ck75 = 0.9 time = 380
.meas tran vdout1_62ck75 FIND v(dout1_62) AT=380.025n

* CHECK dout1_63 Vdout1_63ck75 = 0 time = 380
.meas tran vdout1_63ck75 FIND v(dout1_63) AT=380.025n

* CHECK dout1_64 Vdout1_64ck75 = 0 time = 380
.meas tran vdout1_64ck75 FIND v(dout1_64) AT=380.025n

* CHECK dout1_65 Vdout1_65ck75 = 0 time = 380
.meas tran vdout1_65ck75 FIND v(dout1_65) AT=380.025n

* CHECK dout1_66 Vdout1_66ck75 = 0.9 time = 380
.meas tran vdout1_66ck75 FIND v(dout1_66) AT=380.025n

* CHECK dout1_67 Vdout1_67ck75 = 0.9 time = 380
.meas tran vdout1_67ck75 FIND v(dout1_67) AT=380.025n

* CHECK dout1_68 Vdout1_68ck75 = 0.9 time = 380
.meas tran vdout1_68ck75 FIND v(dout1_68) AT=380.025n

* CHECK dout1_69 Vdout1_69ck75 = 0.9 time = 380
.meas tran vdout1_69ck75 FIND v(dout1_69) AT=380.025n

* CHECK dout1_70 Vdout1_70ck75 = 0 time = 380
.meas tran vdout1_70ck75 FIND v(dout1_70) AT=380.025n

* CHECK dout1_71 Vdout1_71ck75 = 0 time = 380
.meas tran vdout1_71ck75 FIND v(dout1_71) AT=380.025n

* CHECK dout1_0 Vdout1_0ck77 = 0 time = 390
.meas tran vdout1_0ck77 FIND v(dout1_0) AT=390.025n

* CHECK dout1_1 Vdout1_1ck77 = 0.9 time = 390
.meas tran vdout1_1ck77 FIND v(dout1_1) AT=390.025n

* CHECK dout1_2 Vdout1_2ck77 = 0 time = 390
.meas tran vdout1_2ck77 FIND v(dout1_2) AT=390.025n

* CHECK dout1_3 Vdout1_3ck77 = 0.9 time = 390
.meas tran vdout1_3ck77 FIND v(dout1_3) AT=390.025n

* CHECK dout1_4 Vdout1_4ck77 = 0 time = 390
.meas tran vdout1_4ck77 FIND v(dout1_4) AT=390.025n

* CHECK dout1_5 Vdout1_5ck77 = 0.9 time = 390
.meas tran vdout1_5ck77 FIND v(dout1_5) AT=390.025n

* CHECK dout1_6 Vdout1_6ck77 = 0.9 time = 390
.meas tran vdout1_6ck77 FIND v(dout1_6) AT=390.025n

* CHECK dout1_7 Vdout1_7ck77 = 0.9 time = 390
.meas tran vdout1_7ck77 FIND v(dout1_7) AT=390.025n

* CHECK dout1_8 Vdout1_8ck77 = 0.9 time = 390
.meas tran vdout1_8ck77 FIND v(dout1_8) AT=390.025n

* CHECK dout1_9 Vdout1_9ck77 = 0 time = 390
.meas tran vdout1_9ck77 FIND v(dout1_9) AT=390.025n

* CHECK dout1_10 Vdout1_10ck77 = 0 time = 390
.meas tran vdout1_10ck77 FIND v(dout1_10) AT=390.025n

* CHECK dout1_11 Vdout1_11ck77 = 0 time = 390
.meas tran vdout1_11ck77 FIND v(dout1_11) AT=390.025n

* CHECK dout1_12 Vdout1_12ck77 = 0 time = 390
.meas tran vdout1_12ck77 FIND v(dout1_12) AT=390.025n

* CHECK dout1_13 Vdout1_13ck77 = 0 time = 390
.meas tran vdout1_13ck77 FIND v(dout1_13) AT=390.025n

* CHECK dout1_14 Vdout1_14ck77 = 0 time = 390
.meas tran vdout1_14ck77 FIND v(dout1_14) AT=390.025n

* CHECK dout1_15 Vdout1_15ck77 = 0 time = 390
.meas tran vdout1_15ck77 FIND v(dout1_15) AT=390.025n

* CHECK dout1_16 Vdout1_16ck77 = 0 time = 390
.meas tran vdout1_16ck77 FIND v(dout1_16) AT=390.025n

* CHECK dout1_17 Vdout1_17ck77 = 0 time = 390
.meas tran vdout1_17ck77 FIND v(dout1_17) AT=390.025n

* CHECK dout1_18 Vdout1_18ck77 = 0 time = 390
.meas tran vdout1_18ck77 FIND v(dout1_18) AT=390.025n

* CHECK dout1_19 Vdout1_19ck77 = 0 time = 390
.meas tran vdout1_19ck77 FIND v(dout1_19) AT=390.025n

* CHECK dout1_20 Vdout1_20ck77 = 0.9 time = 390
.meas tran vdout1_20ck77 FIND v(dout1_20) AT=390.025n

* CHECK dout1_21 Vdout1_21ck77 = 0 time = 390
.meas tran vdout1_21ck77 FIND v(dout1_21) AT=390.025n

* CHECK dout1_22 Vdout1_22ck77 = 0.9 time = 390
.meas tran vdout1_22ck77 FIND v(dout1_22) AT=390.025n

* CHECK dout1_23 Vdout1_23ck77 = 0.9 time = 390
.meas tran vdout1_23ck77 FIND v(dout1_23) AT=390.025n

* CHECK dout1_24 Vdout1_24ck77 = 0.9 time = 390
.meas tran vdout1_24ck77 FIND v(dout1_24) AT=390.025n

* CHECK dout1_25 Vdout1_25ck77 = 0 time = 390
.meas tran vdout1_25ck77 FIND v(dout1_25) AT=390.025n

* CHECK dout1_26 Vdout1_26ck77 = 0 time = 390
.meas tran vdout1_26ck77 FIND v(dout1_26) AT=390.025n

* CHECK dout1_27 Vdout1_27ck77 = 0.9 time = 390
.meas tran vdout1_27ck77 FIND v(dout1_27) AT=390.025n

* CHECK dout1_28 Vdout1_28ck77 = 0 time = 390
.meas tran vdout1_28ck77 FIND v(dout1_28) AT=390.025n

* CHECK dout1_29 Vdout1_29ck77 = 0 time = 390
.meas tran vdout1_29ck77 FIND v(dout1_29) AT=390.025n

* CHECK dout1_30 Vdout1_30ck77 = 0.9 time = 390
.meas tran vdout1_30ck77 FIND v(dout1_30) AT=390.025n

* CHECK dout1_31 Vdout1_31ck77 = 0 time = 390
.meas tran vdout1_31ck77 FIND v(dout1_31) AT=390.025n

* CHECK dout1_32 Vdout1_32ck77 = 0 time = 390
.meas tran vdout1_32ck77 FIND v(dout1_32) AT=390.025n

* CHECK dout1_33 Vdout1_33ck77 = 0 time = 390
.meas tran vdout1_33ck77 FIND v(dout1_33) AT=390.025n

* CHECK dout1_34 Vdout1_34ck77 = 0 time = 390
.meas tran vdout1_34ck77 FIND v(dout1_34) AT=390.025n

* CHECK dout1_35 Vdout1_35ck77 = 0 time = 390
.meas tran vdout1_35ck77 FIND v(dout1_35) AT=390.025n

* CHECK dout1_36 Vdout1_36ck77 = 0.9 time = 390
.meas tran vdout1_36ck77 FIND v(dout1_36) AT=390.025n

* CHECK dout1_37 Vdout1_37ck77 = 0 time = 390
.meas tran vdout1_37ck77 FIND v(dout1_37) AT=390.025n

* CHECK dout1_38 Vdout1_38ck77 = 0 time = 390
.meas tran vdout1_38ck77 FIND v(dout1_38) AT=390.025n

* CHECK dout1_39 Vdout1_39ck77 = 0 time = 390
.meas tran vdout1_39ck77 FIND v(dout1_39) AT=390.025n

* CHECK dout1_40 Vdout1_40ck77 = 0 time = 390
.meas tran vdout1_40ck77 FIND v(dout1_40) AT=390.025n

* CHECK dout1_41 Vdout1_41ck77 = 0 time = 390
.meas tran vdout1_41ck77 FIND v(dout1_41) AT=390.025n

* CHECK dout1_42 Vdout1_42ck77 = 0.9 time = 390
.meas tran vdout1_42ck77 FIND v(dout1_42) AT=390.025n

* CHECK dout1_43 Vdout1_43ck77 = 0 time = 390
.meas tran vdout1_43ck77 FIND v(dout1_43) AT=390.025n

* CHECK dout1_44 Vdout1_44ck77 = 0.9 time = 390
.meas tran vdout1_44ck77 FIND v(dout1_44) AT=390.025n

* CHECK dout1_45 Vdout1_45ck77 = 0 time = 390
.meas tran vdout1_45ck77 FIND v(dout1_45) AT=390.025n

* CHECK dout1_46 Vdout1_46ck77 = 0 time = 390
.meas tran vdout1_46ck77 FIND v(dout1_46) AT=390.025n

* CHECK dout1_47 Vdout1_47ck77 = 0 time = 390
.meas tran vdout1_47ck77 FIND v(dout1_47) AT=390.025n

* CHECK dout1_48 Vdout1_48ck77 = 0.9 time = 390
.meas tran vdout1_48ck77 FIND v(dout1_48) AT=390.025n

* CHECK dout1_49 Vdout1_49ck77 = 0.9 time = 390
.meas tran vdout1_49ck77 FIND v(dout1_49) AT=390.025n

* CHECK dout1_50 Vdout1_50ck77 = 0.9 time = 390
.meas tran vdout1_50ck77 FIND v(dout1_50) AT=390.025n

* CHECK dout1_51 Vdout1_51ck77 = 0.9 time = 390
.meas tran vdout1_51ck77 FIND v(dout1_51) AT=390.025n

* CHECK dout1_52 Vdout1_52ck77 = 0.9 time = 390
.meas tran vdout1_52ck77 FIND v(dout1_52) AT=390.025n

* CHECK dout1_53 Vdout1_53ck77 = 0.9 time = 390
.meas tran vdout1_53ck77 FIND v(dout1_53) AT=390.025n

* CHECK dout1_54 Vdout1_54ck77 = 0 time = 390
.meas tran vdout1_54ck77 FIND v(dout1_54) AT=390.025n

* CHECK dout1_55 Vdout1_55ck77 = 0.9 time = 390
.meas tran vdout1_55ck77 FIND v(dout1_55) AT=390.025n

* CHECK dout1_56 Vdout1_56ck77 = 0.9 time = 390
.meas tran vdout1_56ck77 FIND v(dout1_56) AT=390.025n

* CHECK dout1_57 Vdout1_57ck77 = 0 time = 390
.meas tran vdout1_57ck77 FIND v(dout1_57) AT=390.025n

* CHECK dout1_58 Vdout1_58ck77 = 0.9 time = 390
.meas tran vdout1_58ck77 FIND v(dout1_58) AT=390.025n

* CHECK dout1_59 Vdout1_59ck77 = 0 time = 390
.meas tran vdout1_59ck77 FIND v(dout1_59) AT=390.025n

* CHECK dout1_60 Vdout1_60ck77 = 0.9 time = 390
.meas tran vdout1_60ck77 FIND v(dout1_60) AT=390.025n

* CHECK dout1_61 Vdout1_61ck77 = 0 time = 390
.meas tran vdout1_61ck77 FIND v(dout1_61) AT=390.025n

* CHECK dout1_62 Vdout1_62ck77 = 0.9 time = 390
.meas tran vdout1_62ck77 FIND v(dout1_62) AT=390.025n

* CHECK dout1_63 Vdout1_63ck77 = 0 time = 390
.meas tran vdout1_63ck77 FIND v(dout1_63) AT=390.025n

* CHECK dout1_64 Vdout1_64ck77 = 0.9 time = 390
.meas tran vdout1_64ck77 FIND v(dout1_64) AT=390.025n

* CHECK dout1_65 Vdout1_65ck77 = 0 time = 390
.meas tran vdout1_65ck77 FIND v(dout1_65) AT=390.025n

* CHECK dout1_66 Vdout1_66ck77 = 0 time = 390
.meas tran vdout1_66ck77 FIND v(dout1_66) AT=390.025n

* CHECK dout1_67 Vdout1_67ck77 = 0.9 time = 390
.meas tran vdout1_67ck77 FIND v(dout1_67) AT=390.025n

* CHECK dout1_68 Vdout1_68ck77 = 0.9 time = 390
.meas tran vdout1_68ck77 FIND v(dout1_68) AT=390.025n

* CHECK dout1_69 Vdout1_69ck77 = 0.9 time = 390
.meas tran vdout1_69ck77 FIND v(dout1_69) AT=390.025n

* CHECK dout1_70 Vdout1_70ck77 = 0.9 time = 390
.meas tran vdout1_70ck77 FIND v(dout1_70) AT=390.025n

* CHECK dout1_71 Vdout1_71ck77 = 0 time = 390
.meas tran vdout1_71ck77 FIND v(dout1_71) AT=390.025n

* CHECK dout1_0 Vdout1_0ck81 = 0 time = 410
.meas tran vdout1_0ck81 FIND v(dout1_0) AT=410.025n

* CHECK dout1_1 Vdout1_1ck81 = 0 time = 410
.meas tran vdout1_1ck81 FIND v(dout1_1) AT=410.025n

* CHECK dout1_2 Vdout1_2ck81 = 0 time = 410
.meas tran vdout1_2ck81 FIND v(dout1_2) AT=410.025n

* CHECK dout1_3 Vdout1_3ck81 = 0 time = 410
.meas tran vdout1_3ck81 FIND v(dout1_3) AT=410.025n

* CHECK dout1_4 Vdout1_4ck81 = 0 time = 410
.meas tran vdout1_4ck81 FIND v(dout1_4) AT=410.025n

* CHECK dout1_5 Vdout1_5ck81 = 0 time = 410
.meas tran vdout1_5ck81 FIND v(dout1_5) AT=410.025n

* CHECK dout1_6 Vdout1_6ck81 = 0.9 time = 410
.meas tran vdout1_6ck81 FIND v(dout1_6) AT=410.025n

* CHECK dout1_7 Vdout1_7ck81 = 0.9 time = 410
.meas tran vdout1_7ck81 FIND v(dout1_7) AT=410.025n

* CHECK dout1_8 Vdout1_8ck81 = 0.9 time = 410
.meas tran vdout1_8ck81 FIND v(dout1_8) AT=410.025n

* CHECK dout1_9 Vdout1_9ck81 = 0.9 time = 410
.meas tran vdout1_9ck81 FIND v(dout1_9) AT=410.025n

* CHECK dout1_10 Vdout1_10ck81 = 0 time = 410
.meas tran vdout1_10ck81 FIND v(dout1_10) AT=410.025n

* CHECK dout1_11 Vdout1_11ck81 = 0 time = 410
.meas tran vdout1_11ck81 FIND v(dout1_11) AT=410.025n

* CHECK dout1_12 Vdout1_12ck81 = 0 time = 410
.meas tran vdout1_12ck81 FIND v(dout1_12) AT=410.025n

* CHECK dout1_13 Vdout1_13ck81 = 0 time = 410
.meas tran vdout1_13ck81 FIND v(dout1_13) AT=410.025n

* CHECK dout1_14 Vdout1_14ck81 = 0 time = 410
.meas tran vdout1_14ck81 FIND v(dout1_14) AT=410.025n

* CHECK dout1_15 Vdout1_15ck81 = 0.9 time = 410
.meas tran vdout1_15ck81 FIND v(dout1_15) AT=410.025n

* CHECK dout1_16 Vdout1_16ck81 = 0 time = 410
.meas tran vdout1_16ck81 FIND v(dout1_16) AT=410.025n

* CHECK dout1_17 Vdout1_17ck81 = 0.9 time = 410
.meas tran vdout1_17ck81 FIND v(dout1_17) AT=410.025n

* CHECK dout1_18 Vdout1_18ck81 = 0.9 time = 410
.meas tran vdout1_18ck81 FIND v(dout1_18) AT=410.025n

* CHECK dout1_19 Vdout1_19ck81 = 0 time = 410
.meas tran vdout1_19ck81 FIND v(dout1_19) AT=410.025n

* CHECK dout1_20 Vdout1_20ck81 = 0.9 time = 410
.meas tran vdout1_20ck81 FIND v(dout1_20) AT=410.025n

* CHECK dout1_21 Vdout1_21ck81 = 0.9 time = 410
.meas tran vdout1_21ck81 FIND v(dout1_21) AT=410.025n

* CHECK dout1_22 Vdout1_22ck81 = 0 time = 410
.meas tran vdout1_22ck81 FIND v(dout1_22) AT=410.025n

* CHECK dout1_23 Vdout1_23ck81 = 0 time = 410
.meas tran vdout1_23ck81 FIND v(dout1_23) AT=410.025n

* CHECK dout1_24 Vdout1_24ck81 = 0 time = 410
.meas tran vdout1_24ck81 FIND v(dout1_24) AT=410.025n

* CHECK dout1_25 Vdout1_25ck81 = 0.9 time = 410
.meas tran vdout1_25ck81 FIND v(dout1_25) AT=410.025n

* CHECK dout1_26 Vdout1_26ck81 = 0 time = 410
.meas tran vdout1_26ck81 FIND v(dout1_26) AT=410.025n

* CHECK dout1_27 Vdout1_27ck81 = 0.9 time = 410
.meas tran vdout1_27ck81 FIND v(dout1_27) AT=410.025n

* CHECK dout1_28 Vdout1_28ck81 = 0 time = 410
.meas tran vdout1_28ck81 FIND v(dout1_28) AT=410.025n

* CHECK dout1_29 Vdout1_29ck81 = 0.9 time = 410
.meas tran vdout1_29ck81 FIND v(dout1_29) AT=410.025n

* CHECK dout1_30 Vdout1_30ck81 = 0 time = 410
.meas tran vdout1_30ck81 FIND v(dout1_30) AT=410.025n

* CHECK dout1_31 Vdout1_31ck81 = 0 time = 410
.meas tran vdout1_31ck81 FIND v(dout1_31) AT=410.025n

* CHECK dout1_32 Vdout1_32ck81 = 0 time = 410
.meas tran vdout1_32ck81 FIND v(dout1_32) AT=410.025n

* CHECK dout1_33 Vdout1_33ck81 = 0.9 time = 410
.meas tran vdout1_33ck81 FIND v(dout1_33) AT=410.025n

* CHECK dout1_34 Vdout1_34ck81 = 0.9 time = 410
.meas tran vdout1_34ck81 FIND v(dout1_34) AT=410.025n

* CHECK dout1_35 Vdout1_35ck81 = 0.9 time = 410
.meas tran vdout1_35ck81 FIND v(dout1_35) AT=410.025n

* CHECK dout1_36 Vdout1_36ck81 = 0 time = 410
.meas tran vdout1_36ck81 FIND v(dout1_36) AT=410.025n

* CHECK dout1_37 Vdout1_37ck81 = 0 time = 410
.meas tran vdout1_37ck81 FIND v(dout1_37) AT=410.025n

* CHECK dout1_38 Vdout1_38ck81 = 0 time = 410
.meas tran vdout1_38ck81 FIND v(dout1_38) AT=410.025n

* CHECK dout1_39 Vdout1_39ck81 = 0 time = 410
.meas tran vdout1_39ck81 FIND v(dout1_39) AT=410.025n

* CHECK dout1_40 Vdout1_40ck81 = 0.9 time = 410
.meas tran vdout1_40ck81 FIND v(dout1_40) AT=410.025n

* CHECK dout1_41 Vdout1_41ck81 = 0 time = 410
.meas tran vdout1_41ck81 FIND v(dout1_41) AT=410.025n

* CHECK dout1_42 Vdout1_42ck81 = 0.9 time = 410
.meas tran vdout1_42ck81 FIND v(dout1_42) AT=410.025n

* CHECK dout1_43 Vdout1_43ck81 = 0.9 time = 410
.meas tran vdout1_43ck81 FIND v(dout1_43) AT=410.025n

* CHECK dout1_44 Vdout1_44ck81 = 0.9 time = 410
.meas tran vdout1_44ck81 FIND v(dout1_44) AT=410.025n

* CHECK dout1_45 Vdout1_45ck81 = 0 time = 410
.meas tran vdout1_45ck81 FIND v(dout1_45) AT=410.025n

* CHECK dout1_46 Vdout1_46ck81 = 0 time = 410
.meas tran vdout1_46ck81 FIND v(dout1_46) AT=410.025n

* CHECK dout1_47 Vdout1_47ck81 = 0.9 time = 410
.meas tran vdout1_47ck81 FIND v(dout1_47) AT=410.025n

* CHECK dout1_48 Vdout1_48ck81 = 0.9 time = 410
.meas tran vdout1_48ck81 FIND v(dout1_48) AT=410.025n

* CHECK dout1_49 Vdout1_49ck81 = 0 time = 410
.meas tran vdout1_49ck81 FIND v(dout1_49) AT=410.025n

* CHECK dout1_50 Vdout1_50ck81 = 0.9 time = 410
.meas tran vdout1_50ck81 FIND v(dout1_50) AT=410.025n

* CHECK dout1_51 Vdout1_51ck81 = 0.9 time = 410
.meas tran vdout1_51ck81 FIND v(dout1_51) AT=410.025n

* CHECK dout1_52 Vdout1_52ck81 = 0 time = 410
.meas tran vdout1_52ck81 FIND v(dout1_52) AT=410.025n

* CHECK dout1_53 Vdout1_53ck81 = 0 time = 410
.meas tran vdout1_53ck81 FIND v(dout1_53) AT=410.025n

* CHECK dout1_54 Vdout1_54ck81 = 0.9 time = 410
.meas tran vdout1_54ck81 FIND v(dout1_54) AT=410.025n

* CHECK dout1_55 Vdout1_55ck81 = 0.9 time = 410
.meas tran vdout1_55ck81 FIND v(dout1_55) AT=410.025n

* CHECK dout1_56 Vdout1_56ck81 = 0 time = 410
.meas tran vdout1_56ck81 FIND v(dout1_56) AT=410.025n

* CHECK dout1_57 Vdout1_57ck81 = 0 time = 410
.meas tran vdout1_57ck81 FIND v(dout1_57) AT=410.025n

* CHECK dout1_58 Vdout1_58ck81 = 0 time = 410
.meas tran vdout1_58ck81 FIND v(dout1_58) AT=410.025n

* CHECK dout1_59 Vdout1_59ck81 = 0 time = 410
.meas tran vdout1_59ck81 FIND v(dout1_59) AT=410.025n

* CHECK dout1_60 Vdout1_60ck81 = 0.9 time = 410
.meas tran vdout1_60ck81 FIND v(dout1_60) AT=410.025n

* CHECK dout1_61 Vdout1_61ck81 = 0.9 time = 410
.meas tran vdout1_61ck81 FIND v(dout1_61) AT=410.025n

* CHECK dout1_62 Vdout1_62ck81 = 0 time = 410
.meas tran vdout1_62ck81 FIND v(dout1_62) AT=410.025n

* CHECK dout1_63 Vdout1_63ck81 = 0.9 time = 410
.meas tran vdout1_63ck81 FIND v(dout1_63) AT=410.025n

* CHECK dout1_64 Vdout1_64ck81 = 0.9 time = 410
.meas tran vdout1_64ck81 FIND v(dout1_64) AT=410.025n

* CHECK dout1_65 Vdout1_65ck81 = 0 time = 410
.meas tran vdout1_65ck81 FIND v(dout1_65) AT=410.025n

* CHECK dout1_66 Vdout1_66ck81 = 0 time = 410
.meas tran vdout1_66ck81 FIND v(dout1_66) AT=410.025n

* CHECK dout1_67 Vdout1_67ck81 = 0 time = 410
.meas tran vdout1_67ck81 FIND v(dout1_67) AT=410.025n

* CHECK dout1_68 Vdout1_68ck81 = 0 time = 410
.meas tran vdout1_68ck81 FIND v(dout1_68) AT=410.025n

* CHECK dout1_69 Vdout1_69ck81 = 0.9 time = 410
.meas tran vdout1_69ck81 FIND v(dout1_69) AT=410.025n

* CHECK dout1_70 Vdout1_70ck81 = 0 time = 410
.meas tran vdout1_70ck81 FIND v(dout1_70) AT=410.025n

* CHECK dout1_71 Vdout1_71ck81 = 0 time = 410
.meas tran vdout1_71ck81 FIND v(dout1_71) AT=410.025n

* CHECK dout1_0 Vdout1_0ck83 = 0.9 time = 420
.meas tran vdout1_0ck83 FIND v(dout1_0) AT=420.025n

* CHECK dout1_1 Vdout1_1ck83 = 0 time = 420
.meas tran vdout1_1ck83 FIND v(dout1_1) AT=420.025n

* CHECK dout1_2 Vdout1_2ck83 = 0 time = 420
.meas tran vdout1_2ck83 FIND v(dout1_2) AT=420.025n

* CHECK dout1_3 Vdout1_3ck83 = 0.9 time = 420
.meas tran vdout1_3ck83 FIND v(dout1_3) AT=420.025n

* CHECK dout1_4 Vdout1_4ck83 = 0 time = 420
.meas tran vdout1_4ck83 FIND v(dout1_4) AT=420.025n

* CHECK dout1_5 Vdout1_5ck83 = 0.9 time = 420
.meas tran vdout1_5ck83 FIND v(dout1_5) AT=420.025n

* CHECK dout1_6 Vdout1_6ck83 = 0 time = 420
.meas tran vdout1_6ck83 FIND v(dout1_6) AT=420.025n

* CHECK dout1_7 Vdout1_7ck83 = 0.9 time = 420
.meas tran vdout1_7ck83 FIND v(dout1_7) AT=420.025n

* CHECK dout1_8 Vdout1_8ck83 = 0.9 time = 420
.meas tran vdout1_8ck83 FIND v(dout1_8) AT=420.025n

* CHECK dout1_9 Vdout1_9ck83 = 0 time = 420
.meas tran vdout1_9ck83 FIND v(dout1_9) AT=420.025n

* CHECK dout1_10 Vdout1_10ck83 = 0 time = 420
.meas tran vdout1_10ck83 FIND v(dout1_10) AT=420.025n

* CHECK dout1_11 Vdout1_11ck83 = 0 time = 420
.meas tran vdout1_11ck83 FIND v(dout1_11) AT=420.025n

* CHECK dout1_12 Vdout1_12ck83 = 0.9 time = 420
.meas tran vdout1_12ck83 FIND v(dout1_12) AT=420.025n

* CHECK dout1_13 Vdout1_13ck83 = 0 time = 420
.meas tran vdout1_13ck83 FIND v(dout1_13) AT=420.025n

* CHECK dout1_14 Vdout1_14ck83 = 0.9 time = 420
.meas tran vdout1_14ck83 FIND v(dout1_14) AT=420.025n

* CHECK dout1_15 Vdout1_15ck83 = 0.9 time = 420
.meas tran vdout1_15ck83 FIND v(dout1_15) AT=420.025n

* CHECK dout1_16 Vdout1_16ck83 = 0 time = 420
.meas tran vdout1_16ck83 FIND v(dout1_16) AT=420.025n

* CHECK dout1_17 Vdout1_17ck83 = 0.9 time = 420
.meas tran vdout1_17ck83 FIND v(dout1_17) AT=420.025n

* CHECK dout1_18 Vdout1_18ck83 = 0 time = 420
.meas tran vdout1_18ck83 FIND v(dout1_18) AT=420.025n

* CHECK dout1_19 Vdout1_19ck83 = 0 time = 420
.meas tran vdout1_19ck83 FIND v(dout1_19) AT=420.025n

* CHECK dout1_20 Vdout1_20ck83 = 0.9 time = 420
.meas tran vdout1_20ck83 FIND v(dout1_20) AT=420.025n

* CHECK dout1_21 Vdout1_21ck83 = 0.9 time = 420
.meas tran vdout1_21ck83 FIND v(dout1_21) AT=420.025n

* CHECK dout1_22 Vdout1_22ck83 = 0.9 time = 420
.meas tran vdout1_22ck83 FIND v(dout1_22) AT=420.025n

* CHECK dout1_23 Vdout1_23ck83 = 0 time = 420
.meas tran vdout1_23ck83 FIND v(dout1_23) AT=420.025n

* CHECK dout1_24 Vdout1_24ck83 = 0.9 time = 420
.meas tran vdout1_24ck83 FIND v(dout1_24) AT=420.025n

* CHECK dout1_25 Vdout1_25ck83 = 0 time = 420
.meas tran vdout1_25ck83 FIND v(dout1_25) AT=420.025n

* CHECK dout1_26 Vdout1_26ck83 = 0 time = 420
.meas tran vdout1_26ck83 FIND v(dout1_26) AT=420.025n

* CHECK dout1_27 Vdout1_27ck83 = 0 time = 420
.meas tran vdout1_27ck83 FIND v(dout1_27) AT=420.025n

* CHECK dout1_28 Vdout1_28ck83 = 0 time = 420
.meas tran vdout1_28ck83 FIND v(dout1_28) AT=420.025n

* CHECK dout1_29 Vdout1_29ck83 = 0.9 time = 420
.meas tran vdout1_29ck83 FIND v(dout1_29) AT=420.025n

* CHECK dout1_30 Vdout1_30ck83 = 0 time = 420
.meas tran vdout1_30ck83 FIND v(dout1_30) AT=420.025n

* CHECK dout1_31 Vdout1_31ck83 = 0.9 time = 420
.meas tran vdout1_31ck83 FIND v(dout1_31) AT=420.025n

* CHECK dout1_32 Vdout1_32ck83 = 0.9 time = 420
.meas tran vdout1_32ck83 FIND v(dout1_32) AT=420.025n

* CHECK dout1_33 Vdout1_33ck83 = 0 time = 420
.meas tran vdout1_33ck83 FIND v(dout1_33) AT=420.025n

* CHECK dout1_34 Vdout1_34ck83 = 0.9 time = 420
.meas tran vdout1_34ck83 FIND v(dout1_34) AT=420.025n

* CHECK dout1_35 Vdout1_35ck83 = 0.9 time = 420
.meas tran vdout1_35ck83 FIND v(dout1_35) AT=420.025n

* CHECK dout1_36 Vdout1_36ck83 = 0 time = 420
.meas tran vdout1_36ck83 FIND v(dout1_36) AT=420.025n

* CHECK dout1_37 Vdout1_37ck83 = 0.9 time = 420
.meas tran vdout1_37ck83 FIND v(dout1_37) AT=420.025n

* CHECK dout1_38 Vdout1_38ck83 = 0 time = 420
.meas tran vdout1_38ck83 FIND v(dout1_38) AT=420.025n

* CHECK dout1_39 Vdout1_39ck83 = 0.9 time = 420
.meas tran vdout1_39ck83 FIND v(dout1_39) AT=420.025n

* CHECK dout1_40 Vdout1_40ck83 = 0 time = 420
.meas tran vdout1_40ck83 FIND v(dout1_40) AT=420.025n

* CHECK dout1_41 Vdout1_41ck83 = 0.9 time = 420
.meas tran vdout1_41ck83 FIND v(dout1_41) AT=420.025n

* CHECK dout1_42 Vdout1_42ck83 = 0.9 time = 420
.meas tran vdout1_42ck83 FIND v(dout1_42) AT=420.025n

* CHECK dout1_43 Vdout1_43ck83 = 0 time = 420
.meas tran vdout1_43ck83 FIND v(dout1_43) AT=420.025n

* CHECK dout1_44 Vdout1_44ck83 = 0 time = 420
.meas tran vdout1_44ck83 FIND v(dout1_44) AT=420.025n

* CHECK dout1_45 Vdout1_45ck83 = 0 time = 420
.meas tran vdout1_45ck83 FIND v(dout1_45) AT=420.025n

* CHECK dout1_46 Vdout1_46ck83 = 0.9 time = 420
.meas tran vdout1_46ck83 FIND v(dout1_46) AT=420.025n

* CHECK dout1_47 Vdout1_47ck83 = 0.9 time = 420
.meas tran vdout1_47ck83 FIND v(dout1_47) AT=420.025n

* CHECK dout1_48 Vdout1_48ck83 = 0 time = 420
.meas tran vdout1_48ck83 FIND v(dout1_48) AT=420.025n

* CHECK dout1_49 Vdout1_49ck83 = 0.9 time = 420
.meas tran vdout1_49ck83 FIND v(dout1_49) AT=420.025n

* CHECK dout1_50 Vdout1_50ck83 = 0.9 time = 420
.meas tran vdout1_50ck83 FIND v(dout1_50) AT=420.025n

* CHECK dout1_51 Vdout1_51ck83 = 0 time = 420
.meas tran vdout1_51ck83 FIND v(dout1_51) AT=420.025n

* CHECK dout1_52 Vdout1_52ck83 = 0 time = 420
.meas tran vdout1_52ck83 FIND v(dout1_52) AT=420.025n

* CHECK dout1_53 Vdout1_53ck83 = 0 time = 420
.meas tran vdout1_53ck83 FIND v(dout1_53) AT=420.025n

* CHECK dout1_54 Vdout1_54ck83 = 0.9 time = 420
.meas tran vdout1_54ck83 FIND v(dout1_54) AT=420.025n

* CHECK dout1_55 Vdout1_55ck83 = 0.9 time = 420
.meas tran vdout1_55ck83 FIND v(dout1_55) AT=420.025n

* CHECK dout1_56 Vdout1_56ck83 = 0 time = 420
.meas tran vdout1_56ck83 FIND v(dout1_56) AT=420.025n

* CHECK dout1_57 Vdout1_57ck83 = 0.9 time = 420
.meas tran vdout1_57ck83 FIND v(dout1_57) AT=420.025n

* CHECK dout1_58 Vdout1_58ck83 = 0 time = 420
.meas tran vdout1_58ck83 FIND v(dout1_58) AT=420.025n

* CHECK dout1_59 Vdout1_59ck83 = 0.9 time = 420
.meas tran vdout1_59ck83 FIND v(dout1_59) AT=420.025n

* CHECK dout1_60 Vdout1_60ck83 = 0 time = 420
.meas tran vdout1_60ck83 FIND v(dout1_60) AT=420.025n

* CHECK dout1_61 Vdout1_61ck83 = 0 time = 420
.meas tran vdout1_61ck83 FIND v(dout1_61) AT=420.025n

* CHECK dout1_62 Vdout1_62ck83 = 0.9 time = 420
.meas tran vdout1_62ck83 FIND v(dout1_62) AT=420.025n

* CHECK dout1_63 Vdout1_63ck83 = 0 time = 420
.meas tran vdout1_63ck83 FIND v(dout1_63) AT=420.025n

* CHECK dout1_64 Vdout1_64ck83 = 0 time = 420
.meas tran vdout1_64ck83 FIND v(dout1_64) AT=420.025n

* CHECK dout1_65 Vdout1_65ck83 = 0.9 time = 420
.meas tran vdout1_65ck83 FIND v(dout1_65) AT=420.025n

* CHECK dout1_66 Vdout1_66ck83 = 0 time = 420
.meas tran vdout1_66ck83 FIND v(dout1_66) AT=420.025n

* CHECK dout1_67 Vdout1_67ck83 = 0.9 time = 420
.meas tran vdout1_67ck83 FIND v(dout1_67) AT=420.025n

* CHECK dout1_68 Vdout1_68ck83 = 0.9 time = 420
.meas tran vdout1_68ck83 FIND v(dout1_68) AT=420.025n

* CHECK dout1_69 Vdout1_69ck83 = 0 time = 420
.meas tran vdout1_69ck83 FIND v(dout1_69) AT=420.025n

* CHECK dout1_70 Vdout1_70ck83 = 0 time = 420
.meas tran vdout1_70ck83 FIND v(dout1_70) AT=420.025n

* CHECK dout1_71 Vdout1_71ck83 = 0.9 time = 420
.meas tran vdout1_71ck83 FIND v(dout1_71) AT=420.025n

* CHECK dout1_0 Vdout1_0ck88 = 0.9 time = 445
.meas tran vdout1_0ck88 FIND v(dout1_0) AT=445.025n

* CHECK dout1_1 Vdout1_1ck88 = 0 time = 445
.meas tran vdout1_1ck88 FIND v(dout1_1) AT=445.025n

* CHECK dout1_2 Vdout1_2ck88 = 0.9 time = 445
.meas tran vdout1_2ck88 FIND v(dout1_2) AT=445.025n

* CHECK dout1_3 Vdout1_3ck88 = 0 time = 445
.meas tran vdout1_3ck88 FIND v(dout1_3) AT=445.025n

* CHECK dout1_4 Vdout1_4ck88 = 0.9 time = 445
.meas tran vdout1_4ck88 FIND v(dout1_4) AT=445.025n

* CHECK dout1_5 Vdout1_5ck88 = 0 time = 445
.meas tran vdout1_5ck88 FIND v(dout1_5) AT=445.025n

* CHECK dout1_6 Vdout1_6ck88 = 0 time = 445
.meas tran vdout1_6ck88 FIND v(dout1_6) AT=445.025n

* CHECK dout1_7 Vdout1_7ck88 = 0 time = 445
.meas tran vdout1_7ck88 FIND v(dout1_7) AT=445.025n

* CHECK dout1_8 Vdout1_8ck88 = 0 time = 445
.meas tran vdout1_8ck88 FIND v(dout1_8) AT=445.025n

* CHECK dout1_9 Vdout1_9ck88 = 0.9 time = 445
.meas tran vdout1_9ck88 FIND v(dout1_9) AT=445.025n

* CHECK dout1_10 Vdout1_10ck88 = 0.9 time = 445
.meas tran vdout1_10ck88 FIND v(dout1_10) AT=445.025n

* CHECK dout1_11 Vdout1_11ck88 = 0 time = 445
.meas tran vdout1_11ck88 FIND v(dout1_11) AT=445.025n

* CHECK dout1_12 Vdout1_12ck88 = 0.9 time = 445
.meas tran vdout1_12ck88 FIND v(dout1_12) AT=445.025n

* CHECK dout1_13 Vdout1_13ck88 = 0 time = 445
.meas tran vdout1_13ck88 FIND v(dout1_13) AT=445.025n

* CHECK dout1_14 Vdout1_14ck88 = 0 time = 445
.meas tran vdout1_14ck88 FIND v(dout1_14) AT=445.025n

* CHECK dout1_15 Vdout1_15ck88 = 0.9 time = 445
.meas tran vdout1_15ck88 FIND v(dout1_15) AT=445.025n

* CHECK dout1_16 Vdout1_16ck88 = 0 time = 445
.meas tran vdout1_16ck88 FIND v(dout1_16) AT=445.025n

* CHECK dout1_17 Vdout1_17ck88 = 0 time = 445
.meas tran vdout1_17ck88 FIND v(dout1_17) AT=445.025n

* CHECK dout1_18 Vdout1_18ck88 = 0.9 time = 445
.meas tran vdout1_18ck88 FIND v(dout1_18) AT=445.025n

* CHECK dout1_19 Vdout1_19ck88 = 0.9 time = 445
.meas tran vdout1_19ck88 FIND v(dout1_19) AT=445.025n

* CHECK dout1_20 Vdout1_20ck88 = 0.9 time = 445
.meas tran vdout1_20ck88 FIND v(dout1_20) AT=445.025n

* CHECK dout1_21 Vdout1_21ck88 = 0.9 time = 445
.meas tran vdout1_21ck88 FIND v(dout1_21) AT=445.025n

* CHECK dout1_22 Vdout1_22ck88 = 0 time = 445
.meas tran vdout1_22ck88 FIND v(dout1_22) AT=445.025n

* CHECK dout1_23 Vdout1_23ck88 = 0 time = 445
.meas tran vdout1_23ck88 FIND v(dout1_23) AT=445.025n

* CHECK dout1_24 Vdout1_24ck88 = 0.9 time = 445
.meas tran vdout1_24ck88 FIND v(dout1_24) AT=445.025n

* CHECK dout1_25 Vdout1_25ck88 = 0 time = 445
.meas tran vdout1_25ck88 FIND v(dout1_25) AT=445.025n

* CHECK dout1_26 Vdout1_26ck88 = 0 time = 445
.meas tran vdout1_26ck88 FIND v(dout1_26) AT=445.025n

* CHECK dout1_27 Vdout1_27ck88 = 0.9 time = 445
.meas tran vdout1_27ck88 FIND v(dout1_27) AT=445.025n

* CHECK dout1_28 Vdout1_28ck88 = 0.9 time = 445
.meas tran vdout1_28ck88 FIND v(dout1_28) AT=445.025n

* CHECK dout1_29 Vdout1_29ck88 = 0 time = 445
.meas tran vdout1_29ck88 FIND v(dout1_29) AT=445.025n

* CHECK dout1_30 Vdout1_30ck88 = 0 time = 445
.meas tran vdout1_30ck88 FIND v(dout1_30) AT=445.025n

* CHECK dout1_31 Vdout1_31ck88 = 0.9 time = 445
.meas tran vdout1_31ck88 FIND v(dout1_31) AT=445.025n

* CHECK dout1_32 Vdout1_32ck88 = 0.9 time = 445
.meas tran vdout1_32ck88 FIND v(dout1_32) AT=445.025n

* CHECK dout1_33 Vdout1_33ck88 = 0.9 time = 445
.meas tran vdout1_33ck88 FIND v(dout1_33) AT=445.025n

* CHECK dout1_34 Vdout1_34ck88 = 0 time = 445
.meas tran vdout1_34ck88 FIND v(dout1_34) AT=445.025n

* CHECK dout1_35 Vdout1_35ck88 = 0.9 time = 445
.meas tran vdout1_35ck88 FIND v(dout1_35) AT=445.025n

* CHECK dout1_36 Vdout1_36ck88 = 0.9 time = 445
.meas tran vdout1_36ck88 FIND v(dout1_36) AT=445.025n

* CHECK dout1_37 Vdout1_37ck88 = 0 time = 445
.meas tran vdout1_37ck88 FIND v(dout1_37) AT=445.025n

* CHECK dout1_38 Vdout1_38ck88 = 0.9 time = 445
.meas tran vdout1_38ck88 FIND v(dout1_38) AT=445.025n

* CHECK dout1_39 Vdout1_39ck88 = 0 time = 445
.meas tran vdout1_39ck88 FIND v(dout1_39) AT=445.025n

* CHECK dout1_40 Vdout1_40ck88 = 0.9 time = 445
.meas tran vdout1_40ck88 FIND v(dout1_40) AT=445.025n

* CHECK dout1_41 Vdout1_41ck88 = 0.9 time = 445
.meas tran vdout1_41ck88 FIND v(dout1_41) AT=445.025n

* CHECK dout1_42 Vdout1_42ck88 = 0 time = 445
.meas tran vdout1_42ck88 FIND v(dout1_42) AT=445.025n

* CHECK dout1_43 Vdout1_43ck88 = 0.9 time = 445
.meas tran vdout1_43ck88 FIND v(dout1_43) AT=445.025n

* CHECK dout1_44 Vdout1_44ck88 = 0 time = 445
.meas tran vdout1_44ck88 FIND v(dout1_44) AT=445.025n

* CHECK dout1_45 Vdout1_45ck88 = 0.9 time = 445
.meas tran vdout1_45ck88 FIND v(dout1_45) AT=445.025n

* CHECK dout1_46 Vdout1_46ck88 = 0 time = 445
.meas tran vdout1_46ck88 FIND v(dout1_46) AT=445.025n

* CHECK dout1_47 Vdout1_47ck88 = 0 time = 445
.meas tran vdout1_47ck88 FIND v(dout1_47) AT=445.025n

* CHECK dout1_48 Vdout1_48ck88 = 0.9 time = 445
.meas tran vdout1_48ck88 FIND v(dout1_48) AT=445.025n

* CHECK dout1_49 Vdout1_49ck88 = 0 time = 445
.meas tran vdout1_49ck88 FIND v(dout1_49) AT=445.025n

* CHECK dout1_50 Vdout1_50ck88 = 0.9 time = 445
.meas tran vdout1_50ck88 FIND v(dout1_50) AT=445.025n

* CHECK dout1_51 Vdout1_51ck88 = 0 time = 445
.meas tran vdout1_51ck88 FIND v(dout1_51) AT=445.025n

* CHECK dout1_52 Vdout1_52ck88 = 0 time = 445
.meas tran vdout1_52ck88 FIND v(dout1_52) AT=445.025n

* CHECK dout1_53 Vdout1_53ck88 = 0.9 time = 445
.meas tran vdout1_53ck88 FIND v(dout1_53) AT=445.025n

* CHECK dout1_54 Vdout1_54ck88 = 0.9 time = 445
.meas tran vdout1_54ck88 FIND v(dout1_54) AT=445.025n

* CHECK dout1_55 Vdout1_55ck88 = 0 time = 445
.meas tran vdout1_55ck88 FIND v(dout1_55) AT=445.025n

* CHECK dout1_56 Vdout1_56ck88 = 0.9 time = 445
.meas tran vdout1_56ck88 FIND v(dout1_56) AT=445.025n

* CHECK dout1_57 Vdout1_57ck88 = 0.9 time = 445
.meas tran vdout1_57ck88 FIND v(dout1_57) AT=445.025n

* CHECK dout1_58 Vdout1_58ck88 = 0 time = 445
.meas tran vdout1_58ck88 FIND v(dout1_58) AT=445.025n

* CHECK dout1_59 Vdout1_59ck88 = 0 time = 445
.meas tran vdout1_59ck88 FIND v(dout1_59) AT=445.025n

* CHECK dout1_60 Vdout1_60ck88 = 0.9 time = 445
.meas tran vdout1_60ck88 FIND v(dout1_60) AT=445.025n

* CHECK dout1_61 Vdout1_61ck88 = 0 time = 445
.meas tran vdout1_61ck88 FIND v(dout1_61) AT=445.025n

* CHECK dout1_62 Vdout1_62ck88 = 0.9 time = 445
.meas tran vdout1_62ck88 FIND v(dout1_62) AT=445.025n

* CHECK dout1_63 Vdout1_63ck88 = 0 time = 445
.meas tran vdout1_63ck88 FIND v(dout1_63) AT=445.025n

* CHECK dout1_64 Vdout1_64ck88 = 0 time = 445
.meas tran vdout1_64ck88 FIND v(dout1_64) AT=445.025n

* CHECK dout1_65 Vdout1_65ck88 = 0 time = 445
.meas tran vdout1_65ck88 FIND v(dout1_65) AT=445.025n

* CHECK dout1_66 Vdout1_66ck88 = 0 time = 445
.meas tran vdout1_66ck88 FIND v(dout1_66) AT=445.025n

* CHECK dout1_67 Vdout1_67ck88 = 0 time = 445
.meas tran vdout1_67ck88 FIND v(dout1_67) AT=445.025n

* CHECK dout1_68 Vdout1_68ck88 = 0 time = 445
.meas tran vdout1_68ck88 FIND v(dout1_68) AT=445.025n

* CHECK dout1_69 Vdout1_69ck88 = 0.9 time = 445
.meas tran vdout1_69ck88 FIND v(dout1_69) AT=445.025n

* CHECK dout1_70 Vdout1_70ck88 = 0 time = 445
.meas tran vdout1_70ck88 FIND v(dout1_70) AT=445.025n

* CHECK dout1_71 Vdout1_71ck88 = 0 time = 445
.meas tran vdout1_71ck88 FIND v(dout1_71) AT=445.025n

* CHECK dout1_0 Vdout1_0ck91 = 0 time = 460
.meas tran vdout1_0ck91 FIND v(dout1_0) AT=460.025n

* CHECK dout1_1 Vdout1_1ck91 = 0 time = 460
.meas tran vdout1_1ck91 FIND v(dout1_1) AT=460.025n

* CHECK dout1_2 Vdout1_2ck91 = 0.9 time = 460
.meas tran vdout1_2ck91 FIND v(dout1_2) AT=460.025n

* CHECK dout1_3 Vdout1_3ck91 = 0 time = 460
.meas tran vdout1_3ck91 FIND v(dout1_3) AT=460.025n

* CHECK dout1_4 Vdout1_4ck91 = 0 time = 460
.meas tran vdout1_4ck91 FIND v(dout1_4) AT=460.025n

* CHECK dout1_5 Vdout1_5ck91 = 0 time = 460
.meas tran vdout1_5ck91 FIND v(dout1_5) AT=460.025n

* CHECK dout1_6 Vdout1_6ck91 = 0 time = 460
.meas tran vdout1_6ck91 FIND v(dout1_6) AT=460.025n

* CHECK dout1_7 Vdout1_7ck91 = 0 time = 460
.meas tran vdout1_7ck91 FIND v(dout1_7) AT=460.025n

* CHECK dout1_8 Vdout1_8ck91 = 0 time = 460
.meas tran vdout1_8ck91 FIND v(dout1_8) AT=460.025n

* CHECK dout1_9 Vdout1_9ck91 = 0 time = 460
.meas tran vdout1_9ck91 FIND v(dout1_9) AT=460.025n

* CHECK dout1_10 Vdout1_10ck91 = 0 time = 460
.meas tran vdout1_10ck91 FIND v(dout1_10) AT=460.025n

* CHECK dout1_11 Vdout1_11ck91 = 0.9 time = 460
.meas tran vdout1_11ck91 FIND v(dout1_11) AT=460.025n

* CHECK dout1_12 Vdout1_12ck91 = 0 time = 460
.meas tran vdout1_12ck91 FIND v(dout1_12) AT=460.025n

* CHECK dout1_13 Vdout1_13ck91 = 0.9 time = 460
.meas tran vdout1_13ck91 FIND v(dout1_13) AT=460.025n

* CHECK dout1_14 Vdout1_14ck91 = 0.9 time = 460
.meas tran vdout1_14ck91 FIND v(dout1_14) AT=460.025n

* CHECK dout1_15 Vdout1_15ck91 = 0 time = 460
.meas tran vdout1_15ck91 FIND v(dout1_15) AT=460.025n

* CHECK dout1_16 Vdout1_16ck91 = 0 time = 460
.meas tran vdout1_16ck91 FIND v(dout1_16) AT=460.025n

* CHECK dout1_17 Vdout1_17ck91 = 0 time = 460
.meas tran vdout1_17ck91 FIND v(dout1_17) AT=460.025n

* CHECK dout1_18 Vdout1_18ck91 = 0.9 time = 460
.meas tran vdout1_18ck91 FIND v(dout1_18) AT=460.025n

* CHECK dout1_19 Vdout1_19ck91 = 0 time = 460
.meas tran vdout1_19ck91 FIND v(dout1_19) AT=460.025n

* CHECK dout1_20 Vdout1_20ck91 = 0.9 time = 460
.meas tran vdout1_20ck91 FIND v(dout1_20) AT=460.025n

* CHECK dout1_21 Vdout1_21ck91 = 0.9 time = 460
.meas tran vdout1_21ck91 FIND v(dout1_21) AT=460.025n

* CHECK dout1_22 Vdout1_22ck91 = 0.9 time = 460
.meas tran vdout1_22ck91 FIND v(dout1_22) AT=460.025n

* CHECK dout1_23 Vdout1_23ck91 = 0 time = 460
.meas tran vdout1_23ck91 FIND v(dout1_23) AT=460.025n

* CHECK dout1_24 Vdout1_24ck91 = 0.9 time = 460
.meas tran vdout1_24ck91 FIND v(dout1_24) AT=460.025n

* CHECK dout1_25 Vdout1_25ck91 = 0.9 time = 460
.meas tran vdout1_25ck91 FIND v(dout1_25) AT=460.025n

* CHECK dout1_26 Vdout1_26ck91 = 0 time = 460
.meas tran vdout1_26ck91 FIND v(dout1_26) AT=460.025n

* CHECK dout1_27 Vdout1_27ck91 = 0.9 time = 460
.meas tran vdout1_27ck91 FIND v(dout1_27) AT=460.025n

* CHECK dout1_28 Vdout1_28ck91 = 0 time = 460
.meas tran vdout1_28ck91 FIND v(dout1_28) AT=460.025n

* CHECK dout1_29 Vdout1_29ck91 = 0.9 time = 460
.meas tran vdout1_29ck91 FIND v(dout1_29) AT=460.025n

* CHECK dout1_30 Vdout1_30ck91 = 0.9 time = 460
.meas tran vdout1_30ck91 FIND v(dout1_30) AT=460.025n

* CHECK dout1_31 Vdout1_31ck91 = 0.9 time = 460
.meas tran vdout1_31ck91 FIND v(dout1_31) AT=460.025n

* CHECK dout1_32 Vdout1_32ck91 = 0 time = 460
.meas tran vdout1_32ck91 FIND v(dout1_32) AT=460.025n

* CHECK dout1_33 Vdout1_33ck91 = 0.9 time = 460
.meas tran vdout1_33ck91 FIND v(dout1_33) AT=460.025n

* CHECK dout1_34 Vdout1_34ck91 = 0 time = 460
.meas tran vdout1_34ck91 FIND v(dout1_34) AT=460.025n

* CHECK dout1_35 Vdout1_35ck91 = 0.9 time = 460
.meas tran vdout1_35ck91 FIND v(dout1_35) AT=460.025n

* CHECK dout1_36 Vdout1_36ck91 = 0.9 time = 460
.meas tran vdout1_36ck91 FIND v(dout1_36) AT=460.025n

* CHECK dout1_37 Vdout1_37ck91 = 0.9 time = 460
.meas tran vdout1_37ck91 FIND v(dout1_37) AT=460.025n

* CHECK dout1_38 Vdout1_38ck91 = 0 time = 460
.meas tran vdout1_38ck91 FIND v(dout1_38) AT=460.025n

* CHECK dout1_39 Vdout1_39ck91 = 0 time = 460
.meas tran vdout1_39ck91 FIND v(dout1_39) AT=460.025n

* CHECK dout1_40 Vdout1_40ck91 = 0 time = 460
.meas tran vdout1_40ck91 FIND v(dout1_40) AT=460.025n

* CHECK dout1_41 Vdout1_41ck91 = 0 time = 460
.meas tran vdout1_41ck91 FIND v(dout1_41) AT=460.025n

* CHECK dout1_42 Vdout1_42ck91 = 0.9 time = 460
.meas tran vdout1_42ck91 FIND v(dout1_42) AT=460.025n

* CHECK dout1_43 Vdout1_43ck91 = 0.9 time = 460
.meas tran vdout1_43ck91 FIND v(dout1_43) AT=460.025n

* CHECK dout1_44 Vdout1_44ck91 = 0 time = 460
.meas tran vdout1_44ck91 FIND v(dout1_44) AT=460.025n

* CHECK dout1_45 Vdout1_45ck91 = 0.9 time = 460
.meas tran vdout1_45ck91 FIND v(dout1_45) AT=460.025n

* CHECK dout1_46 Vdout1_46ck91 = 0.9 time = 460
.meas tran vdout1_46ck91 FIND v(dout1_46) AT=460.025n

* CHECK dout1_47 Vdout1_47ck91 = 0.9 time = 460
.meas tran vdout1_47ck91 FIND v(dout1_47) AT=460.025n

* CHECK dout1_48 Vdout1_48ck91 = 0 time = 460
.meas tran vdout1_48ck91 FIND v(dout1_48) AT=460.025n

* CHECK dout1_49 Vdout1_49ck91 = 0.9 time = 460
.meas tran vdout1_49ck91 FIND v(dout1_49) AT=460.025n

* CHECK dout1_50 Vdout1_50ck91 = 0 time = 460
.meas tran vdout1_50ck91 FIND v(dout1_50) AT=460.025n

* CHECK dout1_51 Vdout1_51ck91 = 0.9 time = 460
.meas tran vdout1_51ck91 FIND v(dout1_51) AT=460.025n

* CHECK dout1_52 Vdout1_52ck91 = 0 time = 460
.meas tran vdout1_52ck91 FIND v(dout1_52) AT=460.025n

* CHECK dout1_53 Vdout1_53ck91 = 0.9 time = 460
.meas tran vdout1_53ck91 FIND v(dout1_53) AT=460.025n

* CHECK dout1_54 Vdout1_54ck91 = 0.9 time = 460
.meas tran vdout1_54ck91 FIND v(dout1_54) AT=460.025n

* CHECK dout1_55 Vdout1_55ck91 = 0.9 time = 460
.meas tran vdout1_55ck91 FIND v(dout1_55) AT=460.025n

* CHECK dout1_56 Vdout1_56ck91 = 0.9 time = 460
.meas tran vdout1_56ck91 FIND v(dout1_56) AT=460.025n

* CHECK dout1_57 Vdout1_57ck91 = 0 time = 460
.meas tran vdout1_57ck91 FIND v(dout1_57) AT=460.025n

* CHECK dout1_58 Vdout1_58ck91 = 0 time = 460
.meas tran vdout1_58ck91 FIND v(dout1_58) AT=460.025n

* CHECK dout1_59 Vdout1_59ck91 = 0 time = 460
.meas tran vdout1_59ck91 FIND v(dout1_59) AT=460.025n

* CHECK dout1_60 Vdout1_60ck91 = 0.9 time = 460
.meas tran vdout1_60ck91 FIND v(dout1_60) AT=460.025n

* CHECK dout1_61 Vdout1_61ck91 = 0.9 time = 460
.meas tran vdout1_61ck91 FIND v(dout1_61) AT=460.025n

* CHECK dout1_62 Vdout1_62ck91 = 0.9 time = 460
.meas tran vdout1_62ck91 FIND v(dout1_62) AT=460.025n

* CHECK dout1_63 Vdout1_63ck91 = 0.9 time = 460
.meas tran vdout1_63ck91 FIND v(dout1_63) AT=460.025n

* CHECK dout1_64 Vdout1_64ck91 = 0.9 time = 460
.meas tran vdout1_64ck91 FIND v(dout1_64) AT=460.025n

* CHECK dout1_65 Vdout1_65ck91 = 0 time = 460
.meas tran vdout1_65ck91 FIND v(dout1_65) AT=460.025n

* CHECK dout1_66 Vdout1_66ck91 = 0 time = 460
.meas tran vdout1_66ck91 FIND v(dout1_66) AT=460.025n

* CHECK dout1_67 Vdout1_67ck91 = 0 time = 460
.meas tran vdout1_67ck91 FIND v(dout1_67) AT=460.025n

* CHECK dout1_68 Vdout1_68ck91 = 0.9 time = 460
.meas tran vdout1_68ck91 FIND v(dout1_68) AT=460.025n

* CHECK dout1_69 Vdout1_69ck91 = 0 time = 460
.meas tran vdout1_69ck91 FIND v(dout1_69) AT=460.025n

* CHECK dout1_70 Vdout1_70ck91 = 0.9 time = 460
.meas tran vdout1_70ck91 FIND v(dout1_70) AT=460.025n

* CHECK dout1_71 Vdout1_71ck91 = 0 time = 460
.meas tran vdout1_71ck91 FIND v(dout1_71) AT=460.025n

* CHECK dout1_0 Vdout1_0ck92 = 0.9 time = 465
.meas tran vdout1_0ck92 FIND v(dout1_0) AT=465.025n

* CHECK dout1_1 Vdout1_1ck92 = 0 time = 465
.meas tran vdout1_1ck92 FIND v(dout1_1) AT=465.025n

* CHECK dout1_2 Vdout1_2ck92 = 0.9 time = 465
.meas tran vdout1_2ck92 FIND v(dout1_2) AT=465.025n

* CHECK dout1_3 Vdout1_3ck92 = 0 time = 465
.meas tran vdout1_3ck92 FIND v(dout1_3) AT=465.025n

* CHECK dout1_4 Vdout1_4ck92 = 0.9 time = 465
.meas tran vdout1_4ck92 FIND v(dout1_4) AT=465.025n

* CHECK dout1_5 Vdout1_5ck92 = 0 time = 465
.meas tran vdout1_5ck92 FIND v(dout1_5) AT=465.025n

* CHECK dout1_6 Vdout1_6ck92 = 0 time = 465
.meas tran vdout1_6ck92 FIND v(dout1_6) AT=465.025n

* CHECK dout1_7 Vdout1_7ck92 = 0 time = 465
.meas tran vdout1_7ck92 FIND v(dout1_7) AT=465.025n

* CHECK dout1_8 Vdout1_8ck92 = 0 time = 465
.meas tran vdout1_8ck92 FIND v(dout1_8) AT=465.025n

* CHECK dout1_9 Vdout1_9ck92 = 0.9 time = 465
.meas tran vdout1_9ck92 FIND v(dout1_9) AT=465.025n

* CHECK dout1_10 Vdout1_10ck92 = 0.9 time = 465
.meas tran vdout1_10ck92 FIND v(dout1_10) AT=465.025n

* CHECK dout1_11 Vdout1_11ck92 = 0 time = 465
.meas tran vdout1_11ck92 FIND v(dout1_11) AT=465.025n

* CHECK dout1_12 Vdout1_12ck92 = 0.9 time = 465
.meas tran vdout1_12ck92 FIND v(dout1_12) AT=465.025n

* CHECK dout1_13 Vdout1_13ck92 = 0 time = 465
.meas tran vdout1_13ck92 FIND v(dout1_13) AT=465.025n

* CHECK dout1_14 Vdout1_14ck92 = 0 time = 465
.meas tran vdout1_14ck92 FIND v(dout1_14) AT=465.025n

* CHECK dout1_15 Vdout1_15ck92 = 0.9 time = 465
.meas tran vdout1_15ck92 FIND v(dout1_15) AT=465.025n

* CHECK dout1_16 Vdout1_16ck92 = 0 time = 465
.meas tran vdout1_16ck92 FIND v(dout1_16) AT=465.025n

* CHECK dout1_17 Vdout1_17ck92 = 0 time = 465
.meas tran vdout1_17ck92 FIND v(dout1_17) AT=465.025n

* CHECK dout1_18 Vdout1_18ck92 = 0.9 time = 465
.meas tran vdout1_18ck92 FIND v(dout1_18) AT=465.025n

* CHECK dout1_19 Vdout1_19ck92 = 0.9 time = 465
.meas tran vdout1_19ck92 FIND v(dout1_19) AT=465.025n

* CHECK dout1_20 Vdout1_20ck92 = 0.9 time = 465
.meas tran vdout1_20ck92 FIND v(dout1_20) AT=465.025n

* CHECK dout1_21 Vdout1_21ck92 = 0.9 time = 465
.meas tran vdout1_21ck92 FIND v(dout1_21) AT=465.025n

* CHECK dout1_22 Vdout1_22ck92 = 0 time = 465
.meas tran vdout1_22ck92 FIND v(dout1_22) AT=465.025n

* CHECK dout1_23 Vdout1_23ck92 = 0 time = 465
.meas tran vdout1_23ck92 FIND v(dout1_23) AT=465.025n

* CHECK dout1_24 Vdout1_24ck92 = 0.9 time = 465
.meas tran vdout1_24ck92 FIND v(dout1_24) AT=465.025n

* CHECK dout1_25 Vdout1_25ck92 = 0 time = 465
.meas tran vdout1_25ck92 FIND v(dout1_25) AT=465.025n

* CHECK dout1_26 Vdout1_26ck92 = 0 time = 465
.meas tran vdout1_26ck92 FIND v(dout1_26) AT=465.025n

* CHECK dout1_27 Vdout1_27ck92 = 0.9 time = 465
.meas tran vdout1_27ck92 FIND v(dout1_27) AT=465.025n

* CHECK dout1_28 Vdout1_28ck92 = 0.9 time = 465
.meas tran vdout1_28ck92 FIND v(dout1_28) AT=465.025n

* CHECK dout1_29 Vdout1_29ck92 = 0 time = 465
.meas tran vdout1_29ck92 FIND v(dout1_29) AT=465.025n

* CHECK dout1_30 Vdout1_30ck92 = 0 time = 465
.meas tran vdout1_30ck92 FIND v(dout1_30) AT=465.025n

* CHECK dout1_31 Vdout1_31ck92 = 0.9 time = 465
.meas tran vdout1_31ck92 FIND v(dout1_31) AT=465.025n

* CHECK dout1_32 Vdout1_32ck92 = 0.9 time = 465
.meas tran vdout1_32ck92 FIND v(dout1_32) AT=465.025n

* CHECK dout1_33 Vdout1_33ck92 = 0.9 time = 465
.meas tran vdout1_33ck92 FIND v(dout1_33) AT=465.025n

* CHECK dout1_34 Vdout1_34ck92 = 0 time = 465
.meas tran vdout1_34ck92 FIND v(dout1_34) AT=465.025n

* CHECK dout1_35 Vdout1_35ck92 = 0.9 time = 465
.meas tran vdout1_35ck92 FIND v(dout1_35) AT=465.025n

* CHECK dout1_36 Vdout1_36ck92 = 0.9 time = 465
.meas tran vdout1_36ck92 FIND v(dout1_36) AT=465.025n

* CHECK dout1_37 Vdout1_37ck92 = 0 time = 465
.meas tran vdout1_37ck92 FIND v(dout1_37) AT=465.025n

* CHECK dout1_38 Vdout1_38ck92 = 0.9 time = 465
.meas tran vdout1_38ck92 FIND v(dout1_38) AT=465.025n

* CHECK dout1_39 Vdout1_39ck92 = 0 time = 465
.meas tran vdout1_39ck92 FIND v(dout1_39) AT=465.025n

* CHECK dout1_40 Vdout1_40ck92 = 0.9 time = 465
.meas tran vdout1_40ck92 FIND v(dout1_40) AT=465.025n

* CHECK dout1_41 Vdout1_41ck92 = 0.9 time = 465
.meas tran vdout1_41ck92 FIND v(dout1_41) AT=465.025n

* CHECK dout1_42 Vdout1_42ck92 = 0 time = 465
.meas tran vdout1_42ck92 FIND v(dout1_42) AT=465.025n

* CHECK dout1_43 Vdout1_43ck92 = 0.9 time = 465
.meas tran vdout1_43ck92 FIND v(dout1_43) AT=465.025n

* CHECK dout1_44 Vdout1_44ck92 = 0 time = 465
.meas tran vdout1_44ck92 FIND v(dout1_44) AT=465.025n

* CHECK dout1_45 Vdout1_45ck92 = 0.9 time = 465
.meas tran vdout1_45ck92 FIND v(dout1_45) AT=465.025n

* CHECK dout1_46 Vdout1_46ck92 = 0 time = 465
.meas tran vdout1_46ck92 FIND v(dout1_46) AT=465.025n

* CHECK dout1_47 Vdout1_47ck92 = 0 time = 465
.meas tran vdout1_47ck92 FIND v(dout1_47) AT=465.025n

* CHECK dout1_48 Vdout1_48ck92 = 0.9 time = 465
.meas tran vdout1_48ck92 FIND v(dout1_48) AT=465.025n

* CHECK dout1_49 Vdout1_49ck92 = 0 time = 465
.meas tran vdout1_49ck92 FIND v(dout1_49) AT=465.025n

* CHECK dout1_50 Vdout1_50ck92 = 0.9 time = 465
.meas tran vdout1_50ck92 FIND v(dout1_50) AT=465.025n

* CHECK dout1_51 Vdout1_51ck92 = 0 time = 465
.meas tran vdout1_51ck92 FIND v(dout1_51) AT=465.025n

* CHECK dout1_52 Vdout1_52ck92 = 0 time = 465
.meas tran vdout1_52ck92 FIND v(dout1_52) AT=465.025n

* CHECK dout1_53 Vdout1_53ck92 = 0.9 time = 465
.meas tran vdout1_53ck92 FIND v(dout1_53) AT=465.025n

* CHECK dout1_54 Vdout1_54ck92 = 0.9 time = 465
.meas tran vdout1_54ck92 FIND v(dout1_54) AT=465.025n

* CHECK dout1_55 Vdout1_55ck92 = 0 time = 465
.meas tran vdout1_55ck92 FIND v(dout1_55) AT=465.025n

* CHECK dout1_56 Vdout1_56ck92 = 0.9 time = 465
.meas tran vdout1_56ck92 FIND v(dout1_56) AT=465.025n

* CHECK dout1_57 Vdout1_57ck92 = 0.9 time = 465
.meas tran vdout1_57ck92 FIND v(dout1_57) AT=465.025n

* CHECK dout1_58 Vdout1_58ck92 = 0 time = 465
.meas tran vdout1_58ck92 FIND v(dout1_58) AT=465.025n

* CHECK dout1_59 Vdout1_59ck92 = 0 time = 465
.meas tran vdout1_59ck92 FIND v(dout1_59) AT=465.025n

* CHECK dout1_60 Vdout1_60ck92 = 0.9 time = 465
.meas tran vdout1_60ck92 FIND v(dout1_60) AT=465.025n

* CHECK dout1_61 Vdout1_61ck92 = 0 time = 465
.meas tran vdout1_61ck92 FIND v(dout1_61) AT=465.025n

* CHECK dout1_62 Vdout1_62ck92 = 0.9 time = 465
.meas tran vdout1_62ck92 FIND v(dout1_62) AT=465.025n

* CHECK dout1_63 Vdout1_63ck92 = 0 time = 465
.meas tran vdout1_63ck92 FIND v(dout1_63) AT=465.025n

* CHECK dout1_64 Vdout1_64ck92 = 0 time = 465
.meas tran vdout1_64ck92 FIND v(dout1_64) AT=465.025n

* CHECK dout1_65 Vdout1_65ck92 = 0 time = 465
.meas tran vdout1_65ck92 FIND v(dout1_65) AT=465.025n

* CHECK dout1_66 Vdout1_66ck92 = 0 time = 465
.meas tran vdout1_66ck92 FIND v(dout1_66) AT=465.025n

* CHECK dout1_67 Vdout1_67ck92 = 0 time = 465
.meas tran vdout1_67ck92 FIND v(dout1_67) AT=465.025n

* CHECK dout1_68 Vdout1_68ck92 = 0 time = 465
.meas tran vdout1_68ck92 FIND v(dout1_68) AT=465.025n

* CHECK dout1_69 Vdout1_69ck92 = 0.9 time = 465
.meas tran vdout1_69ck92 FIND v(dout1_69) AT=465.025n

* CHECK dout1_70 Vdout1_70ck92 = 0 time = 465
.meas tran vdout1_70ck92 FIND v(dout1_70) AT=465.025n

* CHECK dout1_71 Vdout1_71ck92 = 0 time = 465
.meas tran vdout1_71ck92 FIND v(dout1_71) AT=465.025n

* CHECK dout1_0 Vdout1_0ck94 = 0 time = 475
.meas tran vdout1_0ck94 FIND v(dout1_0) AT=475.025n

* CHECK dout1_1 Vdout1_1ck94 = 0 time = 475
.meas tran vdout1_1ck94 FIND v(dout1_1) AT=475.025n

* CHECK dout1_2 Vdout1_2ck94 = 0.9 time = 475
.meas tran vdout1_2ck94 FIND v(dout1_2) AT=475.025n

* CHECK dout1_3 Vdout1_3ck94 = 0 time = 475
.meas tran vdout1_3ck94 FIND v(dout1_3) AT=475.025n

* CHECK dout1_4 Vdout1_4ck94 = 0 time = 475
.meas tran vdout1_4ck94 FIND v(dout1_4) AT=475.025n

* CHECK dout1_5 Vdout1_5ck94 = 0 time = 475
.meas tran vdout1_5ck94 FIND v(dout1_5) AT=475.025n

* CHECK dout1_6 Vdout1_6ck94 = 0 time = 475
.meas tran vdout1_6ck94 FIND v(dout1_6) AT=475.025n

* CHECK dout1_7 Vdout1_7ck94 = 0 time = 475
.meas tran vdout1_7ck94 FIND v(dout1_7) AT=475.025n

* CHECK dout1_8 Vdout1_8ck94 = 0 time = 475
.meas tran vdout1_8ck94 FIND v(dout1_8) AT=475.025n

* CHECK dout1_9 Vdout1_9ck94 = 0 time = 475
.meas tran vdout1_9ck94 FIND v(dout1_9) AT=475.025n

* CHECK dout1_10 Vdout1_10ck94 = 0 time = 475
.meas tran vdout1_10ck94 FIND v(dout1_10) AT=475.025n

* CHECK dout1_11 Vdout1_11ck94 = 0.9 time = 475
.meas tran vdout1_11ck94 FIND v(dout1_11) AT=475.025n

* CHECK dout1_12 Vdout1_12ck94 = 0 time = 475
.meas tran vdout1_12ck94 FIND v(dout1_12) AT=475.025n

* CHECK dout1_13 Vdout1_13ck94 = 0.9 time = 475
.meas tran vdout1_13ck94 FIND v(dout1_13) AT=475.025n

* CHECK dout1_14 Vdout1_14ck94 = 0.9 time = 475
.meas tran vdout1_14ck94 FIND v(dout1_14) AT=475.025n

* CHECK dout1_15 Vdout1_15ck94 = 0 time = 475
.meas tran vdout1_15ck94 FIND v(dout1_15) AT=475.025n

* CHECK dout1_16 Vdout1_16ck94 = 0 time = 475
.meas tran vdout1_16ck94 FIND v(dout1_16) AT=475.025n

* CHECK dout1_17 Vdout1_17ck94 = 0 time = 475
.meas tran vdout1_17ck94 FIND v(dout1_17) AT=475.025n

* CHECK dout1_18 Vdout1_18ck94 = 0.9 time = 475
.meas tran vdout1_18ck94 FIND v(dout1_18) AT=475.025n

* CHECK dout1_19 Vdout1_19ck94 = 0 time = 475
.meas tran vdout1_19ck94 FIND v(dout1_19) AT=475.025n

* CHECK dout1_20 Vdout1_20ck94 = 0.9 time = 475
.meas tran vdout1_20ck94 FIND v(dout1_20) AT=475.025n

* CHECK dout1_21 Vdout1_21ck94 = 0.9 time = 475
.meas tran vdout1_21ck94 FIND v(dout1_21) AT=475.025n

* CHECK dout1_22 Vdout1_22ck94 = 0.9 time = 475
.meas tran vdout1_22ck94 FIND v(dout1_22) AT=475.025n

* CHECK dout1_23 Vdout1_23ck94 = 0 time = 475
.meas tran vdout1_23ck94 FIND v(dout1_23) AT=475.025n

* CHECK dout1_24 Vdout1_24ck94 = 0.9 time = 475
.meas tran vdout1_24ck94 FIND v(dout1_24) AT=475.025n

* CHECK dout1_25 Vdout1_25ck94 = 0.9 time = 475
.meas tran vdout1_25ck94 FIND v(dout1_25) AT=475.025n

* CHECK dout1_26 Vdout1_26ck94 = 0 time = 475
.meas tran vdout1_26ck94 FIND v(dout1_26) AT=475.025n

* CHECK dout1_27 Vdout1_27ck94 = 0.9 time = 475
.meas tran vdout1_27ck94 FIND v(dout1_27) AT=475.025n

* CHECK dout1_28 Vdout1_28ck94 = 0 time = 475
.meas tran vdout1_28ck94 FIND v(dout1_28) AT=475.025n

* CHECK dout1_29 Vdout1_29ck94 = 0.9 time = 475
.meas tran vdout1_29ck94 FIND v(dout1_29) AT=475.025n

* CHECK dout1_30 Vdout1_30ck94 = 0.9 time = 475
.meas tran vdout1_30ck94 FIND v(dout1_30) AT=475.025n

* CHECK dout1_31 Vdout1_31ck94 = 0.9 time = 475
.meas tran vdout1_31ck94 FIND v(dout1_31) AT=475.025n

* CHECK dout1_32 Vdout1_32ck94 = 0 time = 475
.meas tran vdout1_32ck94 FIND v(dout1_32) AT=475.025n

* CHECK dout1_33 Vdout1_33ck94 = 0.9 time = 475
.meas tran vdout1_33ck94 FIND v(dout1_33) AT=475.025n

* CHECK dout1_34 Vdout1_34ck94 = 0 time = 475
.meas tran vdout1_34ck94 FIND v(dout1_34) AT=475.025n

* CHECK dout1_35 Vdout1_35ck94 = 0.9 time = 475
.meas tran vdout1_35ck94 FIND v(dout1_35) AT=475.025n

* CHECK dout1_36 Vdout1_36ck94 = 0.9 time = 475
.meas tran vdout1_36ck94 FIND v(dout1_36) AT=475.025n

* CHECK dout1_37 Vdout1_37ck94 = 0.9 time = 475
.meas tran vdout1_37ck94 FIND v(dout1_37) AT=475.025n

* CHECK dout1_38 Vdout1_38ck94 = 0 time = 475
.meas tran vdout1_38ck94 FIND v(dout1_38) AT=475.025n

* CHECK dout1_39 Vdout1_39ck94 = 0 time = 475
.meas tran vdout1_39ck94 FIND v(dout1_39) AT=475.025n

* CHECK dout1_40 Vdout1_40ck94 = 0 time = 475
.meas tran vdout1_40ck94 FIND v(dout1_40) AT=475.025n

* CHECK dout1_41 Vdout1_41ck94 = 0 time = 475
.meas tran vdout1_41ck94 FIND v(dout1_41) AT=475.025n

* CHECK dout1_42 Vdout1_42ck94 = 0.9 time = 475
.meas tran vdout1_42ck94 FIND v(dout1_42) AT=475.025n

* CHECK dout1_43 Vdout1_43ck94 = 0.9 time = 475
.meas tran vdout1_43ck94 FIND v(dout1_43) AT=475.025n

* CHECK dout1_44 Vdout1_44ck94 = 0 time = 475
.meas tran vdout1_44ck94 FIND v(dout1_44) AT=475.025n

* CHECK dout1_45 Vdout1_45ck94 = 0.9 time = 475
.meas tran vdout1_45ck94 FIND v(dout1_45) AT=475.025n

* CHECK dout1_46 Vdout1_46ck94 = 0.9 time = 475
.meas tran vdout1_46ck94 FIND v(dout1_46) AT=475.025n

* CHECK dout1_47 Vdout1_47ck94 = 0.9 time = 475
.meas tran vdout1_47ck94 FIND v(dout1_47) AT=475.025n

* CHECK dout1_48 Vdout1_48ck94 = 0 time = 475
.meas tran vdout1_48ck94 FIND v(dout1_48) AT=475.025n

* CHECK dout1_49 Vdout1_49ck94 = 0.9 time = 475
.meas tran vdout1_49ck94 FIND v(dout1_49) AT=475.025n

* CHECK dout1_50 Vdout1_50ck94 = 0 time = 475
.meas tran vdout1_50ck94 FIND v(dout1_50) AT=475.025n

* CHECK dout1_51 Vdout1_51ck94 = 0.9 time = 475
.meas tran vdout1_51ck94 FIND v(dout1_51) AT=475.025n

* CHECK dout1_52 Vdout1_52ck94 = 0 time = 475
.meas tran vdout1_52ck94 FIND v(dout1_52) AT=475.025n

* CHECK dout1_53 Vdout1_53ck94 = 0.9 time = 475
.meas tran vdout1_53ck94 FIND v(dout1_53) AT=475.025n

* CHECK dout1_54 Vdout1_54ck94 = 0.9 time = 475
.meas tran vdout1_54ck94 FIND v(dout1_54) AT=475.025n

* CHECK dout1_55 Vdout1_55ck94 = 0.9 time = 475
.meas tran vdout1_55ck94 FIND v(dout1_55) AT=475.025n

* CHECK dout1_56 Vdout1_56ck94 = 0.9 time = 475
.meas tran vdout1_56ck94 FIND v(dout1_56) AT=475.025n

* CHECK dout1_57 Vdout1_57ck94 = 0 time = 475
.meas tran vdout1_57ck94 FIND v(dout1_57) AT=475.025n

* CHECK dout1_58 Vdout1_58ck94 = 0 time = 475
.meas tran vdout1_58ck94 FIND v(dout1_58) AT=475.025n

* CHECK dout1_59 Vdout1_59ck94 = 0 time = 475
.meas tran vdout1_59ck94 FIND v(dout1_59) AT=475.025n

* CHECK dout1_60 Vdout1_60ck94 = 0.9 time = 475
.meas tran vdout1_60ck94 FIND v(dout1_60) AT=475.025n

* CHECK dout1_61 Vdout1_61ck94 = 0.9 time = 475
.meas tran vdout1_61ck94 FIND v(dout1_61) AT=475.025n

* CHECK dout1_62 Vdout1_62ck94 = 0.9 time = 475
.meas tran vdout1_62ck94 FIND v(dout1_62) AT=475.025n

* CHECK dout1_63 Vdout1_63ck94 = 0.9 time = 475
.meas tran vdout1_63ck94 FIND v(dout1_63) AT=475.025n

* CHECK dout1_64 Vdout1_64ck94 = 0.9 time = 475
.meas tran vdout1_64ck94 FIND v(dout1_64) AT=475.025n

* CHECK dout1_65 Vdout1_65ck94 = 0 time = 475
.meas tran vdout1_65ck94 FIND v(dout1_65) AT=475.025n

* CHECK dout1_66 Vdout1_66ck94 = 0 time = 475
.meas tran vdout1_66ck94 FIND v(dout1_66) AT=475.025n

* CHECK dout1_67 Vdout1_67ck94 = 0 time = 475
.meas tran vdout1_67ck94 FIND v(dout1_67) AT=475.025n

* CHECK dout1_68 Vdout1_68ck94 = 0.9 time = 475
.meas tran vdout1_68ck94 FIND v(dout1_68) AT=475.025n

* CHECK dout1_69 Vdout1_69ck94 = 0 time = 475
.meas tran vdout1_69ck94 FIND v(dout1_69) AT=475.025n

* CHECK dout1_70 Vdout1_70ck94 = 0.9 time = 475
.meas tran vdout1_70ck94 FIND v(dout1_70) AT=475.025n

* CHECK dout1_71 Vdout1_71ck94 = 0 time = 475
.meas tran vdout1_71ck94 FIND v(dout1_71) AT=475.025n

* CHECK dout1_0 Vdout1_0ck96 = 0.9 time = 485
.meas tran vdout1_0ck96 FIND v(dout1_0) AT=485.025n

* CHECK dout1_1 Vdout1_1ck96 = 0 time = 485
.meas tran vdout1_1ck96 FIND v(dout1_1) AT=485.025n

* CHECK dout1_2 Vdout1_2ck96 = 0 time = 485
.meas tran vdout1_2ck96 FIND v(dout1_2) AT=485.025n

* CHECK dout1_3 Vdout1_3ck96 = 0 time = 485
.meas tran vdout1_3ck96 FIND v(dout1_3) AT=485.025n

* CHECK dout1_4 Vdout1_4ck96 = 0.9 time = 485
.meas tran vdout1_4ck96 FIND v(dout1_4) AT=485.025n

* CHECK dout1_5 Vdout1_5ck96 = 0.9 time = 485
.meas tran vdout1_5ck96 FIND v(dout1_5) AT=485.025n

* CHECK dout1_6 Vdout1_6ck96 = 0 time = 485
.meas tran vdout1_6ck96 FIND v(dout1_6) AT=485.025n

* CHECK dout1_7 Vdout1_7ck96 = 0.9 time = 485
.meas tran vdout1_7ck96 FIND v(dout1_7) AT=485.025n

* CHECK dout1_8 Vdout1_8ck96 = 0 time = 485
.meas tran vdout1_8ck96 FIND v(dout1_8) AT=485.025n

* CHECK dout1_9 Vdout1_9ck96 = 0.9 time = 485
.meas tran vdout1_9ck96 FIND v(dout1_9) AT=485.025n

* CHECK dout1_10 Vdout1_10ck96 = 0 time = 485
.meas tran vdout1_10ck96 FIND v(dout1_10) AT=485.025n

* CHECK dout1_11 Vdout1_11ck96 = 0.9 time = 485
.meas tran vdout1_11ck96 FIND v(dout1_11) AT=485.025n

* CHECK dout1_12 Vdout1_12ck96 = 0 time = 485
.meas tran vdout1_12ck96 FIND v(dout1_12) AT=485.025n

* CHECK dout1_13 Vdout1_13ck96 = 0.9 time = 485
.meas tran vdout1_13ck96 FIND v(dout1_13) AT=485.025n

* CHECK dout1_14 Vdout1_14ck96 = 0 time = 485
.meas tran vdout1_14ck96 FIND v(dout1_14) AT=485.025n

* CHECK dout1_15 Vdout1_15ck96 = 0.9 time = 485
.meas tran vdout1_15ck96 FIND v(dout1_15) AT=485.025n

* CHECK dout1_16 Vdout1_16ck96 = 0 time = 485
.meas tran vdout1_16ck96 FIND v(dout1_16) AT=485.025n

* CHECK dout1_17 Vdout1_17ck96 = 0 time = 485
.meas tran vdout1_17ck96 FIND v(dout1_17) AT=485.025n

* CHECK dout1_18 Vdout1_18ck96 = 0 time = 485
.meas tran vdout1_18ck96 FIND v(dout1_18) AT=485.025n

* CHECK dout1_19 Vdout1_19ck96 = 0.9 time = 485
.meas tran vdout1_19ck96 FIND v(dout1_19) AT=485.025n

* CHECK dout1_20 Vdout1_20ck96 = 0.9 time = 485
.meas tran vdout1_20ck96 FIND v(dout1_20) AT=485.025n

* CHECK dout1_21 Vdout1_21ck96 = 0.9 time = 485
.meas tran vdout1_21ck96 FIND v(dout1_21) AT=485.025n

* CHECK dout1_22 Vdout1_22ck96 = 0 time = 485
.meas tran vdout1_22ck96 FIND v(dout1_22) AT=485.025n

* CHECK dout1_23 Vdout1_23ck96 = 0 time = 485
.meas tran vdout1_23ck96 FIND v(dout1_23) AT=485.025n

* CHECK dout1_24 Vdout1_24ck96 = 0 time = 485
.meas tran vdout1_24ck96 FIND v(dout1_24) AT=485.025n

* CHECK dout1_25 Vdout1_25ck96 = 0.9 time = 485
.meas tran vdout1_25ck96 FIND v(dout1_25) AT=485.025n

* CHECK dout1_26 Vdout1_26ck96 = 0.9 time = 485
.meas tran vdout1_26ck96 FIND v(dout1_26) AT=485.025n

* CHECK dout1_27 Vdout1_27ck96 = 0 time = 485
.meas tran vdout1_27ck96 FIND v(dout1_27) AT=485.025n

* CHECK dout1_28 Vdout1_28ck96 = 0 time = 485
.meas tran vdout1_28ck96 FIND v(dout1_28) AT=485.025n

* CHECK dout1_29 Vdout1_29ck96 = 0 time = 485
.meas tran vdout1_29ck96 FIND v(dout1_29) AT=485.025n

* CHECK dout1_30 Vdout1_30ck96 = 0 time = 485
.meas tran vdout1_30ck96 FIND v(dout1_30) AT=485.025n

* CHECK dout1_31 Vdout1_31ck96 = 0.9 time = 485
.meas tran vdout1_31ck96 FIND v(dout1_31) AT=485.025n

* CHECK dout1_32 Vdout1_32ck96 = 0 time = 485
.meas tran vdout1_32ck96 FIND v(dout1_32) AT=485.025n

* CHECK dout1_33 Vdout1_33ck96 = 0.9 time = 485
.meas tran vdout1_33ck96 FIND v(dout1_33) AT=485.025n

* CHECK dout1_34 Vdout1_34ck96 = 0 time = 485
.meas tran vdout1_34ck96 FIND v(dout1_34) AT=485.025n

* CHECK dout1_35 Vdout1_35ck96 = 0.9 time = 485
.meas tran vdout1_35ck96 FIND v(dout1_35) AT=485.025n

* CHECK dout1_36 Vdout1_36ck96 = 0 time = 485
.meas tran vdout1_36ck96 FIND v(dout1_36) AT=485.025n

* CHECK dout1_37 Vdout1_37ck96 = 0.9 time = 485
.meas tran vdout1_37ck96 FIND v(dout1_37) AT=485.025n

* CHECK dout1_38 Vdout1_38ck96 = 0.9 time = 485
.meas tran vdout1_38ck96 FIND v(dout1_38) AT=485.025n

* CHECK dout1_39 Vdout1_39ck96 = 0.9 time = 485
.meas tran vdout1_39ck96 FIND v(dout1_39) AT=485.025n

* CHECK dout1_40 Vdout1_40ck96 = 0 time = 485
.meas tran vdout1_40ck96 FIND v(dout1_40) AT=485.025n

* CHECK dout1_41 Vdout1_41ck96 = 0 time = 485
.meas tran vdout1_41ck96 FIND v(dout1_41) AT=485.025n

* CHECK dout1_42 Vdout1_42ck96 = 0 time = 485
.meas tran vdout1_42ck96 FIND v(dout1_42) AT=485.025n

* CHECK dout1_43 Vdout1_43ck96 = 0.9 time = 485
.meas tran vdout1_43ck96 FIND v(dout1_43) AT=485.025n

* CHECK dout1_44 Vdout1_44ck96 = 0.9 time = 485
.meas tran vdout1_44ck96 FIND v(dout1_44) AT=485.025n

* CHECK dout1_45 Vdout1_45ck96 = 0.9 time = 485
.meas tran vdout1_45ck96 FIND v(dout1_45) AT=485.025n

* CHECK dout1_46 Vdout1_46ck96 = 0 time = 485
.meas tran vdout1_46ck96 FIND v(dout1_46) AT=485.025n

* CHECK dout1_47 Vdout1_47ck96 = 0 time = 485
.meas tran vdout1_47ck96 FIND v(dout1_47) AT=485.025n

* CHECK dout1_48 Vdout1_48ck96 = 0 time = 485
.meas tran vdout1_48ck96 FIND v(dout1_48) AT=485.025n

* CHECK dout1_49 Vdout1_49ck96 = 0 time = 485
.meas tran vdout1_49ck96 FIND v(dout1_49) AT=485.025n

* CHECK dout1_50 Vdout1_50ck96 = 0 time = 485
.meas tran vdout1_50ck96 FIND v(dout1_50) AT=485.025n

* CHECK dout1_51 Vdout1_51ck96 = 0 time = 485
.meas tran vdout1_51ck96 FIND v(dout1_51) AT=485.025n

* CHECK dout1_52 Vdout1_52ck96 = 0.9 time = 485
.meas tran vdout1_52ck96 FIND v(dout1_52) AT=485.025n

* CHECK dout1_53 Vdout1_53ck96 = 0 time = 485
.meas tran vdout1_53ck96 FIND v(dout1_53) AT=485.025n

* CHECK dout1_54 Vdout1_54ck96 = 0 time = 485
.meas tran vdout1_54ck96 FIND v(dout1_54) AT=485.025n

* CHECK dout1_55 Vdout1_55ck96 = 0.9 time = 485
.meas tran vdout1_55ck96 FIND v(dout1_55) AT=485.025n

* CHECK dout1_56 Vdout1_56ck96 = 0 time = 485
.meas tran vdout1_56ck96 FIND v(dout1_56) AT=485.025n

* CHECK dout1_57 Vdout1_57ck96 = 0.9 time = 485
.meas tran vdout1_57ck96 FIND v(dout1_57) AT=485.025n

* CHECK dout1_58 Vdout1_58ck96 = 0.9 time = 485
.meas tran vdout1_58ck96 FIND v(dout1_58) AT=485.025n

* CHECK dout1_59 Vdout1_59ck96 = 0 time = 485
.meas tran vdout1_59ck96 FIND v(dout1_59) AT=485.025n

* CHECK dout1_60 Vdout1_60ck96 = 0.9 time = 485
.meas tran vdout1_60ck96 FIND v(dout1_60) AT=485.025n

* CHECK dout1_61 Vdout1_61ck96 = 0 time = 485
.meas tran vdout1_61ck96 FIND v(dout1_61) AT=485.025n

* CHECK dout1_62 Vdout1_62ck96 = 0.9 time = 485
.meas tran vdout1_62ck96 FIND v(dout1_62) AT=485.025n

* CHECK dout1_63 Vdout1_63ck96 = 0.9 time = 485
.meas tran vdout1_63ck96 FIND v(dout1_63) AT=485.025n

* CHECK dout1_64 Vdout1_64ck96 = 0 time = 485
.meas tran vdout1_64ck96 FIND v(dout1_64) AT=485.025n

* CHECK dout1_65 Vdout1_65ck96 = 0 time = 485
.meas tran vdout1_65ck96 FIND v(dout1_65) AT=485.025n

* CHECK dout1_66 Vdout1_66ck96 = 0 time = 485
.meas tran vdout1_66ck96 FIND v(dout1_66) AT=485.025n

* CHECK dout1_67 Vdout1_67ck96 = 0 time = 485
.meas tran vdout1_67ck96 FIND v(dout1_67) AT=485.025n

* CHECK dout1_68 Vdout1_68ck96 = 0 time = 485
.meas tran vdout1_68ck96 FIND v(dout1_68) AT=485.025n

* CHECK dout1_69 Vdout1_69ck96 = 0 time = 485
.meas tran vdout1_69ck96 FIND v(dout1_69) AT=485.025n

* CHECK dout1_70 Vdout1_70ck96 = 0.9 time = 485
.meas tran vdout1_70ck96 FIND v(dout1_70) AT=485.025n

* CHECK dout1_71 Vdout1_71ck96 = 0.9 time = 485
.meas tran vdout1_71ck96 FIND v(dout1_71) AT=485.025n

* CHECK dout1_0 Vdout1_0ck98 = 0.9 time = 495
.meas tran vdout1_0ck98 FIND v(dout1_0) AT=495.025n

* CHECK dout1_1 Vdout1_1ck98 = 0.9 time = 495
.meas tran vdout1_1ck98 FIND v(dout1_1) AT=495.025n

* CHECK dout1_2 Vdout1_2ck98 = 0 time = 495
.meas tran vdout1_2ck98 FIND v(dout1_2) AT=495.025n

* CHECK dout1_3 Vdout1_3ck98 = 0.9 time = 495
.meas tran vdout1_3ck98 FIND v(dout1_3) AT=495.025n

* CHECK dout1_4 Vdout1_4ck98 = 0.9 time = 495
.meas tran vdout1_4ck98 FIND v(dout1_4) AT=495.025n

* CHECK dout1_5 Vdout1_5ck98 = 0 time = 495
.meas tran vdout1_5ck98 FIND v(dout1_5) AT=495.025n

* CHECK dout1_6 Vdout1_6ck98 = 0.9 time = 495
.meas tran vdout1_6ck98 FIND v(dout1_6) AT=495.025n

* CHECK dout1_7 Vdout1_7ck98 = 0.9 time = 495
.meas tran vdout1_7ck98 FIND v(dout1_7) AT=495.025n

* CHECK dout1_8 Vdout1_8ck98 = 0 time = 495
.meas tran vdout1_8ck98 FIND v(dout1_8) AT=495.025n

* CHECK dout1_9 Vdout1_9ck98 = 0 time = 495
.meas tran vdout1_9ck98 FIND v(dout1_9) AT=495.025n

* CHECK dout1_10 Vdout1_10ck98 = 0 time = 495
.meas tran vdout1_10ck98 FIND v(dout1_10) AT=495.025n

* CHECK dout1_11 Vdout1_11ck98 = 0.9 time = 495
.meas tran vdout1_11ck98 FIND v(dout1_11) AT=495.025n

* CHECK dout1_12 Vdout1_12ck98 = 0.9 time = 495
.meas tran vdout1_12ck98 FIND v(dout1_12) AT=495.025n

* CHECK dout1_13 Vdout1_13ck98 = 0.9 time = 495
.meas tran vdout1_13ck98 FIND v(dout1_13) AT=495.025n

* CHECK dout1_14 Vdout1_14ck98 = 0 time = 495
.meas tran vdout1_14ck98 FIND v(dout1_14) AT=495.025n

* CHECK dout1_15 Vdout1_15ck98 = 0.9 time = 495
.meas tran vdout1_15ck98 FIND v(dout1_15) AT=495.025n

* CHECK dout1_16 Vdout1_16ck98 = 0 time = 495
.meas tran vdout1_16ck98 FIND v(dout1_16) AT=495.025n

* CHECK dout1_17 Vdout1_17ck98 = 0.9 time = 495
.meas tran vdout1_17ck98 FIND v(dout1_17) AT=495.025n

* CHECK dout1_18 Vdout1_18ck98 = 0.9 time = 495
.meas tran vdout1_18ck98 FIND v(dout1_18) AT=495.025n

* CHECK dout1_19 Vdout1_19ck98 = 0 time = 495
.meas tran vdout1_19ck98 FIND v(dout1_19) AT=495.025n

* CHECK dout1_20 Vdout1_20ck98 = 0.9 time = 495
.meas tran vdout1_20ck98 FIND v(dout1_20) AT=495.025n

* CHECK dout1_21 Vdout1_21ck98 = 0 time = 495
.meas tran vdout1_21ck98 FIND v(dout1_21) AT=495.025n

* CHECK dout1_22 Vdout1_22ck98 = 0.9 time = 495
.meas tran vdout1_22ck98 FIND v(dout1_22) AT=495.025n

* CHECK dout1_23 Vdout1_23ck98 = 0 time = 495
.meas tran vdout1_23ck98 FIND v(dout1_23) AT=495.025n

* CHECK dout1_24 Vdout1_24ck98 = 0.9 time = 495
.meas tran vdout1_24ck98 FIND v(dout1_24) AT=495.025n

* CHECK dout1_25 Vdout1_25ck98 = 0.9 time = 495
.meas tran vdout1_25ck98 FIND v(dout1_25) AT=495.025n

* CHECK dout1_26 Vdout1_26ck98 = 0.9 time = 495
.meas tran vdout1_26ck98 FIND v(dout1_26) AT=495.025n

* CHECK dout1_27 Vdout1_27ck98 = 0 time = 495
.meas tran vdout1_27ck98 FIND v(dout1_27) AT=495.025n

* CHECK dout1_28 Vdout1_28ck98 = 0.9 time = 495
.meas tran vdout1_28ck98 FIND v(dout1_28) AT=495.025n

* CHECK dout1_29 Vdout1_29ck98 = 0 time = 495
.meas tran vdout1_29ck98 FIND v(dout1_29) AT=495.025n

* CHECK dout1_30 Vdout1_30ck98 = 0 time = 495
.meas tran vdout1_30ck98 FIND v(dout1_30) AT=495.025n

* CHECK dout1_31 Vdout1_31ck98 = 0 time = 495
.meas tran vdout1_31ck98 FIND v(dout1_31) AT=495.025n

* CHECK dout1_32 Vdout1_32ck98 = 0 time = 495
.meas tran vdout1_32ck98 FIND v(dout1_32) AT=495.025n

* CHECK dout1_33 Vdout1_33ck98 = 0 time = 495
.meas tran vdout1_33ck98 FIND v(dout1_33) AT=495.025n

* CHECK dout1_34 Vdout1_34ck98 = 0.9 time = 495
.meas tran vdout1_34ck98 FIND v(dout1_34) AT=495.025n

* CHECK dout1_35 Vdout1_35ck98 = 0.9 time = 495
.meas tran vdout1_35ck98 FIND v(dout1_35) AT=495.025n

* CHECK dout1_36 Vdout1_36ck98 = 0.9 time = 495
.meas tran vdout1_36ck98 FIND v(dout1_36) AT=495.025n

* CHECK dout1_37 Vdout1_37ck98 = 0 time = 495
.meas tran vdout1_37ck98 FIND v(dout1_37) AT=495.025n

* CHECK dout1_38 Vdout1_38ck98 = 0.9 time = 495
.meas tran vdout1_38ck98 FIND v(dout1_38) AT=495.025n

* CHECK dout1_39 Vdout1_39ck98 = 0.9 time = 495
.meas tran vdout1_39ck98 FIND v(dout1_39) AT=495.025n

* CHECK dout1_40 Vdout1_40ck98 = 0 time = 495
.meas tran vdout1_40ck98 FIND v(dout1_40) AT=495.025n

* CHECK dout1_41 Vdout1_41ck98 = 0.9 time = 495
.meas tran vdout1_41ck98 FIND v(dout1_41) AT=495.025n

* CHECK dout1_42 Vdout1_42ck98 = 0 time = 495
.meas tran vdout1_42ck98 FIND v(dout1_42) AT=495.025n

* CHECK dout1_43 Vdout1_43ck98 = 0 time = 495
.meas tran vdout1_43ck98 FIND v(dout1_43) AT=495.025n

* CHECK dout1_44 Vdout1_44ck98 = 0 time = 495
.meas tran vdout1_44ck98 FIND v(dout1_44) AT=495.025n

* CHECK dout1_45 Vdout1_45ck98 = 0 time = 495
.meas tran vdout1_45ck98 FIND v(dout1_45) AT=495.025n

* CHECK dout1_46 Vdout1_46ck98 = 0 time = 495
.meas tran vdout1_46ck98 FIND v(dout1_46) AT=495.025n

* CHECK dout1_47 Vdout1_47ck98 = 0.9 time = 495
.meas tran vdout1_47ck98 FIND v(dout1_47) AT=495.025n

* CHECK dout1_48 Vdout1_48ck98 = 0 time = 495
.meas tran vdout1_48ck98 FIND v(dout1_48) AT=495.025n

* CHECK dout1_49 Vdout1_49ck98 = 0 time = 495
.meas tran vdout1_49ck98 FIND v(dout1_49) AT=495.025n

* CHECK dout1_50 Vdout1_50ck98 = 0 time = 495
.meas tran vdout1_50ck98 FIND v(dout1_50) AT=495.025n

* CHECK dout1_51 Vdout1_51ck98 = 0.9 time = 495
.meas tran vdout1_51ck98 FIND v(dout1_51) AT=495.025n

* CHECK dout1_52 Vdout1_52ck98 = 0 time = 495
.meas tran vdout1_52ck98 FIND v(dout1_52) AT=495.025n

* CHECK dout1_53 Vdout1_53ck98 = 0.9 time = 495
.meas tran vdout1_53ck98 FIND v(dout1_53) AT=495.025n

* CHECK dout1_54 Vdout1_54ck98 = 0.9 time = 495
.meas tran vdout1_54ck98 FIND v(dout1_54) AT=495.025n

* CHECK dout1_55 Vdout1_55ck98 = 0.9 time = 495
.meas tran vdout1_55ck98 FIND v(dout1_55) AT=495.025n

* CHECK dout1_56 Vdout1_56ck98 = 0 time = 495
.meas tran vdout1_56ck98 FIND v(dout1_56) AT=495.025n

* CHECK dout1_57 Vdout1_57ck98 = 0 time = 495
.meas tran vdout1_57ck98 FIND v(dout1_57) AT=495.025n

* CHECK dout1_58 Vdout1_58ck98 = 0.9 time = 495
.meas tran vdout1_58ck98 FIND v(dout1_58) AT=495.025n

* CHECK dout1_59 Vdout1_59ck98 = 0 time = 495
.meas tran vdout1_59ck98 FIND v(dout1_59) AT=495.025n

* CHECK dout1_60 Vdout1_60ck98 = 0 time = 495
.meas tran vdout1_60ck98 FIND v(dout1_60) AT=495.025n

* CHECK dout1_61 Vdout1_61ck98 = 0.9 time = 495
.meas tran vdout1_61ck98 FIND v(dout1_61) AT=495.025n

* CHECK dout1_62 Vdout1_62ck98 = 0 time = 495
.meas tran vdout1_62ck98 FIND v(dout1_62) AT=495.025n

* CHECK dout1_63 Vdout1_63ck98 = 0.9 time = 495
.meas tran vdout1_63ck98 FIND v(dout1_63) AT=495.025n

* CHECK dout1_64 Vdout1_64ck98 = 0.9 time = 495
.meas tran vdout1_64ck98 FIND v(dout1_64) AT=495.025n

* CHECK dout1_65 Vdout1_65ck98 = 0.9 time = 495
.meas tran vdout1_65ck98 FIND v(dout1_65) AT=495.025n

* CHECK dout1_66 Vdout1_66ck98 = 0.9 time = 495
.meas tran vdout1_66ck98 FIND v(dout1_66) AT=495.025n

* CHECK dout1_67 Vdout1_67ck98 = 0 time = 495
.meas tran vdout1_67ck98 FIND v(dout1_67) AT=495.025n

* CHECK dout1_68 Vdout1_68ck98 = 0 time = 495
.meas tran vdout1_68ck98 FIND v(dout1_68) AT=495.025n

* CHECK dout1_69 Vdout1_69ck98 = 0 time = 495
.meas tran vdout1_69ck98 FIND v(dout1_69) AT=495.025n

* CHECK dout1_70 Vdout1_70ck98 = 0 time = 495
.meas tran vdout1_70ck98 FIND v(dout1_70) AT=495.025n

* CHECK dout1_71 Vdout1_71ck98 = 0.9 time = 495
.meas tran vdout1_71ck98 FIND v(dout1_71) AT=495.025n

* CHECK dout1_0 Vdout1_0ck99 = 0.9 time = 500
.meas tran vdout1_0ck99 FIND v(dout1_0) AT=500.025n

* CHECK dout1_1 Vdout1_1ck99 = 0.9 time = 500
.meas tran vdout1_1ck99 FIND v(dout1_1) AT=500.025n

* CHECK dout1_2 Vdout1_2ck99 = 0.9 time = 500
.meas tran vdout1_2ck99 FIND v(dout1_2) AT=500.025n

* CHECK dout1_3 Vdout1_3ck99 = 0 time = 500
.meas tran vdout1_3ck99 FIND v(dout1_3) AT=500.025n

* CHECK dout1_4 Vdout1_4ck99 = 0.9 time = 500
.meas tran vdout1_4ck99 FIND v(dout1_4) AT=500.025n

* CHECK dout1_5 Vdout1_5ck99 = 0.9 time = 500
.meas tran vdout1_5ck99 FIND v(dout1_5) AT=500.025n

* CHECK dout1_6 Vdout1_6ck99 = 0 time = 500
.meas tran vdout1_6ck99 FIND v(dout1_6) AT=500.025n

* CHECK dout1_7 Vdout1_7ck99 = 0.9 time = 500
.meas tran vdout1_7ck99 FIND v(dout1_7) AT=500.025n

* CHECK dout1_8 Vdout1_8ck99 = 0.9 time = 500
.meas tran vdout1_8ck99 FIND v(dout1_8) AT=500.025n

* CHECK dout1_9 Vdout1_9ck99 = 0.9 time = 500
.meas tran vdout1_9ck99 FIND v(dout1_9) AT=500.025n

* CHECK dout1_10 Vdout1_10ck99 = 0.9 time = 500
.meas tran vdout1_10ck99 FIND v(dout1_10) AT=500.025n

* CHECK dout1_11 Vdout1_11ck99 = 0.9 time = 500
.meas tran vdout1_11ck99 FIND v(dout1_11) AT=500.025n

* CHECK dout1_12 Vdout1_12ck99 = 0 time = 500
.meas tran vdout1_12ck99 FIND v(dout1_12) AT=500.025n

* CHECK dout1_13 Vdout1_13ck99 = 0 time = 500
.meas tran vdout1_13ck99 FIND v(dout1_13) AT=500.025n

* CHECK dout1_14 Vdout1_14ck99 = 0 time = 500
.meas tran vdout1_14ck99 FIND v(dout1_14) AT=500.025n

* CHECK dout1_15 Vdout1_15ck99 = 0 time = 500
.meas tran vdout1_15ck99 FIND v(dout1_15) AT=500.025n

* CHECK dout1_16 Vdout1_16ck99 = 0.9 time = 500
.meas tran vdout1_16ck99 FIND v(dout1_16) AT=500.025n

* CHECK dout1_17 Vdout1_17ck99 = 0.9 time = 500
.meas tran vdout1_17ck99 FIND v(dout1_17) AT=500.025n

* CHECK dout1_18 Vdout1_18ck99 = 0 time = 500
.meas tran vdout1_18ck99 FIND v(dout1_18) AT=500.025n

* CHECK dout1_19 Vdout1_19ck99 = 0.9 time = 500
.meas tran vdout1_19ck99 FIND v(dout1_19) AT=500.025n

* CHECK dout1_20 Vdout1_20ck99 = 0 time = 500
.meas tran vdout1_20ck99 FIND v(dout1_20) AT=500.025n

* CHECK dout1_21 Vdout1_21ck99 = 0.9 time = 500
.meas tran vdout1_21ck99 FIND v(dout1_21) AT=500.025n

* CHECK dout1_22 Vdout1_22ck99 = 0.9 time = 500
.meas tran vdout1_22ck99 FIND v(dout1_22) AT=500.025n

* CHECK dout1_23 Vdout1_23ck99 = 0.9 time = 500
.meas tran vdout1_23ck99 FIND v(dout1_23) AT=500.025n

* CHECK dout1_24 Vdout1_24ck99 = 0 time = 500
.meas tran vdout1_24ck99 FIND v(dout1_24) AT=500.025n

* CHECK dout1_25 Vdout1_25ck99 = 0 time = 500
.meas tran vdout1_25ck99 FIND v(dout1_25) AT=500.025n

* CHECK dout1_26 Vdout1_26ck99 = 0.9 time = 500
.meas tran vdout1_26ck99 FIND v(dout1_26) AT=500.025n

* CHECK dout1_27 Vdout1_27ck99 = 0.9 time = 500
.meas tran vdout1_27ck99 FIND v(dout1_27) AT=500.025n

* CHECK dout1_28 Vdout1_28ck99 = 0.9 time = 500
.meas tran vdout1_28ck99 FIND v(dout1_28) AT=500.025n

* CHECK dout1_29 Vdout1_29ck99 = 0.9 time = 500
.meas tran vdout1_29ck99 FIND v(dout1_29) AT=500.025n

* CHECK dout1_30 Vdout1_30ck99 = 0 time = 500
.meas tran vdout1_30ck99 FIND v(dout1_30) AT=500.025n

* CHECK dout1_31 Vdout1_31ck99 = 0.9 time = 500
.meas tran vdout1_31ck99 FIND v(dout1_31) AT=500.025n

* CHECK dout1_32 Vdout1_32ck99 = 0 time = 500
.meas tran vdout1_32ck99 FIND v(dout1_32) AT=500.025n

* CHECK dout1_33 Vdout1_33ck99 = 0.9 time = 500
.meas tran vdout1_33ck99 FIND v(dout1_33) AT=500.025n

* CHECK dout1_34 Vdout1_34ck99 = 0 time = 500
.meas tran vdout1_34ck99 FIND v(dout1_34) AT=500.025n

* CHECK dout1_35 Vdout1_35ck99 = 0 time = 500
.meas tran vdout1_35ck99 FIND v(dout1_35) AT=500.025n

* CHECK dout1_36 Vdout1_36ck99 = 0 time = 500
.meas tran vdout1_36ck99 FIND v(dout1_36) AT=500.025n

* CHECK dout1_37 Vdout1_37ck99 = 0 time = 500
.meas tran vdout1_37ck99 FIND v(dout1_37) AT=500.025n

* CHECK dout1_38 Vdout1_38ck99 = 0.9 time = 500
.meas tran vdout1_38ck99 FIND v(dout1_38) AT=500.025n

* CHECK dout1_39 Vdout1_39ck99 = 0 time = 500
.meas tran vdout1_39ck99 FIND v(dout1_39) AT=500.025n

* CHECK dout1_40 Vdout1_40ck99 = 0.9 time = 500
.meas tran vdout1_40ck99 FIND v(dout1_40) AT=500.025n

* CHECK dout1_41 Vdout1_41ck99 = 0.9 time = 500
.meas tran vdout1_41ck99 FIND v(dout1_41) AT=500.025n

* CHECK dout1_42 Vdout1_42ck99 = 0 time = 500
.meas tran vdout1_42ck99 FIND v(dout1_42) AT=500.025n

* CHECK dout1_43 Vdout1_43ck99 = 0.9 time = 500
.meas tran vdout1_43ck99 FIND v(dout1_43) AT=500.025n

* CHECK dout1_44 Vdout1_44ck99 = 0 time = 500
.meas tran vdout1_44ck99 FIND v(dout1_44) AT=500.025n

* CHECK dout1_45 Vdout1_45ck99 = 0.9 time = 500
.meas tran vdout1_45ck99 FIND v(dout1_45) AT=500.025n

* CHECK dout1_46 Vdout1_46ck99 = 0.9 time = 500
.meas tran vdout1_46ck99 FIND v(dout1_46) AT=500.025n

* CHECK dout1_47 Vdout1_47ck99 = 0 time = 500
.meas tran vdout1_47ck99 FIND v(dout1_47) AT=500.025n

* CHECK dout1_48 Vdout1_48ck99 = 0.9 time = 500
.meas tran vdout1_48ck99 FIND v(dout1_48) AT=500.025n

* CHECK dout1_49 Vdout1_49ck99 = 0 time = 500
.meas tran vdout1_49ck99 FIND v(dout1_49) AT=500.025n

* CHECK dout1_50 Vdout1_50ck99 = 0.9 time = 500
.meas tran vdout1_50ck99 FIND v(dout1_50) AT=500.025n

* CHECK dout1_51 Vdout1_51ck99 = 0 time = 500
.meas tran vdout1_51ck99 FIND v(dout1_51) AT=500.025n

* CHECK dout1_52 Vdout1_52ck99 = 0.9 time = 500
.meas tran vdout1_52ck99 FIND v(dout1_52) AT=500.025n

* CHECK dout1_53 Vdout1_53ck99 = 0 time = 500
.meas tran vdout1_53ck99 FIND v(dout1_53) AT=500.025n

* CHECK dout1_54 Vdout1_54ck99 = 0 time = 500
.meas tran vdout1_54ck99 FIND v(dout1_54) AT=500.025n

* CHECK dout1_55 Vdout1_55ck99 = 0 time = 500
.meas tran vdout1_55ck99 FIND v(dout1_55) AT=500.025n

* CHECK dout1_56 Vdout1_56ck99 = 0 time = 500
.meas tran vdout1_56ck99 FIND v(dout1_56) AT=500.025n

* CHECK dout1_57 Vdout1_57ck99 = 0 time = 500
.meas tran vdout1_57ck99 FIND v(dout1_57) AT=500.025n

* CHECK dout1_58 Vdout1_58ck99 = 0.9 time = 500
.meas tran vdout1_58ck99 FIND v(dout1_58) AT=500.025n

* CHECK dout1_59 Vdout1_59ck99 = 0 time = 500
.meas tran vdout1_59ck99 FIND v(dout1_59) AT=500.025n

* CHECK dout1_60 Vdout1_60ck99 = 0 time = 500
.meas tran vdout1_60ck99 FIND v(dout1_60) AT=500.025n

* CHECK dout1_61 Vdout1_61ck99 = 0 time = 500
.meas tran vdout1_61ck99 FIND v(dout1_61) AT=500.025n

* CHECK dout1_62 Vdout1_62ck99 = 0.9 time = 500
.meas tran vdout1_62ck99 FIND v(dout1_62) AT=500.025n

* CHECK dout1_63 Vdout1_63ck99 = 0 time = 500
.meas tran vdout1_63ck99 FIND v(dout1_63) AT=500.025n

* CHECK dout1_64 Vdout1_64ck99 = 0 time = 500
.meas tran vdout1_64ck99 FIND v(dout1_64) AT=500.025n

* CHECK dout1_65 Vdout1_65ck99 = 0.9 time = 500
.meas tran vdout1_65ck99 FIND v(dout1_65) AT=500.025n

* CHECK dout1_66 Vdout1_66ck99 = 0 time = 500
.meas tran vdout1_66ck99 FIND v(dout1_66) AT=500.025n

* CHECK dout1_67 Vdout1_67ck99 = 0 time = 500
.meas tran vdout1_67ck99 FIND v(dout1_67) AT=500.025n

* CHECK dout1_68 Vdout1_68ck99 = 0.9 time = 500
.meas tran vdout1_68ck99 FIND v(dout1_68) AT=500.025n

* CHECK dout1_69 Vdout1_69ck99 = 0 time = 500
.meas tran vdout1_69ck99 FIND v(dout1_69) AT=500.025n

* CHECK dout1_70 Vdout1_70ck99 = 0.9 time = 500
.meas tran vdout1_70ck99 FIND v(dout1_70) AT=500.025n

* CHECK dout1_71 Vdout1_71ck99 = 0.9 time = 500
.meas tran vdout1_71ck99 FIND v(dout1_71) AT=500.025n

* CHECK dout1_0 Vdout1_0ck102 = 0 time = 515
.meas tran vdout1_0ck102 FIND v(dout1_0) AT=515.025n

* CHECK dout1_1 Vdout1_1ck102 = 0 time = 515
.meas tran vdout1_1ck102 FIND v(dout1_1) AT=515.025n

* CHECK dout1_2 Vdout1_2ck102 = 0.9 time = 515
.meas tran vdout1_2ck102 FIND v(dout1_2) AT=515.025n

* CHECK dout1_3 Vdout1_3ck102 = 0 time = 515
.meas tran vdout1_3ck102 FIND v(dout1_3) AT=515.025n

* CHECK dout1_4 Vdout1_4ck102 = 0 time = 515
.meas tran vdout1_4ck102 FIND v(dout1_4) AT=515.025n

* CHECK dout1_5 Vdout1_5ck102 = 0.9 time = 515
.meas tran vdout1_5ck102 FIND v(dout1_5) AT=515.025n

* CHECK dout1_6 Vdout1_6ck102 = 0 time = 515
.meas tran vdout1_6ck102 FIND v(dout1_6) AT=515.025n

* CHECK dout1_7 Vdout1_7ck102 = 0 time = 515
.meas tran vdout1_7ck102 FIND v(dout1_7) AT=515.025n

* CHECK dout1_8 Vdout1_8ck102 = 0.9 time = 515
.meas tran vdout1_8ck102 FIND v(dout1_8) AT=515.025n

* CHECK dout1_9 Vdout1_9ck102 = 0 time = 515
.meas tran vdout1_9ck102 FIND v(dout1_9) AT=515.025n

* CHECK dout1_10 Vdout1_10ck102 = 0 time = 515
.meas tran vdout1_10ck102 FIND v(dout1_10) AT=515.025n

* CHECK dout1_11 Vdout1_11ck102 = 0 time = 515
.meas tran vdout1_11ck102 FIND v(dout1_11) AT=515.025n

* CHECK dout1_12 Vdout1_12ck102 = 0.9 time = 515
.meas tran vdout1_12ck102 FIND v(dout1_12) AT=515.025n

* CHECK dout1_13 Vdout1_13ck102 = 0 time = 515
.meas tran vdout1_13ck102 FIND v(dout1_13) AT=515.025n

* CHECK dout1_14 Vdout1_14ck102 = 0.9 time = 515
.meas tran vdout1_14ck102 FIND v(dout1_14) AT=515.025n

* CHECK dout1_15 Vdout1_15ck102 = 0 time = 515
.meas tran vdout1_15ck102 FIND v(dout1_15) AT=515.025n

* CHECK dout1_16 Vdout1_16ck102 = 0 time = 515
.meas tran vdout1_16ck102 FIND v(dout1_16) AT=515.025n

* CHECK dout1_17 Vdout1_17ck102 = 0.9 time = 515
.meas tran vdout1_17ck102 FIND v(dout1_17) AT=515.025n

* CHECK dout1_18 Vdout1_18ck102 = 0.9 time = 515
.meas tran vdout1_18ck102 FIND v(dout1_18) AT=515.025n

* CHECK dout1_19 Vdout1_19ck102 = 0.9 time = 515
.meas tran vdout1_19ck102 FIND v(dout1_19) AT=515.025n

* CHECK dout1_20 Vdout1_20ck102 = 0 time = 515
.meas tran vdout1_20ck102 FIND v(dout1_20) AT=515.025n

* CHECK dout1_21 Vdout1_21ck102 = 0.9 time = 515
.meas tran vdout1_21ck102 FIND v(dout1_21) AT=515.025n

* CHECK dout1_22 Vdout1_22ck102 = 0.9 time = 515
.meas tran vdout1_22ck102 FIND v(dout1_22) AT=515.025n

* CHECK dout1_23 Vdout1_23ck102 = 0.9 time = 515
.meas tran vdout1_23ck102 FIND v(dout1_23) AT=515.025n

* CHECK dout1_24 Vdout1_24ck102 = 0.9 time = 515
.meas tran vdout1_24ck102 FIND v(dout1_24) AT=515.025n

* CHECK dout1_25 Vdout1_25ck102 = 0 time = 515
.meas tran vdout1_25ck102 FIND v(dout1_25) AT=515.025n

* CHECK dout1_26 Vdout1_26ck102 = 0.9 time = 515
.meas tran vdout1_26ck102 FIND v(dout1_26) AT=515.025n

* CHECK dout1_27 Vdout1_27ck102 = 0.9 time = 515
.meas tran vdout1_27ck102 FIND v(dout1_27) AT=515.025n

* CHECK dout1_28 Vdout1_28ck102 = 0.9 time = 515
.meas tran vdout1_28ck102 FIND v(dout1_28) AT=515.025n

* CHECK dout1_29 Vdout1_29ck102 = 0.9 time = 515
.meas tran vdout1_29ck102 FIND v(dout1_29) AT=515.025n

* CHECK dout1_30 Vdout1_30ck102 = 0 time = 515
.meas tran vdout1_30ck102 FIND v(dout1_30) AT=515.025n

* CHECK dout1_31 Vdout1_31ck102 = 0 time = 515
.meas tran vdout1_31ck102 FIND v(dout1_31) AT=515.025n

* CHECK dout1_32 Vdout1_32ck102 = 0 time = 515
.meas tran vdout1_32ck102 FIND v(dout1_32) AT=515.025n

* CHECK dout1_33 Vdout1_33ck102 = 0.9 time = 515
.meas tran vdout1_33ck102 FIND v(dout1_33) AT=515.025n

* CHECK dout1_34 Vdout1_34ck102 = 0.9 time = 515
.meas tran vdout1_34ck102 FIND v(dout1_34) AT=515.025n

* CHECK dout1_35 Vdout1_35ck102 = 0.9 time = 515
.meas tran vdout1_35ck102 FIND v(dout1_35) AT=515.025n

* CHECK dout1_36 Vdout1_36ck102 = 0 time = 515
.meas tran vdout1_36ck102 FIND v(dout1_36) AT=515.025n

* CHECK dout1_37 Vdout1_37ck102 = 0 time = 515
.meas tran vdout1_37ck102 FIND v(dout1_37) AT=515.025n

* CHECK dout1_38 Vdout1_38ck102 = 0 time = 515
.meas tran vdout1_38ck102 FIND v(dout1_38) AT=515.025n

* CHECK dout1_39 Vdout1_39ck102 = 0.9 time = 515
.meas tran vdout1_39ck102 FIND v(dout1_39) AT=515.025n

* CHECK dout1_40 Vdout1_40ck102 = 0 time = 515
.meas tran vdout1_40ck102 FIND v(dout1_40) AT=515.025n

* CHECK dout1_41 Vdout1_41ck102 = 0 time = 515
.meas tran vdout1_41ck102 FIND v(dout1_41) AT=515.025n

* CHECK dout1_42 Vdout1_42ck102 = 0.9 time = 515
.meas tran vdout1_42ck102 FIND v(dout1_42) AT=515.025n

* CHECK dout1_43 Vdout1_43ck102 = 0.9 time = 515
.meas tran vdout1_43ck102 FIND v(dout1_43) AT=515.025n

* CHECK dout1_44 Vdout1_44ck102 = 0.9 time = 515
.meas tran vdout1_44ck102 FIND v(dout1_44) AT=515.025n

* CHECK dout1_45 Vdout1_45ck102 = 0.9 time = 515
.meas tran vdout1_45ck102 FIND v(dout1_45) AT=515.025n

* CHECK dout1_46 Vdout1_46ck102 = 0.9 time = 515
.meas tran vdout1_46ck102 FIND v(dout1_46) AT=515.025n

* CHECK dout1_47 Vdout1_47ck102 = 0.9 time = 515
.meas tran vdout1_47ck102 FIND v(dout1_47) AT=515.025n

* CHECK dout1_48 Vdout1_48ck102 = 0 time = 515
.meas tran vdout1_48ck102 FIND v(dout1_48) AT=515.025n

* CHECK dout1_49 Vdout1_49ck102 = 0 time = 515
.meas tran vdout1_49ck102 FIND v(dout1_49) AT=515.025n

* CHECK dout1_50 Vdout1_50ck102 = 0 time = 515
.meas tran vdout1_50ck102 FIND v(dout1_50) AT=515.025n

* CHECK dout1_51 Vdout1_51ck102 = 0 time = 515
.meas tran vdout1_51ck102 FIND v(dout1_51) AT=515.025n

* CHECK dout1_52 Vdout1_52ck102 = 0 time = 515
.meas tran vdout1_52ck102 FIND v(dout1_52) AT=515.025n

* CHECK dout1_53 Vdout1_53ck102 = 0.9 time = 515
.meas tran vdout1_53ck102 FIND v(dout1_53) AT=515.025n

* CHECK dout1_54 Vdout1_54ck102 = 0.9 time = 515
.meas tran vdout1_54ck102 FIND v(dout1_54) AT=515.025n

* CHECK dout1_55 Vdout1_55ck102 = 0 time = 515
.meas tran vdout1_55ck102 FIND v(dout1_55) AT=515.025n

* CHECK dout1_56 Vdout1_56ck102 = 0.9 time = 515
.meas tran vdout1_56ck102 FIND v(dout1_56) AT=515.025n

* CHECK dout1_57 Vdout1_57ck102 = 0.9 time = 515
.meas tran vdout1_57ck102 FIND v(dout1_57) AT=515.025n

* CHECK dout1_58 Vdout1_58ck102 = 0 time = 515
.meas tran vdout1_58ck102 FIND v(dout1_58) AT=515.025n

* CHECK dout1_59 Vdout1_59ck102 = 0 time = 515
.meas tran vdout1_59ck102 FIND v(dout1_59) AT=515.025n

* CHECK dout1_60 Vdout1_60ck102 = 0 time = 515
.meas tran vdout1_60ck102 FIND v(dout1_60) AT=515.025n

* CHECK dout1_61 Vdout1_61ck102 = 0.9 time = 515
.meas tran vdout1_61ck102 FIND v(dout1_61) AT=515.025n

* CHECK dout1_62 Vdout1_62ck102 = 0.9 time = 515
.meas tran vdout1_62ck102 FIND v(dout1_62) AT=515.025n

* CHECK dout1_63 Vdout1_63ck102 = 0.9 time = 515
.meas tran vdout1_63ck102 FIND v(dout1_63) AT=515.025n

* CHECK dout1_64 Vdout1_64ck102 = 0.9 time = 515
.meas tran vdout1_64ck102 FIND v(dout1_64) AT=515.025n

* CHECK dout1_65 Vdout1_65ck102 = 0.9 time = 515
.meas tran vdout1_65ck102 FIND v(dout1_65) AT=515.025n

* CHECK dout1_66 Vdout1_66ck102 = 0.9 time = 515
.meas tran vdout1_66ck102 FIND v(dout1_66) AT=515.025n

* CHECK dout1_67 Vdout1_67ck102 = 0 time = 515
.meas tran vdout1_67ck102 FIND v(dout1_67) AT=515.025n

* CHECK dout1_68 Vdout1_68ck102 = 0 time = 515
.meas tran vdout1_68ck102 FIND v(dout1_68) AT=515.025n

* CHECK dout1_69 Vdout1_69ck102 = 0.9 time = 515
.meas tran vdout1_69ck102 FIND v(dout1_69) AT=515.025n

* CHECK dout1_70 Vdout1_70ck102 = 0.9 time = 515
.meas tran vdout1_70ck102 FIND v(dout1_70) AT=515.025n

* CHECK dout1_71 Vdout1_71ck102 = 0.9 time = 515
.meas tran vdout1_71ck102 FIND v(dout1_71) AT=515.025n

* CHECK dout1_0 Vdout1_0ck107 = 0 time = 540
.meas tran vdout1_0ck107 FIND v(dout1_0) AT=540.025n

* CHECK dout1_1 Vdout1_1ck107 = 0 time = 540
.meas tran vdout1_1ck107 FIND v(dout1_1) AT=540.025n

* CHECK dout1_2 Vdout1_2ck107 = 0.9 time = 540
.meas tran vdout1_2ck107 FIND v(dout1_2) AT=540.025n

* CHECK dout1_3 Vdout1_3ck107 = 0 time = 540
.meas tran vdout1_3ck107 FIND v(dout1_3) AT=540.025n

* CHECK dout1_4 Vdout1_4ck107 = 0 time = 540
.meas tran vdout1_4ck107 FIND v(dout1_4) AT=540.025n

* CHECK dout1_5 Vdout1_5ck107 = 0.9 time = 540
.meas tran vdout1_5ck107 FIND v(dout1_5) AT=540.025n

* CHECK dout1_6 Vdout1_6ck107 = 0 time = 540
.meas tran vdout1_6ck107 FIND v(dout1_6) AT=540.025n

* CHECK dout1_7 Vdout1_7ck107 = 0 time = 540
.meas tran vdout1_7ck107 FIND v(dout1_7) AT=540.025n

* CHECK dout1_8 Vdout1_8ck107 = 0.9 time = 540
.meas tran vdout1_8ck107 FIND v(dout1_8) AT=540.025n

* CHECK dout1_9 Vdout1_9ck107 = 0 time = 540
.meas tran vdout1_9ck107 FIND v(dout1_9) AT=540.025n

* CHECK dout1_10 Vdout1_10ck107 = 0 time = 540
.meas tran vdout1_10ck107 FIND v(dout1_10) AT=540.025n

* CHECK dout1_11 Vdout1_11ck107 = 0 time = 540
.meas tran vdout1_11ck107 FIND v(dout1_11) AT=540.025n

* CHECK dout1_12 Vdout1_12ck107 = 0.9 time = 540
.meas tran vdout1_12ck107 FIND v(dout1_12) AT=540.025n

* CHECK dout1_13 Vdout1_13ck107 = 0 time = 540
.meas tran vdout1_13ck107 FIND v(dout1_13) AT=540.025n

* CHECK dout1_14 Vdout1_14ck107 = 0.9 time = 540
.meas tran vdout1_14ck107 FIND v(dout1_14) AT=540.025n

* CHECK dout1_15 Vdout1_15ck107 = 0 time = 540
.meas tran vdout1_15ck107 FIND v(dout1_15) AT=540.025n

* CHECK dout1_16 Vdout1_16ck107 = 0 time = 540
.meas tran vdout1_16ck107 FIND v(dout1_16) AT=540.025n

* CHECK dout1_17 Vdout1_17ck107 = 0.9 time = 540
.meas tran vdout1_17ck107 FIND v(dout1_17) AT=540.025n

* CHECK dout1_18 Vdout1_18ck107 = 0.9 time = 540
.meas tran vdout1_18ck107 FIND v(dout1_18) AT=540.025n

* CHECK dout1_19 Vdout1_19ck107 = 0.9 time = 540
.meas tran vdout1_19ck107 FIND v(dout1_19) AT=540.025n

* CHECK dout1_20 Vdout1_20ck107 = 0 time = 540
.meas tran vdout1_20ck107 FIND v(dout1_20) AT=540.025n

* CHECK dout1_21 Vdout1_21ck107 = 0.9 time = 540
.meas tran vdout1_21ck107 FIND v(dout1_21) AT=540.025n

* CHECK dout1_22 Vdout1_22ck107 = 0.9 time = 540
.meas tran vdout1_22ck107 FIND v(dout1_22) AT=540.025n

* CHECK dout1_23 Vdout1_23ck107 = 0.9 time = 540
.meas tran vdout1_23ck107 FIND v(dout1_23) AT=540.025n

* CHECK dout1_24 Vdout1_24ck107 = 0.9 time = 540
.meas tran vdout1_24ck107 FIND v(dout1_24) AT=540.025n

* CHECK dout1_25 Vdout1_25ck107 = 0 time = 540
.meas tran vdout1_25ck107 FIND v(dout1_25) AT=540.025n

* CHECK dout1_26 Vdout1_26ck107 = 0.9 time = 540
.meas tran vdout1_26ck107 FIND v(dout1_26) AT=540.025n

* CHECK dout1_27 Vdout1_27ck107 = 0.9 time = 540
.meas tran vdout1_27ck107 FIND v(dout1_27) AT=540.025n

* CHECK dout1_28 Vdout1_28ck107 = 0.9 time = 540
.meas tran vdout1_28ck107 FIND v(dout1_28) AT=540.025n

* CHECK dout1_29 Vdout1_29ck107 = 0.9 time = 540
.meas tran vdout1_29ck107 FIND v(dout1_29) AT=540.025n

* CHECK dout1_30 Vdout1_30ck107 = 0 time = 540
.meas tran vdout1_30ck107 FIND v(dout1_30) AT=540.025n

* CHECK dout1_31 Vdout1_31ck107 = 0 time = 540
.meas tran vdout1_31ck107 FIND v(dout1_31) AT=540.025n

* CHECK dout1_32 Vdout1_32ck107 = 0 time = 540
.meas tran vdout1_32ck107 FIND v(dout1_32) AT=540.025n

* CHECK dout1_33 Vdout1_33ck107 = 0.9 time = 540
.meas tran vdout1_33ck107 FIND v(dout1_33) AT=540.025n

* CHECK dout1_34 Vdout1_34ck107 = 0.9 time = 540
.meas tran vdout1_34ck107 FIND v(dout1_34) AT=540.025n

* CHECK dout1_35 Vdout1_35ck107 = 0.9 time = 540
.meas tran vdout1_35ck107 FIND v(dout1_35) AT=540.025n

* CHECK dout1_36 Vdout1_36ck107 = 0 time = 540
.meas tran vdout1_36ck107 FIND v(dout1_36) AT=540.025n

* CHECK dout1_37 Vdout1_37ck107 = 0 time = 540
.meas tran vdout1_37ck107 FIND v(dout1_37) AT=540.025n

* CHECK dout1_38 Vdout1_38ck107 = 0 time = 540
.meas tran vdout1_38ck107 FIND v(dout1_38) AT=540.025n

* CHECK dout1_39 Vdout1_39ck107 = 0.9 time = 540
.meas tran vdout1_39ck107 FIND v(dout1_39) AT=540.025n

* CHECK dout1_40 Vdout1_40ck107 = 0 time = 540
.meas tran vdout1_40ck107 FIND v(dout1_40) AT=540.025n

* CHECK dout1_41 Vdout1_41ck107 = 0 time = 540
.meas tran vdout1_41ck107 FIND v(dout1_41) AT=540.025n

* CHECK dout1_42 Vdout1_42ck107 = 0.9 time = 540
.meas tran vdout1_42ck107 FIND v(dout1_42) AT=540.025n

* CHECK dout1_43 Vdout1_43ck107 = 0.9 time = 540
.meas tran vdout1_43ck107 FIND v(dout1_43) AT=540.025n

* CHECK dout1_44 Vdout1_44ck107 = 0.9 time = 540
.meas tran vdout1_44ck107 FIND v(dout1_44) AT=540.025n

* CHECK dout1_45 Vdout1_45ck107 = 0.9 time = 540
.meas tran vdout1_45ck107 FIND v(dout1_45) AT=540.025n

* CHECK dout1_46 Vdout1_46ck107 = 0.9 time = 540
.meas tran vdout1_46ck107 FIND v(dout1_46) AT=540.025n

* CHECK dout1_47 Vdout1_47ck107 = 0.9 time = 540
.meas tran vdout1_47ck107 FIND v(dout1_47) AT=540.025n

* CHECK dout1_48 Vdout1_48ck107 = 0 time = 540
.meas tran vdout1_48ck107 FIND v(dout1_48) AT=540.025n

* CHECK dout1_49 Vdout1_49ck107 = 0 time = 540
.meas tran vdout1_49ck107 FIND v(dout1_49) AT=540.025n

* CHECK dout1_50 Vdout1_50ck107 = 0 time = 540
.meas tran vdout1_50ck107 FIND v(dout1_50) AT=540.025n

* CHECK dout1_51 Vdout1_51ck107 = 0 time = 540
.meas tran vdout1_51ck107 FIND v(dout1_51) AT=540.025n

* CHECK dout1_52 Vdout1_52ck107 = 0 time = 540
.meas tran vdout1_52ck107 FIND v(dout1_52) AT=540.025n

* CHECK dout1_53 Vdout1_53ck107 = 0.9 time = 540
.meas tran vdout1_53ck107 FIND v(dout1_53) AT=540.025n

* CHECK dout1_54 Vdout1_54ck107 = 0.9 time = 540
.meas tran vdout1_54ck107 FIND v(dout1_54) AT=540.025n

* CHECK dout1_55 Vdout1_55ck107 = 0 time = 540
.meas tran vdout1_55ck107 FIND v(dout1_55) AT=540.025n

* CHECK dout1_56 Vdout1_56ck107 = 0.9 time = 540
.meas tran vdout1_56ck107 FIND v(dout1_56) AT=540.025n

* CHECK dout1_57 Vdout1_57ck107 = 0.9 time = 540
.meas tran vdout1_57ck107 FIND v(dout1_57) AT=540.025n

* CHECK dout1_58 Vdout1_58ck107 = 0 time = 540
.meas tran vdout1_58ck107 FIND v(dout1_58) AT=540.025n

* CHECK dout1_59 Vdout1_59ck107 = 0 time = 540
.meas tran vdout1_59ck107 FIND v(dout1_59) AT=540.025n

* CHECK dout1_60 Vdout1_60ck107 = 0 time = 540
.meas tran vdout1_60ck107 FIND v(dout1_60) AT=540.025n

* CHECK dout1_61 Vdout1_61ck107 = 0.9 time = 540
.meas tran vdout1_61ck107 FIND v(dout1_61) AT=540.025n

* CHECK dout1_62 Vdout1_62ck107 = 0.9 time = 540
.meas tran vdout1_62ck107 FIND v(dout1_62) AT=540.025n

* CHECK dout1_63 Vdout1_63ck107 = 0.9 time = 540
.meas tran vdout1_63ck107 FIND v(dout1_63) AT=540.025n

* CHECK dout1_64 Vdout1_64ck107 = 0.9 time = 540
.meas tran vdout1_64ck107 FIND v(dout1_64) AT=540.025n

* CHECK dout1_65 Vdout1_65ck107 = 0.9 time = 540
.meas tran vdout1_65ck107 FIND v(dout1_65) AT=540.025n

* CHECK dout1_66 Vdout1_66ck107 = 0.9 time = 540
.meas tran vdout1_66ck107 FIND v(dout1_66) AT=540.025n

* CHECK dout1_67 Vdout1_67ck107 = 0 time = 540
.meas tran vdout1_67ck107 FIND v(dout1_67) AT=540.025n

* CHECK dout1_68 Vdout1_68ck107 = 0 time = 540
.meas tran vdout1_68ck107 FIND v(dout1_68) AT=540.025n

* CHECK dout1_69 Vdout1_69ck107 = 0.9 time = 540
.meas tran vdout1_69ck107 FIND v(dout1_69) AT=540.025n

* CHECK dout1_70 Vdout1_70ck107 = 0.9 time = 540
.meas tran vdout1_70ck107 FIND v(dout1_70) AT=540.025n

* CHECK dout1_71 Vdout1_71ck107 = 0.9 time = 540
.meas tran vdout1_71ck107 FIND v(dout1_71) AT=540.025n

* CHECK dout1_0 Vdout1_0ck108 = 0.9 time = 545
.meas tran vdout1_0ck108 FIND v(dout1_0) AT=545.025n

* CHECK dout1_1 Vdout1_1ck108 = 0.9 time = 545
.meas tran vdout1_1ck108 FIND v(dout1_1) AT=545.025n

* CHECK dout1_2 Vdout1_2ck108 = 0 time = 545
.meas tran vdout1_2ck108 FIND v(dout1_2) AT=545.025n

* CHECK dout1_3 Vdout1_3ck108 = 0.9 time = 545
.meas tran vdout1_3ck108 FIND v(dout1_3) AT=545.025n

* CHECK dout1_4 Vdout1_4ck108 = 0 time = 545
.meas tran vdout1_4ck108 FIND v(dout1_4) AT=545.025n

* CHECK dout1_5 Vdout1_5ck108 = 0 time = 545
.meas tran vdout1_5ck108 FIND v(dout1_5) AT=545.025n

* CHECK dout1_6 Vdout1_6ck108 = 0.9 time = 545
.meas tran vdout1_6ck108 FIND v(dout1_6) AT=545.025n

* CHECK dout1_7 Vdout1_7ck108 = 0 time = 545
.meas tran vdout1_7ck108 FIND v(dout1_7) AT=545.025n

* CHECK dout1_8 Vdout1_8ck108 = 0.9 time = 545
.meas tran vdout1_8ck108 FIND v(dout1_8) AT=545.025n

* CHECK dout1_9 Vdout1_9ck108 = 0.9 time = 545
.meas tran vdout1_9ck108 FIND v(dout1_9) AT=545.025n

* CHECK dout1_10 Vdout1_10ck108 = 0 time = 545
.meas tran vdout1_10ck108 FIND v(dout1_10) AT=545.025n

* CHECK dout1_11 Vdout1_11ck108 = 0.9 time = 545
.meas tran vdout1_11ck108 FIND v(dout1_11) AT=545.025n

* CHECK dout1_12 Vdout1_12ck108 = 0.9 time = 545
.meas tran vdout1_12ck108 FIND v(dout1_12) AT=545.025n

* CHECK dout1_13 Vdout1_13ck108 = 0.9 time = 545
.meas tran vdout1_13ck108 FIND v(dout1_13) AT=545.025n

* CHECK dout1_14 Vdout1_14ck108 = 0 time = 545
.meas tran vdout1_14ck108 FIND v(dout1_14) AT=545.025n

* CHECK dout1_15 Vdout1_15ck108 = 0.9 time = 545
.meas tran vdout1_15ck108 FIND v(dout1_15) AT=545.025n

* CHECK dout1_16 Vdout1_16ck108 = 0 time = 545
.meas tran vdout1_16ck108 FIND v(dout1_16) AT=545.025n

* CHECK dout1_17 Vdout1_17ck108 = 0 time = 545
.meas tran vdout1_17ck108 FIND v(dout1_17) AT=545.025n

* CHECK dout1_18 Vdout1_18ck108 = 0 time = 545
.meas tran vdout1_18ck108 FIND v(dout1_18) AT=545.025n

* CHECK dout1_19 Vdout1_19ck108 = 0.9 time = 545
.meas tran vdout1_19ck108 FIND v(dout1_19) AT=545.025n

* CHECK dout1_20 Vdout1_20ck108 = 0 time = 545
.meas tran vdout1_20ck108 FIND v(dout1_20) AT=545.025n

* CHECK dout1_21 Vdout1_21ck108 = 0 time = 545
.meas tran vdout1_21ck108 FIND v(dout1_21) AT=545.025n

* CHECK dout1_22 Vdout1_22ck108 = 0.9 time = 545
.meas tran vdout1_22ck108 FIND v(dout1_22) AT=545.025n

* CHECK dout1_23 Vdout1_23ck108 = 0 time = 545
.meas tran vdout1_23ck108 FIND v(dout1_23) AT=545.025n

* CHECK dout1_24 Vdout1_24ck108 = 0.9 time = 545
.meas tran vdout1_24ck108 FIND v(dout1_24) AT=545.025n

* CHECK dout1_25 Vdout1_25ck108 = 0 time = 545
.meas tran vdout1_25ck108 FIND v(dout1_25) AT=545.025n

* CHECK dout1_26 Vdout1_26ck108 = 0 time = 545
.meas tran vdout1_26ck108 FIND v(dout1_26) AT=545.025n

* CHECK dout1_27 Vdout1_27ck108 = 0.9 time = 545
.meas tran vdout1_27ck108 FIND v(dout1_27) AT=545.025n

* CHECK dout1_28 Vdout1_28ck108 = 0 time = 545
.meas tran vdout1_28ck108 FIND v(dout1_28) AT=545.025n

* CHECK dout1_29 Vdout1_29ck108 = 0 time = 545
.meas tran vdout1_29ck108 FIND v(dout1_29) AT=545.025n

* CHECK dout1_30 Vdout1_30ck108 = 0 time = 545
.meas tran vdout1_30ck108 FIND v(dout1_30) AT=545.025n

* CHECK dout1_31 Vdout1_31ck108 = 0.9 time = 545
.meas tran vdout1_31ck108 FIND v(dout1_31) AT=545.025n

* CHECK dout1_32 Vdout1_32ck108 = 0 time = 545
.meas tran vdout1_32ck108 FIND v(dout1_32) AT=545.025n

* CHECK dout1_33 Vdout1_33ck108 = 0 time = 545
.meas tran vdout1_33ck108 FIND v(dout1_33) AT=545.025n

* CHECK dout1_34 Vdout1_34ck108 = 0.9 time = 545
.meas tran vdout1_34ck108 FIND v(dout1_34) AT=545.025n

* CHECK dout1_35 Vdout1_35ck108 = 0.9 time = 545
.meas tran vdout1_35ck108 FIND v(dout1_35) AT=545.025n

* CHECK dout1_36 Vdout1_36ck108 = 0 time = 545
.meas tran vdout1_36ck108 FIND v(dout1_36) AT=545.025n

* CHECK dout1_37 Vdout1_37ck108 = 0.9 time = 545
.meas tran vdout1_37ck108 FIND v(dout1_37) AT=545.025n

* CHECK dout1_38 Vdout1_38ck108 = 0 time = 545
.meas tran vdout1_38ck108 FIND v(dout1_38) AT=545.025n

* CHECK dout1_39 Vdout1_39ck108 = 0 time = 545
.meas tran vdout1_39ck108 FIND v(dout1_39) AT=545.025n

* CHECK dout1_40 Vdout1_40ck108 = 0.9 time = 545
.meas tran vdout1_40ck108 FIND v(dout1_40) AT=545.025n

* CHECK dout1_41 Vdout1_41ck108 = 0.9 time = 545
.meas tran vdout1_41ck108 FIND v(dout1_41) AT=545.025n

* CHECK dout1_42 Vdout1_42ck108 = 0 time = 545
.meas tran vdout1_42ck108 FIND v(dout1_42) AT=545.025n

* CHECK dout1_43 Vdout1_43ck108 = 0 time = 545
.meas tran vdout1_43ck108 FIND v(dout1_43) AT=545.025n

* CHECK dout1_44 Vdout1_44ck108 = 0 time = 545
.meas tran vdout1_44ck108 FIND v(dout1_44) AT=545.025n

* CHECK dout1_45 Vdout1_45ck108 = 0 time = 545
.meas tran vdout1_45ck108 FIND v(dout1_45) AT=545.025n

* CHECK dout1_46 Vdout1_46ck108 = 0 time = 545
.meas tran vdout1_46ck108 FIND v(dout1_46) AT=545.025n

* CHECK dout1_47 Vdout1_47ck108 = 0 time = 545
.meas tran vdout1_47ck108 FIND v(dout1_47) AT=545.025n

* CHECK dout1_48 Vdout1_48ck108 = 0 time = 545
.meas tran vdout1_48ck108 FIND v(dout1_48) AT=545.025n

* CHECK dout1_49 Vdout1_49ck108 = 0.9 time = 545
.meas tran vdout1_49ck108 FIND v(dout1_49) AT=545.025n

* CHECK dout1_50 Vdout1_50ck108 = 0 time = 545
.meas tran vdout1_50ck108 FIND v(dout1_50) AT=545.025n

* CHECK dout1_51 Vdout1_51ck108 = 0 time = 545
.meas tran vdout1_51ck108 FIND v(dout1_51) AT=545.025n

* CHECK dout1_52 Vdout1_52ck108 = 0 time = 545
.meas tran vdout1_52ck108 FIND v(dout1_52) AT=545.025n

* CHECK dout1_53 Vdout1_53ck108 = 0.9 time = 545
.meas tran vdout1_53ck108 FIND v(dout1_53) AT=545.025n

* CHECK dout1_54 Vdout1_54ck108 = 0.9 time = 545
.meas tran vdout1_54ck108 FIND v(dout1_54) AT=545.025n

* CHECK dout1_55 Vdout1_55ck108 = 0.9 time = 545
.meas tran vdout1_55ck108 FIND v(dout1_55) AT=545.025n

* CHECK dout1_56 Vdout1_56ck108 = 0 time = 545
.meas tran vdout1_56ck108 FIND v(dout1_56) AT=545.025n

* CHECK dout1_57 Vdout1_57ck108 = 0 time = 545
.meas tran vdout1_57ck108 FIND v(dout1_57) AT=545.025n

* CHECK dout1_58 Vdout1_58ck108 = 0.9 time = 545
.meas tran vdout1_58ck108 FIND v(dout1_58) AT=545.025n

* CHECK dout1_59 Vdout1_59ck108 = 0.9 time = 545
.meas tran vdout1_59ck108 FIND v(dout1_59) AT=545.025n

* CHECK dout1_60 Vdout1_60ck108 = 0.9 time = 545
.meas tran vdout1_60ck108 FIND v(dout1_60) AT=545.025n

* CHECK dout1_61 Vdout1_61ck108 = 0.9 time = 545
.meas tran vdout1_61ck108 FIND v(dout1_61) AT=545.025n

* CHECK dout1_62 Vdout1_62ck108 = 0.9 time = 545
.meas tran vdout1_62ck108 FIND v(dout1_62) AT=545.025n

* CHECK dout1_63 Vdout1_63ck108 = 0 time = 545
.meas tran vdout1_63ck108 FIND v(dout1_63) AT=545.025n

* CHECK dout1_64 Vdout1_64ck108 = 0.9 time = 545
.meas tran vdout1_64ck108 FIND v(dout1_64) AT=545.025n

* CHECK dout1_65 Vdout1_65ck108 = 0 time = 545
.meas tran vdout1_65ck108 FIND v(dout1_65) AT=545.025n

* CHECK dout1_66 Vdout1_66ck108 = 0 time = 545
.meas tran vdout1_66ck108 FIND v(dout1_66) AT=545.025n

* CHECK dout1_67 Vdout1_67ck108 = 0.9 time = 545
.meas tran vdout1_67ck108 FIND v(dout1_67) AT=545.025n

* CHECK dout1_68 Vdout1_68ck108 = 0 time = 545
.meas tran vdout1_68ck108 FIND v(dout1_68) AT=545.025n

* CHECK dout1_69 Vdout1_69ck108 = 0.9 time = 545
.meas tran vdout1_69ck108 FIND v(dout1_69) AT=545.025n

* CHECK dout1_70 Vdout1_70ck108 = 0.9 time = 545
.meas tran vdout1_70ck108 FIND v(dout1_70) AT=545.025n

* CHECK dout1_71 Vdout1_71ck108 = 0 time = 545
.meas tran vdout1_71ck108 FIND v(dout1_71) AT=545.025n

* CHECK dout1_0 Vdout1_0ck109 = 0.9 time = 550
.meas tran vdout1_0ck109 FIND v(dout1_0) AT=550.025n

* CHECK dout1_1 Vdout1_1ck109 = 0.9 time = 550
.meas tran vdout1_1ck109 FIND v(dout1_1) AT=550.025n

* CHECK dout1_2 Vdout1_2ck109 = 0 time = 550
.meas tran vdout1_2ck109 FIND v(dout1_2) AT=550.025n

* CHECK dout1_3 Vdout1_3ck109 = 0 time = 550
.meas tran vdout1_3ck109 FIND v(dout1_3) AT=550.025n

* CHECK dout1_4 Vdout1_4ck109 = 0.9 time = 550
.meas tran vdout1_4ck109 FIND v(dout1_4) AT=550.025n

* CHECK dout1_5 Vdout1_5ck109 = 0.9 time = 550
.meas tran vdout1_5ck109 FIND v(dout1_5) AT=550.025n

* CHECK dout1_6 Vdout1_6ck109 = 0 time = 550
.meas tran vdout1_6ck109 FIND v(dout1_6) AT=550.025n

* CHECK dout1_7 Vdout1_7ck109 = 0 time = 550
.meas tran vdout1_7ck109 FIND v(dout1_7) AT=550.025n

* CHECK dout1_8 Vdout1_8ck109 = 0 time = 550
.meas tran vdout1_8ck109 FIND v(dout1_8) AT=550.025n

* CHECK dout1_9 Vdout1_9ck109 = 0 time = 550
.meas tran vdout1_9ck109 FIND v(dout1_9) AT=550.025n

* CHECK dout1_10 Vdout1_10ck109 = 0.9 time = 550
.meas tran vdout1_10ck109 FIND v(dout1_10) AT=550.025n

* CHECK dout1_11 Vdout1_11ck109 = 0.9 time = 550
.meas tran vdout1_11ck109 FIND v(dout1_11) AT=550.025n

* CHECK dout1_12 Vdout1_12ck109 = 0 time = 550
.meas tran vdout1_12ck109 FIND v(dout1_12) AT=550.025n

* CHECK dout1_13 Vdout1_13ck109 = 0 time = 550
.meas tran vdout1_13ck109 FIND v(dout1_13) AT=550.025n

* CHECK dout1_14 Vdout1_14ck109 = 0 time = 550
.meas tran vdout1_14ck109 FIND v(dout1_14) AT=550.025n

* CHECK dout1_15 Vdout1_15ck109 = 0.9 time = 550
.meas tran vdout1_15ck109 FIND v(dout1_15) AT=550.025n

* CHECK dout1_16 Vdout1_16ck109 = 0.9 time = 550
.meas tran vdout1_16ck109 FIND v(dout1_16) AT=550.025n

* CHECK dout1_17 Vdout1_17ck109 = 0.9 time = 550
.meas tran vdout1_17ck109 FIND v(dout1_17) AT=550.025n

* CHECK dout1_18 Vdout1_18ck109 = 0.9 time = 550
.meas tran vdout1_18ck109 FIND v(dout1_18) AT=550.025n

* CHECK dout1_19 Vdout1_19ck109 = 0.9 time = 550
.meas tran vdout1_19ck109 FIND v(dout1_19) AT=550.025n

* CHECK dout1_20 Vdout1_20ck109 = 0.9 time = 550
.meas tran vdout1_20ck109 FIND v(dout1_20) AT=550.025n

* CHECK dout1_21 Vdout1_21ck109 = 0.9 time = 550
.meas tran vdout1_21ck109 FIND v(dout1_21) AT=550.025n

* CHECK dout1_22 Vdout1_22ck109 = 0.9 time = 550
.meas tran vdout1_22ck109 FIND v(dout1_22) AT=550.025n

* CHECK dout1_23 Vdout1_23ck109 = 0 time = 550
.meas tran vdout1_23ck109 FIND v(dout1_23) AT=550.025n

* CHECK dout1_24 Vdout1_24ck109 = 0 time = 550
.meas tran vdout1_24ck109 FIND v(dout1_24) AT=550.025n

* CHECK dout1_25 Vdout1_25ck109 = 0 time = 550
.meas tran vdout1_25ck109 FIND v(dout1_25) AT=550.025n

* CHECK dout1_26 Vdout1_26ck109 = 0.9 time = 550
.meas tran vdout1_26ck109 FIND v(dout1_26) AT=550.025n

* CHECK dout1_27 Vdout1_27ck109 = 0.9 time = 550
.meas tran vdout1_27ck109 FIND v(dout1_27) AT=550.025n

* CHECK dout1_28 Vdout1_28ck109 = 0 time = 550
.meas tran vdout1_28ck109 FIND v(dout1_28) AT=550.025n

* CHECK dout1_29 Vdout1_29ck109 = 0.9 time = 550
.meas tran vdout1_29ck109 FIND v(dout1_29) AT=550.025n

* CHECK dout1_30 Vdout1_30ck109 = 0 time = 550
.meas tran vdout1_30ck109 FIND v(dout1_30) AT=550.025n

* CHECK dout1_31 Vdout1_31ck109 = 0 time = 550
.meas tran vdout1_31ck109 FIND v(dout1_31) AT=550.025n

* CHECK dout1_32 Vdout1_32ck109 = 0 time = 550
.meas tran vdout1_32ck109 FIND v(dout1_32) AT=550.025n

* CHECK dout1_33 Vdout1_33ck109 = 0.9 time = 550
.meas tran vdout1_33ck109 FIND v(dout1_33) AT=550.025n

* CHECK dout1_34 Vdout1_34ck109 = 0.9 time = 550
.meas tran vdout1_34ck109 FIND v(dout1_34) AT=550.025n

* CHECK dout1_35 Vdout1_35ck109 = 0 time = 550
.meas tran vdout1_35ck109 FIND v(dout1_35) AT=550.025n

* CHECK dout1_36 Vdout1_36ck109 = 0.9 time = 550
.meas tran vdout1_36ck109 FIND v(dout1_36) AT=550.025n

* CHECK dout1_37 Vdout1_37ck109 = 0 time = 550
.meas tran vdout1_37ck109 FIND v(dout1_37) AT=550.025n

* CHECK dout1_38 Vdout1_38ck109 = 0 time = 550
.meas tran vdout1_38ck109 FIND v(dout1_38) AT=550.025n

* CHECK dout1_39 Vdout1_39ck109 = 0 time = 550
.meas tran vdout1_39ck109 FIND v(dout1_39) AT=550.025n

* CHECK dout1_40 Vdout1_40ck109 = 0 time = 550
.meas tran vdout1_40ck109 FIND v(dout1_40) AT=550.025n

* CHECK dout1_41 Vdout1_41ck109 = 0.9 time = 550
.meas tran vdout1_41ck109 FIND v(dout1_41) AT=550.025n

* CHECK dout1_42 Vdout1_42ck109 = 0 time = 550
.meas tran vdout1_42ck109 FIND v(dout1_42) AT=550.025n

* CHECK dout1_43 Vdout1_43ck109 = 0.9 time = 550
.meas tran vdout1_43ck109 FIND v(dout1_43) AT=550.025n

* CHECK dout1_44 Vdout1_44ck109 = 0 time = 550
.meas tran vdout1_44ck109 FIND v(dout1_44) AT=550.025n

* CHECK dout1_45 Vdout1_45ck109 = 0 time = 550
.meas tran vdout1_45ck109 FIND v(dout1_45) AT=550.025n

* CHECK dout1_46 Vdout1_46ck109 = 0.9 time = 550
.meas tran vdout1_46ck109 FIND v(dout1_46) AT=550.025n

* CHECK dout1_47 Vdout1_47ck109 = 0 time = 550
.meas tran vdout1_47ck109 FIND v(dout1_47) AT=550.025n

* CHECK dout1_48 Vdout1_48ck109 = 0 time = 550
.meas tran vdout1_48ck109 FIND v(dout1_48) AT=550.025n

* CHECK dout1_49 Vdout1_49ck109 = 0 time = 550
.meas tran vdout1_49ck109 FIND v(dout1_49) AT=550.025n

* CHECK dout1_50 Vdout1_50ck109 = 0.9 time = 550
.meas tran vdout1_50ck109 FIND v(dout1_50) AT=550.025n

* CHECK dout1_51 Vdout1_51ck109 = 0.9 time = 550
.meas tran vdout1_51ck109 FIND v(dout1_51) AT=550.025n

* CHECK dout1_52 Vdout1_52ck109 = 0 time = 550
.meas tran vdout1_52ck109 FIND v(dout1_52) AT=550.025n

* CHECK dout1_53 Vdout1_53ck109 = 0.9 time = 550
.meas tran vdout1_53ck109 FIND v(dout1_53) AT=550.025n

* CHECK dout1_54 Vdout1_54ck109 = 0.9 time = 550
.meas tran vdout1_54ck109 FIND v(dout1_54) AT=550.025n

* CHECK dout1_55 Vdout1_55ck109 = 0.9 time = 550
.meas tran vdout1_55ck109 FIND v(dout1_55) AT=550.025n

* CHECK dout1_56 Vdout1_56ck109 = 0 time = 550
.meas tran vdout1_56ck109 FIND v(dout1_56) AT=550.025n

* CHECK dout1_57 Vdout1_57ck109 = 0.9 time = 550
.meas tran vdout1_57ck109 FIND v(dout1_57) AT=550.025n

* CHECK dout1_58 Vdout1_58ck109 = 0 time = 550
.meas tran vdout1_58ck109 FIND v(dout1_58) AT=550.025n

* CHECK dout1_59 Vdout1_59ck109 = 0 time = 550
.meas tran vdout1_59ck109 FIND v(dout1_59) AT=550.025n

* CHECK dout1_60 Vdout1_60ck109 = 0.9 time = 550
.meas tran vdout1_60ck109 FIND v(dout1_60) AT=550.025n

* CHECK dout1_61 Vdout1_61ck109 = 0 time = 550
.meas tran vdout1_61ck109 FIND v(dout1_61) AT=550.025n

* CHECK dout1_62 Vdout1_62ck109 = 0.9 time = 550
.meas tran vdout1_62ck109 FIND v(dout1_62) AT=550.025n

* CHECK dout1_63 Vdout1_63ck109 = 0 time = 550
.meas tran vdout1_63ck109 FIND v(dout1_63) AT=550.025n

* CHECK dout1_64 Vdout1_64ck109 = 0 time = 550
.meas tran vdout1_64ck109 FIND v(dout1_64) AT=550.025n

* CHECK dout1_65 Vdout1_65ck109 = 0 time = 550
.meas tran vdout1_65ck109 FIND v(dout1_65) AT=550.025n

* CHECK dout1_66 Vdout1_66ck109 = 0.9 time = 550
.meas tran vdout1_66ck109 FIND v(dout1_66) AT=550.025n

* CHECK dout1_67 Vdout1_67ck109 = 0 time = 550
.meas tran vdout1_67ck109 FIND v(dout1_67) AT=550.025n

* CHECK dout1_68 Vdout1_68ck109 = 0.9 time = 550
.meas tran vdout1_68ck109 FIND v(dout1_68) AT=550.025n

* CHECK dout1_69 Vdout1_69ck109 = 0.9 time = 550
.meas tran vdout1_69ck109 FIND v(dout1_69) AT=550.025n

* CHECK dout1_70 Vdout1_70ck109 = 0.9 time = 550
.meas tran vdout1_70ck109 FIND v(dout1_70) AT=550.025n

* CHECK dout1_71 Vdout1_71ck109 = 0 time = 550
.meas tran vdout1_71ck109 FIND v(dout1_71) AT=550.025n

* CHECK dout1_0 Vdout1_0ck111 = 0 time = 560
.meas tran vdout1_0ck111 FIND v(dout1_0) AT=560.025n

* CHECK dout1_1 Vdout1_1ck111 = 0.9 time = 560
.meas tran vdout1_1ck111 FIND v(dout1_1) AT=560.025n

* CHECK dout1_2 Vdout1_2ck111 = 0.9 time = 560
.meas tran vdout1_2ck111 FIND v(dout1_2) AT=560.025n

* CHECK dout1_3 Vdout1_3ck111 = 0 time = 560
.meas tran vdout1_3ck111 FIND v(dout1_3) AT=560.025n

* CHECK dout1_4 Vdout1_4ck111 = 0.9 time = 560
.meas tran vdout1_4ck111 FIND v(dout1_4) AT=560.025n

* CHECK dout1_5 Vdout1_5ck111 = 0.9 time = 560
.meas tran vdout1_5ck111 FIND v(dout1_5) AT=560.025n

* CHECK dout1_6 Vdout1_6ck111 = 0 time = 560
.meas tran vdout1_6ck111 FIND v(dout1_6) AT=560.025n

* CHECK dout1_7 Vdout1_7ck111 = 0.9 time = 560
.meas tran vdout1_7ck111 FIND v(dout1_7) AT=560.025n

* CHECK dout1_8 Vdout1_8ck111 = 0.9 time = 560
.meas tran vdout1_8ck111 FIND v(dout1_8) AT=560.025n

* CHECK dout1_9 Vdout1_9ck111 = 0.9 time = 560
.meas tran vdout1_9ck111 FIND v(dout1_9) AT=560.025n

* CHECK dout1_10 Vdout1_10ck111 = 0 time = 560
.meas tran vdout1_10ck111 FIND v(dout1_10) AT=560.025n

* CHECK dout1_11 Vdout1_11ck111 = 0.9 time = 560
.meas tran vdout1_11ck111 FIND v(dout1_11) AT=560.025n

* CHECK dout1_12 Vdout1_12ck111 = 0 time = 560
.meas tran vdout1_12ck111 FIND v(dout1_12) AT=560.025n

* CHECK dout1_13 Vdout1_13ck111 = 0.9 time = 560
.meas tran vdout1_13ck111 FIND v(dout1_13) AT=560.025n

* CHECK dout1_14 Vdout1_14ck111 = 0 time = 560
.meas tran vdout1_14ck111 FIND v(dout1_14) AT=560.025n

* CHECK dout1_15 Vdout1_15ck111 = 0.9 time = 560
.meas tran vdout1_15ck111 FIND v(dout1_15) AT=560.025n

* CHECK dout1_16 Vdout1_16ck111 = 0 time = 560
.meas tran vdout1_16ck111 FIND v(dout1_16) AT=560.025n

* CHECK dout1_17 Vdout1_17ck111 = 0 time = 560
.meas tran vdout1_17ck111 FIND v(dout1_17) AT=560.025n

* CHECK dout1_18 Vdout1_18ck111 = 0.9 time = 560
.meas tran vdout1_18ck111 FIND v(dout1_18) AT=560.025n

* CHECK dout1_19 Vdout1_19ck111 = 0.9 time = 560
.meas tran vdout1_19ck111 FIND v(dout1_19) AT=560.025n

* CHECK dout1_20 Vdout1_20ck111 = 0.9 time = 560
.meas tran vdout1_20ck111 FIND v(dout1_20) AT=560.025n

* CHECK dout1_21 Vdout1_21ck111 = 0 time = 560
.meas tran vdout1_21ck111 FIND v(dout1_21) AT=560.025n

* CHECK dout1_22 Vdout1_22ck111 = 0.9 time = 560
.meas tran vdout1_22ck111 FIND v(dout1_22) AT=560.025n

* CHECK dout1_23 Vdout1_23ck111 = 0 time = 560
.meas tran vdout1_23ck111 FIND v(dout1_23) AT=560.025n

* CHECK dout1_24 Vdout1_24ck111 = 0 time = 560
.meas tran vdout1_24ck111 FIND v(dout1_24) AT=560.025n

* CHECK dout1_25 Vdout1_25ck111 = 0.9 time = 560
.meas tran vdout1_25ck111 FIND v(dout1_25) AT=560.025n

* CHECK dout1_26 Vdout1_26ck111 = 0 time = 560
.meas tran vdout1_26ck111 FIND v(dout1_26) AT=560.025n

* CHECK dout1_27 Vdout1_27ck111 = 0 time = 560
.meas tran vdout1_27ck111 FIND v(dout1_27) AT=560.025n

* CHECK dout1_28 Vdout1_28ck111 = 0.9 time = 560
.meas tran vdout1_28ck111 FIND v(dout1_28) AT=560.025n

* CHECK dout1_29 Vdout1_29ck111 = 0 time = 560
.meas tran vdout1_29ck111 FIND v(dout1_29) AT=560.025n

* CHECK dout1_30 Vdout1_30ck111 = 0 time = 560
.meas tran vdout1_30ck111 FIND v(dout1_30) AT=560.025n

* CHECK dout1_31 Vdout1_31ck111 = 0 time = 560
.meas tran vdout1_31ck111 FIND v(dout1_31) AT=560.025n

* CHECK dout1_32 Vdout1_32ck111 = 0.9 time = 560
.meas tran vdout1_32ck111 FIND v(dout1_32) AT=560.025n

* CHECK dout1_33 Vdout1_33ck111 = 0.9 time = 560
.meas tran vdout1_33ck111 FIND v(dout1_33) AT=560.025n

* CHECK dout1_34 Vdout1_34ck111 = 0 time = 560
.meas tran vdout1_34ck111 FIND v(dout1_34) AT=560.025n

* CHECK dout1_35 Vdout1_35ck111 = 0.9 time = 560
.meas tran vdout1_35ck111 FIND v(dout1_35) AT=560.025n

* CHECK dout1_36 Vdout1_36ck111 = 0.9 time = 560
.meas tran vdout1_36ck111 FIND v(dout1_36) AT=560.025n

* CHECK dout1_37 Vdout1_37ck111 = 0 time = 560
.meas tran vdout1_37ck111 FIND v(dout1_37) AT=560.025n

* CHECK dout1_38 Vdout1_38ck111 = 0 time = 560
.meas tran vdout1_38ck111 FIND v(dout1_38) AT=560.025n

* CHECK dout1_39 Vdout1_39ck111 = 0.9 time = 560
.meas tran vdout1_39ck111 FIND v(dout1_39) AT=560.025n

* CHECK dout1_40 Vdout1_40ck111 = 0 time = 560
.meas tran vdout1_40ck111 FIND v(dout1_40) AT=560.025n

* CHECK dout1_41 Vdout1_41ck111 = 0.9 time = 560
.meas tran vdout1_41ck111 FIND v(dout1_41) AT=560.025n

* CHECK dout1_42 Vdout1_42ck111 = 0.9 time = 560
.meas tran vdout1_42ck111 FIND v(dout1_42) AT=560.025n

* CHECK dout1_43 Vdout1_43ck111 = 0.9 time = 560
.meas tran vdout1_43ck111 FIND v(dout1_43) AT=560.025n

* CHECK dout1_44 Vdout1_44ck111 = 0 time = 560
.meas tran vdout1_44ck111 FIND v(dout1_44) AT=560.025n

* CHECK dout1_45 Vdout1_45ck111 = 0 time = 560
.meas tran vdout1_45ck111 FIND v(dout1_45) AT=560.025n

* CHECK dout1_46 Vdout1_46ck111 = 0 time = 560
.meas tran vdout1_46ck111 FIND v(dout1_46) AT=560.025n

* CHECK dout1_47 Vdout1_47ck111 = 0 time = 560
.meas tran vdout1_47ck111 FIND v(dout1_47) AT=560.025n

* CHECK dout1_48 Vdout1_48ck111 = 0.9 time = 560
.meas tran vdout1_48ck111 FIND v(dout1_48) AT=560.025n

* CHECK dout1_49 Vdout1_49ck111 = 0.9 time = 560
.meas tran vdout1_49ck111 FIND v(dout1_49) AT=560.025n

* CHECK dout1_50 Vdout1_50ck111 = 0.9 time = 560
.meas tran vdout1_50ck111 FIND v(dout1_50) AT=560.025n

* CHECK dout1_51 Vdout1_51ck111 = 0.9 time = 560
.meas tran vdout1_51ck111 FIND v(dout1_51) AT=560.025n

* CHECK dout1_52 Vdout1_52ck111 = 0.9 time = 560
.meas tran vdout1_52ck111 FIND v(dout1_52) AT=560.025n

* CHECK dout1_53 Vdout1_53ck111 = 0 time = 560
.meas tran vdout1_53ck111 FIND v(dout1_53) AT=560.025n

* CHECK dout1_54 Vdout1_54ck111 = 0.9 time = 560
.meas tran vdout1_54ck111 FIND v(dout1_54) AT=560.025n

* CHECK dout1_55 Vdout1_55ck111 = 0.9 time = 560
.meas tran vdout1_55ck111 FIND v(dout1_55) AT=560.025n

* CHECK dout1_56 Vdout1_56ck111 = 0.9 time = 560
.meas tran vdout1_56ck111 FIND v(dout1_56) AT=560.025n

* CHECK dout1_57 Vdout1_57ck111 = 0 time = 560
.meas tran vdout1_57ck111 FIND v(dout1_57) AT=560.025n

* CHECK dout1_58 Vdout1_58ck111 = 0 time = 560
.meas tran vdout1_58ck111 FIND v(dout1_58) AT=560.025n

* CHECK dout1_59 Vdout1_59ck111 = 0 time = 560
.meas tran vdout1_59ck111 FIND v(dout1_59) AT=560.025n

* CHECK dout1_60 Vdout1_60ck111 = 0.9 time = 560
.meas tran vdout1_60ck111 FIND v(dout1_60) AT=560.025n

* CHECK dout1_61 Vdout1_61ck111 = 0.9 time = 560
.meas tran vdout1_61ck111 FIND v(dout1_61) AT=560.025n

* CHECK dout1_62 Vdout1_62ck111 = 0 time = 560
.meas tran vdout1_62ck111 FIND v(dout1_62) AT=560.025n

* CHECK dout1_63 Vdout1_63ck111 = 0.9 time = 560
.meas tran vdout1_63ck111 FIND v(dout1_63) AT=560.025n

* CHECK dout1_64 Vdout1_64ck111 = 0.9 time = 560
.meas tran vdout1_64ck111 FIND v(dout1_64) AT=560.025n

* CHECK dout1_65 Vdout1_65ck111 = 0 time = 560
.meas tran vdout1_65ck111 FIND v(dout1_65) AT=560.025n

* CHECK dout1_66 Vdout1_66ck111 = 0 time = 560
.meas tran vdout1_66ck111 FIND v(dout1_66) AT=560.025n

* CHECK dout1_67 Vdout1_67ck111 = 0.9 time = 560
.meas tran vdout1_67ck111 FIND v(dout1_67) AT=560.025n

* CHECK dout1_68 Vdout1_68ck111 = 0 time = 560
.meas tran vdout1_68ck111 FIND v(dout1_68) AT=560.025n

* CHECK dout1_69 Vdout1_69ck111 = 0.9 time = 560
.meas tran vdout1_69ck111 FIND v(dout1_69) AT=560.025n

* CHECK dout1_70 Vdout1_70ck111 = 0 time = 560
.meas tran vdout1_70ck111 FIND v(dout1_70) AT=560.025n

* CHECK dout1_71 Vdout1_71ck111 = 0.9 time = 560
.meas tran vdout1_71ck111 FIND v(dout1_71) AT=560.025n

* CHECK dout1_0 Vdout1_0ck112 = 0.9 time = 565
.meas tran vdout1_0ck112 FIND v(dout1_0) AT=565.025n

* CHECK dout1_1 Vdout1_1ck112 = 0.9 time = 565
.meas tran vdout1_1ck112 FIND v(dout1_1) AT=565.025n

* CHECK dout1_2 Vdout1_2ck112 = 0.9 time = 565
.meas tran vdout1_2ck112 FIND v(dout1_2) AT=565.025n

* CHECK dout1_3 Vdout1_3ck112 = 0.9 time = 565
.meas tran vdout1_3ck112 FIND v(dout1_3) AT=565.025n

* CHECK dout1_4 Vdout1_4ck112 = 0 time = 565
.meas tran vdout1_4ck112 FIND v(dout1_4) AT=565.025n

* CHECK dout1_5 Vdout1_5ck112 = 0 time = 565
.meas tran vdout1_5ck112 FIND v(dout1_5) AT=565.025n

* CHECK dout1_6 Vdout1_6ck112 = 0.9 time = 565
.meas tran vdout1_6ck112 FIND v(dout1_6) AT=565.025n

* CHECK dout1_7 Vdout1_7ck112 = 0.9 time = 565
.meas tran vdout1_7ck112 FIND v(dout1_7) AT=565.025n

* CHECK dout1_8 Vdout1_8ck112 = 0.9 time = 565
.meas tran vdout1_8ck112 FIND v(dout1_8) AT=565.025n

* CHECK dout1_9 Vdout1_9ck112 = 0 time = 565
.meas tran vdout1_9ck112 FIND v(dout1_9) AT=565.025n

* CHECK dout1_10 Vdout1_10ck112 = 0.9 time = 565
.meas tran vdout1_10ck112 FIND v(dout1_10) AT=565.025n

* CHECK dout1_11 Vdout1_11ck112 = 0 time = 565
.meas tran vdout1_11ck112 FIND v(dout1_11) AT=565.025n

* CHECK dout1_12 Vdout1_12ck112 = 0.9 time = 565
.meas tran vdout1_12ck112 FIND v(dout1_12) AT=565.025n

* CHECK dout1_13 Vdout1_13ck112 = 0 time = 565
.meas tran vdout1_13ck112 FIND v(dout1_13) AT=565.025n

* CHECK dout1_14 Vdout1_14ck112 = 0.9 time = 565
.meas tran vdout1_14ck112 FIND v(dout1_14) AT=565.025n

* CHECK dout1_15 Vdout1_15ck112 = 0.9 time = 565
.meas tran vdout1_15ck112 FIND v(dout1_15) AT=565.025n

* CHECK dout1_16 Vdout1_16ck112 = 0.9 time = 565
.meas tran vdout1_16ck112 FIND v(dout1_16) AT=565.025n

* CHECK dout1_17 Vdout1_17ck112 = 0.9 time = 565
.meas tran vdout1_17ck112 FIND v(dout1_17) AT=565.025n

* CHECK dout1_18 Vdout1_18ck112 = 0 time = 565
.meas tran vdout1_18ck112 FIND v(dout1_18) AT=565.025n

* CHECK dout1_19 Vdout1_19ck112 = 0.9 time = 565
.meas tran vdout1_19ck112 FIND v(dout1_19) AT=565.025n

* CHECK dout1_20 Vdout1_20ck112 = 0.9 time = 565
.meas tran vdout1_20ck112 FIND v(dout1_20) AT=565.025n

* CHECK dout1_21 Vdout1_21ck112 = 0 time = 565
.meas tran vdout1_21ck112 FIND v(dout1_21) AT=565.025n

* CHECK dout1_22 Vdout1_22ck112 = 0.9 time = 565
.meas tran vdout1_22ck112 FIND v(dout1_22) AT=565.025n

* CHECK dout1_23 Vdout1_23ck112 = 0 time = 565
.meas tran vdout1_23ck112 FIND v(dout1_23) AT=565.025n

* CHECK dout1_24 Vdout1_24ck112 = 0 time = 565
.meas tran vdout1_24ck112 FIND v(dout1_24) AT=565.025n

* CHECK dout1_25 Vdout1_25ck112 = 0 time = 565
.meas tran vdout1_25ck112 FIND v(dout1_25) AT=565.025n

* CHECK dout1_26 Vdout1_26ck112 = 0.9 time = 565
.meas tran vdout1_26ck112 FIND v(dout1_26) AT=565.025n

* CHECK dout1_27 Vdout1_27ck112 = 0 time = 565
.meas tran vdout1_27ck112 FIND v(dout1_27) AT=565.025n

* CHECK dout1_28 Vdout1_28ck112 = 0 time = 565
.meas tran vdout1_28ck112 FIND v(dout1_28) AT=565.025n

* CHECK dout1_29 Vdout1_29ck112 = 0 time = 565
.meas tran vdout1_29ck112 FIND v(dout1_29) AT=565.025n

* CHECK dout1_30 Vdout1_30ck112 = 0.9 time = 565
.meas tran vdout1_30ck112 FIND v(dout1_30) AT=565.025n

* CHECK dout1_31 Vdout1_31ck112 = 0 time = 565
.meas tran vdout1_31ck112 FIND v(dout1_31) AT=565.025n

* CHECK dout1_32 Vdout1_32ck112 = 0.9 time = 565
.meas tran vdout1_32ck112 FIND v(dout1_32) AT=565.025n

* CHECK dout1_33 Vdout1_33ck112 = 0 time = 565
.meas tran vdout1_33ck112 FIND v(dout1_33) AT=565.025n

* CHECK dout1_34 Vdout1_34ck112 = 0 time = 565
.meas tran vdout1_34ck112 FIND v(dout1_34) AT=565.025n

* CHECK dout1_35 Vdout1_35ck112 = 0.9 time = 565
.meas tran vdout1_35ck112 FIND v(dout1_35) AT=565.025n

* CHECK dout1_36 Vdout1_36ck112 = 0.9 time = 565
.meas tran vdout1_36ck112 FIND v(dout1_36) AT=565.025n

* CHECK dout1_37 Vdout1_37ck112 = 0.9 time = 565
.meas tran vdout1_37ck112 FIND v(dout1_37) AT=565.025n

* CHECK dout1_38 Vdout1_38ck112 = 0.9 time = 565
.meas tran vdout1_38ck112 FIND v(dout1_38) AT=565.025n

* CHECK dout1_39 Vdout1_39ck112 = 0 time = 565
.meas tran vdout1_39ck112 FIND v(dout1_39) AT=565.025n

* CHECK dout1_40 Vdout1_40ck112 = 0.9 time = 565
.meas tran vdout1_40ck112 FIND v(dout1_40) AT=565.025n

* CHECK dout1_41 Vdout1_41ck112 = 0.9 time = 565
.meas tran vdout1_41ck112 FIND v(dout1_41) AT=565.025n

* CHECK dout1_42 Vdout1_42ck112 = 0 time = 565
.meas tran vdout1_42ck112 FIND v(dout1_42) AT=565.025n

* CHECK dout1_43 Vdout1_43ck112 = 0 time = 565
.meas tran vdout1_43ck112 FIND v(dout1_43) AT=565.025n

* CHECK dout1_44 Vdout1_44ck112 = 0.9 time = 565
.meas tran vdout1_44ck112 FIND v(dout1_44) AT=565.025n

* CHECK dout1_45 Vdout1_45ck112 = 0 time = 565
.meas tran vdout1_45ck112 FIND v(dout1_45) AT=565.025n

* CHECK dout1_46 Vdout1_46ck112 = 0.9 time = 565
.meas tran vdout1_46ck112 FIND v(dout1_46) AT=565.025n

* CHECK dout1_47 Vdout1_47ck112 = 0 time = 565
.meas tran vdout1_47ck112 FIND v(dout1_47) AT=565.025n

* CHECK dout1_48 Vdout1_48ck112 = 0.9 time = 565
.meas tran vdout1_48ck112 FIND v(dout1_48) AT=565.025n

* CHECK dout1_49 Vdout1_49ck112 = 0.9 time = 565
.meas tran vdout1_49ck112 FIND v(dout1_49) AT=565.025n

* CHECK dout1_50 Vdout1_50ck112 = 0.9 time = 565
.meas tran vdout1_50ck112 FIND v(dout1_50) AT=565.025n

* CHECK dout1_51 Vdout1_51ck112 = 0 time = 565
.meas tran vdout1_51ck112 FIND v(dout1_51) AT=565.025n

* CHECK dout1_52 Vdout1_52ck112 = 0 time = 565
.meas tran vdout1_52ck112 FIND v(dout1_52) AT=565.025n

* CHECK dout1_53 Vdout1_53ck112 = 0 time = 565
.meas tran vdout1_53ck112 FIND v(dout1_53) AT=565.025n

* CHECK dout1_54 Vdout1_54ck112 = 0 time = 565
.meas tran vdout1_54ck112 FIND v(dout1_54) AT=565.025n

* CHECK dout1_55 Vdout1_55ck112 = 0 time = 565
.meas tran vdout1_55ck112 FIND v(dout1_55) AT=565.025n

* CHECK dout1_56 Vdout1_56ck112 = 0.9 time = 565
.meas tran vdout1_56ck112 FIND v(dout1_56) AT=565.025n

* CHECK dout1_57 Vdout1_57ck112 = 0.9 time = 565
.meas tran vdout1_57ck112 FIND v(dout1_57) AT=565.025n

* CHECK dout1_58 Vdout1_58ck112 = 0 time = 565
.meas tran vdout1_58ck112 FIND v(dout1_58) AT=565.025n

* CHECK dout1_59 Vdout1_59ck112 = 0.9 time = 565
.meas tran vdout1_59ck112 FIND v(dout1_59) AT=565.025n

* CHECK dout1_60 Vdout1_60ck112 = 0 time = 565
.meas tran vdout1_60ck112 FIND v(dout1_60) AT=565.025n

* CHECK dout1_61 Vdout1_61ck112 = 0 time = 565
.meas tran vdout1_61ck112 FIND v(dout1_61) AT=565.025n

* CHECK dout1_62 Vdout1_62ck112 = 0 time = 565
.meas tran vdout1_62ck112 FIND v(dout1_62) AT=565.025n

* CHECK dout1_63 Vdout1_63ck112 = 0.9 time = 565
.meas tran vdout1_63ck112 FIND v(dout1_63) AT=565.025n

* CHECK dout1_64 Vdout1_64ck112 = 0 time = 565
.meas tran vdout1_64ck112 FIND v(dout1_64) AT=565.025n

* CHECK dout1_65 Vdout1_65ck112 = 0 time = 565
.meas tran vdout1_65ck112 FIND v(dout1_65) AT=565.025n

* CHECK dout1_66 Vdout1_66ck112 = 0 time = 565
.meas tran vdout1_66ck112 FIND v(dout1_66) AT=565.025n

* CHECK dout1_67 Vdout1_67ck112 = 0.9 time = 565
.meas tran vdout1_67ck112 FIND v(dout1_67) AT=565.025n

* CHECK dout1_68 Vdout1_68ck112 = 0 time = 565
.meas tran vdout1_68ck112 FIND v(dout1_68) AT=565.025n

* CHECK dout1_69 Vdout1_69ck112 = 0.9 time = 565
.meas tran vdout1_69ck112 FIND v(dout1_69) AT=565.025n

* CHECK dout1_70 Vdout1_70ck112 = 0 time = 565
.meas tran vdout1_70ck112 FIND v(dout1_70) AT=565.025n

* CHECK dout1_71 Vdout1_71ck112 = 0 time = 565
.meas tran vdout1_71ck112 FIND v(dout1_71) AT=565.025n

* CHECK dout1_0 Vdout1_0ck114 = 0 time = 575
.meas tran vdout1_0ck114 FIND v(dout1_0) AT=575.025n

* CHECK dout1_1 Vdout1_1ck114 = 0.9 time = 575
.meas tran vdout1_1ck114 FIND v(dout1_1) AT=575.025n

* CHECK dout1_2 Vdout1_2ck114 = 0.9 time = 575
.meas tran vdout1_2ck114 FIND v(dout1_2) AT=575.025n

* CHECK dout1_3 Vdout1_3ck114 = 0 time = 575
.meas tran vdout1_3ck114 FIND v(dout1_3) AT=575.025n

* CHECK dout1_4 Vdout1_4ck114 = 0.9 time = 575
.meas tran vdout1_4ck114 FIND v(dout1_4) AT=575.025n

* CHECK dout1_5 Vdout1_5ck114 = 0.9 time = 575
.meas tran vdout1_5ck114 FIND v(dout1_5) AT=575.025n

* CHECK dout1_6 Vdout1_6ck114 = 0 time = 575
.meas tran vdout1_6ck114 FIND v(dout1_6) AT=575.025n

* CHECK dout1_7 Vdout1_7ck114 = 0.9 time = 575
.meas tran vdout1_7ck114 FIND v(dout1_7) AT=575.025n

* CHECK dout1_8 Vdout1_8ck114 = 0.9 time = 575
.meas tran vdout1_8ck114 FIND v(dout1_8) AT=575.025n

* CHECK dout1_9 Vdout1_9ck114 = 0.9 time = 575
.meas tran vdout1_9ck114 FIND v(dout1_9) AT=575.025n

* CHECK dout1_10 Vdout1_10ck114 = 0 time = 575
.meas tran vdout1_10ck114 FIND v(dout1_10) AT=575.025n

* CHECK dout1_11 Vdout1_11ck114 = 0.9 time = 575
.meas tran vdout1_11ck114 FIND v(dout1_11) AT=575.025n

* CHECK dout1_12 Vdout1_12ck114 = 0 time = 575
.meas tran vdout1_12ck114 FIND v(dout1_12) AT=575.025n

* CHECK dout1_13 Vdout1_13ck114 = 0.9 time = 575
.meas tran vdout1_13ck114 FIND v(dout1_13) AT=575.025n

* CHECK dout1_14 Vdout1_14ck114 = 0 time = 575
.meas tran vdout1_14ck114 FIND v(dout1_14) AT=575.025n

* CHECK dout1_15 Vdout1_15ck114 = 0.9 time = 575
.meas tran vdout1_15ck114 FIND v(dout1_15) AT=575.025n

* CHECK dout1_16 Vdout1_16ck114 = 0 time = 575
.meas tran vdout1_16ck114 FIND v(dout1_16) AT=575.025n

* CHECK dout1_17 Vdout1_17ck114 = 0 time = 575
.meas tran vdout1_17ck114 FIND v(dout1_17) AT=575.025n

* CHECK dout1_18 Vdout1_18ck114 = 0.9 time = 575
.meas tran vdout1_18ck114 FIND v(dout1_18) AT=575.025n

* CHECK dout1_19 Vdout1_19ck114 = 0.9 time = 575
.meas tran vdout1_19ck114 FIND v(dout1_19) AT=575.025n

* CHECK dout1_20 Vdout1_20ck114 = 0.9 time = 575
.meas tran vdout1_20ck114 FIND v(dout1_20) AT=575.025n

* CHECK dout1_21 Vdout1_21ck114 = 0 time = 575
.meas tran vdout1_21ck114 FIND v(dout1_21) AT=575.025n

* CHECK dout1_22 Vdout1_22ck114 = 0.9 time = 575
.meas tran vdout1_22ck114 FIND v(dout1_22) AT=575.025n

* CHECK dout1_23 Vdout1_23ck114 = 0 time = 575
.meas tran vdout1_23ck114 FIND v(dout1_23) AT=575.025n

* CHECK dout1_24 Vdout1_24ck114 = 0 time = 575
.meas tran vdout1_24ck114 FIND v(dout1_24) AT=575.025n

* CHECK dout1_25 Vdout1_25ck114 = 0.9 time = 575
.meas tran vdout1_25ck114 FIND v(dout1_25) AT=575.025n

* CHECK dout1_26 Vdout1_26ck114 = 0 time = 575
.meas tran vdout1_26ck114 FIND v(dout1_26) AT=575.025n

* CHECK dout1_27 Vdout1_27ck114 = 0 time = 575
.meas tran vdout1_27ck114 FIND v(dout1_27) AT=575.025n

* CHECK dout1_28 Vdout1_28ck114 = 0.9 time = 575
.meas tran vdout1_28ck114 FIND v(dout1_28) AT=575.025n

* CHECK dout1_29 Vdout1_29ck114 = 0 time = 575
.meas tran vdout1_29ck114 FIND v(dout1_29) AT=575.025n

* CHECK dout1_30 Vdout1_30ck114 = 0 time = 575
.meas tran vdout1_30ck114 FIND v(dout1_30) AT=575.025n

* CHECK dout1_31 Vdout1_31ck114 = 0 time = 575
.meas tran vdout1_31ck114 FIND v(dout1_31) AT=575.025n

* CHECK dout1_32 Vdout1_32ck114 = 0.9 time = 575
.meas tran vdout1_32ck114 FIND v(dout1_32) AT=575.025n

* CHECK dout1_33 Vdout1_33ck114 = 0.9 time = 575
.meas tran vdout1_33ck114 FIND v(dout1_33) AT=575.025n

* CHECK dout1_34 Vdout1_34ck114 = 0 time = 575
.meas tran vdout1_34ck114 FIND v(dout1_34) AT=575.025n

* CHECK dout1_35 Vdout1_35ck114 = 0.9 time = 575
.meas tran vdout1_35ck114 FIND v(dout1_35) AT=575.025n

* CHECK dout1_36 Vdout1_36ck114 = 0.9 time = 575
.meas tran vdout1_36ck114 FIND v(dout1_36) AT=575.025n

* CHECK dout1_37 Vdout1_37ck114 = 0 time = 575
.meas tran vdout1_37ck114 FIND v(dout1_37) AT=575.025n

* CHECK dout1_38 Vdout1_38ck114 = 0 time = 575
.meas tran vdout1_38ck114 FIND v(dout1_38) AT=575.025n

* CHECK dout1_39 Vdout1_39ck114 = 0.9 time = 575
.meas tran vdout1_39ck114 FIND v(dout1_39) AT=575.025n

* CHECK dout1_40 Vdout1_40ck114 = 0 time = 575
.meas tran vdout1_40ck114 FIND v(dout1_40) AT=575.025n

* CHECK dout1_41 Vdout1_41ck114 = 0.9 time = 575
.meas tran vdout1_41ck114 FIND v(dout1_41) AT=575.025n

* CHECK dout1_42 Vdout1_42ck114 = 0.9 time = 575
.meas tran vdout1_42ck114 FIND v(dout1_42) AT=575.025n

* CHECK dout1_43 Vdout1_43ck114 = 0.9 time = 575
.meas tran vdout1_43ck114 FIND v(dout1_43) AT=575.025n

* CHECK dout1_44 Vdout1_44ck114 = 0 time = 575
.meas tran vdout1_44ck114 FIND v(dout1_44) AT=575.025n

* CHECK dout1_45 Vdout1_45ck114 = 0 time = 575
.meas tran vdout1_45ck114 FIND v(dout1_45) AT=575.025n

* CHECK dout1_46 Vdout1_46ck114 = 0 time = 575
.meas tran vdout1_46ck114 FIND v(dout1_46) AT=575.025n

* CHECK dout1_47 Vdout1_47ck114 = 0 time = 575
.meas tran vdout1_47ck114 FIND v(dout1_47) AT=575.025n

* CHECK dout1_48 Vdout1_48ck114 = 0.9 time = 575
.meas tran vdout1_48ck114 FIND v(dout1_48) AT=575.025n

* CHECK dout1_49 Vdout1_49ck114 = 0.9 time = 575
.meas tran vdout1_49ck114 FIND v(dout1_49) AT=575.025n

* CHECK dout1_50 Vdout1_50ck114 = 0.9 time = 575
.meas tran vdout1_50ck114 FIND v(dout1_50) AT=575.025n

* CHECK dout1_51 Vdout1_51ck114 = 0.9 time = 575
.meas tran vdout1_51ck114 FIND v(dout1_51) AT=575.025n

* CHECK dout1_52 Vdout1_52ck114 = 0.9 time = 575
.meas tran vdout1_52ck114 FIND v(dout1_52) AT=575.025n

* CHECK dout1_53 Vdout1_53ck114 = 0 time = 575
.meas tran vdout1_53ck114 FIND v(dout1_53) AT=575.025n

* CHECK dout1_54 Vdout1_54ck114 = 0.9 time = 575
.meas tran vdout1_54ck114 FIND v(dout1_54) AT=575.025n

* CHECK dout1_55 Vdout1_55ck114 = 0.9 time = 575
.meas tran vdout1_55ck114 FIND v(dout1_55) AT=575.025n

* CHECK dout1_56 Vdout1_56ck114 = 0.9 time = 575
.meas tran vdout1_56ck114 FIND v(dout1_56) AT=575.025n

* CHECK dout1_57 Vdout1_57ck114 = 0 time = 575
.meas tran vdout1_57ck114 FIND v(dout1_57) AT=575.025n

* CHECK dout1_58 Vdout1_58ck114 = 0 time = 575
.meas tran vdout1_58ck114 FIND v(dout1_58) AT=575.025n

* CHECK dout1_59 Vdout1_59ck114 = 0 time = 575
.meas tran vdout1_59ck114 FIND v(dout1_59) AT=575.025n

* CHECK dout1_60 Vdout1_60ck114 = 0.9 time = 575
.meas tran vdout1_60ck114 FIND v(dout1_60) AT=575.025n

* CHECK dout1_61 Vdout1_61ck114 = 0.9 time = 575
.meas tran vdout1_61ck114 FIND v(dout1_61) AT=575.025n

* CHECK dout1_62 Vdout1_62ck114 = 0 time = 575
.meas tran vdout1_62ck114 FIND v(dout1_62) AT=575.025n

* CHECK dout1_63 Vdout1_63ck114 = 0.9 time = 575
.meas tran vdout1_63ck114 FIND v(dout1_63) AT=575.025n

* CHECK dout1_64 Vdout1_64ck114 = 0.9 time = 575
.meas tran vdout1_64ck114 FIND v(dout1_64) AT=575.025n

* CHECK dout1_65 Vdout1_65ck114 = 0 time = 575
.meas tran vdout1_65ck114 FIND v(dout1_65) AT=575.025n

* CHECK dout1_66 Vdout1_66ck114 = 0 time = 575
.meas tran vdout1_66ck114 FIND v(dout1_66) AT=575.025n

* CHECK dout1_67 Vdout1_67ck114 = 0.9 time = 575
.meas tran vdout1_67ck114 FIND v(dout1_67) AT=575.025n

* CHECK dout1_68 Vdout1_68ck114 = 0 time = 575
.meas tran vdout1_68ck114 FIND v(dout1_68) AT=575.025n

* CHECK dout1_69 Vdout1_69ck114 = 0.9 time = 575
.meas tran vdout1_69ck114 FIND v(dout1_69) AT=575.025n

* CHECK dout1_70 Vdout1_70ck114 = 0 time = 575
.meas tran vdout1_70ck114 FIND v(dout1_70) AT=575.025n

* CHECK dout1_71 Vdout1_71ck114 = 0.9 time = 575
.meas tran vdout1_71ck114 FIND v(dout1_71) AT=575.025n

* CHECK dout1_0 Vdout1_0ck119 = 0 time = 600
.meas tran vdout1_0ck119 FIND v(dout1_0) AT=600.025n

* CHECK dout1_1 Vdout1_1ck119 = 0.9 time = 600
.meas tran vdout1_1ck119 FIND v(dout1_1) AT=600.025n

* CHECK dout1_2 Vdout1_2ck119 = 0.9 time = 600
.meas tran vdout1_2ck119 FIND v(dout1_2) AT=600.025n

* CHECK dout1_3 Vdout1_3ck119 = 0 time = 600
.meas tran vdout1_3ck119 FIND v(dout1_3) AT=600.025n

* CHECK dout1_4 Vdout1_4ck119 = 0.9 time = 600
.meas tran vdout1_4ck119 FIND v(dout1_4) AT=600.025n

* CHECK dout1_5 Vdout1_5ck119 = 0.9 time = 600
.meas tran vdout1_5ck119 FIND v(dout1_5) AT=600.025n

* CHECK dout1_6 Vdout1_6ck119 = 0 time = 600
.meas tran vdout1_6ck119 FIND v(dout1_6) AT=600.025n

* CHECK dout1_7 Vdout1_7ck119 = 0.9 time = 600
.meas tran vdout1_7ck119 FIND v(dout1_7) AT=600.025n

* CHECK dout1_8 Vdout1_8ck119 = 0.9 time = 600
.meas tran vdout1_8ck119 FIND v(dout1_8) AT=600.025n

* CHECK dout1_9 Vdout1_9ck119 = 0.9 time = 600
.meas tran vdout1_9ck119 FIND v(dout1_9) AT=600.025n

* CHECK dout1_10 Vdout1_10ck119 = 0 time = 600
.meas tran vdout1_10ck119 FIND v(dout1_10) AT=600.025n

* CHECK dout1_11 Vdout1_11ck119 = 0.9 time = 600
.meas tran vdout1_11ck119 FIND v(dout1_11) AT=600.025n

* CHECK dout1_12 Vdout1_12ck119 = 0 time = 600
.meas tran vdout1_12ck119 FIND v(dout1_12) AT=600.025n

* CHECK dout1_13 Vdout1_13ck119 = 0.9 time = 600
.meas tran vdout1_13ck119 FIND v(dout1_13) AT=600.025n

* CHECK dout1_14 Vdout1_14ck119 = 0 time = 600
.meas tran vdout1_14ck119 FIND v(dout1_14) AT=600.025n

* CHECK dout1_15 Vdout1_15ck119 = 0.9 time = 600
.meas tran vdout1_15ck119 FIND v(dout1_15) AT=600.025n

* CHECK dout1_16 Vdout1_16ck119 = 0 time = 600
.meas tran vdout1_16ck119 FIND v(dout1_16) AT=600.025n

* CHECK dout1_17 Vdout1_17ck119 = 0 time = 600
.meas tran vdout1_17ck119 FIND v(dout1_17) AT=600.025n

* CHECK dout1_18 Vdout1_18ck119 = 0.9 time = 600
.meas tran vdout1_18ck119 FIND v(dout1_18) AT=600.025n

* CHECK dout1_19 Vdout1_19ck119 = 0.9 time = 600
.meas tran vdout1_19ck119 FIND v(dout1_19) AT=600.025n

* CHECK dout1_20 Vdout1_20ck119 = 0.9 time = 600
.meas tran vdout1_20ck119 FIND v(dout1_20) AT=600.025n

* CHECK dout1_21 Vdout1_21ck119 = 0 time = 600
.meas tran vdout1_21ck119 FIND v(dout1_21) AT=600.025n

* CHECK dout1_22 Vdout1_22ck119 = 0.9 time = 600
.meas tran vdout1_22ck119 FIND v(dout1_22) AT=600.025n

* CHECK dout1_23 Vdout1_23ck119 = 0 time = 600
.meas tran vdout1_23ck119 FIND v(dout1_23) AT=600.025n

* CHECK dout1_24 Vdout1_24ck119 = 0 time = 600
.meas tran vdout1_24ck119 FIND v(dout1_24) AT=600.025n

* CHECK dout1_25 Vdout1_25ck119 = 0.9 time = 600
.meas tran vdout1_25ck119 FIND v(dout1_25) AT=600.025n

* CHECK dout1_26 Vdout1_26ck119 = 0 time = 600
.meas tran vdout1_26ck119 FIND v(dout1_26) AT=600.025n

* CHECK dout1_27 Vdout1_27ck119 = 0 time = 600
.meas tran vdout1_27ck119 FIND v(dout1_27) AT=600.025n

* CHECK dout1_28 Vdout1_28ck119 = 0.9 time = 600
.meas tran vdout1_28ck119 FIND v(dout1_28) AT=600.025n

* CHECK dout1_29 Vdout1_29ck119 = 0 time = 600
.meas tran vdout1_29ck119 FIND v(dout1_29) AT=600.025n

* CHECK dout1_30 Vdout1_30ck119 = 0 time = 600
.meas tran vdout1_30ck119 FIND v(dout1_30) AT=600.025n

* CHECK dout1_31 Vdout1_31ck119 = 0 time = 600
.meas tran vdout1_31ck119 FIND v(dout1_31) AT=600.025n

* CHECK dout1_32 Vdout1_32ck119 = 0.9 time = 600
.meas tran vdout1_32ck119 FIND v(dout1_32) AT=600.025n

* CHECK dout1_33 Vdout1_33ck119 = 0.9 time = 600
.meas tran vdout1_33ck119 FIND v(dout1_33) AT=600.025n

* CHECK dout1_34 Vdout1_34ck119 = 0 time = 600
.meas tran vdout1_34ck119 FIND v(dout1_34) AT=600.025n

* CHECK dout1_35 Vdout1_35ck119 = 0.9 time = 600
.meas tran vdout1_35ck119 FIND v(dout1_35) AT=600.025n

* CHECK dout1_36 Vdout1_36ck119 = 0.9 time = 600
.meas tran vdout1_36ck119 FIND v(dout1_36) AT=600.025n

* CHECK dout1_37 Vdout1_37ck119 = 0 time = 600
.meas tran vdout1_37ck119 FIND v(dout1_37) AT=600.025n

* CHECK dout1_38 Vdout1_38ck119 = 0 time = 600
.meas tran vdout1_38ck119 FIND v(dout1_38) AT=600.025n

* CHECK dout1_39 Vdout1_39ck119 = 0.9 time = 600
.meas tran vdout1_39ck119 FIND v(dout1_39) AT=600.025n

* CHECK dout1_40 Vdout1_40ck119 = 0 time = 600
.meas tran vdout1_40ck119 FIND v(dout1_40) AT=600.025n

* CHECK dout1_41 Vdout1_41ck119 = 0.9 time = 600
.meas tran vdout1_41ck119 FIND v(dout1_41) AT=600.025n

* CHECK dout1_42 Vdout1_42ck119 = 0.9 time = 600
.meas tran vdout1_42ck119 FIND v(dout1_42) AT=600.025n

* CHECK dout1_43 Vdout1_43ck119 = 0.9 time = 600
.meas tran vdout1_43ck119 FIND v(dout1_43) AT=600.025n

* CHECK dout1_44 Vdout1_44ck119 = 0 time = 600
.meas tran vdout1_44ck119 FIND v(dout1_44) AT=600.025n

* CHECK dout1_45 Vdout1_45ck119 = 0 time = 600
.meas tran vdout1_45ck119 FIND v(dout1_45) AT=600.025n

* CHECK dout1_46 Vdout1_46ck119 = 0 time = 600
.meas tran vdout1_46ck119 FIND v(dout1_46) AT=600.025n

* CHECK dout1_47 Vdout1_47ck119 = 0 time = 600
.meas tran vdout1_47ck119 FIND v(dout1_47) AT=600.025n

* CHECK dout1_48 Vdout1_48ck119 = 0.9 time = 600
.meas tran vdout1_48ck119 FIND v(dout1_48) AT=600.025n

* CHECK dout1_49 Vdout1_49ck119 = 0.9 time = 600
.meas tran vdout1_49ck119 FIND v(dout1_49) AT=600.025n

* CHECK dout1_50 Vdout1_50ck119 = 0.9 time = 600
.meas tran vdout1_50ck119 FIND v(dout1_50) AT=600.025n

* CHECK dout1_51 Vdout1_51ck119 = 0.9 time = 600
.meas tran vdout1_51ck119 FIND v(dout1_51) AT=600.025n

* CHECK dout1_52 Vdout1_52ck119 = 0.9 time = 600
.meas tran vdout1_52ck119 FIND v(dout1_52) AT=600.025n

* CHECK dout1_53 Vdout1_53ck119 = 0 time = 600
.meas tran vdout1_53ck119 FIND v(dout1_53) AT=600.025n

* CHECK dout1_54 Vdout1_54ck119 = 0.9 time = 600
.meas tran vdout1_54ck119 FIND v(dout1_54) AT=600.025n

* CHECK dout1_55 Vdout1_55ck119 = 0.9 time = 600
.meas tran vdout1_55ck119 FIND v(dout1_55) AT=600.025n

* CHECK dout1_56 Vdout1_56ck119 = 0.9 time = 600
.meas tran vdout1_56ck119 FIND v(dout1_56) AT=600.025n

* CHECK dout1_57 Vdout1_57ck119 = 0 time = 600
.meas tran vdout1_57ck119 FIND v(dout1_57) AT=600.025n

* CHECK dout1_58 Vdout1_58ck119 = 0 time = 600
.meas tran vdout1_58ck119 FIND v(dout1_58) AT=600.025n

* CHECK dout1_59 Vdout1_59ck119 = 0 time = 600
.meas tran vdout1_59ck119 FIND v(dout1_59) AT=600.025n

* CHECK dout1_60 Vdout1_60ck119 = 0.9 time = 600
.meas tran vdout1_60ck119 FIND v(dout1_60) AT=600.025n

* CHECK dout1_61 Vdout1_61ck119 = 0.9 time = 600
.meas tran vdout1_61ck119 FIND v(dout1_61) AT=600.025n

* CHECK dout1_62 Vdout1_62ck119 = 0 time = 600
.meas tran vdout1_62ck119 FIND v(dout1_62) AT=600.025n

* CHECK dout1_63 Vdout1_63ck119 = 0.9 time = 600
.meas tran vdout1_63ck119 FIND v(dout1_63) AT=600.025n

* CHECK dout1_64 Vdout1_64ck119 = 0.9 time = 600
.meas tran vdout1_64ck119 FIND v(dout1_64) AT=600.025n

* CHECK dout1_65 Vdout1_65ck119 = 0 time = 600
.meas tran vdout1_65ck119 FIND v(dout1_65) AT=600.025n

* CHECK dout1_66 Vdout1_66ck119 = 0 time = 600
.meas tran vdout1_66ck119 FIND v(dout1_66) AT=600.025n

* CHECK dout1_67 Vdout1_67ck119 = 0.9 time = 600
.meas tran vdout1_67ck119 FIND v(dout1_67) AT=600.025n

* CHECK dout1_68 Vdout1_68ck119 = 0 time = 600
.meas tran vdout1_68ck119 FIND v(dout1_68) AT=600.025n

* CHECK dout1_69 Vdout1_69ck119 = 0.9 time = 600
.meas tran vdout1_69ck119 FIND v(dout1_69) AT=600.025n

* CHECK dout1_70 Vdout1_70ck119 = 0 time = 600
.meas tran vdout1_70ck119 FIND v(dout1_70) AT=600.025n

* CHECK dout1_71 Vdout1_71ck119 = 0.9 time = 600
.meas tran vdout1_71ck119 FIND v(dout1_71) AT=600.025n

* CHECK dout1_0 Vdout1_0ck123 = 0 time = 620
.meas tran vdout1_0ck123 FIND v(dout1_0) AT=620.025n

* CHECK dout1_1 Vdout1_1ck123 = 0 time = 620
.meas tran vdout1_1ck123 FIND v(dout1_1) AT=620.025n

* CHECK dout1_2 Vdout1_2ck123 = 0.9 time = 620
.meas tran vdout1_2ck123 FIND v(dout1_2) AT=620.025n

* CHECK dout1_3 Vdout1_3ck123 = 0 time = 620
.meas tran vdout1_3ck123 FIND v(dout1_3) AT=620.025n

* CHECK dout1_4 Vdout1_4ck123 = 0.9 time = 620
.meas tran vdout1_4ck123 FIND v(dout1_4) AT=620.025n

* CHECK dout1_5 Vdout1_5ck123 = 0 time = 620
.meas tran vdout1_5ck123 FIND v(dout1_5) AT=620.025n

* CHECK dout1_6 Vdout1_6ck123 = 0 time = 620
.meas tran vdout1_6ck123 FIND v(dout1_6) AT=620.025n

* CHECK dout1_7 Vdout1_7ck123 = 0.9 time = 620
.meas tran vdout1_7ck123 FIND v(dout1_7) AT=620.025n

* CHECK dout1_8 Vdout1_8ck123 = 0 time = 620
.meas tran vdout1_8ck123 FIND v(dout1_8) AT=620.025n

* CHECK dout1_9 Vdout1_9ck123 = 0 time = 620
.meas tran vdout1_9ck123 FIND v(dout1_9) AT=620.025n

* CHECK dout1_10 Vdout1_10ck123 = 0 time = 620
.meas tran vdout1_10ck123 FIND v(dout1_10) AT=620.025n

* CHECK dout1_11 Vdout1_11ck123 = 0.9 time = 620
.meas tran vdout1_11ck123 FIND v(dout1_11) AT=620.025n

* CHECK dout1_12 Vdout1_12ck123 = 0.9 time = 620
.meas tran vdout1_12ck123 FIND v(dout1_12) AT=620.025n

* CHECK dout1_13 Vdout1_13ck123 = 0.9 time = 620
.meas tran vdout1_13ck123 FIND v(dout1_13) AT=620.025n

* CHECK dout1_14 Vdout1_14ck123 = 0.9 time = 620
.meas tran vdout1_14ck123 FIND v(dout1_14) AT=620.025n

* CHECK dout1_15 Vdout1_15ck123 = 0.9 time = 620
.meas tran vdout1_15ck123 FIND v(dout1_15) AT=620.025n

* CHECK dout1_16 Vdout1_16ck123 = 0.9 time = 620
.meas tran vdout1_16ck123 FIND v(dout1_16) AT=620.025n

* CHECK dout1_17 Vdout1_17ck123 = 0 time = 620
.meas tran vdout1_17ck123 FIND v(dout1_17) AT=620.025n

* CHECK dout1_18 Vdout1_18ck123 = 0.9 time = 620
.meas tran vdout1_18ck123 FIND v(dout1_18) AT=620.025n

* CHECK dout1_19 Vdout1_19ck123 = 0 time = 620
.meas tran vdout1_19ck123 FIND v(dout1_19) AT=620.025n

* CHECK dout1_20 Vdout1_20ck123 = 0.9 time = 620
.meas tran vdout1_20ck123 FIND v(dout1_20) AT=620.025n

* CHECK dout1_21 Vdout1_21ck123 = 0.9 time = 620
.meas tran vdout1_21ck123 FIND v(dout1_21) AT=620.025n

* CHECK dout1_22 Vdout1_22ck123 = 0.9 time = 620
.meas tran vdout1_22ck123 FIND v(dout1_22) AT=620.025n

* CHECK dout1_23 Vdout1_23ck123 = 0 time = 620
.meas tran vdout1_23ck123 FIND v(dout1_23) AT=620.025n

* CHECK dout1_24 Vdout1_24ck123 = 0 time = 620
.meas tran vdout1_24ck123 FIND v(dout1_24) AT=620.025n

* CHECK dout1_25 Vdout1_25ck123 = 0 time = 620
.meas tran vdout1_25ck123 FIND v(dout1_25) AT=620.025n

* CHECK dout1_26 Vdout1_26ck123 = 0 time = 620
.meas tran vdout1_26ck123 FIND v(dout1_26) AT=620.025n

* CHECK dout1_27 Vdout1_27ck123 = 0.9 time = 620
.meas tran vdout1_27ck123 FIND v(dout1_27) AT=620.025n

* CHECK dout1_28 Vdout1_28ck123 = 0.9 time = 620
.meas tran vdout1_28ck123 FIND v(dout1_28) AT=620.025n

* CHECK dout1_29 Vdout1_29ck123 = 0 time = 620
.meas tran vdout1_29ck123 FIND v(dout1_29) AT=620.025n

* CHECK dout1_30 Vdout1_30ck123 = 0.9 time = 620
.meas tran vdout1_30ck123 FIND v(dout1_30) AT=620.025n

* CHECK dout1_31 Vdout1_31ck123 = 0 time = 620
.meas tran vdout1_31ck123 FIND v(dout1_31) AT=620.025n

* CHECK dout1_32 Vdout1_32ck123 = 0 time = 620
.meas tran vdout1_32ck123 FIND v(dout1_32) AT=620.025n

* CHECK dout1_33 Vdout1_33ck123 = 0.9 time = 620
.meas tran vdout1_33ck123 FIND v(dout1_33) AT=620.025n

* CHECK dout1_34 Vdout1_34ck123 = 0 time = 620
.meas tran vdout1_34ck123 FIND v(dout1_34) AT=620.025n

* CHECK dout1_35 Vdout1_35ck123 = 0.9 time = 620
.meas tran vdout1_35ck123 FIND v(dout1_35) AT=620.025n

* CHECK dout1_36 Vdout1_36ck123 = 0.9 time = 620
.meas tran vdout1_36ck123 FIND v(dout1_36) AT=620.025n

* CHECK dout1_37 Vdout1_37ck123 = 0 time = 620
.meas tran vdout1_37ck123 FIND v(dout1_37) AT=620.025n

* CHECK dout1_38 Vdout1_38ck123 = 0 time = 620
.meas tran vdout1_38ck123 FIND v(dout1_38) AT=620.025n

* CHECK dout1_39 Vdout1_39ck123 = 0 time = 620
.meas tran vdout1_39ck123 FIND v(dout1_39) AT=620.025n

* CHECK dout1_40 Vdout1_40ck123 = 0.9 time = 620
.meas tran vdout1_40ck123 FIND v(dout1_40) AT=620.025n

* CHECK dout1_41 Vdout1_41ck123 = 0 time = 620
.meas tran vdout1_41ck123 FIND v(dout1_41) AT=620.025n

* CHECK dout1_42 Vdout1_42ck123 = 0 time = 620
.meas tran vdout1_42ck123 FIND v(dout1_42) AT=620.025n

* CHECK dout1_43 Vdout1_43ck123 = 0.9 time = 620
.meas tran vdout1_43ck123 FIND v(dout1_43) AT=620.025n

* CHECK dout1_44 Vdout1_44ck123 = 0 time = 620
.meas tran vdout1_44ck123 FIND v(dout1_44) AT=620.025n

* CHECK dout1_45 Vdout1_45ck123 = 0 time = 620
.meas tran vdout1_45ck123 FIND v(dout1_45) AT=620.025n

* CHECK dout1_46 Vdout1_46ck123 = 0 time = 620
.meas tran vdout1_46ck123 FIND v(dout1_46) AT=620.025n

* CHECK dout1_47 Vdout1_47ck123 = 0.9 time = 620
.meas tran vdout1_47ck123 FIND v(dout1_47) AT=620.025n

* CHECK dout1_48 Vdout1_48ck123 = 0.9 time = 620
.meas tran vdout1_48ck123 FIND v(dout1_48) AT=620.025n

* CHECK dout1_49 Vdout1_49ck123 = 0 time = 620
.meas tran vdout1_49ck123 FIND v(dout1_49) AT=620.025n

* CHECK dout1_50 Vdout1_50ck123 = 0.9 time = 620
.meas tran vdout1_50ck123 FIND v(dout1_50) AT=620.025n

* CHECK dout1_51 Vdout1_51ck123 = 0.9 time = 620
.meas tran vdout1_51ck123 FIND v(dout1_51) AT=620.025n

* CHECK dout1_52 Vdout1_52ck123 = 0 time = 620
.meas tran vdout1_52ck123 FIND v(dout1_52) AT=620.025n

* CHECK dout1_53 Vdout1_53ck123 = 0 time = 620
.meas tran vdout1_53ck123 FIND v(dout1_53) AT=620.025n

* CHECK dout1_54 Vdout1_54ck123 = 0 time = 620
.meas tran vdout1_54ck123 FIND v(dout1_54) AT=620.025n

* CHECK dout1_55 Vdout1_55ck123 = 0.9 time = 620
.meas tran vdout1_55ck123 FIND v(dout1_55) AT=620.025n

* CHECK dout1_56 Vdout1_56ck123 = 0.9 time = 620
.meas tran vdout1_56ck123 FIND v(dout1_56) AT=620.025n

* CHECK dout1_57 Vdout1_57ck123 = 0.9 time = 620
.meas tran vdout1_57ck123 FIND v(dout1_57) AT=620.025n

* CHECK dout1_58 Vdout1_58ck123 = 0.9 time = 620
.meas tran vdout1_58ck123 FIND v(dout1_58) AT=620.025n

* CHECK dout1_59 Vdout1_59ck123 = 0.9 time = 620
.meas tran vdout1_59ck123 FIND v(dout1_59) AT=620.025n

* CHECK dout1_60 Vdout1_60ck123 = 0.9 time = 620
.meas tran vdout1_60ck123 FIND v(dout1_60) AT=620.025n

* CHECK dout1_61 Vdout1_61ck123 = 0.9 time = 620
.meas tran vdout1_61ck123 FIND v(dout1_61) AT=620.025n

* CHECK dout1_62 Vdout1_62ck123 = 0.9 time = 620
.meas tran vdout1_62ck123 FIND v(dout1_62) AT=620.025n

* CHECK dout1_63 Vdout1_63ck123 = 0 time = 620
.meas tran vdout1_63ck123 FIND v(dout1_63) AT=620.025n

* CHECK dout1_64 Vdout1_64ck123 = 0 time = 620
.meas tran vdout1_64ck123 FIND v(dout1_64) AT=620.025n

* CHECK dout1_65 Vdout1_65ck123 = 0 time = 620
.meas tran vdout1_65ck123 FIND v(dout1_65) AT=620.025n

* CHECK dout1_66 Vdout1_66ck123 = 0 time = 620
.meas tran vdout1_66ck123 FIND v(dout1_66) AT=620.025n

* CHECK dout1_67 Vdout1_67ck123 = 0.9 time = 620
.meas tran vdout1_67ck123 FIND v(dout1_67) AT=620.025n

* CHECK dout1_68 Vdout1_68ck123 = 0 time = 620
.meas tran vdout1_68ck123 FIND v(dout1_68) AT=620.025n

* CHECK dout1_69 Vdout1_69ck123 = 0 time = 620
.meas tran vdout1_69ck123 FIND v(dout1_69) AT=620.025n

* CHECK dout1_70 Vdout1_70ck123 = 0 time = 620
.meas tran vdout1_70ck123 FIND v(dout1_70) AT=620.025n

* CHECK dout1_71 Vdout1_71ck123 = 0 time = 620
.meas tran vdout1_71ck123 FIND v(dout1_71) AT=620.025n

* CHECK dout1_0 Vdout1_0ck126 = 0.9 time = 635
.meas tran vdout1_0ck126 FIND v(dout1_0) AT=635.025n

* CHECK dout1_1 Vdout1_1ck126 = 0 time = 635
.meas tran vdout1_1ck126 FIND v(dout1_1) AT=635.025n

* CHECK dout1_2 Vdout1_2ck126 = 0.9 time = 635
.meas tran vdout1_2ck126 FIND v(dout1_2) AT=635.025n

* CHECK dout1_3 Vdout1_3ck126 = 0.9 time = 635
.meas tran vdout1_3ck126 FIND v(dout1_3) AT=635.025n

* CHECK dout1_4 Vdout1_4ck126 = 0 time = 635
.meas tran vdout1_4ck126 FIND v(dout1_4) AT=635.025n

* CHECK dout1_5 Vdout1_5ck126 = 0 time = 635
.meas tran vdout1_5ck126 FIND v(dout1_5) AT=635.025n

* CHECK dout1_6 Vdout1_6ck126 = 0.9 time = 635
.meas tran vdout1_6ck126 FIND v(dout1_6) AT=635.025n

* CHECK dout1_7 Vdout1_7ck126 = 0 time = 635
.meas tran vdout1_7ck126 FIND v(dout1_7) AT=635.025n

* CHECK dout1_8 Vdout1_8ck126 = 0.9 time = 635
.meas tran vdout1_8ck126 FIND v(dout1_8) AT=635.025n

* CHECK dout1_9 Vdout1_9ck126 = 0 time = 635
.meas tran vdout1_9ck126 FIND v(dout1_9) AT=635.025n

* CHECK dout1_10 Vdout1_10ck126 = 0 time = 635
.meas tran vdout1_10ck126 FIND v(dout1_10) AT=635.025n

* CHECK dout1_11 Vdout1_11ck126 = 0.9 time = 635
.meas tran vdout1_11ck126 FIND v(dout1_11) AT=635.025n

* CHECK dout1_12 Vdout1_12ck126 = 0.9 time = 635
.meas tran vdout1_12ck126 FIND v(dout1_12) AT=635.025n

* CHECK dout1_13 Vdout1_13ck126 = 0.9 time = 635
.meas tran vdout1_13ck126 FIND v(dout1_13) AT=635.025n

* CHECK dout1_14 Vdout1_14ck126 = 0 time = 635
.meas tran vdout1_14ck126 FIND v(dout1_14) AT=635.025n

* CHECK dout1_15 Vdout1_15ck126 = 0 time = 635
.meas tran vdout1_15ck126 FIND v(dout1_15) AT=635.025n

* CHECK dout1_16 Vdout1_16ck126 = 0 time = 635
.meas tran vdout1_16ck126 FIND v(dout1_16) AT=635.025n

* CHECK dout1_17 Vdout1_17ck126 = 0.9 time = 635
.meas tran vdout1_17ck126 FIND v(dout1_17) AT=635.025n

* CHECK dout1_18 Vdout1_18ck126 = 0 time = 635
.meas tran vdout1_18ck126 FIND v(dout1_18) AT=635.025n

* CHECK dout1_19 Vdout1_19ck126 = 0 time = 635
.meas tran vdout1_19ck126 FIND v(dout1_19) AT=635.025n

* CHECK dout1_20 Vdout1_20ck126 = 0 time = 635
.meas tran vdout1_20ck126 FIND v(dout1_20) AT=635.025n

* CHECK dout1_21 Vdout1_21ck126 = 0 time = 635
.meas tran vdout1_21ck126 FIND v(dout1_21) AT=635.025n

* CHECK dout1_22 Vdout1_22ck126 = 0 time = 635
.meas tran vdout1_22ck126 FIND v(dout1_22) AT=635.025n

* CHECK dout1_23 Vdout1_23ck126 = 0 time = 635
.meas tran vdout1_23ck126 FIND v(dout1_23) AT=635.025n

* CHECK dout1_24 Vdout1_24ck126 = 0 time = 635
.meas tran vdout1_24ck126 FIND v(dout1_24) AT=635.025n

* CHECK dout1_25 Vdout1_25ck126 = 0.9 time = 635
.meas tran vdout1_25ck126 FIND v(dout1_25) AT=635.025n

* CHECK dout1_26 Vdout1_26ck126 = 0 time = 635
.meas tran vdout1_26ck126 FIND v(dout1_26) AT=635.025n

* CHECK dout1_27 Vdout1_27ck126 = 0.9 time = 635
.meas tran vdout1_27ck126 FIND v(dout1_27) AT=635.025n

* CHECK dout1_28 Vdout1_28ck126 = 0.9 time = 635
.meas tran vdout1_28ck126 FIND v(dout1_28) AT=635.025n

* CHECK dout1_29 Vdout1_29ck126 = 0.9 time = 635
.meas tran vdout1_29ck126 FIND v(dout1_29) AT=635.025n

* CHECK dout1_30 Vdout1_30ck126 = 0 time = 635
.meas tran vdout1_30ck126 FIND v(dout1_30) AT=635.025n

* CHECK dout1_31 Vdout1_31ck126 = 0 time = 635
.meas tran vdout1_31ck126 FIND v(dout1_31) AT=635.025n

* CHECK dout1_32 Vdout1_32ck126 = 0.9 time = 635
.meas tran vdout1_32ck126 FIND v(dout1_32) AT=635.025n

* CHECK dout1_33 Vdout1_33ck126 = 0 time = 635
.meas tran vdout1_33ck126 FIND v(dout1_33) AT=635.025n

* CHECK dout1_34 Vdout1_34ck126 = 0 time = 635
.meas tran vdout1_34ck126 FIND v(dout1_34) AT=635.025n

* CHECK dout1_35 Vdout1_35ck126 = 0.9 time = 635
.meas tran vdout1_35ck126 FIND v(dout1_35) AT=635.025n

* CHECK dout1_36 Vdout1_36ck126 = 0 time = 635
.meas tran vdout1_36ck126 FIND v(dout1_36) AT=635.025n

* CHECK dout1_37 Vdout1_37ck126 = 0 time = 635
.meas tran vdout1_37ck126 FIND v(dout1_37) AT=635.025n

* CHECK dout1_38 Vdout1_38ck126 = 0.9 time = 635
.meas tran vdout1_38ck126 FIND v(dout1_38) AT=635.025n

* CHECK dout1_39 Vdout1_39ck126 = 0.9 time = 635
.meas tran vdout1_39ck126 FIND v(dout1_39) AT=635.025n

* CHECK dout1_40 Vdout1_40ck126 = 0.9 time = 635
.meas tran vdout1_40ck126 FIND v(dout1_40) AT=635.025n

* CHECK dout1_41 Vdout1_41ck126 = 0.9 time = 635
.meas tran vdout1_41ck126 FIND v(dout1_41) AT=635.025n

* CHECK dout1_42 Vdout1_42ck126 = 0.9 time = 635
.meas tran vdout1_42ck126 FIND v(dout1_42) AT=635.025n

* CHECK dout1_43 Vdout1_43ck126 = 0 time = 635
.meas tran vdout1_43ck126 FIND v(dout1_43) AT=635.025n

* CHECK dout1_44 Vdout1_44ck126 = 0.9 time = 635
.meas tran vdout1_44ck126 FIND v(dout1_44) AT=635.025n

* CHECK dout1_45 Vdout1_45ck126 = 0.9 time = 635
.meas tran vdout1_45ck126 FIND v(dout1_45) AT=635.025n

* CHECK dout1_46 Vdout1_46ck126 = 0 time = 635
.meas tran vdout1_46ck126 FIND v(dout1_46) AT=635.025n

* CHECK dout1_47 Vdout1_47ck126 = 0.9 time = 635
.meas tran vdout1_47ck126 FIND v(dout1_47) AT=635.025n

* CHECK dout1_48 Vdout1_48ck126 = 0.9 time = 635
.meas tran vdout1_48ck126 FIND v(dout1_48) AT=635.025n

* CHECK dout1_49 Vdout1_49ck126 = 0.9 time = 635
.meas tran vdout1_49ck126 FIND v(dout1_49) AT=635.025n

* CHECK dout1_50 Vdout1_50ck126 = 0 time = 635
.meas tran vdout1_50ck126 FIND v(dout1_50) AT=635.025n

* CHECK dout1_51 Vdout1_51ck126 = 0 time = 635
.meas tran vdout1_51ck126 FIND v(dout1_51) AT=635.025n

* CHECK dout1_52 Vdout1_52ck126 = 0.9 time = 635
.meas tran vdout1_52ck126 FIND v(dout1_52) AT=635.025n

* CHECK dout1_53 Vdout1_53ck126 = 0.9 time = 635
.meas tran vdout1_53ck126 FIND v(dout1_53) AT=635.025n

* CHECK dout1_54 Vdout1_54ck126 = 0 time = 635
.meas tran vdout1_54ck126 FIND v(dout1_54) AT=635.025n

* CHECK dout1_55 Vdout1_55ck126 = 0 time = 635
.meas tran vdout1_55ck126 FIND v(dout1_55) AT=635.025n

* CHECK dout1_56 Vdout1_56ck126 = 0 time = 635
.meas tran vdout1_56ck126 FIND v(dout1_56) AT=635.025n

* CHECK dout1_57 Vdout1_57ck126 = 0 time = 635
.meas tran vdout1_57ck126 FIND v(dout1_57) AT=635.025n

* CHECK dout1_58 Vdout1_58ck126 = 0 time = 635
.meas tran vdout1_58ck126 FIND v(dout1_58) AT=635.025n

* CHECK dout1_59 Vdout1_59ck126 = 0.9 time = 635
.meas tran vdout1_59ck126 FIND v(dout1_59) AT=635.025n

* CHECK dout1_60 Vdout1_60ck126 = 0 time = 635
.meas tran vdout1_60ck126 FIND v(dout1_60) AT=635.025n

* CHECK dout1_61 Vdout1_61ck126 = 0 time = 635
.meas tran vdout1_61ck126 FIND v(dout1_61) AT=635.025n

* CHECK dout1_62 Vdout1_62ck126 = 0.9 time = 635
.meas tran vdout1_62ck126 FIND v(dout1_62) AT=635.025n

* CHECK dout1_63 Vdout1_63ck126 = 0.9 time = 635
.meas tran vdout1_63ck126 FIND v(dout1_63) AT=635.025n

* CHECK dout1_64 Vdout1_64ck126 = 0.9 time = 635
.meas tran vdout1_64ck126 FIND v(dout1_64) AT=635.025n

* CHECK dout1_65 Vdout1_65ck126 = 0.9 time = 635
.meas tran vdout1_65ck126 FIND v(dout1_65) AT=635.025n

* CHECK dout1_66 Vdout1_66ck126 = 0.9 time = 635
.meas tran vdout1_66ck126 FIND v(dout1_66) AT=635.025n

* CHECK dout1_67 Vdout1_67ck126 = 0 time = 635
.meas tran vdout1_67ck126 FIND v(dout1_67) AT=635.025n

* CHECK dout1_68 Vdout1_68ck126 = 0.9 time = 635
.meas tran vdout1_68ck126 FIND v(dout1_68) AT=635.025n

* CHECK dout1_69 Vdout1_69ck126 = 0 time = 635
.meas tran vdout1_69ck126 FIND v(dout1_69) AT=635.025n

* CHECK dout1_70 Vdout1_70ck126 = 0.9 time = 635
.meas tran vdout1_70ck126 FIND v(dout1_70) AT=635.025n

* CHECK dout1_71 Vdout1_71ck126 = 0.9 time = 635
.meas tran vdout1_71ck126 FIND v(dout1_71) AT=635.025n

* CHECK dout1_0 Vdout1_0ck129 = 0.9 time = 650
.meas tran vdout1_0ck129 FIND v(dout1_0) AT=650.025n

* CHECK dout1_1 Vdout1_1ck129 = 0 time = 650
.meas tran vdout1_1ck129 FIND v(dout1_1) AT=650.025n

* CHECK dout1_2 Vdout1_2ck129 = 0.9 time = 650
.meas tran vdout1_2ck129 FIND v(dout1_2) AT=650.025n

* CHECK dout1_3 Vdout1_3ck129 = 0 time = 650
.meas tran vdout1_3ck129 FIND v(dout1_3) AT=650.025n

* CHECK dout1_4 Vdout1_4ck129 = 0.9 time = 650
.meas tran vdout1_4ck129 FIND v(dout1_4) AT=650.025n

* CHECK dout1_5 Vdout1_5ck129 = 0.9 time = 650
.meas tran vdout1_5ck129 FIND v(dout1_5) AT=650.025n

* CHECK dout1_6 Vdout1_6ck129 = 0.9 time = 650
.meas tran vdout1_6ck129 FIND v(dout1_6) AT=650.025n

* CHECK dout1_7 Vdout1_7ck129 = 0.9 time = 650
.meas tran vdout1_7ck129 FIND v(dout1_7) AT=650.025n

* CHECK dout1_8 Vdout1_8ck129 = 0 time = 650
.meas tran vdout1_8ck129 FIND v(dout1_8) AT=650.025n

* CHECK dout1_9 Vdout1_9ck129 = 0.9 time = 650
.meas tran vdout1_9ck129 FIND v(dout1_9) AT=650.025n

* CHECK dout1_10 Vdout1_10ck129 = 0 time = 650
.meas tran vdout1_10ck129 FIND v(dout1_10) AT=650.025n

* CHECK dout1_11 Vdout1_11ck129 = 0 time = 650
.meas tran vdout1_11ck129 FIND v(dout1_11) AT=650.025n

* CHECK dout1_12 Vdout1_12ck129 = 0 time = 650
.meas tran vdout1_12ck129 FIND v(dout1_12) AT=650.025n

* CHECK dout1_13 Vdout1_13ck129 = 0 time = 650
.meas tran vdout1_13ck129 FIND v(dout1_13) AT=650.025n

* CHECK dout1_14 Vdout1_14ck129 = 0.9 time = 650
.meas tran vdout1_14ck129 FIND v(dout1_14) AT=650.025n

* CHECK dout1_15 Vdout1_15ck129 = 0.9 time = 650
.meas tran vdout1_15ck129 FIND v(dout1_15) AT=650.025n

* CHECK dout1_16 Vdout1_16ck129 = 0.9 time = 650
.meas tran vdout1_16ck129 FIND v(dout1_16) AT=650.025n

* CHECK dout1_17 Vdout1_17ck129 = 0 time = 650
.meas tran vdout1_17ck129 FIND v(dout1_17) AT=650.025n

* CHECK dout1_18 Vdout1_18ck129 = 0 time = 650
.meas tran vdout1_18ck129 FIND v(dout1_18) AT=650.025n

* CHECK dout1_19 Vdout1_19ck129 = 0 time = 650
.meas tran vdout1_19ck129 FIND v(dout1_19) AT=650.025n

* CHECK dout1_20 Vdout1_20ck129 = 0 time = 650
.meas tran vdout1_20ck129 FIND v(dout1_20) AT=650.025n

* CHECK dout1_21 Vdout1_21ck129 = 0.9 time = 650
.meas tran vdout1_21ck129 FIND v(dout1_21) AT=650.025n

* CHECK dout1_22 Vdout1_22ck129 = 0 time = 650
.meas tran vdout1_22ck129 FIND v(dout1_22) AT=650.025n

* CHECK dout1_23 Vdout1_23ck129 = 0.9 time = 650
.meas tran vdout1_23ck129 FIND v(dout1_23) AT=650.025n

* CHECK dout1_24 Vdout1_24ck129 = 0.9 time = 650
.meas tran vdout1_24ck129 FIND v(dout1_24) AT=650.025n

* CHECK dout1_25 Vdout1_25ck129 = 0.9 time = 650
.meas tran vdout1_25ck129 FIND v(dout1_25) AT=650.025n

* CHECK dout1_26 Vdout1_26ck129 = 0 time = 650
.meas tran vdout1_26ck129 FIND v(dout1_26) AT=650.025n

* CHECK dout1_27 Vdout1_27ck129 = 0.9 time = 650
.meas tran vdout1_27ck129 FIND v(dout1_27) AT=650.025n

* CHECK dout1_28 Vdout1_28ck129 = 0.9 time = 650
.meas tran vdout1_28ck129 FIND v(dout1_28) AT=650.025n

* CHECK dout1_29 Vdout1_29ck129 = 0 time = 650
.meas tran vdout1_29ck129 FIND v(dout1_29) AT=650.025n

* CHECK dout1_30 Vdout1_30ck129 = 0.9 time = 650
.meas tran vdout1_30ck129 FIND v(dout1_30) AT=650.025n

* CHECK dout1_31 Vdout1_31ck129 = 0.9 time = 650
.meas tran vdout1_31ck129 FIND v(dout1_31) AT=650.025n

* CHECK dout1_32 Vdout1_32ck129 = 0.9 time = 650
.meas tran vdout1_32ck129 FIND v(dout1_32) AT=650.025n

* CHECK dout1_33 Vdout1_33ck129 = 0.9 time = 650
.meas tran vdout1_33ck129 FIND v(dout1_33) AT=650.025n

* CHECK dout1_34 Vdout1_34ck129 = 0 time = 650
.meas tran vdout1_34ck129 FIND v(dout1_34) AT=650.025n

* CHECK dout1_35 Vdout1_35ck129 = 0.9 time = 650
.meas tran vdout1_35ck129 FIND v(dout1_35) AT=650.025n

* CHECK dout1_36 Vdout1_36ck129 = 0.9 time = 650
.meas tran vdout1_36ck129 FIND v(dout1_36) AT=650.025n

* CHECK dout1_37 Vdout1_37ck129 = 0.9 time = 650
.meas tran vdout1_37ck129 FIND v(dout1_37) AT=650.025n

* CHECK dout1_38 Vdout1_38ck129 = 0.9 time = 650
.meas tran vdout1_38ck129 FIND v(dout1_38) AT=650.025n

* CHECK dout1_39 Vdout1_39ck129 = 0 time = 650
.meas tran vdout1_39ck129 FIND v(dout1_39) AT=650.025n

* CHECK dout1_40 Vdout1_40ck129 = 0 time = 650
.meas tran vdout1_40ck129 FIND v(dout1_40) AT=650.025n

* CHECK dout1_41 Vdout1_41ck129 = 0 time = 650
.meas tran vdout1_41ck129 FIND v(dout1_41) AT=650.025n

* CHECK dout1_42 Vdout1_42ck129 = 0 time = 650
.meas tran vdout1_42ck129 FIND v(dout1_42) AT=650.025n

* CHECK dout1_43 Vdout1_43ck129 = 0 time = 650
.meas tran vdout1_43ck129 FIND v(dout1_43) AT=650.025n

* CHECK dout1_44 Vdout1_44ck129 = 0.9 time = 650
.meas tran vdout1_44ck129 FIND v(dout1_44) AT=650.025n

* CHECK dout1_45 Vdout1_45ck129 = 0 time = 650
.meas tran vdout1_45ck129 FIND v(dout1_45) AT=650.025n

* CHECK dout1_46 Vdout1_46ck129 = 0 time = 650
.meas tran vdout1_46ck129 FIND v(dout1_46) AT=650.025n

* CHECK dout1_47 Vdout1_47ck129 = 0 time = 650
.meas tran vdout1_47ck129 FIND v(dout1_47) AT=650.025n

* CHECK dout1_48 Vdout1_48ck129 = 0.9 time = 650
.meas tran vdout1_48ck129 FIND v(dout1_48) AT=650.025n

* CHECK dout1_49 Vdout1_49ck129 = 0.9 time = 650
.meas tran vdout1_49ck129 FIND v(dout1_49) AT=650.025n

* CHECK dout1_50 Vdout1_50ck129 = 0.9 time = 650
.meas tran vdout1_50ck129 FIND v(dout1_50) AT=650.025n

* CHECK dout1_51 Vdout1_51ck129 = 0 time = 650
.meas tran vdout1_51ck129 FIND v(dout1_51) AT=650.025n

* CHECK dout1_52 Vdout1_52ck129 = 0.9 time = 650
.meas tran vdout1_52ck129 FIND v(dout1_52) AT=650.025n

* CHECK dout1_53 Vdout1_53ck129 = 0 time = 650
.meas tran vdout1_53ck129 FIND v(dout1_53) AT=650.025n

* CHECK dout1_54 Vdout1_54ck129 = 0.9 time = 650
.meas tran vdout1_54ck129 FIND v(dout1_54) AT=650.025n

* CHECK dout1_55 Vdout1_55ck129 = 0.9 time = 650
.meas tran vdout1_55ck129 FIND v(dout1_55) AT=650.025n

* CHECK dout1_56 Vdout1_56ck129 = 0 time = 650
.meas tran vdout1_56ck129 FIND v(dout1_56) AT=650.025n

* CHECK dout1_57 Vdout1_57ck129 = 0.9 time = 650
.meas tran vdout1_57ck129 FIND v(dout1_57) AT=650.025n

* CHECK dout1_58 Vdout1_58ck129 = 0 time = 650
.meas tran vdout1_58ck129 FIND v(dout1_58) AT=650.025n

* CHECK dout1_59 Vdout1_59ck129 = 0 time = 650
.meas tran vdout1_59ck129 FIND v(dout1_59) AT=650.025n

* CHECK dout1_60 Vdout1_60ck129 = 0 time = 650
.meas tran vdout1_60ck129 FIND v(dout1_60) AT=650.025n

* CHECK dout1_61 Vdout1_61ck129 = 0.9 time = 650
.meas tran vdout1_61ck129 FIND v(dout1_61) AT=650.025n

* CHECK dout1_62 Vdout1_62ck129 = 0 time = 650
.meas tran vdout1_62ck129 FIND v(dout1_62) AT=650.025n

* CHECK dout1_63 Vdout1_63ck129 = 0 time = 650
.meas tran vdout1_63ck129 FIND v(dout1_63) AT=650.025n

* CHECK dout1_64 Vdout1_64ck129 = 0 time = 650
.meas tran vdout1_64ck129 FIND v(dout1_64) AT=650.025n

* CHECK dout1_65 Vdout1_65ck129 = 0.9 time = 650
.meas tran vdout1_65ck129 FIND v(dout1_65) AT=650.025n

* CHECK dout1_66 Vdout1_66ck129 = 0 time = 650
.meas tran vdout1_66ck129 FIND v(dout1_66) AT=650.025n

* CHECK dout1_67 Vdout1_67ck129 = 0.9 time = 650
.meas tran vdout1_67ck129 FIND v(dout1_67) AT=650.025n

* CHECK dout1_68 Vdout1_68ck129 = 0.9 time = 650
.meas tran vdout1_68ck129 FIND v(dout1_68) AT=650.025n

* CHECK dout1_69 Vdout1_69ck129 = 0 time = 650
.meas tran vdout1_69ck129 FIND v(dout1_69) AT=650.025n

* CHECK dout1_70 Vdout1_70ck129 = 0.9 time = 650
.meas tran vdout1_70ck129 FIND v(dout1_70) AT=650.025n

* CHECK dout1_71 Vdout1_71ck129 = 0 time = 650
.meas tran vdout1_71ck129 FIND v(dout1_71) AT=650.025n

* CHECK dout1_0 Vdout1_0ck133 = 0.9 time = 670
.meas tran vdout1_0ck133 FIND v(dout1_0) AT=670.025n

* CHECK dout1_1 Vdout1_1ck133 = 0 time = 670
.meas tran vdout1_1ck133 FIND v(dout1_1) AT=670.025n

* CHECK dout1_2 Vdout1_2ck133 = 0.9 time = 670
.meas tran vdout1_2ck133 FIND v(dout1_2) AT=670.025n

* CHECK dout1_3 Vdout1_3ck133 = 0 time = 670
.meas tran vdout1_3ck133 FIND v(dout1_3) AT=670.025n

* CHECK dout1_4 Vdout1_4ck133 = 0.9 time = 670
.meas tran vdout1_4ck133 FIND v(dout1_4) AT=670.025n

* CHECK dout1_5 Vdout1_5ck133 = 0 time = 670
.meas tran vdout1_5ck133 FIND v(dout1_5) AT=670.025n

* CHECK dout1_6 Vdout1_6ck133 = 0 time = 670
.meas tran vdout1_6ck133 FIND v(dout1_6) AT=670.025n

* CHECK dout1_7 Vdout1_7ck133 = 0.9 time = 670
.meas tran vdout1_7ck133 FIND v(dout1_7) AT=670.025n

* CHECK dout1_8 Vdout1_8ck133 = 0 time = 670
.meas tran vdout1_8ck133 FIND v(dout1_8) AT=670.025n

* CHECK dout1_9 Vdout1_9ck133 = 0 time = 670
.meas tran vdout1_9ck133 FIND v(dout1_9) AT=670.025n

* CHECK dout1_10 Vdout1_10ck133 = 0.9 time = 670
.meas tran vdout1_10ck133 FIND v(dout1_10) AT=670.025n

* CHECK dout1_11 Vdout1_11ck133 = 0.9 time = 670
.meas tran vdout1_11ck133 FIND v(dout1_11) AT=670.025n

* CHECK dout1_12 Vdout1_12ck133 = 0.9 time = 670
.meas tran vdout1_12ck133 FIND v(dout1_12) AT=670.025n

* CHECK dout1_13 Vdout1_13ck133 = 0.9 time = 670
.meas tran vdout1_13ck133 FIND v(dout1_13) AT=670.025n

* CHECK dout1_14 Vdout1_14ck133 = 0.9 time = 670
.meas tran vdout1_14ck133 FIND v(dout1_14) AT=670.025n

* CHECK dout1_15 Vdout1_15ck133 = 0.9 time = 670
.meas tran vdout1_15ck133 FIND v(dout1_15) AT=670.025n

* CHECK dout1_16 Vdout1_16ck133 = 0.9 time = 670
.meas tran vdout1_16ck133 FIND v(dout1_16) AT=670.025n

* CHECK dout1_17 Vdout1_17ck133 = 0 time = 670
.meas tran vdout1_17ck133 FIND v(dout1_17) AT=670.025n

* CHECK dout1_18 Vdout1_18ck133 = 0 time = 670
.meas tran vdout1_18ck133 FIND v(dout1_18) AT=670.025n

* CHECK dout1_19 Vdout1_19ck133 = 0 time = 670
.meas tran vdout1_19ck133 FIND v(dout1_19) AT=670.025n

* CHECK dout1_20 Vdout1_20ck133 = 0.9 time = 670
.meas tran vdout1_20ck133 FIND v(dout1_20) AT=670.025n

* CHECK dout1_21 Vdout1_21ck133 = 0.9 time = 670
.meas tran vdout1_21ck133 FIND v(dout1_21) AT=670.025n

* CHECK dout1_22 Vdout1_22ck133 = 0.9 time = 670
.meas tran vdout1_22ck133 FIND v(dout1_22) AT=670.025n

* CHECK dout1_23 Vdout1_23ck133 = 0 time = 670
.meas tran vdout1_23ck133 FIND v(dout1_23) AT=670.025n

* CHECK dout1_24 Vdout1_24ck133 = 0.9 time = 670
.meas tran vdout1_24ck133 FIND v(dout1_24) AT=670.025n

* CHECK dout1_25 Vdout1_25ck133 = 0.9 time = 670
.meas tran vdout1_25ck133 FIND v(dout1_25) AT=670.025n

* CHECK dout1_26 Vdout1_26ck133 = 0 time = 670
.meas tran vdout1_26ck133 FIND v(dout1_26) AT=670.025n

* CHECK dout1_27 Vdout1_27ck133 = 0 time = 670
.meas tran vdout1_27ck133 FIND v(dout1_27) AT=670.025n

* CHECK dout1_28 Vdout1_28ck133 = 0 time = 670
.meas tran vdout1_28ck133 FIND v(dout1_28) AT=670.025n

* CHECK dout1_29 Vdout1_29ck133 = 0.9 time = 670
.meas tran vdout1_29ck133 FIND v(dout1_29) AT=670.025n

* CHECK dout1_30 Vdout1_30ck133 = 0.9 time = 670
.meas tran vdout1_30ck133 FIND v(dout1_30) AT=670.025n

* CHECK dout1_31 Vdout1_31ck133 = 0 time = 670
.meas tran vdout1_31ck133 FIND v(dout1_31) AT=670.025n

* CHECK dout1_32 Vdout1_32ck133 = 0 time = 670
.meas tran vdout1_32ck133 FIND v(dout1_32) AT=670.025n

* CHECK dout1_33 Vdout1_33ck133 = 0.9 time = 670
.meas tran vdout1_33ck133 FIND v(dout1_33) AT=670.025n

* CHECK dout1_34 Vdout1_34ck133 = 0 time = 670
.meas tran vdout1_34ck133 FIND v(dout1_34) AT=670.025n

* CHECK dout1_35 Vdout1_35ck133 = 0 time = 670
.meas tran vdout1_35ck133 FIND v(dout1_35) AT=670.025n

* CHECK dout1_36 Vdout1_36ck133 = 0 time = 670
.meas tran vdout1_36ck133 FIND v(dout1_36) AT=670.025n

* CHECK dout1_37 Vdout1_37ck133 = 0 time = 670
.meas tran vdout1_37ck133 FIND v(dout1_37) AT=670.025n

* CHECK dout1_38 Vdout1_38ck133 = 0 time = 670
.meas tran vdout1_38ck133 FIND v(dout1_38) AT=670.025n

* CHECK dout1_39 Vdout1_39ck133 = 0.9 time = 670
.meas tran vdout1_39ck133 FIND v(dout1_39) AT=670.025n

* CHECK dout1_40 Vdout1_40ck133 = 0.9 time = 670
.meas tran vdout1_40ck133 FIND v(dout1_40) AT=670.025n

* CHECK dout1_41 Vdout1_41ck133 = 0.9 time = 670
.meas tran vdout1_41ck133 FIND v(dout1_41) AT=670.025n

* CHECK dout1_42 Vdout1_42ck133 = 0 time = 670
.meas tran vdout1_42ck133 FIND v(dout1_42) AT=670.025n

* CHECK dout1_43 Vdout1_43ck133 = 0 time = 670
.meas tran vdout1_43ck133 FIND v(dout1_43) AT=670.025n

* CHECK dout1_44 Vdout1_44ck133 = 0.9 time = 670
.meas tran vdout1_44ck133 FIND v(dout1_44) AT=670.025n

* CHECK dout1_45 Vdout1_45ck133 = 0.9 time = 670
.meas tran vdout1_45ck133 FIND v(dout1_45) AT=670.025n

* CHECK dout1_46 Vdout1_46ck133 = 0 time = 670
.meas tran vdout1_46ck133 FIND v(dout1_46) AT=670.025n

* CHECK dout1_47 Vdout1_47ck133 = 0 time = 670
.meas tran vdout1_47ck133 FIND v(dout1_47) AT=670.025n

* CHECK dout1_48 Vdout1_48ck133 = 0.9 time = 670
.meas tran vdout1_48ck133 FIND v(dout1_48) AT=670.025n

* CHECK dout1_49 Vdout1_49ck133 = 0 time = 670
.meas tran vdout1_49ck133 FIND v(dout1_49) AT=670.025n

* CHECK dout1_50 Vdout1_50ck133 = 0 time = 670
.meas tran vdout1_50ck133 FIND v(dout1_50) AT=670.025n

* CHECK dout1_51 Vdout1_51ck133 = 0.9 time = 670
.meas tran vdout1_51ck133 FIND v(dout1_51) AT=670.025n

* CHECK dout1_52 Vdout1_52ck133 = 0 time = 670
.meas tran vdout1_52ck133 FIND v(dout1_52) AT=670.025n

* CHECK dout1_53 Vdout1_53ck133 = 0 time = 670
.meas tran vdout1_53ck133 FIND v(dout1_53) AT=670.025n

* CHECK dout1_54 Vdout1_54ck133 = 0 time = 670
.meas tran vdout1_54ck133 FIND v(dout1_54) AT=670.025n

* CHECK dout1_55 Vdout1_55ck133 = 0.9 time = 670
.meas tran vdout1_55ck133 FIND v(dout1_55) AT=670.025n

* CHECK dout1_56 Vdout1_56ck133 = 0 time = 670
.meas tran vdout1_56ck133 FIND v(dout1_56) AT=670.025n

* CHECK dout1_57 Vdout1_57ck133 = 0 time = 670
.meas tran vdout1_57ck133 FIND v(dout1_57) AT=670.025n

* CHECK dout1_58 Vdout1_58ck133 = 0 time = 670
.meas tran vdout1_58ck133 FIND v(dout1_58) AT=670.025n

* CHECK dout1_59 Vdout1_59ck133 = 0 time = 670
.meas tran vdout1_59ck133 FIND v(dout1_59) AT=670.025n

* CHECK dout1_60 Vdout1_60ck133 = 0 time = 670
.meas tran vdout1_60ck133 FIND v(dout1_60) AT=670.025n

* CHECK dout1_61 Vdout1_61ck133 = 0.9 time = 670
.meas tran vdout1_61ck133 FIND v(dout1_61) AT=670.025n

* CHECK dout1_62 Vdout1_62ck133 = 0 time = 670
.meas tran vdout1_62ck133 FIND v(dout1_62) AT=670.025n

* CHECK dout1_63 Vdout1_63ck133 = 0.9 time = 670
.meas tran vdout1_63ck133 FIND v(dout1_63) AT=670.025n

* CHECK dout1_64 Vdout1_64ck133 = 0 time = 670
.meas tran vdout1_64ck133 FIND v(dout1_64) AT=670.025n

* CHECK dout1_65 Vdout1_65ck133 = 0 time = 670
.meas tran vdout1_65ck133 FIND v(dout1_65) AT=670.025n

* CHECK dout1_66 Vdout1_66ck133 = 0 time = 670
.meas tran vdout1_66ck133 FIND v(dout1_66) AT=670.025n

* CHECK dout1_67 Vdout1_67ck133 = 0.9 time = 670
.meas tran vdout1_67ck133 FIND v(dout1_67) AT=670.025n

* CHECK dout1_68 Vdout1_68ck133 = 0.9 time = 670
.meas tran vdout1_68ck133 FIND v(dout1_68) AT=670.025n

* CHECK dout1_69 Vdout1_69ck133 = 0.9 time = 670
.meas tran vdout1_69ck133 FIND v(dout1_69) AT=670.025n

* CHECK dout1_70 Vdout1_70ck133 = 0 time = 670
.meas tran vdout1_70ck133 FIND v(dout1_70) AT=670.025n

* CHECK dout1_71 Vdout1_71ck133 = 0 time = 670
.meas tran vdout1_71ck133 FIND v(dout1_71) AT=670.025n

* CHECK dout1_0 Vdout1_0ck136 = 0.9 time = 685
.meas tran vdout1_0ck136 FIND v(dout1_0) AT=685.025n

* CHECK dout1_1 Vdout1_1ck136 = 0 time = 685
.meas tran vdout1_1ck136 FIND v(dout1_1) AT=685.025n

* CHECK dout1_2 Vdout1_2ck136 = 0.9 time = 685
.meas tran vdout1_2ck136 FIND v(dout1_2) AT=685.025n

* CHECK dout1_3 Vdout1_3ck136 = 0 time = 685
.meas tran vdout1_3ck136 FIND v(dout1_3) AT=685.025n

* CHECK dout1_4 Vdout1_4ck136 = 0.9 time = 685
.meas tran vdout1_4ck136 FIND v(dout1_4) AT=685.025n

* CHECK dout1_5 Vdout1_5ck136 = 0 time = 685
.meas tran vdout1_5ck136 FIND v(dout1_5) AT=685.025n

* CHECK dout1_6 Vdout1_6ck136 = 0 time = 685
.meas tran vdout1_6ck136 FIND v(dout1_6) AT=685.025n

* CHECK dout1_7 Vdout1_7ck136 = 0.9 time = 685
.meas tran vdout1_7ck136 FIND v(dout1_7) AT=685.025n

* CHECK dout1_8 Vdout1_8ck136 = 0 time = 685
.meas tran vdout1_8ck136 FIND v(dout1_8) AT=685.025n

* CHECK dout1_9 Vdout1_9ck136 = 0 time = 685
.meas tran vdout1_9ck136 FIND v(dout1_9) AT=685.025n

* CHECK dout1_10 Vdout1_10ck136 = 0.9 time = 685
.meas tran vdout1_10ck136 FIND v(dout1_10) AT=685.025n

* CHECK dout1_11 Vdout1_11ck136 = 0.9 time = 685
.meas tran vdout1_11ck136 FIND v(dout1_11) AT=685.025n

* CHECK dout1_12 Vdout1_12ck136 = 0.9 time = 685
.meas tran vdout1_12ck136 FIND v(dout1_12) AT=685.025n

* CHECK dout1_13 Vdout1_13ck136 = 0.9 time = 685
.meas tran vdout1_13ck136 FIND v(dout1_13) AT=685.025n

* CHECK dout1_14 Vdout1_14ck136 = 0.9 time = 685
.meas tran vdout1_14ck136 FIND v(dout1_14) AT=685.025n

* CHECK dout1_15 Vdout1_15ck136 = 0.9 time = 685
.meas tran vdout1_15ck136 FIND v(dout1_15) AT=685.025n

* CHECK dout1_16 Vdout1_16ck136 = 0.9 time = 685
.meas tran vdout1_16ck136 FIND v(dout1_16) AT=685.025n

* CHECK dout1_17 Vdout1_17ck136 = 0 time = 685
.meas tran vdout1_17ck136 FIND v(dout1_17) AT=685.025n

* CHECK dout1_18 Vdout1_18ck136 = 0 time = 685
.meas tran vdout1_18ck136 FIND v(dout1_18) AT=685.025n

* CHECK dout1_19 Vdout1_19ck136 = 0 time = 685
.meas tran vdout1_19ck136 FIND v(dout1_19) AT=685.025n

* CHECK dout1_20 Vdout1_20ck136 = 0.9 time = 685
.meas tran vdout1_20ck136 FIND v(dout1_20) AT=685.025n

* CHECK dout1_21 Vdout1_21ck136 = 0.9 time = 685
.meas tran vdout1_21ck136 FIND v(dout1_21) AT=685.025n

* CHECK dout1_22 Vdout1_22ck136 = 0.9 time = 685
.meas tran vdout1_22ck136 FIND v(dout1_22) AT=685.025n

* CHECK dout1_23 Vdout1_23ck136 = 0 time = 685
.meas tran vdout1_23ck136 FIND v(dout1_23) AT=685.025n

* CHECK dout1_24 Vdout1_24ck136 = 0.9 time = 685
.meas tran vdout1_24ck136 FIND v(dout1_24) AT=685.025n

* CHECK dout1_25 Vdout1_25ck136 = 0.9 time = 685
.meas tran vdout1_25ck136 FIND v(dout1_25) AT=685.025n

* CHECK dout1_26 Vdout1_26ck136 = 0 time = 685
.meas tran vdout1_26ck136 FIND v(dout1_26) AT=685.025n

* CHECK dout1_27 Vdout1_27ck136 = 0 time = 685
.meas tran vdout1_27ck136 FIND v(dout1_27) AT=685.025n

* CHECK dout1_28 Vdout1_28ck136 = 0 time = 685
.meas tran vdout1_28ck136 FIND v(dout1_28) AT=685.025n

* CHECK dout1_29 Vdout1_29ck136 = 0.9 time = 685
.meas tran vdout1_29ck136 FIND v(dout1_29) AT=685.025n

* CHECK dout1_30 Vdout1_30ck136 = 0.9 time = 685
.meas tran vdout1_30ck136 FIND v(dout1_30) AT=685.025n

* CHECK dout1_31 Vdout1_31ck136 = 0 time = 685
.meas tran vdout1_31ck136 FIND v(dout1_31) AT=685.025n

* CHECK dout1_32 Vdout1_32ck136 = 0 time = 685
.meas tran vdout1_32ck136 FIND v(dout1_32) AT=685.025n

* CHECK dout1_33 Vdout1_33ck136 = 0.9 time = 685
.meas tran vdout1_33ck136 FIND v(dout1_33) AT=685.025n

* CHECK dout1_34 Vdout1_34ck136 = 0 time = 685
.meas tran vdout1_34ck136 FIND v(dout1_34) AT=685.025n

* CHECK dout1_35 Vdout1_35ck136 = 0 time = 685
.meas tran vdout1_35ck136 FIND v(dout1_35) AT=685.025n

* CHECK dout1_36 Vdout1_36ck136 = 0 time = 685
.meas tran vdout1_36ck136 FIND v(dout1_36) AT=685.025n

* CHECK dout1_37 Vdout1_37ck136 = 0 time = 685
.meas tran vdout1_37ck136 FIND v(dout1_37) AT=685.025n

* CHECK dout1_38 Vdout1_38ck136 = 0 time = 685
.meas tran vdout1_38ck136 FIND v(dout1_38) AT=685.025n

* CHECK dout1_39 Vdout1_39ck136 = 0.9 time = 685
.meas tran vdout1_39ck136 FIND v(dout1_39) AT=685.025n

* CHECK dout1_40 Vdout1_40ck136 = 0.9 time = 685
.meas tran vdout1_40ck136 FIND v(dout1_40) AT=685.025n

* CHECK dout1_41 Vdout1_41ck136 = 0.9 time = 685
.meas tran vdout1_41ck136 FIND v(dout1_41) AT=685.025n

* CHECK dout1_42 Vdout1_42ck136 = 0 time = 685
.meas tran vdout1_42ck136 FIND v(dout1_42) AT=685.025n

* CHECK dout1_43 Vdout1_43ck136 = 0 time = 685
.meas tran vdout1_43ck136 FIND v(dout1_43) AT=685.025n

* CHECK dout1_44 Vdout1_44ck136 = 0.9 time = 685
.meas tran vdout1_44ck136 FIND v(dout1_44) AT=685.025n

* CHECK dout1_45 Vdout1_45ck136 = 0.9 time = 685
.meas tran vdout1_45ck136 FIND v(dout1_45) AT=685.025n

* CHECK dout1_46 Vdout1_46ck136 = 0 time = 685
.meas tran vdout1_46ck136 FIND v(dout1_46) AT=685.025n

* CHECK dout1_47 Vdout1_47ck136 = 0 time = 685
.meas tran vdout1_47ck136 FIND v(dout1_47) AT=685.025n

* CHECK dout1_48 Vdout1_48ck136 = 0.9 time = 685
.meas tran vdout1_48ck136 FIND v(dout1_48) AT=685.025n

* CHECK dout1_49 Vdout1_49ck136 = 0 time = 685
.meas tran vdout1_49ck136 FIND v(dout1_49) AT=685.025n

* CHECK dout1_50 Vdout1_50ck136 = 0 time = 685
.meas tran vdout1_50ck136 FIND v(dout1_50) AT=685.025n

* CHECK dout1_51 Vdout1_51ck136 = 0.9 time = 685
.meas tran vdout1_51ck136 FIND v(dout1_51) AT=685.025n

* CHECK dout1_52 Vdout1_52ck136 = 0 time = 685
.meas tran vdout1_52ck136 FIND v(dout1_52) AT=685.025n

* CHECK dout1_53 Vdout1_53ck136 = 0 time = 685
.meas tran vdout1_53ck136 FIND v(dout1_53) AT=685.025n

* CHECK dout1_54 Vdout1_54ck136 = 0 time = 685
.meas tran vdout1_54ck136 FIND v(dout1_54) AT=685.025n

* CHECK dout1_55 Vdout1_55ck136 = 0.9 time = 685
.meas tran vdout1_55ck136 FIND v(dout1_55) AT=685.025n

* CHECK dout1_56 Vdout1_56ck136 = 0 time = 685
.meas tran vdout1_56ck136 FIND v(dout1_56) AT=685.025n

* CHECK dout1_57 Vdout1_57ck136 = 0 time = 685
.meas tran vdout1_57ck136 FIND v(dout1_57) AT=685.025n

* CHECK dout1_58 Vdout1_58ck136 = 0 time = 685
.meas tran vdout1_58ck136 FIND v(dout1_58) AT=685.025n

* CHECK dout1_59 Vdout1_59ck136 = 0 time = 685
.meas tran vdout1_59ck136 FIND v(dout1_59) AT=685.025n

* CHECK dout1_60 Vdout1_60ck136 = 0 time = 685
.meas tran vdout1_60ck136 FIND v(dout1_60) AT=685.025n

* CHECK dout1_61 Vdout1_61ck136 = 0.9 time = 685
.meas tran vdout1_61ck136 FIND v(dout1_61) AT=685.025n

* CHECK dout1_62 Vdout1_62ck136 = 0 time = 685
.meas tran vdout1_62ck136 FIND v(dout1_62) AT=685.025n

* CHECK dout1_63 Vdout1_63ck136 = 0.9 time = 685
.meas tran vdout1_63ck136 FIND v(dout1_63) AT=685.025n

* CHECK dout1_64 Vdout1_64ck136 = 0 time = 685
.meas tran vdout1_64ck136 FIND v(dout1_64) AT=685.025n

* CHECK dout1_65 Vdout1_65ck136 = 0 time = 685
.meas tran vdout1_65ck136 FIND v(dout1_65) AT=685.025n

* CHECK dout1_66 Vdout1_66ck136 = 0 time = 685
.meas tran vdout1_66ck136 FIND v(dout1_66) AT=685.025n

* CHECK dout1_67 Vdout1_67ck136 = 0.9 time = 685
.meas tran vdout1_67ck136 FIND v(dout1_67) AT=685.025n

* CHECK dout1_68 Vdout1_68ck136 = 0.9 time = 685
.meas tran vdout1_68ck136 FIND v(dout1_68) AT=685.025n

* CHECK dout1_69 Vdout1_69ck136 = 0.9 time = 685
.meas tran vdout1_69ck136 FIND v(dout1_69) AT=685.025n

* CHECK dout1_70 Vdout1_70ck136 = 0 time = 685
.meas tran vdout1_70ck136 FIND v(dout1_70) AT=685.025n

* CHECK dout1_71 Vdout1_71ck136 = 0 time = 685
.meas tran vdout1_71ck136 FIND v(dout1_71) AT=685.025n

* CHECK dout1_0 Vdout1_0ck141 = 0 time = 710
.meas tran vdout1_0ck141 FIND v(dout1_0) AT=710.025n

* CHECK dout1_1 Vdout1_1ck141 = 0.9 time = 710
.meas tran vdout1_1ck141 FIND v(dout1_1) AT=710.025n

* CHECK dout1_2 Vdout1_2ck141 = 0.9 time = 710
.meas tran vdout1_2ck141 FIND v(dout1_2) AT=710.025n

* CHECK dout1_3 Vdout1_3ck141 = 0 time = 710
.meas tran vdout1_3ck141 FIND v(dout1_3) AT=710.025n

* CHECK dout1_4 Vdout1_4ck141 = 0 time = 710
.meas tran vdout1_4ck141 FIND v(dout1_4) AT=710.025n

* CHECK dout1_5 Vdout1_5ck141 = 0.9 time = 710
.meas tran vdout1_5ck141 FIND v(dout1_5) AT=710.025n

* CHECK dout1_6 Vdout1_6ck141 = 0 time = 710
.meas tran vdout1_6ck141 FIND v(dout1_6) AT=710.025n

* CHECK dout1_7 Vdout1_7ck141 = 0.9 time = 710
.meas tran vdout1_7ck141 FIND v(dout1_7) AT=710.025n

* CHECK dout1_8 Vdout1_8ck141 = 0.9 time = 710
.meas tran vdout1_8ck141 FIND v(dout1_8) AT=710.025n

* CHECK dout1_9 Vdout1_9ck141 = 0.9 time = 710
.meas tran vdout1_9ck141 FIND v(dout1_9) AT=710.025n

* CHECK dout1_10 Vdout1_10ck141 = 0.9 time = 710
.meas tran vdout1_10ck141 FIND v(dout1_10) AT=710.025n

* CHECK dout1_11 Vdout1_11ck141 = 0.9 time = 710
.meas tran vdout1_11ck141 FIND v(dout1_11) AT=710.025n

* CHECK dout1_12 Vdout1_12ck141 = 0.9 time = 710
.meas tran vdout1_12ck141 FIND v(dout1_12) AT=710.025n

* CHECK dout1_13 Vdout1_13ck141 = 0 time = 710
.meas tran vdout1_13ck141 FIND v(dout1_13) AT=710.025n

* CHECK dout1_14 Vdout1_14ck141 = 0.9 time = 710
.meas tran vdout1_14ck141 FIND v(dout1_14) AT=710.025n

* CHECK dout1_15 Vdout1_15ck141 = 0 time = 710
.meas tran vdout1_15ck141 FIND v(dout1_15) AT=710.025n

* CHECK dout1_16 Vdout1_16ck141 = 0.9 time = 710
.meas tran vdout1_16ck141 FIND v(dout1_16) AT=710.025n

* CHECK dout1_17 Vdout1_17ck141 = 0.9 time = 710
.meas tran vdout1_17ck141 FIND v(dout1_17) AT=710.025n

* CHECK dout1_18 Vdout1_18ck141 = 0.9 time = 710
.meas tran vdout1_18ck141 FIND v(dout1_18) AT=710.025n

* CHECK dout1_19 Vdout1_19ck141 = 0 time = 710
.meas tran vdout1_19ck141 FIND v(dout1_19) AT=710.025n

* CHECK dout1_20 Vdout1_20ck141 = 0 time = 710
.meas tran vdout1_20ck141 FIND v(dout1_20) AT=710.025n

* CHECK dout1_21 Vdout1_21ck141 = 0.9 time = 710
.meas tran vdout1_21ck141 FIND v(dout1_21) AT=710.025n

* CHECK dout1_22 Vdout1_22ck141 = 0.9 time = 710
.meas tran vdout1_22ck141 FIND v(dout1_22) AT=710.025n

* CHECK dout1_23 Vdout1_23ck141 = 0.9 time = 710
.meas tran vdout1_23ck141 FIND v(dout1_23) AT=710.025n

* CHECK dout1_24 Vdout1_24ck141 = 0.9 time = 710
.meas tran vdout1_24ck141 FIND v(dout1_24) AT=710.025n

* CHECK dout1_25 Vdout1_25ck141 = 0 time = 710
.meas tran vdout1_25ck141 FIND v(dout1_25) AT=710.025n

* CHECK dout1_26 Vdout1_26ck141 = 0.9 time = 710
.meas tran vdout1_26ck141 FIND v(dout1_26) AT=710.025n

* CHECK dout1_27 Vdout1_27ck141 = 0 time = 710
.meas tran vdout1_27ck141 FIND v(dout1_27) AT=710.025n

* CHECK dout1_28 Vdout1_28ck141 = 0.9 time = 710
.meas tran vdout1_28ck141 FIND v(dout1_28) AT=710.025n

* CHECK dout1_29 Vdout1_29ck141 = 0.9 time = 710
.meas tran vdout1_29ck141 FIND v(dout1_29) AT=710.025n

* CHECK dout1_30 Vdout1_30ck141 = 0.9 time = 710
.meas tran vdout1_30ck141 FIND v(dout1_30) AT=710.025n

* CHECK dout1_31 Vdout1_31ck141 = 0 time = 710
.meas tran vdout1_31ck141 FIND v(dout1_31) AT=710.025n

* CHECK dout1_32 Vdout1_32ck141 = 0.9 time = 710
.meas tran vdout1_32ck141 FIND v(dout1_32) AT=710.025n

* CHECK dout1_33 Vdout1_33ck141 = 0.9 time = 710
.meas tran vdout1_33ck141 FIND v(dout1_33) AT=710.025n

* CHECK dout1_34 Vdout1_34ck141 = 0 time = 710
.meas tran vdout1_34ck141 FIND v(dout1_34) AT=710.025n

* CHECK dout1_35 Vdout1_35ck141 = 0 time = 710
.meas tran vdout1_35ck141 FIND v(dout1_35) AT=710.025n

* CHECK dout1_36 Vdout1_36ck141 = 0.9 time = 710
.meas tran vdout1_36ck141 FIND v(dout1_36) AT=710.025n

* CHECK dout1_37 Vdout1_37ck141 = 0.9 time = 710
.meas tran vdout1_37ck141 FIND v(dout1_37) AT=710.025n

* CHECK dout1_38 Vdout1_38ck141 = 0 time = 710
.meas tran vdout1_38ck141 FIND v(dout1_38) AT=710.025n

* CHECK dout1_39 Vdout1_39ck141 = 0 time = 710
.meas tran vdout1_39ck141 FIND v(dout1_39) AT=710.025n

* CHECK dout1_40 Vdout1_40ck141 = 0.9 time = 710
.meas tran vdout1_40ck141 FIND v(dout1_40) AT=710.025n

* CHECK dout1_41 Vdout1_41ck141 = 0.9 time = 710
.meas tran vdout1_41ck141 FIND v(dout1_41) AT=710.025n

* CHECK dout1_42 Vdout1_42ck141 = 0.9 time = 710
.meas tran vdout1_42ck141 FIND v(dout1_42) AT=710.025n

* CHECK dout1_43 Vdout1_43ck141 = 0.9 time = 710
.meas tran vdout1_43ck141 FIND v(dout1_43) AT=710.025n

* CHECK dout1_44 Vdout1_44ck141 = 0 time = 710
.meas tran vdout1_44ck141 FIND v(dout1_44) AT=710.025n

* CHECK dout1_45 Vdout1_45ck141 = 0.9 time = 710
.meas tran vdout1_45ck141 FIND v(dout1_45) AT=710.025n

* CHECK dout1_46 Vdout1_46ck141 = 0.9 time = 710
.meas tran vdout1_46ck141 FIND v(dout1_46) AT=710.025n

* CHECK dout1_47 Vdout1_47ck141 = 0 time = 710
.meas tran vdout1_47ck141 FIND v(dout1_47) AT=710.025n

* CHECK dout1_48 Vdout1_48ck141 = 0 time = 710
.meas tran vdout1_48ck141 FIND v(dout1_48) AT=710.025n

* CHECK dout1_49 Vdout1_49ck141 = 0.9 time = 710
.meas tran vdout1_49ck141 FIND v(dout1_49) AT=710.025n

* CHECK dout1_50 Vdout1_50ck141 = 0.9 time = 710
.meas tran vdout1_50ck141 FIND v(dout1_50) AT=710.025n

* CHECK dout1_51 Vdout1_51ck141 = 0.9 time = 710
.meas tran vdout1_51ck141 FIND v(dout1_51) AT=710.025n

* CHECK dout1_52 Vdout1_52ck141 = 0 time = 710
.meas tran vdout1_52ck141 FIND v(dout1_52) AT=710.025n

* CHECK dout1_53 Vdout1_53ck141 = 0 time = 710
.meas tran vdout1_53ck141 FIND v(dout1_53) AT=710.025n

* CHECK dout1_54 Vdout1_54ck141 = 0.9 time = 710
.meas tran vdout1_54ck141 FIND v(dout1_54) AT=710.025n

* CHECK dout1_55 Vdout1_55ck141 = 0.9 time = 710
.meas tran vdout1_55ck141 FIND v(dout1_55) AT=710.025n

* CHECK dout1_56 Vdout1_56ck141 = 0.9 time = 710
.meas tran vdout1_56ck141 FIND v(dout1_56) AT=710.025n

* CHECK dout1_57 Vdout1_57ck141 = 0.9 time = 710
.meas tran vdout1_57ck141 FIND v(dout1_57) AT=710.025n

* CHECK dout1_58 Vdout1_58ck141 = 0.9 time = 710
.meas tran vdout1_58ck141 FIND v(dout1_58) AT=710.025n

* CHECK dout1_59 Vdout1_59ck141 = 0.9 time = 710
.meas tran vdout1_59ck141 FIND v(dout1_59) AT=710.025n

* CHECK dout1_60 Vdout1_60ck141 = 0.9 time = 710
.meas tran vdout1_60ck141 FIND v(dout1_60) AT=710.025n

* CHECK dout1_61 Vdout1_61ck141 = 0.9 time = 710
.meas tran vdout1_61ck141 FIND v(dout1_61) AT=710.025n

* CHECK dout1_62 Vdout1_62ck141 = 0.9 time = 710
.meas tran vdout1_62ck141 FIND v(dout1_62) AT=710.025n

* CHECK dout1_63 Vdout1_63ck141 = 0 time = 710
.meas tran vdout1_63ck141 FIND v(dout1_63) AT=710.025n

* CHECK dout1_64 Vdout1_64ck141 = 0 time = 710
.meas tran vdout1_64ck141 FIND v(dout1_64) AT=710.025n

* CHECK dout1_65 Vdout1_65ck141 = 0 time = 710
.meas tran vdout1_65ck141 FIND v(dout1_65) AT=710.025n

* CHECK dout1_66 Vdout1_66ck141 = 0 time = 710
.meas tran vdout1_66ck141 FIND v(dout1_66) AT=710.025n

* CHECK dout1_67 Vdout1_67ck141 = 0 time = 710
.meas tran vdout1_67ck141 FIND v(dout1_67) AT=710.025n

* CHECK dout1_68 Vdout1_68ck141 = 0 time = 710
.meas tran vdout1_68ck141 FIND v(dout1_68) AT=710.025n

* CHECK dout1_69 Vdout1_69ck141 = 0.9 time = 710
.meas tran vdout1_69ck141 FIND v(dout1_69) AT=710.025n

* CHECK dout1_70 Vdout1_70ck141 = 0.9 time = 710
.meas tran vdout1_70ck141 FIND v(dout1_70) AT=710.025n

* CHECK dout1_71 Vdout1_71ck141 = 0 time = 710
.meas tran vdout1_71ck141 FIND v(dout1_71) AT=710.025n

* CHECK dout1_0 Vdout1_0ck146 = 0 time = 735
.meas tran vdout1_0ck146 FIND v(dout1_0) AT=735.025n

* CHECK dout1_1 Vdout1_1ck146 = 0 time = 735
.meas tran vdout1_1ck146 FIND v(dout1_1) AT=735.025n

* CHECK dout1_2 Vdout1_2ck146 = 0.9 time = 735
.meas tran vdout1_2ck146 FIND v(dout1_2) AT=735.025n

* CHECK dout1_3 Vdout1_3ck146 = 0 time = 735
.meas tran vdout1_3ck146 FIND v(dout1_3) AT=735.025n

* CHECK dout1_4 Vdout1_4ck146 = 0.9 time = 735
.meas tran vdout1_4ck146 FIND v(dout1_4) AT=735.025n

* CHECK dout1_5 Vdout1_5ck146 = 0.9 time = 735
.meas tran vdout1_5ck146 FIND v(dout1_5) AT=735.025n

* CHECK dout1_6 Vdout1_6ck146 = 0 time = 735
.meas tran vdout1_6ck146 FIND v(dout1_6) AT=735.025n

* CHECK dout1_7 Vdout1_7ck146 = 0.9 time = 735
.meas tran vdout1_7ck146 FIND v(dout1_7) AT=735.025n

* CHECK dout1_8 Vdout1_8ck146 = 0 time = 735
.meas tran vdout1_8ck146 FIND v(dout1_8) AT=735.025n

* CHECK dout1_9 Vdout1_9ck146 = 0.9 time = 735
.meas tran vdout1_9ck146 FIND v(dout1_9) AT=735.025n

* CHECK dout1_10 Vdout1_10ck146 = 0.9 time = 735
.meas tran vdout1_10ck146 FIND v(dout1_10) AT=735.025n

* CHECK dout1_11 Vdout1_11ck146 = 0 time = 735
.meas tran vdout1_11ck146 FIND v(dout1_11) AT=735.025n

* CHECK dout1_12 Vdout1_12ck146 = 0 time = 735
.meas tran vdout1_12ck146 FIND v(dout1_12) AT=735.025n

* CHECK dout1_13 Vdout1_13ck146 = 0.9 time = 735
.meas tran vdout1_13ck146 FIND v(dout1_13) AT=735.025n

* CHECK dout1_14 Vdout1_14ck146 = 0.9 time = 735
.meas tran vdout1_14ck146 FIND v(dout1_14) AT=735.025n

* CHECK dout1_15 Vdout1_15ck146 = 0 time = 735
.meas tran vdout1_15ck146 FIND v(dout1_15) AT=735.025n

* CHECK dout1_16 Vdout1_16ck146 = 0.9 time = 735
.meas tran vdout1_16ck146 FIND v(dout1_16) AT=735.025n

* CHECK dout1_17 Vdout1_17ck146 = 0.9 time = 735
.meas tran vdout1_17ck146 FIND v(dout1_17) AT=735.025n

* CHECK dout1_18 Vdout1_18ck146 = 0 time = 735
.meas tran vdout1_18ck146 FIND v(dout1_18) AT=735.025n

* CHECK dout1_19 Vdout1_19ck146 = 0 time = 735
.meas tran vdout1_19ck146 FIND v(dout1_19) AT=735.025n

* CHECK dout1_20 Vdout1_20ck146 = 0 time = 735
.meas tran vdout1_20ck146 FIND v(dout1_20) AT=735.025n

* CHECK dout1_21 Vdout1_21ck146 = 0.9 time = 735
.meas tran vdout1_21ck146 FIND v(dout1_21) AT=735.025n

* CHECK dout1_22 Vdout1_22ck146 = 0.9 time = 735
.meas tran vdout1_22ck146 FIND v(dout1_22) AT=735.025n

* CHECK dout1_23 Vdout1_23ck146 = 0.9 time = 735
.meas tran vdout1_23ck146 FIND v(dout1_23) AT=735.025n

* CHECK dout1_24 Vdout1_24ck146 = 0 time = 735
.meas tran vdout1_24ck146 FIND v(dout1_24) AT=735.025n

* CHECK dout1_25 Vdout1_25ck146 = 0 time = 735
.meas tran vdout1_25ck146 FIND v(dout1_25) AT=735.025n

* CHECK dout1_26 Vdout1_26ck146 = 0 time = 735
.meas tran vdout1_26ck146 FIND v(dout1_26) AT=735.025n

* CHECK dout1_27 Vdout1_27ck146 = 0.9 time = 735
.meas tran vdout1_27ck146 FIND v(dout1_27) AT=735.025n

* CHECK dout1_28 Vdout1_28ck146 = 0 time = 735
.meas tran vdout1_28ck146 FIND v(dout1_28) AT=735.025n

* CHECK dout1_29 Vdout1_29ck146 = 0.9 time = 735
.meas tran vdout1_29ck146 FIND v(dout1_29) AT=735.025n

* CHECK dout1_30 Vdout1_30ck146 = 0 time = 735
.meas tran vdout1_30ck146 FIND v(dout1_30) AT=735.025n

* CHECK dout1_31 Vdout1_31ck146 = 0.9 time = 735
.meas tran vdout1_31ck146 FIND v(dout1_31) AT=735.025n

* CHECK dout1_32 Vdout1_32ck146 = 0 time = 735
.meas tran vdout1_32ck146 FIND v(dout1_32) AT=735.025n

* CHECK dout1_33 Vdout1_33ck146 = 0.9 time = 735
.meas tran vdout1_33ck146 FIND v(dout1_33) AT=735.025n

* CHECK dout1_34 Vdout1_34ck146 = 0 time = 735
.meas tran vdout1_34ck146 FIND v(dout1_34) AT=735.025n

* CHECK dout1_35 Vdout1_35ck146 = 0 time = 735
.meas tran vdout1_35ck146 FIND v(dout1_35) AT=735.025n

* CHECK dout1_36 Vdout1_36ck146 = 0 time = 735
.meas tran vdout1_36ck146 FIND v(dout1_36) AT=735.025n

* CHECK dout1_37 Vdout1_37ck146 = 0 time = 735
.meas tran vdout1_37ck146 FIND v(dout1_37) AT=735.025n

* CHECK dout1_38 Vdout1_38ck146 = 0.9 time = 735
.meas tran vdout1_38ck146 FIND v(dout1_38) AT=735.025n

* CHECK dout1_39 Vdout1_39ck146 = 0 time = 735
.meas tran vdout1_39ck146 FIND v(dout1_39) AT=735.025n

* CHECK dout1_40 Vdout1_40ck146 = 0.9 time = 735
.meas tran vdout1_40ck146 FIND v(dout1_40) AT=735.025n

* CHECK dout1_41 Vdout1_41ck146 = 0.9 time = 735
.meas tran vdout1_41ck146 FIND v(dout1_41) AT=735.025n

* CHECK dout1_42 Vdout1_42ck146 = 0.9 time = 735
.meas tran vdout1_42ck146 FIND v(dout1_42) AT=735.025n

* CHECK dout1_43 Vdout1_43ck146 = 0.9 time = 735
.meas tran vdout1_43ck146 FIND v(dout1_43) AT=735.025n

* CHECK dout1_44 Vdout1_44ck146 = 0 time = 735
.meas tran vdout1_44ck146 FIND v(dout1_44) AT=735.025n

* CHECK dout1_45 Vdout1_45ck146 = 0.9 time = 735
.meas tran vdout1_45ck146 FIND v(dout1_45) AT=735.025n

* CHECK dout1_46 Vdout1_46ck146 = 0.9 time = 735
.meas tran vdout1_46ck146 FIND v(dout1_46) AT=735.025n

* CHECK dout1_47 Vdout1_47ck146 = 0 time = 735
.meas tran vdout1_47ck146 FIND v(dout1_47) AT=735.025n

* CHECK dout1_48 Vdout1_48ck146 = 0.9 time = 735
.meas tran vdout1_48ck146 FIND v(dout1_48) AT=735.025n

* CHECK dout1_49 Vdout1_49ck146 = 0.9 time = 735
.meas tran vdout1_49ck146 FIND v(dout1_49) AT=735.025n

* CHECK dout1_50 Vdout1_50ck146 = 0.9 time = 735
.meas tran vdout1_50ck146 FIND v(dout1_50) AT=735.025n

* CHECK dout1_51 Vdout1_51ck146 = 0 time = 735
.meas tran vdout1_51ck146 FIND v(dout1_51) AT=735.025n

* CHECK dout1_52 Vdout1_52ck146 = 0.9 time = 735
.meas tran vdout1_52ck146 FIND v(dout1_52) AT=735.025n

* CHECK dout1_53 Vdout1_53ck146 = 0.9 time = 735
.meas tran vdout1_53ck146 FIND v(dout1_53) AT=735.025n

* CHECK dout1_54 Vdout1_54ck146 = 0.9 time = 735
.meas tran vdout1_54ck146 FIND v(dout1_54) AT=735.025n

* CHECK dout1_55 Vdout1_55ck146 = 0 time = 735
.meas tran vdout1_55ck146 FIND v(dout1_55) AT=735.025n

* CHECK dout1_56 Vdout1_56ck146 = 0.9 time = 735
.meas tran vdout1_56ck146 FIND v(dout1_56) AT=735.025n

* CHECK dout1_57 Vdout1_57ck146 = 0 time = 735
.meas tran vdout1_57ck146 FIND v(dout1_57) AT=735.025n

* CHECK dout1_58 Vdout1_58ck146 = 0 time = 735
.meas tran vdout1_58ck146 FIND v(dout1_58) AT=735.025n

* CHECK dout1_59 Vdout1_59ck146 = 0.9 time = 735
.meas tran vdout1_59ck146 FIND v(dout1_59) AT=735.025n

* CHECK dout1_60 Vdout1_60ck146 = 0 time = 735
.meas tran vdout1_60ck146 FIND v(dout1_60) AT=735.025n

* CHECK dout1_61 Vdout1_61ck146 = 0.9 time = 735
.meas tran vdout1_61ck146 FIND v(dout1_61) AT=735.025n

* CHECK dout1_62 Vdout1_62ck146 = 0.9 time = 735
.meas tran vdout1_62ck146 FIND v(dout1_62) AT=735.025n

* CHECK dout1_63 Vdout1_63ck146 = 0.9 time = 735
.meas tran vdout1_63ck146 FIND v(dout1_63) AT=735.025n

* CHECK dout1_64 Vdout1_64ck146 = 0 time = 735
.meas tran vdout1_64ck146 FIND v(dout1_64) AT=735.025n

* CHECK dout1_65 Vdout1_65ck146 = 0 time = 735
.meas tran vdout1_65ck146 FIND v(dout1_65) AT=735.025n

* CHECK dout1_66 Vdout1_66ck146 = 0.9 time = 735
.meas tran vdout1_66ck146 FIND v(dout1_66) AT=735.025n

* CHECK dout1_67 Vdout1_67ck146 = 0 time = 735
.meas tran vdout1_67ck146 FIND v(dout1_67) AT=735.025n

* CHECK dout1_68 Vdout1_68ck146 = 0.9 time = 735
.meas tran vdout1_68ck146 FIND v(dout1_68) AT=735.025n

* CHECK dout1_69 Vdout1_69ck146 = 0 time = 735
.meas tran vdout1_69ck146 FIND v(dout1_69) AT=735.025n

* CHECK dout1_70 Vdout1_70ck146 = 0.9 time = 735
.meas tran vdout1_70ck146 FIND v(dout1_70) AT=735.025n

* CHECK dout1_71 Vdout1_71ck146 = 0.9 time = 735
.meas tran vdout1_71ck146 FIND v(dout1_71) AT=735.025n

* CHECK dout1_0 Vdout1_0ck147 = 0 time = 740
.meas tran vdout1_0ck147 FIND v(dout1_0) AT=740.025n

* CHECK dout1_1 Vdout1_1ck147 = 0 time = 740
.meas tran vdout1_1ck147 FIND v(dout1_1) AT=740.025n

* CHECK dout1_2 Vdout1_2ck147 = 0.9 time = 740
.meas tran vdout1_2ck147 FIND v(dout1_2) AT=740.025n

* CHECK dout1_3 Vdout1_3ck147 = 0 time = 740
.meas tran vdout1_3ck147 FIND v(dout1_3) AT=740.025n

* CHECK dout1_4 Vdout1_4ck147 = 0.9 time = 740
.meas tran vdout1_4ck147 FIND v(dout1_4) AT=740.025n

* CHECK dout1_5 Vdout1_5ck147 = 0.9 time = 740
.meas tran vdout1_5ck147 FIND v(dout1_5) AT=740.025n

* CHECK dout1_6 Vdout1_6ck147 = 0 time = 740
.meas tran vdout1_6ck147 FIND v(dout1_6) AT=740.025n

* CHECK dout1_7 Vdout1_7ck147 = 0.9 time = 740
.meas tran vdout1_7ck147 FIND v(dout1_7) AT=740.025n

* CHECK dout1_8 Vdout1_8ck147 = 0 time = 740
.meas tran vdout1_8ck147 FIND v(dout1_8) AT=740.025n

* CHECK dout1_9 Vdout1_9ck147 = 0.9 time = 740
.meas tran vdout1_9ck147 FIND v(dout1_9) AT=740.025n

* CHECK dout1_10 Vdout1_10ck147 = 0.9 time = 740
.meas tran vdout1_10ck147 FIND v(dout1_10) AT=740.025n

* CHECK dout1_11 Vdout1_11ck147 = 0 time = 740
.meas tran vdout1_11ck147 FIND v(dout1_11) AT=740.025n

* CHECK dout1_12 Vdout1_12ck147 = 0 time = 740
.meas tran vdout1_12ck147 FIND v(dout1_12) AT=740.025n

* CHECK dout1_13 Vdout1_13ck147 = 0.9 time = 740
.meas tran vdout1_13ck147 FIND v(dout1_13) AT=740.025n

* CHECK dout1_14 Vdout1_14ck147 = 0.9 time = 740
.meas tran vdout1_14ck147 FIND v(dout1_14) AT=740.025n

* CHECK dout1_15 Vdout1_15ck147 = 0 time = 740
.meas tran vdout1_15ck147 FIND v(dout1_15) AT=740.025n

* CHECK dout1_16 Vdout1_16ck147 = 0.9 time = 740
.meas tran vdout1_16ck147 FIND v(dout1_16) AT=740.025n

* CHECK dout1_17 Vdout1_17ck147 = 0.9 time = 740
.meas tran vdout1_17ck147 FIND v(dout1_17) AT=740.025n

* CHECK dout1_18 Vdout1_18ck147 = 0 time = 740
.meas tran vdout1_18ck147 FIND v(dout1_18) AT=740.025n

* CHECK dout1_19 Vdout1_19ck147 = 0 time = 740
.meas tran vdout1_19ck147 FIND v(dout1_19) AT=740.025n

* CHECK dout1_20 Vdout1_20ck147 = 0 time = 740
.meas tran vdout1_20ck147 FIND v(dout1_20) AT=740.025n

* CHECK dout1_21 Vdout1_21ck147 = 0.9 time = 740
.meas tran vdout1_21ck147 FIND v(dout1_21) AT=740.025n

* CHECK dout1_22 Vdout1_22ck147 = 0.9 time = 740
.meas tran vdout1_22ck147 FIND v(dout1_22) AT=740.025n

* CHECK dout1_23 Vdout1_23ck147 = 0.9 time = 740
.meas tran vdout1_23ck147 FIND v(dout1_23) AT=740.025n

* CHECK dout1_24 Vdout1_24ck147 = 0 time = 740
.meas tran vdout1_24ck147 FIND v(dout1_24) AT=740.025n

* CHECK dout1_25 Vdout1_25ck147 = 0 time = 740
.meas tran vdout1_25ck147 FIND v(dout1_25) AT=740.025n

* CHECK dout1_26 Vdout1_26ck147 = 0 time = 740
.meas tran vdout1_26ck147 FIND v(dout1_26) AT=740.025n

* CHECK dout1_27 Vdout1_27ck147 = 0.9 time = 740
.meas tran vdout1_27ck147 FIND v(dout1_27) AT=740.025n

* CHECK dout1_28 Vdout1_28ck147 = 0 time = 740
.meas tran vdout1_28ck147 FIND v(dout1_28) AT=740.025n

* CHECK dout1_29 Vdout1_29ck147 = 0.9 time = 740
.meas tran vdout1_29ck147 FIND v(dout1_29) AT=740.025n

* CHECK dout1_30 Vdout1_30ck147 = 0 time = 740
.meas tran vdout1_30ck147 FIND v(dout1_30) AT=740.025n

* CHECK dout1_31 Vdout1_31ck147 = 0.9 time = 740
.meas tran vdout1_31ck147 FIND v(dout1_31) AT=740.025n

* CHECK dout1_32 Vdout1_32ck147 = 0 time = 740
.meas tran vdout1_32ck147 FIND v(dout1_32) AT=740.025n

* CHECK dout1_33 Vdout1_33ck147 = 0.9 time = 740
.meas tran vdout1_33ck147 FIND v(dout1_33) AT=740.025n

* CHECK dout1_34 Vdout1_34ck147 = 0 time = 740
.meas tran vdout1_34ck147 FIND v(dout1_34) AT=740.025n

* CHECK dout1_35 Vdout1_35ck147 = 0 time = 740
.meas tran vdout1_35ck147 FIND v(dout1_35) AT=740.025n

* CHECK dout1_36 Vdout1_36ck147 = 0 time = 740
.meas tran vdout1_36ck147 FIND v(dout1_36) AT=740.025n

* CHECK dout1_37 Vdout1_37ck147 = 0 time = 740
.meas tran vdout1_37ck147 FIND v(dout1_37) AT=740.025n

* CHECK dout1_38 Vdout1_38ck147 = 0.9 time = 740
.meas tran vdout1_38ck147 FIND v(dout1_38) AT=740.025n

* CHECK dout1_39 Vdout1_39ck147 = 0 time = 740
.meas tran vdout1_39ck147 FIND v(dout1_39) AT=740.025n

* CHECK dout1_40 Vdout1_40ck147 = 0.9 time = 740
.meas tran vdout1_40ck147 FIND v(dout1_40) AT=740.025n

* CHECK dout1_41 Vdout1_41ck147 = 0.9 time = 740
.meas tran vdout1_41ck147 FIND v(dout1_41) AT=740.025n

* CHECK dout1_42 Vdout1_42ck147 = 0.9 time = 740
.meas tran vdout1_42ck147 FIND v(dout1_42) AT=740.025n

* CHECK dout1_43 Vdout1_43ck147 = 0.9 time = 740
.meas tran vdout1_43ck147 FIND v(dout1_43) AT=740.025n

* CHECK dout1_44 Vdout1_44ck147 = 0 time = 740
.meas tran vdout1_44ck147 FIND v(dout1_44) AT=740.025n

* CHECK dout1_45 Vdout1_45ck147 = 0.9 time = 740
.meas tran vdout1_45ck147 FIND v(dout1_45) AT=740.025n

* CHECK dout1_46 Vdout1_46ck147 = 0.9 time = 740
.meas tran vdout1_46ck147 FIND v(dout1_46) AT=740.025n

* CHECK dout1_47 Vdout1_47ck147 = 0 time = 740
.meas tran vdout1_47ck147 FIND v(dout1_47) AT=740.025n

* CHECK dout1_48 Vdout1_48ck147 = 0.9 time = 740
.meas tran vdout1_48ck147 FIND v(dout1_48) AT=740.025n

* CHECK dout1_49 Vdout1_49ck147 = 0.9 time = 740
.meas tran vdout1_49ck147 FIND v(dout1_49) AT=740.025n

* CHECK dout1_50 Vdout1_50ck147 = 0.9 time = 740
.meas tran vdout1_50ck147 FIND v(dout1_50) AT=740.025n

* CHECK dout1_51 Vdout1_51ck147 = 0 time = 740
.meas tran vdout1_51ck147 FIND v(dout1_51) AT=740.025n

* CHECK dout1_52 Vdout1_52ck147 = 0.9 time = 740
.meas tran vdout1_52ck147 FIND v(dout1_52) AT=740.025n

* CHECK dout1_53 Vdout1_53ck147 = 0.9 time = 740
.meas tran vdout1_53ck147 FIND v(dout1_53) AT=740.025n

* CHECK dout1_54 Vdout1_54ck147 = 0.9 time = 740
.meas tran vdout1_54ck147 FIND v(dout1_54) AT=740.025n

* CHECK dout1_55 Vdout1_55ck147 = 0 time = 740
.meas tran vdout1_55ck147 FIND v(dout1_55) AT=740.025n

* CHECK dout1_56 Vdout1_56ck147 = 0.9 time = 740
.meas tran vdout1_56ck147 FIND v(dout1_56) AT=740.025n

* CHECK dout1_57 Vdout1_57ck147 = 0 time = 740
.meas tran vdout1_57ck147 FIND v(dout1_57) AT=740.025n

* CHECK dout1_58 Vdout1_58ck147 = 0 time = 740
.meas tran vdout1_58ck147 FIND v(dout1_58) AT=740.025n

* CHECK dout1_59 Vdout1_59ck147 = 0.9 time = 740
.meas tran vdout1_59ck147 FIND v(dout1_59) AT=740.025n

* CHECK dout1_60 Vdout1_60ck147 = 0 time = 740
.meas tran vdout1_60ck147 FIND v(dout1_60) AT=740.025n

* CHECK dout1_61 Vdout1_61ck147 = 0.9 time = 740
.meas tran vdout1_61ck147 FIND v(dout1_61) AT=740.025n

* CHECK dout1_62 Vdout1_62ck147 = 0.9 time = 740
.meas tran vdout1_62ck147 FIND v(dout1_62) AT=740.025n

* CHECK dout1_63 Vdout1_63ck147 = 0.9 time = 740
.meas tran vdout1_63ck147 FIND v(dout1_63) AT=740.025n

* CHECK dout1_64 Vdout1_64ck147 = 0 time = 740
.meas tran vdout1_64ck147 FIND v(dout1_64) AT=740.025n

* CHECK dout1_65 Vdout1_65ck147 = 0 time = 740
.meas tran vdout1_65ck147 FIND v(dout1_65) AT=740.025n

* CHECK dout1_66 Vdout1_66ck147 = 0.9 time = 740
.meas tran vdout1_66ck147 FIND v(dout1_66) AT=740.025n

* CHECK dout1_67 Vdout1_67ck147 = 0 time = 740
.meas tran vdout1_67ck147 FIND v(dout1_67) AT=740.025n

* CHECK dout1_68 Vdout1_68ck147 = 0.9 time = 740
.meas tran vdout1_68ck147 FIND v(dout1_68) AT=740.025n

* CHECK dout1_69 Vdout1_69ck147 = 0 time = 740
.meas tran vdout1_69ck147 FIND v(dout1_69) AT=740.025n

* CHECK dout1_70 Vdout1_70ck147 = 0.9 time = 740
.meas tran vdout1_70ck147 FIND v(dout1_70) AT=740.025n

* CHECK dout1_71 Vdout1_71ck147 = 0.9 time = 740
.meas tran vdout1_71ck147 FIND v(dout1_71) AT=740.025n

* CHECK dout1_0 Vdout1_0ck152 = 0 time = 765
.meas tran vdout1_0ck152 FIND v(dout1_0) AT=765.025n

* CHECK dout1_1 Vdout1_1ck152 = 0 time = 765
.meas tran vdout1_1ck152 FIND v(dout1_1) AT=765.025n

* CHECK dout1_2 Vdout1_2ck152 = 0.9 time = 765
.meas tran vdout1_2ck152 FIND v(dout1_2) AT=765.025n

* CHECK dout1_3 Vdout1_3ck152 = 0.9 time = 765
.meas tran vdout1_3ck152 FIND v(dout1_3) AT=765.025n

* CHECK dout1_4 Vdout1_4ck152 = 0 time = 765
.meas tran vdout1_4ck152 FIND v(dout1_4) AT=765.025n

* CHECK dout1_5 Vdout1_5ck152 = 0 time = 765
.meas tran vdout1_5ck152 FIND v(dout1_5) AT=765.025n

* CHECK dout1_6 Vdout1_6ck152 = 0.9 time = 765
.meas tran vdout1_6ck152 FIND v(dout1_6) AT=765.025n

* CHECK dout1_7 Vdout1_7ck152 = 0.9 time = 765
.meas tran vdout1_7ck152 FIND v(dout1_7) AT=765.025n

* CHECK dout1_8 Vdout1_8ck152 = 0.9 time = 765
.meas tran vdout1_8ck152 FIND v(dout1_8) AT=765.025n

* CHECK dout1_9 Vdout1_9ck152 = 0 time = 765
.meas tran vdout1_9ck152 FIND v(dout1_9) AT=765.025n

* CHECK dout1_10 Vdout1_10ck152 = 0 time = 765
.meas tran vdout1_10ck152 FIND v(dout1_10) AT=765.025n

* CHECK dout1_11 Vdout1_11ck152 = 0.9 time = 765
.meas tran vdout1_11ck152 FIND v(dout1_11) AT=765.025n

* CHECK dout1_12 Vdout1_12ck152 = 0 time = 765
.meas tran vdout1_12ck152 FIND v(dout1_12) AT=765.025n

* CHECK dout1_13 Vdout1_13ck152 = 0 time = 765
.meas tran vdout1_13ck152 FIND v(dout1_13) AT=765.025n

* CHECK dout1_14 Vdout1_14ck152 = 0.9 time = 765
.meas tran vdout1_14ck152 FIND v(dout1_14) AT=765.025n

* CHECK dout1_15 Vdout1_15ck152 = 0.9 time = 765
.meas tran vdout1_15ck152 FIND v(dout1_15) AT=765.025n

* CHECK dout1_16 Vdout1_16ck152 = 0.9 time = 765
.meas tran vdout1_16ck152 FIND v(dout1_16) AT=765.025n

* CHECK dout1_17 Vdout1_17ck152 = 0.9 time = 765
.meas tran vdout1_17ck152 FIND v(dout1_17) AT=765.025n

* CHECK dout1_18 Vdout1_18ck152 = 0.9 time = 765
.meas tran vdout1_18ck152 FIND v(dout1_18) AT=765.025n

* CHECK dout1_19 Vdout1_19ck152 = 0 time = 765
.meas tran vdout1_19ck152 FIND v(dout1_19) AT=765.025n

* CHECK dout1_20 Vdout1_20ck152 = 0 time = 765
.meas tran vdout1_20ck152 FIND v(dout1_20) AT=765.025n

* CHECK dout1_21 Vdout1_21ck152 = 0.9 time = 765
.meas tran vdout1_21ck152 FIND v(dout1_21) AT=765.025n

* CHECK dout1_22 Vdout1_22ck152 = 0 time = 765
.meas tran vdout1_22ck152 FIND v(dout1_22) AT=765.025n

* CHECK dout1_23 Vdout1_23ck152 = 0 time = 765
.meas tran vdout1_23ck152 FIND v(dout1_23) AT=765.025n

* CHECK dout1_24 Vdout1_24ck152 = 0 time = 765
.meas tran vdout1_24ck152 FIND v(dout1_24) AT=765.025n

* CHECK dout1_25 Vdout1_25ck152 = 0.9 time = 765
.meas tran vdout1_25ck152 FIND v(dout1_25) AT=765.025n

* CHECK dout1_26 Vdout1_26ck152 = 0 time = 765
.meas tran vdout1_26ck152 FIND v(dout1_26) AT=765.025n

* CHECK dout1_27 Vdout1_27ck152 = 0 time = 765
.meas tran vdout1_27ck152 FIND v(dout1_27) AT=765.025n

* CHECK dout1_28 Vdout1_28ck152 = 0.9 time = 765
.meas tran vdout1_28ck152 FIND v(dout1_28) AT=765.025n

* CHECK dout1_29 Vdout1_29ck152 = 0.9 time = 765
.meas tran vdout1_29ck152 FIND v(dout1_29) AT=765.025n

* CHECK dout1_30 Vdout1_30ck152 = 0 time = 765
.meas tran vdout1_30ck152 FIND v(dout1_30) AT=765.025n

* CHECK dout1_31 Vdout1_31ck152 = 0 time = 765
.meas tran vdout1_31ck152 FIND v(dout1_31) AT=765.025n

* CHECK dout1_32 Vdout1_32ck152 = 0 time = 765
.meas tran vdout1_32ck152 FIND v(dout1_32) AT=765.025n

* CHECK dout1_33 Vdout1_33ck152 = 0 time = 765
.meas tran vdout1_33ck152 FIND v(dout1_33) AT=765.025n

* CHECK dout1_34 Vdout1_34ck152 = 0 time = 765
.meas tran vdout1_34ck152 FIND v(dout1_34) AT=765.025n

* CHECK dout1_35 Vdout1_35ck152 = 0.9 time = 765
.meas tran vdout1_35ck152 FIND v(dout1_35) AT=765.025n

* CHECK dout1_36 Vdout1_36ck152 = 0 time = 765
.meas tran vdout1_36ck152 FIND v(dout1_36) AT=765.025n

* CHECK dout1_37 Vdout1_37ck152 = 0 time = 765
.meas tran vdout1_37ck152 FIND v(dout1_37) AT=765.025n

* CHECK dout1_38 Vdout1_38ck152 = 0 time = 765
.meas tran vdout1_38ck152 FIND v(dout1_38) AT=765.025n

* CHECK dout1_39 Vdout1_39ck152 = 0.9 time = 765
.meas tran vdout1_39ck152 FIND v(dout1_39) AT=765.025n

* CHECK dout1_40 Vdout1_40ck152 = 0.9 time = 765
.meas tran vdout1_40ck152 FIND v(dout1_40) AT=765.025n

* CHECK dout1_41 Vdout1_41ck152 = 0 time = 765
.meas tran vdout1_41ck152 FIND v(dout1_41) AT=765.025n

* CHECK dout1_42 Vdout1_42ck152 = 0 time = 765
.meas tran vdout1_42ck152 FIND v(dout1_42) AT=765.025n

* CHECK dout1_43 Vdout1_43ck152 = 0.9 time = 765
.meas tran vdout1_43ck152 FIND v(dout1_43) AT=765.025n

* CHECK dout1_44 Vdout1_44ck152 = 0 time = 765
.meas tran vdout1_44ck152 FIND v(dout1_44) AT=765.025n

* CHECK dout1_45 Vdout1_45ck152 = 0 time = 765
.meas tran vdout1_45ck152 FIND v(dout1_45) AT=765.025n

* CHECK dout1_46 Vdout1_46ck152 = 0.9 time = 765
.meas tran vdout1_46ck152 FIND v(dout1_46) AT=765.025n

* CHECK dout1_47 Vdout1_47ck152 = 0 time = 765
.meas tran vdout1_47ck152 FIND v(dout1_47) AT=765.025n

* CHECK dout1_48 Vdout1_48ck152 = 0.9 time = 765
.meas tran vdout1_48ck152 FIND v(dout1_48) AT=765.025n

* CHECK dout1_49 Vdout1_49ck152 = 0 time = 765
.meas tran vdout1_49ck152 FIND v(dout1_49) AT=765.025n

* CHECK dout1_50 Vdout1_50ck152 = 0 time = 765
.meas tran vdout1_50ck152 FIND v(dout1_50) AT=765.025n

* CHECK dout1_51 Vdout1_51ck152 = 0 time = 765
.meas tran vdout1_51ck152 FIND v(dout1_51) AT=765.025n

* CHECK dout1_52 Vdout1_52ck152 = 0.9 time = 765
.meas tran vdout1_52ck152 FIND v(dout1_52) AT=765.025n

* CHECK dout1_53 Vdout1_53ck152 = 0 time = 765
.meas tran vdout1_53ck152 FIND v(dout1_53) AT=765.025n

* CHECK dout1_54 Vdout1_54ck152 = 0 time = 765
.meas tran vdout1_54ck152 FIND v(dout1_54) AT=765.025n

* CHECK dout1_55 Vdout1_55ck152 = 0.9 time = 765
.meas tran vdout1_55ck152 FIND v(dout1_55) AT=765.025n

* CHECK dout1_56 Vdout1_56ck152 = 0.9 time = 765
.meas tran vdout1_56ck152 FIND v(dout1_56) AT=765.025n

* CHECK dout1_57 Vdout1_57ck152 = 0.9 time = 765
.meas tran vdout1_57ck152 FIND v(dout1_57) AT=765.025n

* CHECK dout1_58 Vdout1_58ck152 = 0 time = 765
.meas tran vdout1_58ck152 FIND v(dout1_58) AT=765.025n

* CHECK dout1_59 Vdout1_59ck152 = 0.9 time = 765
.meas tran vdout1_59ck152 FIND v(dout1_59) AT=765.025n

* CHECK dout1_60 Vdout1_60ck152 = 0.9 time = 765
.meas tran vdout1_60ck152 FIND v(dout1_60) AT=765.025n

* CHECK dout1_61 Vdout1_61ck152 = 0 time = 765
.meas tran vdout1_61ck152 FIND v(dout1_61) AT=765.025n

* CHECK dout1_62 Vdout1_62ck152 = 0 time = 765
.meas tran vdout1_62ck152 FIND v(dout1_62) AT=765.025n

* CHECK dout1_63 Vdout1_63ck152 = 0 time = 765
.meas tran vdout1_63ck152 FIND v(dout1_63) AT=765.025n

* CHECK dout1_64 Vdout1_64ck152 = 0.9 time = 765
.meas tran vdout1_64ck152 FIND v(dout1_64) AT=765.025n

* CHECK dout1_65 Vdout1_65ck152 = 0 time = 765
.meas tran vdout1_65ck152 FIND v(dout1_65) AT=765.025n

* CHECK dout1_66 Vdout1_66ck152 = 0.9 time = 765
.meas tran vdout1_66ck152 FIND v(dout1_66) AT=765.025n

* CHECK dout1_67 Vdout1_67ck152 = 0.9 time = 765
.meas tran vdout1_67ck152 FIND v(dout1_67) AT=765.025n

* CHECK dout1_68 Vdout1_68ck152 = 0.9 time = 765
.meas tran vdout1_68ck152 FIND v(dout1_68) AT=765.025n

* CHECK dout1_69 Vdout1_69ck152 = 0 time = 765
.meas tran vdout1_69ck152 FIND v(dout1_69) AT=765.025n

* CHECK dout1_70 Vdout1_70ck152 = 0.9 time = 765
.meas tran vdout1_70ck152 FIND v(dout1_70) AT=765.025n

* CHECK dout1_71 Vdout1_71ck152 = 0.9 time = 765
.meas tran vdout1_71ck152 FIND v(dout1_71) AT=765.025n

* CHECK dout1_0 Vdout1_0ck153 = 0 time = 770
.meas tran vdout1_0ck153 FIND v(dout1_0) AT=770.025n

* CHECK dout1_1 Vdout1_1ck153 = 0 time = 770
.meas tran vdout1_1ck153 FIND v(dout1_1) AT=770.025n

* CHECK dout1_2 Vdout1_2ck153 = 0.9 time = 770
.meas tran vdout1_2ck153 FIND v(dout1_2) AT=770.025n

* CHECK dout1_3 Vdout1_3ck153 = 0 time = 770
.meas tran vdout1_3ck153 FIND v(dout1_3) AT=770.025n

* CHECK dout1_4 Vdout1_4ck153 = 0.9 time = 770
.meas tran vdout1_4ck153 FIND v(dout1_4) AT=770.025n

* CHECK dout1_5 Vdout1_5ck153 = 0 time = 770
.meas tran vdout1_5ck153 FIND v(dout1_5) AT=770.025n

* CHECK dout1_6 Vdout1_6ck153 = 0 time = 770
.meas tran vdout1_6ck153 FIND v(dout1_6) AT=770.025n

* CHECK dout1_7 Vdout1_7ck153 = 0.9 time = 770
.meas tran vdout1_7ck153 FIND v(dout1_7) AT=770.025n

* CHECK dout1_8 Vdout1_8ck153 = 0.9 time = 770
.meas tran vdout1_8ck153 FIND v(dout1_8) AT=770.025n

* CHECK dout1_9 Vdout1_9ck153 = 0 time = 770
.meas tran vdout1_9ck153 FIND v(dout1_9) AT=770.025n

* CHECK dout1_10 Vdout1_10ck153 = 0.9 time = 770
.meas tran vdout1_10ck153 FIND v(dout1_10) AT=770.025n

* CHECK dout1_11 Vdout1_11ck153 = 0.9 time = 770
.meas tran vdout1_11ck153 FIND v(dout1_11) AT=770.025n

* CHECK dout1_12 Vdout1_12ck153 = 0.9 time = 770
.meas tran vdout1_12ck153 FIND v(dout1_12) AT=770.025n

* CHECK dout1_13 Vdout1_13ck153 = 0.9 time = 770
.meas tran vdout1_13ck153 FIND v(dout1_13) AT=770.025n

* CHECK dout1_14 Vdout1_14ck153 = 0 time = 770
.meas tran vdout1_14ck153 FIND v(dout1_14) AT=770.025n

* CHECK dout1_15 Vdout1_15ck153 = 0 time = 770
.meas tran vdout1_15ck153 FIND v(dout1_15) AT=770.025n

* CHECK dout1_16 Vdout1_16ck153 = 0.9 time = 770
.meas tran vdout1_16ck153 FIND v(dout1_16) AT=770.025n

* CHECK dout1_17 Vdout1_17ck153 = 0.9 time = 770
.meas tran vdout1_17ck153 FIND v(dout1_17) AT=770.025n

* CHECK dout1_18 Vdout1_18ck153 = 0 time = 770
.meas tran vdout1_18ck153 FIND v(dout1_18) AT=770.025n

* CHECK dout1_19 Vdout1_19ck153 = 0 time = 770
.meas tran vdout1_19ck153 FIND v(dout1_19) AT=770.025n

* CHECK dout1_20 Vdout1_20ck153 = 0 time = 770
.meas tran vdout1_20ck153 FIND v(dout1_20) AT=770.025n

* CHECK dout1_21 Vdout1_21ck153 = 0.9 time = 770
.meas tran vdout1_21ck153 FIND v(dout1_21) AT=770.025n

* CHECK dout1_22 Vdout1_22ck153 = 0.9 time = 770
.meas tran vdout1_22ck153 FIND v(dout1_22) AT=770.025n

* CHECK dout1_23 Vdout1_23ck153 = 0 time = 770
.meas tran vdout1_23ck153 FIND v(dout1_23) AT=770.025n

* CHECK dout1_24 Vdout1_24ck153 = 0 time = 770
.meas tran vdout1_24ck153 FIND v(dout1_24) AT=770.025n

* CHECK dout1_25 Vdout1_25ck153 = 0 time = 770
.meas tran vdout1_25ck153 FIND v(dout1_25) AT=770.025n

* CHECK dout1_26 Vdout1_26ck153 = 0 time = 770
.meas tran vdout1_26ck153 FIND v(dout1_26) AT=770.025n

* CHECK dout1_27 Vdout1_27ck153 = 0.9 time = 770
.meas tran vdout1_27ck153 FIND v(dout1_27) AT=770.025n

* CHECK dout1_28 Vdout1_28ck153 = 0 time = 770
.meas tran vdout1_28ck153 FIND v(dout1_28) AT=770.025n

* CHECK dout1_29 Vdout1_29ck153 = 0.9 time = 770
.meas tran vdout1_29ck153 FIND v(dout1_29) AT=770.025n

* CHECK dout1_30 Vdout1_30ck153 = 0.9 time = 770
.meas tran vdout1_30ck153 FIND v(dout1_30) AT=770.025n

* CHECK dout1_31 Vdout1_31ck153 = 0.9 time = 770
.meas tran vdout1_31ck153 FIND v(dout1_31) AT=770.025n

* CHECK dout1_32 Vdout1_32ck153 = 0 time = 770
.meas tran vdout1_32ck153 FIND v(dout1_32) AT=770.025n

* CHECK dout1_33 Vdout1_33ck153 = 0.9 time = 770
.meas tran vdout1_33ck153 FIND v(dout1_33) AT=770.025n

* CHECK dout1_34 Vdout1_34ck153 = 0.9 time = 770
.meas tran vdout1_34ck153 FIND v(dout1_34) AT=770.025n

* CHECK dout1_35 Vdout1_35ck153 = 0 time = 770
.meas tran vdout1_35ck153 FIND v(dout1_35) AT=770.025n

* CHECK dout1_36 Vdout1_36ck153 = 0.9 time = 770
.meas tran vdout1_36ck153 FIND v(dout1_36) AT=770.025n

* CHECK dout1_37 Vdout1_37ck153 = 0 time = 770
.meas tran vdout1_37ck153 FIND v(dout1_37) AT=770.025n

* CHECK dout1_38 Vdout1_38ck153 = 0.9 time = 770
.meas tran vdout1_38ck153 FIND v(dout1_38) AT=770.025n

* CHECK dout1_39 Vdout1_39ck153 = 0 time = 770
.meas tran vdout1_39ck153 FIND v(dout1_39) AT=770.025n

* CHECK dout1_40 Vdout1_40ck153 = 0.9 time = 770
.meas tran vdout1_40ck153 FIND v(dout1_40) AT=770.025n

* CHECK dout1_41 Vdout1_41ck153 = 0 time = 770
.meas tran vdout1_41ck153 FIND v(dout1_41) AT=770.025n

* CHECK dout1_42 Vdout1_42ck153 = 0.9 time = 770
.meas tran vdout1_42ck153 FIND v(dout1_42) AT=770.025n

* CHECK dout1_43 Vdout1_43ck153 = 0.9 time = 770
.meas tran vdout1_43ck153 FIND v(dout1_43) AT=770.025n

* CHECK dout1_44 Vdout1_44ck153 = 0.9 time = 770
.meas tran vdout1_44ck153 FIND v(dout1_44) AT=770.025n

* CHECK dout1_45 Vdout1_45ck153 = 0 time = 770
.meas tran vdout1_45ck153 FIND v(dout1_45) AT=770.025n

* CHECK dout1_46 Vdout1_46ck153 = 0 time = 770
.meas tran vdout1_46ck153 FIND v(dout1_46) AT=770.025n

* CHECK dout1_47 Vdout1_47ck153 = 0 time = 770
.meas tran vdout1_47ck153 FIND v(dout1_47) AT=770.025n

* CHECK dout1_48 Vdout1_48ck153 = 0 time = 770
.meas tran vdout1_48ck153 FIND v(dout1_48) AT=770.025n

* CHECK dout1_49 Vdout1_49ck153 = 0 time = 770
.meas tran vdout1_49ck153 FIND v(dout1_49) AT=770.025n

* CHECK dout1_50 Vdout1_50ck153 = 0.9 time = 770
.meas tran vdout1_50ck153 FIND v(dout1_50) AT=770.025n

* CHECK dout1_51 Vdout1_51ck153 = 0.9 time = 770
.meas tran vdout1_51ck153 FIND v(dout1_51) AT=770.025n

* CHECK dout1_52 Vdout1_52ck153 = 0 time = 770
.meas tran vdout1_52ck153 FIND v(dout1_52) AT=770.025n

* CHECK dout1_53 Vdout1_53ck153 = 0 time = 770
.meas tran vdout1_53ck153 FIND v(dout1_53) AT=770.025n

* CHECK dout1_54 Vdout1_54ck153 = 0 time = 770
.meas tran vdout1_54ck153 FIND v(dout1_54) AT=770.025n

* CHECK dout1_55 Vdout1_55ck153 = 0 time = 770
.meas tran vdout1_55ck153 FIND v(dout1_55) AT=770.025n

* CHECK dout1_56 Vdout1_56ck153 = 0 time = 770
.meas tran vdout1_56ck153 FIND v(dout1_56) AT=770.025n

* CHECK dout1_57 Vdout1_57ck153 = 0 time = 770
.meas tran vdout1_57ck153 FIND v(dout1_57) AT=770.025n

* CHECK dout1_58 Vdout1_58ck153 = 0.9 time = 770
.meas tran vdout1_58ck153 FIND v(dout1_58) AT=770.025n

* CHECK dout1_59 Vdout1_59ck153 = 0 time = 770
.meas tran vdout1_59ck153 FIND v(dout1_59) AT=770.025n

* CHECK dout1_60 Vdout1_60ck153 = 0 time = 770
.meas tran vdout1_60ck153 FIND v(dout1_60) AT=770.025n

* CHECK dout1_61 Vdout1_61ck153 = 0 time = 770
.meas tran vdout1_61ck153 FIND v(dout1_61) AT=770.025n

* CHECK dout1_62 Vdout1_62ck153 = 0.9 time = 770
.meas tran vdout1_62ck153 FIND v(dout1_62) AT=770.025n

* CHECK dout1_63 Vdout1_63ck153 = 0.9 time = 770
.meas tran vdout1_63ck153 FIND v(dout1_63) AT=770.025n

* CHECK dout1_64 Vdout1_64ck153 = 0.9 time = 770
.meas tran vdout1_64ck153 FIND v(dout1_64) AT=770.025n

* CHECK dout1_65 Vdout1_65ck153 = 0 time = 770
.meas tran vdout1_65ck153 FIND v(dout1_65) AT=770.025n

* CHECK dout1_66 Vdout1_66ck153 = 0.9 time = 770
.meas tran vdout1_66ck153 FIND v(dout1_66) AT=770.025n

* CHECK dout1_67 Vdout1_67ck153 = 0.9 time = 770
.meas tran vdout1_67ck153 FIND v(dout1_67) AT=770.025n

* CHECK dout1_68 Vdout1_68ck153 = 0 time = 770
.meas tran vdout1_68ck153 FIND v(dout1_68) AT=770.025n

* CHECK dout1_69 Vdout1_69ck153 = 0.9 time = 770
.meas tran vdout1_69ck153 FIND v(dout1_69) AT=770.025n

* CHECK dout1_70 Vdout1_70ck153 = 0.9 time = 770
.meas tran vdout1_70ck153 FIND v(dout1_70) AT=770.025n

* CHECK dout1_71 Vdout1_71ck153 = 0.9 time = 770
.meas tran vdout1_71ck153 FIND v(dout1_71) AT=770.025n

* CHECK dout1_0 Vdout1_0ck155 = 0 time = 780
.meas tran vdout1_0ck155 FIND v(dout1_0) AT=780.025n

* CHECK dout1_1 Vdout1_1ck155 = 0 time = 780
.meas tran vdout1_1ck155 FIND v(dout1_1) AT=780.025n

* CHECK dout1_2 Vdout1_2ck155 = 0.9 time = 780
.meas tran vdout1_2ck155 FIND v(dout1_2) AT=780.025n

* CHECK dout1_3 Vdout1_3ck155 = 0 time = 780
.meas tran vdout1_3ck155 FIND v(dout1_3) AT=780.025n

* CHECK dout1_4 Vdout1_4ck155 = 0.9 time = 780
.meas tran vdout1_4ck155 FIND v(dout1_4) AT=780.025n

* CHECK dout1_5 Vdout1_5ck155 = 0 time = 780
.meas tran vdout1_5ck155 FIND v(dout1_5) AT=780.025n

* CHECK dout1_6 Vdout1_6ck155 = 0 time = 780
.meas tran vdout1_6ck155 FIND v(dout1_6) AT=780.025n

* CHECK dout1_7 Vdout1_7ck155 = 0.9 time = 780
.meas tran vdout1_7ck155 FIND v(dout1_7) AT=780.025n

* CHECK dout1_8 Vdout1_8ck155 = 0.9 time = 780
.meas tran vdout1_8ck155 FIND v(dout1_8) AT=780.025n

* CHECK dout1_9 Vdout1_9ck155 = 0 time = 780
.meas tran vdout1_9ck155 FIND v(dout1_9) AT=780.025n

* CHECK dout1_10 Vdout1_10ck155 = 0.9 time = 780
.meas tran vdout1_10ck155 FIND v(dout1_10) AT=780.025n

* CHECK dout1_11 Vdout1_11ck155 = 0.9 time = 780
.meas tran vdout1_11ck155 FIND v(dout1_11) AT=780.025n

* CHECK dout1_12 Vdout1_12ck155 = 0.9 time = 780
.meas tran vdout1_12ck155 FIND v(dout1_12) AT=780.025n

* CHECK dout1_13 Vdout1_13ck155 = 0.9 time = 780
.meas tran vdout1_13ck155 FIND v(dout1_13) AT=780.025n

* CHECK dout1_14 Vdout1_14ck155 = 0 time = 780
.meas tran vdout1_14ck155 FIND v(dout1_14) AT=780.025n

* CHECK dout1_15 Vdout1_15ck155 = 0 time = 780
.meas tran vdout1_15ck155 FIND v(dout1_15) AT=780.025n

* CHECK dout1_16 Vdout1_16ck155 = 0.9 time = 780
.meas tran vdout1_16ck155 FIND v(dout1_16) AT=780.025n

* CHECK dout1_17 Vdout1_17ck155 = 0.9 time = 780
.meas tran vdout1_17ck155 FIND v(dout1_17) AT=780.025n

* CHECK dout1_18 Vdout1_18ck155 = 0 time = 780
.meas tran vdout1_18ck155 FIND v(dout1_18) AT=780.025n

* CHECK dout1_19 Vdout1_19ck155 = 0 time = 780
.meas tran vdout1_19ck155 FIND v(dout1_19) AT=780.025n

* CHECK dout1_20 Vdout1_20ck155 = 0 time = 780
.meas tran vdout1_20ck155 FIND v(dout1_20) AT=780.025n

* CHECK dout1_21 Vdout1_21ck155 = 0.9 time = 780
.meas tran vdout1_21ck155 FIND v(dout1_21) AT=780.025n

* CHECK dout1_22 Vdout1_22ck155 = 0.9 time = 780
.meas tran vdout1_22ck155 FIND v(dout1_22) AT=780.025n

* CHECK dout1_23 Vdout1_23ck155 = 0 time = 780
.meas tran vdout1_23ck155 FIND v(dout1_23) AT=780.025n

* CHECK dout1_24 Vdout1_24ck155 = 0 time = 780
.meas tran vdout1_24ck155 FIND v(dout1_24) AT=780.025n

* CHECK dout1_25 Vdout1_25ck155 = 0 time = 780
.meas tran vdout1_25ck155 FIND v(dout1_25) AT=780.025n

* CHECK dout1_26 Vdout1_26ck155 = 0 time = 780
.meas tran vdout1_26ck155 FIND v(dout1_26) AT=780.025n

* CHECK dout1_27 Vdout1_27ck155 = 0.9 time = 780
.meas tran vdout1_27ck155 FIND v(dout1_27) AT=780.025n

* CHECK dout1_28 Vdout1_28ck155 = 0 time = 780
.meas tran vdout1_28ck155 FIND v(dout1_28) AT=780.025n

* CHECK dout1_29 Vdout1_29ck155 = 0.9 time = 780
.meas tran vdout1_29ck155 FIND v(dout1_29) AT=780.025n

* CHECK dout1_30 Vdout1_30ck155 = 0.9 time = 780
.meas tran vdout1_30ck155 FIND v(dout1_30) AT=780.025n

* CHECK dout1_31 Vdout1_31ck155 = 0.9 time = 780
.meas tran vdout1_31ck155 FIND v(dout1_31) AT=780.025n

* CHECK dout1_32 Vdout1_32ck155 = 0 time = 780
.meas tran vdout1_32ck155 FIND v(dout1_32) AT=780.025n

* CHECK dout1_33 Vdout1_33ck155 = 0.9 time = 780
.meas tran vdout1_33ck155 FIND v(dout1_33) AT=780.025n

* CHECK dout1_34 Vdout1_34ck155 = 0.9 time = 780
.meas tran vdout1_34ck155 FIND v(dout1_34) AT=780.025n

* CHECK dout1_35 Vdout1_35ck155 = 0 time = 780
.meas tran vdout1_35ck155 FIND v(dout1_35) AT=780.025n

* CHECK dout1_36 Vdout1_36ck155 = 0.9 time = 780
.meas tran vdout1_36ck155 FIND v(dout1_36) AT=780.025n

* CHECK dout1_37 Vdout1_37ck155 = 0 time = 780
.meas tran vdout1_37ck155 FIND v(dout1_37) AT=780.025n

* CHECK dout1_38 Vdout1_38ck155 = 0.9 time = 780
.meas tran vdout1_38ck155 FIND v(dout1_38) AT=780.025n

* CHECK dout1_39 Vdout1_39ck155 = 0 time = 780
.meas tran vdout1_39ck155 FIND v(dout1_39) AT=780.025n

* CHECK dout1_40 Vdout1_40ck155 = 0.9 time = 780
.meas tran vdout1_40ck155 FIND v(dout1_40) AT=780.025n

* CHECK dout1_41 Vdout1_41ck155 = 0 time = 780
.meas tran vdout1_41ck155 FIND v(dout1_41) AT=780.025n

* CHECK dout1_42 Vdout1_42ck155 = 0.9 time = 780
.meas tran vdout1_42ck155 FIND v(dout1_42) AT=780.025n

* CHECK dout1_43 Vdout1_43ck155 = 0.9 time = 780
.meas tran vdout1_43ck155 FIND v(dout1_43) AT=780.025n

* CHECK dout1_44 Vdout1_44ck155 = 0.9 time = 780
.meas tran vdout1_44ck155 FIND v(dout1_44) AT=780.025n

* CHECK dout1_45 Vdout1_45ck155 = 0 time = 780
.meas tran vdout1_45ck155 FIND v(dout1_45) AT=780.025n

* CHECK dout1_46 Vdout1_46ck155 = 0 time = 780
.meas tran vdout1_46ck155 FIND v(dout1_46) AT=780.025n

* CHECK dout1_47 Vdout1_47ck155 = 0 time = 780
.meas tran vdout1_47ck155 FIND v(dout1_47) AT=780.025n

* CHECK dout1_48 Vdout1_48ck155 = 0 time = 780
.meas tran vdout1_48ck155 FIND v(dout1_48) AT=780.025n

* CHECK dout1_49 Vdout1_49ck155 = 0 time = 780
.meas tran vdout1_49ck155 FIND v(dout1_49) AT=780.025n

* CHECK dout1_50 Vdout1_50ck155 = 0.9 time = 780
.meas tran vdout1_50ck155 FIND v(dout1_50) AT=780.025n

* CHECK dout1_51 Vdout1_51ck155 = 0.9 time = 780
.meas tran vdout1_51ck155 FIND v(dout1_51) AT=780.025n

* CHECK dout1_52 Vdout1_52ck155 = 0 time = 780
.meas tran vdout1_52ck155 FIND v(dout1_52) AT=780.025n

* CHECK dout1_53 Vdout1_53ck155 = 0 time = 780
.meas tran vdout1_53ck155 FIND v(dout1_53) AT=780.025n

* CHECK dout1_54 Vdout1_54ck155 = 0 time = 780
.meas tran vdout1_54ck155 FIND v(dout1_54) AT=780.025n

* CHECK dout1_55 Vdout1_55ck155 = 0 time = 780
.meas tran vdout1_55ck155 FIND v(dout1_55) AT=780.025n

* CHECK dout1_56 Vdout1_56ck155 = 0 time = 780
.meas tran vdout1_56ck155 FIND v(dout1_56) AT=780.025n

* CHECK dout1_57 Vdout1_57ck155 = 0 time = 780
.meas tran vdout1_57ck155 FIND v(dout1_57) AT=780.025n

* CHECK dout1_58 Vdout1_58ck155 = 0.9 time = 780
.meas tran vdout1_58ck155 FIND v(dout1_58) AT=780.025n

* CHECK dout1_59 Vdout1_59ck155 = 0 time = 780
.meas tran vdout1_59ck155 FIND v(dout1_59) AT=780.025n

* CHECK dout1_60 Vdout1_60ck155 = 0 time = 780
.meas tran vdout1_60ck155 FIND v(dout1_60) AT=780.025n

* CHECK dout1_61 Vdout1_61ck155 = 0 time = 780
.meas tran vdout1_61ck155 FIND v(dout1_61) AT=780.025n

* CHECK dout1_62 Vdout1_62ck155 = 0.9 time = 780
.meas tran vdout1_62ck155 FIND v(dout1_62) AT=780.025n

* CHECK dout1_63 Vdout1_63ck155 = 0.9 time = 780
.meas tran vdout1_63ck155 FIND v(dout1_63) AT=780.025n

* CHECK dout1_64 Vdout1_64ck155 = 0.9 time = 780
.meas tran vdout1_64ck155 FIND v(dout1_64) AT=780.025n

* CHECK dout1_65 Vdout1_65ck155 = 0 time = 780
.meas tran vdout1_65ck155 FIND v(dout1_65) AT=780.025n

* CHECK dout1_66 Vdout1_66ck155 = 0.9 time = 780
.meas tran vdout1_66ck155 FIND v(dout1_66) AT=780.025n

* CHECK dout1_67 Vdout1_67ck155 = 0.9 time = 780
.meas tran vdout1_67ck155 FIND v(dout1_67) AT=780.025n

* CHECK dout1_68 Vdout1_68ck155 = 0 time = 780
.meas tran vdout1_68ck155 FIND v(dout1_68) AT=780.025n

* CHECK dout1_69 Vdout1_69ck155 = 0.9 time = 780
.meas tran vdout1_69ck155 FIND v(dout1_69) AT=780.025n

* CHECK dout1_70 Vdout1_70ck155 = 0.9 time = 780
.meas tran vdout1_70ck155 FIND v(dout1_70) AT=780.025n

* CHECK dout1_71 Vdout1_71ck155 = 0.9 time = 780
.meas tran vdout1_71ck155 FIND v(dout1_71) AT=780.025n

* CHECK dout1_0 Vdout1_0ck156 = 0 time = 785
.meas tran vdout1_0ck156 FIND v(dout1_0) AT=785.025n

* CHECK dout1_1 Vdout1_1ck156 = 0 time = 785
.meas tran vdout1_1ck156 FIND v(dout1_1) AT=785.025n

* CHECK dout1_2 Vdout1_2ck156 = 0.9 time = 785
.meas tran vdout1_2ck156 FIND v(dout1_2) AT=785.025n

* CHECK dout1_3 Vdout1_3ck156 = 0 time = 785
.meas tran vdout1_3ck156 FIND v(dout1_3) AT=785.025n

* CHECK dout1_4 Vdout1_4ck156 = 0.9 time = 785
.meas tran vdout1_4ck156 FIND v(dout1_4) AT=785.025n

* CHECK dout1_5 Vdout1_5ck156 = 0 time = 785
.meas tran vdout1_5ck156 FIND v(dout1_5) AT=785.025n

* CHECK dout1_6 Vdout1_6ck156 = 0 time = 785
.meas tran vdout1_6ck156 FIND v(dout1_6) AT=785.025n

* CHECK dout1_7 Vdout1_7ck156 = 0.9 time = 785
.meas tran vdout1_7ck156 FIND v(dout1_7) AT=785.025n

* CHECK dout1_8 Vdout1_8ck156 = 0.9 time = 785
.meas tran vdout1_8ck156 FIND v(dout1_8) AT=785.025n

* CHECK dout1_9 Vdout1_9ck156 = 0 time = 785
.meas tran vdout1_9ck156 FIND v(dout1_9) AT=785.025n

* CHECK dout1_10 Vdout1_10ck156 = 0.9 time = 785
.meas tran vdout1_10ck156 FIND v(dout1_10) AT=785.025n

* CHECK dout1_11 Vdout1_11ck156 = 0.9 time = 785
.meas tran vdout1_11ck156 FIND v(dout1_11) AT=785.025n

* CHECK dout1_12 Vdout1_12ck156 = 0.9 time = 785
.meas tran vdout1_12ck156 FIND v(dout1_12) AT=785.025n

* CHECK dout1_13 Vdout1_13ck156 = 0.9 time = 785
.meas tran vdout1_13ck156 FIND v(dout1_13) AT=785.025n

* CHECK dout1_14 Vdout1_14ck156 = 0 time = 785
.meas tran vdout1_14ck156 FIND v(dout1_14) AT=785.025n

* CHECK dout1_15 Vdout1_15ck156 = 0 time = 785
.meas tran vdout1_15ck156 FIND v(dout1_15) AT=785.025n

* CHECK dout1_16 Vdout1_16ck156 = 0.9 time = 785
.meas tran vdout1_16ck156 FIND v(dout1_16) AT=785.025n

* CHECK dout1_17 Vdout1_17ck156 = 0.9 time = 785
.meas tran vdout1_17ck156 FIND v(dout1_17) AT=785.025n

* CHECK dout1_18 Vdout1_18ck156 = 0 time = 785
.meas tran vdout1_18ck156 FIND v(dout1_18) AT=785.025n

* CHECK dout1_19 Vdout1_19ck156 = 0 time = 785
.meas tran vdout1_19ck156 FIND v(dout1_19) AT=785.025n

* CHECK dout1_20 Vdout1_20ck156 = 0 time = 785
.meas tran vdout1_20ck156 FIND v(dout1_20) AT=785.025n

* CHECK dout1_21 Vdout1_21ck156 = 0.9 time = 785
.meas tran vdout1_21ck156 FIND v(dout1_21) AT=785.025n

* CHECK dout1_22 Vdout1_22ck156 = 0.9 time = 785
.meas tran vdout1_22ck156 FIND v(dout1_22) AT=785.025n

* CHECK dout1_23 Vdout1_23ck156 = 0 time = 785
.meas tran vdout1_23ck156 FIND v(dout1_23) AT=785.025n

* CHECK dout1_24 Vdout1_24ck156 = 0 time = 785
.meas tran vdout1_24ck156 FIND v(dout1_24) AT=785.025n

* CHECK dout1_25 Vdout1_25ck156 = 0 time = 785
.meas tran vdout1_25ck156 FIND v(dout1_25) AT=785.025n

* CHECK dout1_26 Vdout1_26ck156 = 0 time = 785
.meas tran vdout1_26ck156 FIND v(dout1_26) AT=785.025n

* CHECK dout1_27 Vdout1_27ck156 = 0.9 time = 785
.meas tran vdout1_27ck156 FIND v(dout1_27) AT=785.025n

* CHECK dout1_28 Vdout1_28ck156 = 0 time = 785
.meas tran vdout1_28ck156 FIND v(dout1_28) AT=785.025n

* CHECK dout1_29 Vdout1_29ck156 = 0.9 time = 785
.meas tran vdout1_29ck156 FIND v(dout1_29) AT=785.025n

* CHECK dout1_30 Vdout1_30ck156 = 0.9 time = 785
.meas tran vdout1_30ck156 FIND v(dout1_30) AT=785.025n

* CHECK dout1_31 Vdout1_31ck156 = 0.9 time = 785
.meas tran vdout1_31ck156 FIND v(dout1_31) AT=785.025n

* CHECK dout1_32 Vdout1_32ck156 = 0 time = 785
.meas tran vdout1_32ck156 FIND v(dout1_32) AT=785.025n

* CHECK dout1_33 Vdout1_33ck156 = 0.9 time = 785
.meas tran vdout1_33ck156 FIND v(dout1_33) AT=785.025n

* CHECK dout1_34 Vdout1_34ck156 = 0.9 time = 785
.meas tran vdout1_34ck156 FIND v(dout1_34) AT=785.025n

* CHECK dout1_35 Vdout1_35ck156 = 0 time = 785
.meas tran vdout1_35ck156 FIND v(dout1_35) AT=785.025n

* CHECK dout1_36 Vdout1_36ck156 = 0.9 time = 785
.meas tran vdout1_36ck156 FIND v(dout1_36) AT=785.025n

* CHECK dout1_37 Vdout1_37ck156 = 0 time = 785
.meas tran vdout1_37ck156 FIND v(dout1_37) AT=785.025n

* CHECK dout1_38 Vdout1_38ck156 = 0.9 time = 785
.meas tran vdout1_38ck156 FIND v(dout1_38) AT=785.025n

* CHECK dout1_39 Vdout1_39ck156 = 0 time = 785
.meas tran vdout1_39ck156 FIND v(dout1_39) AT=785.025n

* CHECK dout1_40 Vdout1_40ck156 = 0.9 time = 785
.meas tran vdout1_40ck156 FIND v(dout1_40) AT=785.025n

* CHECK dout1_41 Vdout1_41ck156 = 0 time = 785
.meas tran vdout1_41ck156 FIND v(dout1_41) AT=785.025n

* CHECK dout1_42 Vdout1_42ck156 = 0.9 time = 785
.meas tran vdout1_42ck156 FIND v(dout1_42) AT=785.025n

* CHECK dout1_43 Vdout1_43ck156 = 0.9 time = 785
.meas tran vdout1_43ck156 FIND v(dout1_43) AT=785.025n

* CHECK dout1_44 Vdout1_44ck156 = 0.9 time = 785
.meas tran vdout1_44ck156 FIND v(dout1_44) AT=785.025n

* CHECK dout1_45 Vdout1_45ck156 = 0 time = 785
.meas tran vdout1_45ck156 FIND v(dout1_45) AT=785.025n

* CHECK dout1_46 Vdout1_46ck156 = 0 time = 785
.meas tran vdout1_46ck156 FIND v(dout1_46) AT=785.025n

* CHECK dout1_47 Vdout1_47ck156 = 0 time = 785
.meas tran vdout1_47ck156 FIND v(dout1_47) AT=785.025n

* CHECK dout1_48 Vdout1_48ck156 = 0 time = 785
.meas tran vdout1_48ck156 FIND v(dout1_48) AT=785.025n

* CHECK dout1_49 Vdout1_49ck156 = 0 time = 785
.meas tran vdout1_49ck156 FIND v(dout1_49) AT=785.025n

* CHECK dout1_50 Vdout1_50ck156 = 0.9 time = 785
.meas tran vdout1_50ck156 FIND v(dout1_50) AT=785.025n

* CHECK dout1_51 Vdout1_51ck156 = 0.9 time = 785
.meas tran vdout1_51ck156 FIND v(dout1_51) AT=785.025n

* CHECK dout1_52 Vdout1_52ck156 = 0 time = 785
.meas tran vdout1_52ck156 FIND v(dout1_52) AT=785.025n

* CHECK dout1_53 Vdout1_53ck156 = 0 time = 785
.meas tran vdout1_53ck156 FIND v(dout1_53) AT=785.025n

* CHECK dout1_54 Vdout1_54ck156 = 0 time = 785
.meas tran vdout1_54ck156 FIND v(dout1_54) AT=785.025n

* CHECK dout1_55 Vdout1_55ck156 = 0 time = 785
.meas tran vdout1_55ck156 FIND v(dout1_55) AT=785.025n

* CHECK dout1_56 Vdout1_56ck156 = 0 time = 785
.meas tran vdout1_56ck156 FIND v(dout1_56) AT=785.025n

* CHECK dout1_57 Vdout1_57ck156 = 0 time = 785
.meas tran vdout1_57ck156 FIND v(dout1_57) AT=785.025n

* CHECK dout1_58 Vdout1_58ck156 = 0.9 time = 785
.meas tran vdout1_58ck156 FIND v(dout1_58) AT=785.025n

* CHECK dout1_59 Vdout1_59ck156 = 0 time = 785
.meas tran vdout1_59ck156 FIND v(dout1_59) AT=785.025n

* CHECK dout1_60 Vdout1_60ck156 = 0 time = 785
.meas tran vdout1_60ck156 FIND v(dout1_60) AT=785.025n

* CHECK dout1_61 Vdout1_61ck156 = 0 time = 785
.meas tran vdout1_61ck156 FIND v(dout1_61) AT=785.025n

* CHECK dout1_62 Vdout1_62ck156 = 0.9 time = 785
.meas tran vdout1_62ck156 FIND v(dout1_62) AT=785.025n

* CHECK dout1_63 Vdout1_63ck156 = 0.9 time = 785
.meas tran vdout1_63ck156 FIND v(dout1_63) AT=785.025n

* CHECK dout1_64 Vdout1_64ck156 = 0.9 time = 785
.meas tran vdout1_64ck156 FIND v(dout1_64) AT=785.025n

* CHECK dout1_65 Vdout1_65ck156 = 0 time = 785
.meas tran vdout1_65ck156 FIND v(dout1_65) AT=785.025n

* CHECK dout1_66 Vdout1_66ck156 = 0.9 time = 785
.meas tran vdout1_66ck156 FIND v(dout1_66) AT=785.025n

* CHECK dout1_67 Vdout1_67ck156 = 0.9 time = 785
.meas tran vdout1_67ck156 FIND v(dout1_67) AT=785.025n

* CHECK dout1_68 Vdout1_68ck156 = 0 time = 785
.meas tran vdout1_68ck156 FIND v(dout1_68) AT=785.025n

* CHECK dout1_69 Vdout1_69ck156 = 0.9 time = 785
.meas tran vdout1_69ck156 FIND v(dout1_69) AT=785.025n

* CHECK dout1_70 Vdout1_70ck156 = 0.9 time = 785
.meas tran vdout1_70ck156 FIND v(dout1_70) AT=785.025n

* CHECK dout1_71 Vdout1_71ck156 = 0.9 time = 785
.meas tran vdout1_71ck156 FIND v(dout1_71) AT=785.025n

* CHECK dout1_0 Vdout1_0ck157 = 0 time = 790
.meas tran vdout1_0ck157 FIND v(dout1_0) AT=790.025n

* CHECK dout1_1 Vdout1_1ck157 = 0 time = 790
.meas tran vdout1_1ck157 FIND v(dout1_1) AT=790.025n

* CHECK dout1_2 Vdout1_2ck157 = 0.9 time = 790
.meas tran vdout1_2ck157 FIND v(dout1_2) AT=790.025n

* CHECK dout1_3 Vdout1_3ck157 = 0.9 time = 790
.meas tran vdout1_3ck157 FIND v(dout1_3) AT=790.025n

* CHECK dout1_4 Vdout1_4ck157 = 0 time = 790
.meas tran vdout1_4ck157 FIND v(dout1_4) AT=790.025n

* CHECK dout1_5 Vdout1_5ck157 = 0 time = 790
.meas tran vdout1_5ck157 FIND v(dout1_5) AT=790.025n

* CHECK dout1_6 Vdout1_6ck157 = 0.9 time = 790
.meas tran vdout1_6ck157 FIND v(dout1_6) AT=790.025n

* CHECK dout1_7 Vdout1_7ck157 = 0.9 time = 790
.meas tran vdout1_7ck157 FIND v(dout1_7) AT=790.025n

* CHECK dout1_8 Vdout1_8ck157 = 0.9 time = 790
.meas tran vdout1_8ck157 FIND v(dout1_8) AT=790.025n

* CHECK dout1_9 Vdout1_9ck157 = 0 time = 790
.meas tran vdout1_9ck157 FIND v(dout1_9) AT=790.025n

* CHECK dout1_10 Vdout1_10ck157 = 0 time = 790
.meas tran vdout1_10ck157 FIND v(dout1_10) AT=790.025n

* CHECK dout1_11 Vdout1_11ck157 = 0.9 time = 790
.meas tran vdout1_11ck157 FIND v(dout1_11) AT=790.025n

* CHECK dout1_12 Vdout1_12ck157 = 0 time = 790
.meas tran vdout1_12ck157 FIND v(dout1_12) AT=790.025n

* CHECK dout1_13 Vdout1_13ck157 = 0 time = 790
.meas tran vdout1_13ck157 FIND v(dout1_13) AT=790.025n

* CHECK dout1_14 Vdout1_14ck157 = 0.9 time = 790
.meas tran vdout1_14ck157 FIND v(dout1_14) AT=790.025n

* CHECK dout1_15 Vdout1_15ck157 = 0.9 time = 790
.meas tran vdout1_15ck157 FIND v(dout1_15) AT=790.025n

* CHECK dout1_16 Vdout1_16ck157 = 0.9 time = 790
.meas tran vdout1_16ck157 FIND v(dout1_16) AT=790.025n

* CHECK dout1_17 Vdout1_17ck157 = 0.9 time = 790
.meas tran vdout1_17ck157 FIND v(dout1_17) AT=790.025n

* CHECK dout1_18 Vdout1_18ck157 = 0.9 time = 790
.meas tran vdout1_18ck157 FIND v(dout1_18) AT=790.025n

* CHECK dout1_19 Vdout1_19ck157 = 0 time = 790
.meas tran vdout1_19ck157 FIND v(dout1_19) AT=790.025n

* CHECK dout1_20 Vdout1_20ck157 = 0 time = 790
.meas tran vdout1_20ck157 FIND v(dout1_20) AT=790.025n

* CHECK dout1_21 Vdout1_21ck157 = 0.9 time = 790
.meas tran vdout1_21ck157 FIND v(dout1_21) AT=790.025n

* CHECK dout1_22 Vdout1_22ck157 = 0 time = 790
.meas tran vdout1_22ck157 FIND v(dout1_22) AT=790.025n

* CHECK dout1_23 Vdout1_23ck157 = 0 time = 790
.meas tran vdout1_23ck157 FIND v(dout1_23) AT=790.025n

* CHECK dout1_24 Vdout1_24ck157 = 0 time = 790
.meas tran vdout1_24ck157 FIND v(dout1_24) AT=790.025n

* CHECK dout1_25 Vdout1_25ck157 = 0.9 time = 790
.meas tran vdout1_25ck157 FIND v(dout1_25) AT=790.025n

* CHECK dout1_26 Vdout1_26ck157 = 0 time = 790
.meas tran vdout1_26ck157 FIND v(dout1_26) AT=790.025n

* CHECK dout1_27 Vdout1_27ck157 = 0 time = 790
.meas tran vdout1_27ck157 FIND v(dout1_27) AT=790.025n

* CHECK dout1_28 Vdout1_28ck157 = 0.9 time = 790
.meas tran vdout1_28ck157 FIND v(dout1_28) AT=790.025n

* CHECK dout1_29 Vdout1_29ck157 = 0.9 time = 790
.meas tran vdout1_29ck157 FIND v(dout1_29) AT=790.025n

* CHECK dout1_30 Vdout1_30ck157 = 0 time = 790
.meas tran vdout1_30ck157 FIND v(dout1_30) AT=790.025n

* CHECK dout1_31 Vdout1_31ck157 = 0 time = 790
.meas tran vdout1_31ck157 FIND v(dout1_31) AT=790.025n

* CHECK dout1_32 Vdout1_32ck157 = 0 time = 790
.meas tran vdout1_32ck157 FIND v(dout1_32) AT=790.025n

* CHECK dout1_33 Vdout1_33ck157 = 0 time = 790
.meas tran vdout1_33ck157 FIND v(dout1_33) AT=790.025n

* CHECK dout1_34 Vdout1_34ck157 = 0 time = 790
.meas tran vdout1_34ck157 FIND v(dout1_34) AT=790.025n

* CHECK dout1_35 Vdout1_35ck157 = 0.9 time = 790
.meas tran vdout1_35ck157 FIND v(dout1_35) AT=790.025n

* CHECK dout1_36 Vdout1_36ck157 = 0 time = 790
.meas tran vdout1_36ck157 FIND v(dout1_36) AT=790.025n

* CHECK dout1_37 Vdout1_37ck157 = 0 time = 790
.meas tran vdout1_37ck157 FIND v(dout1_37) AT=790.025n

* CHECK dout1_38 Vdout1_38ck157 = 0 time = 790
.meas tran vdout1_38ck157 FIND v(dout1_38) AT=790.025n

* CHECK dout1_39 Vdout1_39ck157 = 0.9 time = 790
.meas tran vdout1_39ck157 FIND v(dout1_39) AT=790.025n

* CHECK dout1_40 Vdout1_40ck157 = 0.9 time = 790
.meas tran vdout1_40ck157 FIND v(dout1_40) AT=790.025n

* CHECK dout1_41 Vdout1_41ck157 = 0 time = 790
.meas tran vdout1_41ck157 FIND v(dout1_41) AT=790.025n

* CHECK dout1_42 Vdout1_42ck157 = 0 time = 790
.meas tran vdout1_42ck157 FIND v(dout1_42) AT=790.025n

* CHECK dout1_43 Vdout1_43ck157 = 0.9 time = 790
.meas tran vdout1_43ck157 FIND v(dout1_43) AT=790.025n

* CHECK dout1_44 Vdout1_44ck157 = 0 time = 790
.meas tran vdout1_44ck157 FIND v(dout1_44) AT=790.025n

* CHECK dout1_45 Vdout1_45ck157 = 0 time = 790
.meas tran vdout1_45ck157 FIND v(dout1_45) AT=790.025n

* CHECK dout1_46 Vdout1_46ck157 = 0.9 time = 790
.meas tran vdout1_46ck157 FIND v(dout1_46) AT=790.025n

* CHECK dout1_47 Vdout1_47ck157 = 0 time = 790
.meas tran vdout1_47ck157 FIND v(dout1_47) AT=790.025n

* CHECK dout1_48 Vdout1_48ck157 = 0.9 time = 790
.meas tran vdout1_48ck157 FIND v(dout1_48) AT=790.025n

* CHECK dout1_49 Vdout1_49ck157 = 0 time = 790
.meas tran vdout1_49ck157 FIND v(dout1_49) AT=790.025n

* CHECK dout1_50 Vdout1_50ck157 = 0 time = 790
.meas tran vdout1_50ck157 FIND v(dout1_50) AT=790.025n

* CHECK dout1_51 Vdout1_51ck157 = 0 time = 790
.meas tran vdout1_51ck157 FIND v(dout1_51) AT=790.025n

* CHECK dout1_52 Vdout1_52ck157 = 0.9 time = 790
.meas tran vdout1_52ck157 FIND v(dout1_52) AT=790.025n

* CHECK dout1_53 Vdout1_53ck157 = 0 time = 790
.meas tran vdout1_53ck157 FIND v(dout1_53) AT=790.025n

* CHECK dout1_54 Vdout1_54ck157 = 0 time = 790
.meas tran vdout1_54ck157 FIND v(dout1_54) AT=790.025n

* CHECK dout1_55 Vdout1_55ck157 = 0.9 time = 790
.meas tran vdout1_55ck157 FIND v(dout1_55) AT=790.025n

* CHECK dout1_56 Vdout1_56ck157 = 0.9 time = 790
.meas tran vdout1_56ck157 FIND v(dout1_56) AT=790.025n

* CHECK dout1_57 Vdout1_57ck157 = 0.9 time = 790
.meas tran vdout1_57ck157 FIND v(dout1_57) AT=790.025n

* CHECK dout1_58 Vdout1_58ck157 = 0 time = 790
.meas tran vdout1_58ck157 FIND v(dout1_58) AT=790.025n

* CHECK dout1_59 Vdout1_59ck157 = 0.9 time = 790
.meas tran vdout1_59ck157 FIND v(dout1_59) AT=790.025n

* CHECK dout1_60 Vdout1_60ck157 = 0.9 time = 790
.meas tran vdout1_60ck157 FIND v(dout1_60) AT=790.025n

* CHECK dout1_61 Vdout1_61ck157 = 0 time = 790
.meas tran vdout1_61ck157 FIND v(dout1_61) AT=790.025n

* CHECK dout1_62 Vdout1_62ck157 = 0 time = 790
.meas tran vdout1_62ck157 FIND v(dout1_62) AT=790.025n

* CHECK dout1_63 Vdout1_63ck157 = 0 time = 790
.meas tran vdout1_63ck157 FIND v(dout1_63) AT=790.025n

* CHECK dout1_64 Vdout1_64ck157 = 0.9 time = 790
.meas tran vdout1_64ck157 FIND v(dout1_64) AT=790.025n

* CHECK dout1_65 Vdout1_65ck157 = 0 time = 790
.meas tran vdout1_65ck157 FIND v(dout1_65) AT=790.025n

* CHECK dout1_66 Vdout1_66ck157 = 0.9 time = 790
.meas tran vdout1_66ck157 FIND v(dout1_66) AT=790.025n

* CHECK dout1_67 Vdout1_67ck157 = 0.9 time = 790
.meas tran vdout1_67ck157 FIND v(dout1_67) AT=790.025n

* CHECK dout1_68 Vdout1_68ck157 = 0.9 time = 790
.meas tran vdout1_68ck157 FIND v(dout1_68) AT=790.025n

* CHECK dout1_69 Vdout1_69ck157 = 0 time = 790
.meas tran vdout1_69ck157 FIND v(dout1_69) AT=790.025n

* CHECK dout1_70 Vdout1_70ck157 = 0.9 time = 790
.meas tran vdout1_70ck157 FIND v(dout1_70) AT=790.025n

* CHECK dout1_71 Vdout1_71ck157 = 0.9 time = 790
.meas tran vdout1_71ck157 FIND v(dout1_71) AT=790.025n

* CHECK dout1_0 Vdout1_0ck162 = 0 time = 815
.meas tran vdout1_0ck162 FIND v(dout1_0) AT=815.025n

* CHECK dout1_1 Vdout1_1ck162 = 0 time = 815
.meas tran vdout1_1ck162 FIND v(dout1_1) AT=815.025n

* CHECK dout1_2 Vdout1_2ck162 = 0 time = 815
.meas tran vdout1_2ck162 FIND v(dout1_2) AT=815.025n

* CHECK dout1_3 Vdout1_3ck162 = 0.9 time = 815
.meas tran vdout1_3ck162 FIND v(dout1_3) AT=815.025n

* CHECK dout1_4 Vdout1_4ck162 = 0 time = 815
.meas tran vdout1_4ck162 FIND v(dout1_4) AT=815.025n

* CHECK dout1_5 Vdout1_5ck162 = 0.9 time = 815
.meas tran vdout1_5ck162 FIND v(dout1_5) AT=815.025n

* CHECK dout1_6 Vdout1_6ck162 = 0 time = 815
.meas tran vdout1_6ck162 FIND v(dout1_6) AT=815.025n

* CHECK dout1_7 Vdout1_7ck162 = 0.9 time = 815
.meas tran vdout1_7ck162 FIND v(dout1_7) AT=815.025n

* CHECK dout1_8 Vdout1_8ck162 = 0 time = 815
.meas tran vdout1_8ck162 FIND v(dout1_8) AT=815.025n

* CHECK dout1_9 Vdout1_9ck162 = 0.9 time = 815
.meas tran vdout1_9ck162 FIND v(dout1_9) AT=815.025n

* CHECK dout1_10 Vdout1_10ck162 = 0 time = 815
.meas tran vdout1_10ck162 FIND v(dout1_10) AT=815.025n

* CHECK dout1_11 Vdout1_11ck162 = 0 time = 815
.meas tran vdout1_11ck162 FIND v(dout1_11) AT=815.025n

* CHECK dout1_12 Vdout1_12ck162 = 0.9 time = 815
.meas tran vdout1_12ck162 FIND v(dout1_12) AT=815.025n

* CHECK dout1_13 Vdout1_13ck162 = 0 time = 815
.meas tran vdout1_13ck162 FIND v(dout1_13) AT=815.025n

* CHECK dout1_14 Vdout1_14ck162 = 0.9 time = 815
.meas tran vdout1_14ck162 FIND v(dout1_14) AT=815.025n

* CHECK dout1_15 Vdout1_15ck162 = 0.9 time = 815
.meas tran vdout1_15ck162 FIND v(dout1_15) AT=815.025n

* CHECK dout1_16 Vdout1_16ck162 = 0 time = 815
.meas tran vdout1_16ck162 FIND v(dout1_16) AT=815.025n

* CHECK dout1_17 Vdout1_17ck162 = 0.9 time = 815
.meas tran vdout1_17ck162 FIND v(dout1_17) AT=815.025n

* CHECK dout1_18 Vdout1_18ck162 = 0.9 time = 815
.meas tran vdout1_18ck162 FIND v(dout1_18) AT=815.025n

* CHECK dout1_19 Vdout1_19ck162 = 0.9 time = 815
.meas tran vdout1_19ck162 FIND v(dout1_19) AT=815.025n

* CHECK dout1_20 Vdout1_20ck162 = 0.9 time = 815
.meas tran vdout1_20ck162 FIND v(dout1_20) AT=815.025n

* CHECK dout1_21 Vdout1_21ck162 = 0.9 time = 815
.meas tran vdout1_21ck162 FIND v(dout1_21) AT=815.025n

* CHECK dout1_22 Vdout1_22ck162 = 0 time = 815
.meas tran vdout1_22ck162 FIND v(dout1_22) AT=815.025n

* CHECK dout1_23 Vdout1_23ck162 = 0 time = 815
.meas tran vdout1_23ck162 FIND v(dout1_23) AT=815.025n

* CHECK dout1_24 Vdout1_24ck162 = 0 time = 815
.meas tran vdout1_24ck162 FIND v(dout1_24) AT=815.025n

* CHECK dout1_25 Vdout1_25ck162 = 0 time = 815
.meas tran vdout1_25ck162 FIND v(dout1_25) AT=815.025n

* CHECK dout1_26 Vdout1_26ck162 = 0.9 time = 815
.meas tran vdout1_26ck162 FIND v(dout1_26) AT=815.025n

* CHECK dout1_27 Vdout1_27ck162 = 0 time = 815
.meas tran vdout1_27ck162 FIND v(dout1_27) AT=815.025n

* CHECK dout1_28 Vdout1_28ck162 = 0.9 time = 815
.meas tran vdout1_28ck162 FIND v(dout1_28) AT=815.025n

* CHECK dout1_29 Vdout1_29ck162 = 0 time = 815
.meas tran vdout1_29ck162 FIND v(dout1_29) AT=815.025n

* CHECK dout1_30 Vdout1_30ck162 = 0 time = 815
.meas tran vdout1_30ck162 FIND v(dout1_30) AT=815.025n

* CHECK dout1_31 Vdout1_31ck162 = 0 time = 815
.meas tran vdout1_31ck162 FIND v(dout1_31) AT=815.025n

* CHECK dout1_32 Vdout1_32ck162 = 0 time = 815
.meas tran vdout1_32ck162 FIND v(dout1_32) AT=815.025n

* CHECK dout1_33 Vdout1_33ck162 = 0 time = 815
.meas tran vdout1_33ck162 FIND v(dout1_33) AT=815.025n

* CHECK dout1_34 Vdout1_34ck162 = 0.9 time = 815
.meas tran vdout1_34ck162 FIND v(dout1_34) AT=815.025n

* CHECK dout1_35 Vdout1_35ck162 = 0 time = 815
.meas tran vdout1_35ck162 FIND v(dout1_35) AT=815.025n

* CHECK dout1_36 Vdout1_36ck162 = 0.9 time = 815
.meas tran vdout1_36ck162 FIND v(dout1_36) AT=815.025n

* CHECK dout1_37 Vdout1_37ck162 = 0.9 time = 815
.meas tran vdout1_37ck162 FIND v(dout1_37) AT=815.025n

* CHECK dout1_38 Vdout1_38ck162 = 0.9 time = 815
.meas tran vdout1_38ck162 FIND v(dout1_38) AT=815.025n

* CHECK dout1_39 Vdout1_39ck162 = 0 time = 815
.meas tran vdout1_39ck162 FIND v(dout1_39) AT=815.025n

* CHECK dout1_40 Vdout1_40ck162 = 0.9 time = 815
.meas tran vdout1_40ck162 FIND v(dout1_40) AT=815.025n

* CHECK dout1_41 Vdout1_41ck162 = 0 time = 815
.meas tran vdout1_41ck162 FIND v(dout1_41) AT=815.025n

* CHECK dout1_42 Vdout1_42ck162 = 0.9 time = 815
.meas tran vdout1_42ck162 FIND v(dout1_42) AT=815.025n

* CHECK dout1_43 Vdout1_43ck162 = 0 time = 815
.meas tran vdout1_43ck162 FIND v(dout1_43) AT=815.025n

* CHECK dout1_44 Vdout1_44ck162 = 0 time = 815
.meas tran vdout1_44ck162 FIND v(dout1_44) AT=815.025n

* CHECK dout1_45 Vdout1_45ck162 = 0.9 time = 815
.meas tran vdout1_45ck162 FIND v(dout1_45) AT=815.025n

* CHECK dout1_46 Vdout1_46ck162 = 0.9 time = 815
.meas tran vdout1_46ck162 FIND v(dout1_46) AT=815.025n

* CHECK dout1_47 Vdout1_47ck162 = 0.9 time = 815
.meas tran vdout1_47ck162 FIND v(dout1_47) AT=815.025n

* CHECK dout1_48 Vdout1_48ck162 = 0 time = 815
.meas tran vdout1_48ck162 FIND v(dout1_48) AT=815.025n

* CHECK dout1_49 Vdout1_49ck162 = 0.9 time = 815
.meas tran vdout1_49ck162 FIND v(dout1_49) AT=815.025n

* CHECK dout1_50 Vdout1_50ck162 = 0.9 time = 815
.meas tran vdout1_50ck162 FIND v(dout1_50) AT=815.025n

* CHECK dout1_51 Vdout1_51ck162 = 0 time = 815
.meas tran vdout1_51ck162 FIND v(dout1_51) AT=815.025n

* CHECK dout1_52 Vdout1_52ck162 = 0 time = 815
.meas tran vdout1_52ck162 FIND v(dout1_52) AT=815.025n

* CHECK dout1_53 Vdout1_53ck162 = 0.9 time = 815
.meas tran vdout1_53ck162 FIND v(dout1_53) AT=815.025n

* CHECK dout1_54 Vdout1_54ck162 = 0 time = 815
.meas tran vdout1_54ck162 FIND v(dout1_54) AT=815.025n

* CHECK dout1_55 Vdout1_55ck162 = 0 time = 815
.meas tran vdout1_55ck162 FIND v(dout1_55) AT=815.025n

* CHECK dout1_56 Vdout1_56ck162 = 0.9 time = 815
.meas tran vdout1_56ck162 FIND v(dout1_56) AT=815.025n

* CHECK dout1_57 Vdout1_57ck162 = 0 time = 815
.meas tran vdout1_57ck162 FIND v(dout1_57) AT=815.025n

* CHECK dout1_58 Vdout1_58ck162 = 0.9 time = 815
.meas tran vdout1_58ck162 FIND v(dout1_58) AT=815.025n

* CHECK dout1_59 Vdout1_59ck162 = 0.9 time = 815
.meas tran vdout1_59ck162 FIND v(dout1_59) AT=815.025n

* CHECK dout1_60 Vdout1_60ck162 = 0.9 time = 815
.meas tran vdout1_60ck162 FIND v(dout1_60) AT=815.025n

* CHECK dout1_61 Vdout1_61ck162 = 0.9 time = 815
.meas tran vdout1_61ck162 FIND v(dout1_61) AT=815.025n

* CHECK dout1_62 Vdout1_62ck162 = 0 time = 815
.meas tran vdout1_62ck162 FIND v(dout1_62) AT=815.025n

* CHECK dout1_63 Vdout1_63ck162 = 0.9 time = 815
.meas tran vdout1_63ck162 FIND v(dout1_63) AT=815.025n

* CHECK dout1_64 Vdout1_64ck162 = 0 time = 815
.meas tran vdout1_64ck162 FIND v(dout1_64) AT=815.025n

* CHECK dout1_65 Vdout1_65ck162 = 0 time = 815
.meas tran vdout1_65ck162 FIND v(dout1_65) AT=815.025n

* CHECK dout1_66 Vdout1_66ck162 = 0.9 time = 815
.meas tran vdout1_66ck162 FIND v(dout1_66) AT=815.025n

* CHECK dout1_67 Vdout1_67ck162 = 0.9 time = 815
.meas tran vdout1_67ck162 FIND v(dout1_67) AT=815.025n

* CHECK dout1_68 Vdout1_68ck162 = 0 time = 815
.meas tran vdout1_68ck162 FIND v(dout1_68) AT=815.025n

* CHECK dout1_69 Vdout1_69ck162 = 0 time = 815
.meas tran vdout1_69ck162 FIND v(dout1_69) AT=815.025n

* CHECK dout1_70 Vdout1_70ck162 = 0.9 time = 815
.meas tran vdout1_70ck162 FIND v(dout1_70) AT=815.025n

* CHECK dout1_71 Vdout1_71ck162 = 0 time = 815
.meas tran vdout1_71ck162 FIND v(dout1_71) AT=815.025n

* CHECK dout1_0 Vdout1_0ck163 = 0.9 time = 820
.meas tran vdout1_0ck163 FIND v(dout1_0) AT=820.025n

* CHECK dout1_1 Vdout1_1ck163 = 0 time = 820
.meas tran vdout1_1ck163 FIND v(dout1_1) AT=820.025n

* CHECK dout1_2 Vdout1_2ck163 = 0.9 time = 820
.meas tran vdout1_2ck163 FIND v(dout1_2) AT=820.025n

* CHECK dout1_3 Vdout1_3ck163 = 0.9 time = 820
.meas tran vdout1_3ck163 FIND v(dout1_3) AT=820.025n

* CHECK dout1_4 Vdout1_4ck163 = 0 time = 820
.meas tran vdout1_4ck163 FIND v(dout1_4) AT=820.025n

* CHECK dout1_5 Vdout1_5ck163 = 0 time = 820
.meas tran vdout1_5ck163 FIND v(dout1_5) AT=820.025n

* CHECK dout1_6 Vdout1_6ck163 = 0 time = 820
.meas tran vdout1_6ck163 FIND v(dout1_6) AT=820.025n

* CHECK dout1_7 Vdout1_7ck163 = 0.9 time = 820
.meas tran vdout1_7ck163 FIND v(dout1_7) AT=820.025n

* CHECK dout1_8 Vdout1_8ck163 = 0.9 time = 820
.meas tran vdout1_8ck163 FIND v(dout1_8) AT=820.025n

* CHECK dout1_9 Vdout1_9ck163 = 0 time = 820
.meas tran vdout1_9ck163 FIND v(dout1_9) AT=820.025n

* CHECK dout1_10 Vdout1_10ck163 = 0.9 time = 820
.meas tran vdout1_10ck163 FIND v(dout1_10) AT=820.025n

* CHECK dout1_11 Vdout1_11ck163 = 0.9 time = 820
.meas tran vdout1_11ck163 FIND v(dout1_11) AT=820.025n

* CHECK dout1_12 Vdout1_12ck163 = 0.9 time = 820
.meas tran vdout1_12ck163 FIND v(dout1_12) AT=820.025n

* CHECK dout1_13 Vdout1_13ck163 = 0.9 time = 820
.meas tran vdout1_13ck163 FIND v(dout1_13) AT=820.025n

* CHECK dout1_14 Vdout1_14ck163 = 0 time = 820
.meas tran vdout1_14ck163 FIND v(dout1_14) AT=820.025n

* CHECK dout1_15 Vdout1_15ck163 = 0.9 time = 820
.meas tran vdout1_15ck163 FIND v(dout1_15) AT=820.025n

* CHECK dout1_16 Vdout1_16ck163 = 0 time = 820
.meas tran vdout1_16ck163 FIND v(dout1_16) AT=820.025n

* CHECK dout1_17 Vdout1_17ck163 = 0.9 time = 820
.meas tran vdout1_17ck163 FIND v(dout1_17) AT=820.025n

* CHECK dout1_18 Vdout1_18ck163 = 0.9 time = 820
.meas tran vdout1_18ck163 FIND v(dout1_18) AT=820.025n

* CHECK dout1_19 Vdout1_19ck163 = 0.9 time = 820
.meas tran vdout1_19ck163 FIND v(dout1_19) AT=820.025n

* CHECK dout1_20 Vdout1_20ck163 = 0.9 time = 820
.meas tran vdout1_20ck163 FIND v(dout1_20) AT=820.025n

* CHECK dout1_21 Vdout1_21ck163 = 0 time = 820
.meas tran vdout1_21ck163 FIND v(dout1_21) AT=820.025n

* CHECK dout1_22 Vdout1_22ck163 = 0.9 time = 820
.meas tran vdout1_22ck163 FIND v(dout1_22) AT=820.025n

* CHECK dout1_23 Vdout1_23ck163 = 0.9 time = 820
.meas tran vdout1_23ck163 FIND v(dout1_23) AT=820.025n

* CHECK dout1_24 Vdout1_24ck163 = 0 time = 820
.meas tran vdout1_24ck163 FIND v(dout1_24) AT=820.025n

* CHECK dout1_25 Vdout1_25ck163 = 0 time = 820
.meas tran vdout1_25ck163 FIND v(dout1_25) AT=820.025n

* CHECK dout1_26 Vdout1_26ck163 = 0.9 time = 820
.meas tran vdout1_26ck163 FIND v(dout1_26) AT=820.025n

* CHECK dout1_27 Vdout1_27ck163 = 0.9 time = 820
.meas tran vdout1_27ck163 FIND v(dout1_27) AT=820.025n

* CHECK dout1_28 Vdout1_28ck163 = 0 time = 820
.meas tran vdout1_28ck163 FIND v(dout1_28) AT=820.025n

* CHECK dout1_29 Vdout1_29ck163 = 0.9 time = 820
.meas tran vdout1_29ck163 FIND v(dout1_29) AT=820.025n

* CHECK dout1_30 Vdout1_30ck163 = 0.9 time = 820
.meas tran vdout1_30ck163 FIND v(dout1_30) AT=820.025n

* CHECK dout1_31 Vdout1_31ck163 = 0 time = 820
.meas tran vdout1_31ck163 FIND v(dout1_31) AT=820.025n

* CHECK dout1_32 Vdout1_32ck163 = 0 time = 820
.meas tran vdout1_32ck163 FIND v(dout1_32) AT=820.025n

* CHECK dout1_33 Vdout1_33ck163 = 0 time = 820
.meas tran vdout1_33ck163 FIND v(dout1_33) AT=820.025n

* CHECK dout1_34 Vdout1_34ck163 = 0 time = 820
.meas tran vdout1_34ck163 FIND v(dout1_34) AT=820.025n

* CHECK dout1_35 Vdout1_35ck163 = 0.9 time = 820
.meas tran vdout1_35ck163 FIND v(dout1_35) AT=820.025n

* CHECK dout1_36 Vdout1_36ck163 = 0 time = 820
.meas tran vdout1_36ck163 FIND v(dout1_36) AT=820.025n

* CHECK dout1_37 Vdout1_37ck163 = 0 time = 820
.meas tran vdout1_37ck163 FIND v(dout1_37) AT=820.025n

* CHECK dout1_38 Vdout1_38ck163 = 0 time = 820
.meas tran vdout1_38ck163 FIND v(dout1_38) AT=820.025n

* CHECK dout1_39 Vdout1_39ck163 = 0 time = 820
.meas tran vdout1_39ck163 FIND v(dout1_39) AT=820.025n

* CHECK dout1_40 Vdout1_40ck163 = 0 time = 820
.meas tran vdout1_40ck163 FIND v(dout1_40) AT=820.025n

* CHECK dout1_41 Vdout1_41ck163 = 0.9 time = 820
.meas tran vdout1_41ck163 FIND v(dout1_41) AT=820.025n

* CHECK dout1_42 Vdout1_42ck163 = 0.9 time = 820
.meas tran vdout1_42ck163 FIND v(dout1_42) AT=820.025n

* CHECK dout1_43 Vdout1_43ck163 = 0.9 time = 820
.meas tran vdout1_43ck163 FIND v(dout1_43) AT=820.025n

* CHECK dout1_44 Vdout1_44ck163 = 0 time = 820
.meas tran vdout1_44ck163 FIND v(dout1_44) AT=820.025n

* CHECK dout1_45 Vdout1_45ck163 = 0.9 time = 820
.meas tran vdout1_45ck163 FIND v(dout1_45) AT=820.025n

* CHECK dout1_46 Vdout1_46ck163 = 0.9 time = 820
.meas tran vdout1_46ck163 FIND v(dout1_46) AT=820.025n

* CHECK dout1_47 Vdout1_47ck163 = 0.9 time = 820
.meas tran vdout1_47ck163 FIND v(dout1_47) AT=820.025n

* CHECK dout1_48 Vdout1_48ck163 = 0 time = 820
.meas tran vdout1_48ck163 FIND v(dout1_48) AT=820.025n

* CHECK dout1_49 Vdout1_49ck163 = 0 time = 820
.meas tran vdout1_49ck163 FIND v(dout1_49) AT=820.025n

* CHECK dout1_50 Vdout1_50ck163 = 0.9 time = 820
.meas tran vdout1_50ck163 FIND v(dout1_50) AT=820.025n

* CHECK dout1_51 Vdout1_51ck163 = 0 time = 820
.meas tran vdout1_51ck163 FIND v(dout1_51) AT=820.025n

* CHECK dout1_52 Vdout1_52ck163 = 0 time = 820
.meas tran vdout1_52ck163 FIND v(dout1_52) AT=820.025n

* CHECK dout1_53 Vdout1_53ck163 = 0.9 time = 820
.meas tran vdout1_53ck163 FIND v(dout1_53) AT=820.025n

* CHECK dout1_54 Vdout1_54ck163 = 0 time = 820
.meas tran vdout1_54ck163 FIND v(dout1_54) AT=820.025n

* CHECK dout1_55 Vdout1_55ck163 = 0.9 time = 820
.meas tran vdout1_55ck163 FIND v(dout1_55) AT=820.025n

* CHECK dout1_56 Vdout1_56ck163 = 0 time = 820
.meas tran vdout1_56ck163 FIND v(dout1_56) AT=820.025n

* CHECK dout1_57 Vdout1_57ck163 = 0.9 time = 820
.meas tran vdout1_57ck163 FIND v(dout1_57) AT=820.025n

* CHECK dout1_58 Vdout1_58ck163 = 0.9 time = 820
.meas tran vdout1_58ck163 FIND v(dout1_58) AT=820.025n

* CHECK dout1_59 Vdout1_59ck163 = 0 time = 820
.meas tran vdout1_59ck163 FIND v(dout1_59) AT=820.025n

* CHECK dout1_60 Vdout1_60ck163 = 0.9 time = 820
.meas tran vdout1_60ck163 FIND v(dout1_60) AT=820.025n

* CHECK dout1_61 Vdout1_61ck163 = 0.9 time = 820
.meas tran vdout1_61ck163 FIND v(dout1_61) AT=820.025n

* CHECK dout1_62 Vdout1_62ck163 = 0 time = 820
.meas tran vdout1_62ck163 FIND v(dout1_62) AT=820.025n

* CHECK dout1_63 Vdout1_63ck163 = 0.9 time = 820
.meas tran vdout1_63ck163 FIND v(dout1_63) AT=820.025n

* CHECK dout1_64 Vdout1_64ck163 = 0.9 time = 820
.meas tran vdout1_64ck163 FIND v(dout1_64) AT=820.025n

* CHECK dout1_65 Vdout1_65ck163 = 0.9 time = 820
.meas tran vdout1_65ck163 FIND v(dout1_65) AT=820.025n

* CHECK dout1_66 Vdout1_66ck163 = 0.9 time = 820
.meas tran vdout1_66ck163 FIND v(dout1_66) AT=820.025n

* CHECK dout1_67 Vdout1_67ck163 = 0.9 time = 820
.meas tran vdout1_67ck163 FIND v(dout1_67) AT=820.025n

* CHECK dout1_68 Vdout1_68ck163 = 0 time = 820
.meas tran vdout1_68ck163 FIND v(dout1_68) AT=820.025n

* CHECK dout1_69 Vdout1_69ck163 = 0.9 time = 820
.meas tran vdout1_69ck163 FIND v(dout1_69) AT=820.025n

* CHECK dout1_70 Vdout1_70ck163 = 0.9 time = 820
.meas tran vdout1_70ck163 FIND v(dout1_70) AT=820.025n

* CHECK dout1_71 Vdout1_71ck163 = 0 time = 820
.meas tran vdout1_71ck163 FIND v(dout1_71) AT=820.025n

* CHECK dout1_0 Vdout1_0ck164 = 0.9 time = 825
.meas tran vdout1_0ck164 FIND v(dout1_0) AT=825.025n

* CHECK dout1_1 Vdout1_1ck164 = 0 time = 825
.meas tran vdout1_1ck164 FIND v(dout1_1) AT=825.025n

* CHECK dout1_2 Vdout1_2ck164 = 0.9 time = 825
.meas tran vdout1_2ck164 FIND v(dout1_2) AT=825.025n

* CHECK dout1_3 Vdout1_3ck164 = 0.9 time = 825
.meas tran vdout1_3ck164 FIND v(dout1_3) AT=825.025n

* CHECK dout1_4 Vdout1_4ck164 = 0 time = 825
.meas tran vdout1_4ck164 FIND v(dout1_4) AT=825.025n

* CHECK dout1_5 Vdout1_5ck164 = 0 time = 825
.meas tran vdout1_5ck164 FIND v(dout1_5) AT=825.025n

* CHECK dout1_6 Vdout1_6ck164 = 0 time = 825
.meas tran vdout1_6ck164 FIND v(dout1_6) AT=825.025n

* CHECK dout1_7 Vdout1_7ck164 = 0.9 time = 825
.meas tran vdout1_7ck164 FIND v(dout1_7) AT=825.025n

* CHECK dout1_8 Vdout1_8ck164 = 0.9 time = 825
.meas tran vdout1_8ck164 FIND v(dout1_8) AT=825.025n

* CHECK dout1_9 Vdout1_9ck164 = 0 time = 825
.meas tran vdout1_9ck164 FIND v(dout1_9) AT=825.025n

* CHECK dout1_10 Vdout1_10ck164 = 0.9 time = 825
.meas tran vdout1_10ck164 FIND v(dout1_10) AT=825.025n

* CHECK dout1_11 Vdout1_11ck164 = 0.9 time = 825
.meas tran vdout1_11ck164 FIND v(dout1_11) AT=825.025n

* CHECK dout1_12 Vdout1_12ck164 = 0.9 time = 825
.meas tran vdout1_12ck164 FIND v(dout1_12) AT=825.025n

* CHECK dout1_13 Vdout1_13ck164 = 0.9 time = 825
.meas tran vdout1_13ck164 FIND v(dout1_13) AT=825.025n

* CHECK dout1_14 Vdout1_14ck164 = 0 time = 825
.meas tran vdout1_14ck164 FIND v(dout1_14) AT=825.025n

* CHECK dout1_15 Vdout1_15ck164 = 0.9 time = 825
.meas tran vdout1_15ck164 FIND v(dout1_15) AT=825.025n

* CHECK dout1_16 Vdout1_16ck164 = 0 time = 825
.meas tran vdout1_16ck164 FIND v(dout1_16) AT=825.025n

* CHECK dout1_17 Vdout1_17ck164 = 0.9 time = 825
.meas tran vdout1_17ck164 FIND v(dout1_17) AT=825.025n

* CHECK dout1_18 Vdout1_18ck164 = 0.9 time = 825
.meas tran vdout1_18ck164 FIND v(dout1_18) AT=825.025n

* CHECK dout1_19 Vdout1_19ck164 = 0.9 time = 825
.meas tran vdout1_19ck164 FIND v(dout1_19) AT=825.025n

* CHECK dout1_20 Vdout1_20ck164 = 0.9 time = 825
.meas tran vdout1_20ck164 FIND v(dout1_20) AT=825.025n

* CHECK dout1_21 Vdout1_21ck164 = 0 time = 825
.meas tran vdout1_21ck164 FIND v(dout1_21) AT=825.025n

* CHECK dout1_22 Vdout1_22ck164 = 0.9 time = 825
.meas tran vdout1_22ck164 FIND v(dout1_22) AT=825.025n

* CHECK dout1_23 Vdout1_23ck164 = 0.9 time = 825
.meas tran vdout1_23ck164 FIND v(dout1_23) AT=825.025n

* CHECK dout1_24 Vdout1_24ck164 = 0 time = 825
.meas tran vdout1_24ck164 FIND v(dout1_24) AT=825.025n

* CHECK dout1_25 Vdout1_25ck164 = 0 time = 825
.meas tran vdout1_25ck164 FIND v(dout1_25) AT=825.025n

* CHECK dout1_26 Vdout1_26ck164 = 0.9 time = 825
.meas tran vdout1_26ck164 FIND v(dout1_26) AT=825.025n

* CHECK dout1_27 Vdout1_27ck164 = 0.9 time = 825
.meas tran vdout1_27ck164 FIND v(dout1_27) AT=825.025n

* CHECK dout1_28 Vdout1_28ck164 = 0 time = 825
.meas tran vdout1_28ck164 FIND v(dout1_28) AT=825.025n

* CHECK dout1_29 Vdout1_29ck164 = 0.9 time = 825
.meas tran vdout1_29ck164 FIND v(dout1_29) AT=825.025n

* CHECK dout1_30 Vdout1_30ck164 = 0.9 time = 825
.meas tran vdout1_30ck164 FIND v(dout1_30) AT=825.025n

* CHECK dout1_31 Vdout1_31ck164 = 0 time = 825
.meas tran vdout1_31ck164 FIND v(dout1_31) AT=825.025n

* CHECK dout1_32 Vdout1_32ck164 = 0 time = 825
.meas tran vdout1_32ck164 FIND v(dout1_32) AT=825.025n

* CHECK dout1_33 Vdout1_33ck164 = 0 time = 825
.meas tran vdout1_33ck164 FIND v(dout1_33) AT=825.025n

* CHECK dout1_34 Vdout1_34ck164 = 0 time = 825
.meas tran vdout1_34ck164 FIND v(dout1_34) AT=825.025n

* CHECK dout1_35 Vdout1_35ck164 = 0.9 time = 825
.meas tran vdout1_35ck164 FIND v(dout1_35) AT=825.025n

* CHECK dout1_36 Vdout1_36ck164 = 0 time = 825
.meas tran vdout1_36ck164 FIND v(dout1_36) AT=825.025n

* CHECK dout1_37 Vdout1_37ck164 = 0 time = 825
.meas tran vdout1_37ck164 FIND v(dout1_37) AT=825.025n

* CHECK dout1_38 Vdout1_38ck164 = 0 time = 825
.meas tran vdout1_38ck164 FIND v(dout1_38) AT=825.025n

* CHECK dout1_39 Vdout1_39ck164 = 0 time = 825
.meas tran vdout1_39ck164 FIND v(dout1_39) AT=825.025n

* CHECK dout1_40 Vdout1_40ck164 = 0 time = 825
.meas tran vdout1_40ck164 FIND v(dout1_40) AT=825.025n

* CHECK dout1_41 Vdout1_41ck164 = 0.9 time = 825
.meas tran vdout1_41ck164 FIND v(dout1_41) AT=825.025n

* CHECK dout1_42 Vdout1_42ck164 = 0.9 time = 825
.meas tran vdout1_42ck164 FIND v(dout1_42) AT=825.025n

* CHECK dout1_43 Vdout1_43ck164 = 0.9 time = 825
.meas tran vdout1_43ck164 FIND v(dout1_43) AT=825.025n

* CHECK dout1_44 Vdout1_44ck164 = 0 time = 825
.meas tran vdout1_44ck164 FIND v(dout1_44) AT=825.025n

* CHECK dout1_45 Vdout1_45ck164 = 0.9 time = 825
.meas tran vdout1_45ck164 FIND v(dout1_45) AT=825.025n

* CHECK dout1_46 Vdout1_46ck164 = 0.9 time = 825
.meas tran vdout1_46ck164 FIND v(dout1_46) AT=825.025n

* CHECK dout1_47 Vdout1_47ck164 = 0.9 time = 825
.meas tran vdout1_47ck164 FIND v(dout1_47) AT=825.025n

* CHECK dout1_48 Vdout1_48ck164 = 0 time = 825
.meas tran vdout1_48ck164 FIND v(dout1_48) AT=825.025n

* CHECK dout1_49 Vdout1_49ck164 = 0 time = 825
.meas tran vdout1_49ck164 FIND v(dout1_49) AT=825.025n

* CHECK dout1_50 Vdout1_50ck164 = 0.9 time = 825
.meas tran vdout1_50ck164 FIND v(dout1_50) AT=825.025n

* CHECK dout1_51 Vdout1_51ck164 = 0 time = 825
.meas tran vdout1_51ck164 FIND v(dout1_51) AT=825.025n

* CHECK dout1_52 Vdout1_52ck164 = 0 time = 825
.meas tran vdout1_52ck164 FIND v(dout1_52) AT=825.025n

* CHECK dout1_53 Vdout1_53ck164 = 0.9 time = 825
.meas tran vdout1_53ck164 FIND v(dout1_53) AT=825.025n

* CHECK dout1_54 Vdout1_54ck164 = 0 time = 825
.meas tran vdout1_54ck164 FIND v(dout1_54) AT=825.025n

* CHECK dout1_55 Vdout1_55ck164 = 0.9 time = 825
.meas tran vdout1_55ck164 FIND v(dout1_55) AT=825.025n

* CHECK dout1_56 Vdout1_56ck164 = 0 time = 825
.meas tran vdout1_56ck164 FIND v(dout1_56) AT=825.025n

* CHECK dout1_57 Vdout1_57ck164 = 0.9 time = 825
.meas tran vdout1_57ck164 FIND v(dout1_57) AT=825.025n

* CHECK dout1_58 Vdout1_58ck164 = 0.9 time = 825
.meas tran vdout1_58ck164 FIND v(dout1_58) AT=825.025n

* CHECK dout1_59 Vdout1_59ck164 = 0 time = 825
.meas tran vdout1_59ck164 FIND v(dout1_59) AT=825.025n

* CHECK dout1_60 Vdout1_60ck164 = 0.9 time = 825
.meas tran vdout1_60ck164 FIND v(dout1_60) AT=825.025n

* CHECK dout1_61 Vdout1_61ck164 = 0.9 time = 825
.meas tran vdout1_61ck164 FIND v(dout1_61) AT=825.025n

* CHECK dout1_62 Vdout1_62ck164 = 0 time = 825
.meas tran vdout1_62ck164 FIND v(dout1_62) AT=825.025n

* CHECK dout1_63 Vdout1_63ck164 = 0.9 time = 825
.meas tran vdout1_63ck164 FIND v(dout1_63) AT=825.025n

* CHECK dout1_64 Vdout1_64ck164 = 0.9 time = 825
.meas tran vdout1_64ck164 FIND v(dout1_64) AT=825.025n

* CHECK dout1_65 Vdout1_65ck164 = 0.9 time = 825
.meas tran vdout1_65ck164 FIND v(dout1_65) AT=825.025n

* CHECK dout1_66 Vdout1_66ck164 = 0.9 time = 825
.meas tran vdout1_66ck164 FIND v(dout1_66) AT=825.025n

* CHECK dout1_67 Vdout1_67ck164 = 0.9 time = 825
.meas tran vdout1_67ck164 FIND v(dout1_67) AT=825.025n

* CHECK dout1_68 Vdout1_68ck164 = 0 time = 825
.meas tran vdout1_68ck164 FIND v(dout1_68) AT=825.025n

* CHECK dout1_69 Vdout1_69ck164 = 0.9 time = 825
.meas tran vdout1_69ck164 FIND v(dout1_69) AT=825.025n

* CHECK dout1_70 Vdout1_70ck164 = 0.9 time = 825
.meas tran vdout1_70ck164 FIND v(dout1_70) AT=825.025n

* CHECK dout1_71 Vdout1_71ck164 = 0 time = 825
.meas tran vdout1_71ck164 FIND v(dout1_71) AT=825.025n

* CHECK dout1_0 Vdout1_0ck165 = 0.9 time = 830
.meas tran vdout1_0ck165 FIND v(dout1_0) AT=830.025n

* CHECK dout1_1 Vdout1_1ck165 = 0 time = 830
.meas tran vdout1_1ck165 FIND v(dout1_1) AT=830.025n

* CHECK dout1_2 Vdout1_2ck165 = 0.9 time = 830
.meas tran vdout1_2ck165 FIND v(dout1_2) AT=830.025n

* CHECK dout1_3 Vdout1_3ck165 = 0 time = 830
.meas tran vdout1_3ck165 FIND v(dout1_3) AT=830.025n

* CHECK dout1_4 Vdout1_4ck165 = 0.9 time = 830
.meas tran vdout1_4ck165 FIND v(dout1_4) AT=830.025n

* CHECK dout1_5 Vdout1_5ck165 = 0.9 time = 830
.meas tran vdout1_5ck165 FIND v(dout1_5) AT=830.025n

* CHECK dout1_6 Vdout1_6ck165 = 0 time = 830
.meas tran vdout1_6ck165 FIND v(dout1_6) AT=830.025n

* CHECK dout1_7 Vdout1_7ck165 = 0 time = 830
.meas tran vdout1_7ck165 FIND v(dout1_7) AT=830.025n

* CHECK dout1_8 Vdout1_8ck165 = 0.9 time = 830
.meas tran vdout1_8ck165 FIND v(dout1_8) AT=830.025n

* CHECK dout1_9 Vdout1_9ck165 = 0.9 time = 830
.meas tran vdout1_9ck165 FIND v(dout1_9) AT=830.025n

* CHECK dout1_10 Vdout1_10ck165 = 0.9 time = 830
.meas tran vdout1_10ck165 FIND v(dout1_10) AT=830.025n

* CHECK dout1_11 Vdout1_11ck165 = 0 time = 830
.meas tran vdout1_11ck165 FIND v(dout1_11) AT=830.025n

* CHECK dout1_12 Vdout1_12ck165 = 0.9 time = 830
.meas tran vdout1_12ck165 FIND v(dout1_12) AT=830.025n

* CHECK dout1_13 Vdout1_13ck165 = 0.9 time = 830
.meas tran vdout1_13ck165 FIND v(dout1_13) AT=830.025n

* CHECK dout1_14 Vdout1_14ck165 = 0.9 time = 830
.meas tran vdout1_14ck165 FIND v(dout1_14) AT=830.025n

* CHECK dout1_15 Vdout1_15ck165 = 0 time = 830
.meas tran vdout1_15ck165 FIND v(dout1_15) AT=830.025n

* CHECK dout1_16 Vdout1_16ck165 = 0.9 time = 830
.meas tran vdout1_16ck165 FIND v(dout1_16) AT=830.025n

* CHECK dout1_17 Vdout1_17ck165 = 0.9 time = 830
.meas tran vdout1_17ck165 FIND v(dout1_17) AT=830.025n

* CHECK dout1_18 Vdout1_18ck165 = 0.9 time = 830
.meas tran vdout1_18ck165 FIND v(dout1_18) AT=830.025n

* CHECK dout1_19 Vdout1_19ck165 = 0.9 time = 830
.meas tran vdout1_19ck165 FIND v(dout1_19) AT=830.025n

* CHECK dout1_20 Vdout1_20ck165 = 0 time = 830
.meas tran vdout1_20ck165 FIND v(dout1_20) AT=830.025n

* CHECK dout1_21 Vdout1_21ck165 = 0 time = 830
.meas tran vdout1_21ck165 FIND v(dout1_21) AT=830.025n

* CHECK dout1_22 Vdout1_22ck165 = 0.9 time = 830
.meas tran vdout1_22ck165 FIND v(dout1_22) AT=830.025n

* CHECK dout1_23 Vdout1_23ck165 = 0 time = 830
.meas tran vdout1_23ck165 FIND v(dout1_23) AT=830.025n

* CHECK dout1_24 Vdout1_24ck165 = 0 time = 830
.meas tran vdout1_24ck165 FIND v(dout1_24) AT=830.025n

* CHECK dout1_25 Vdout1_25ck165 = 0 time = 830
.meas tran vdout1_25ck165 FIND v(dout1_25) AT=830.025n

* CHECK dout1_26 Vdout1_26ck165 = 0.9 time = 830
.meas tran vdout1_26ck165 FIND v(dout1_26) AT=830.025n

* CHECK dout1_27 Vdout1_27ck165 = 0 time = 830
.meas tran vdout1_27ck165 FIND v(dout1_27) AT=830.025n

* CHECK dout1_28 Vdout1_28ck165 = 0.9 time = 830
.meas tran vdout1_28ck165 FIND v(dout1_28) AT=830.025n

* CHECK dout1_29 Vdout1_29ck165 = 0 time = 830
.meas tran vdout1_29ck165 FIND v(dout1_29) AT=830.025n

* CHECK dout1_30 Vdout1_30ck165 = 0.9 time = 830
.meas tran vdout1_30ck165 FIND v(dout1_30) AT=830.025n

* CHECK dout1_31 Vdout1_31ck165 = 0 time = 830
.meas tran vdout1_31ck165 FIND v(dout1_31) AT=830.025n

* CHECK dout1_32 Vdout1_32ck165 = 0 time = 830
.meas tran vdout1_32ck165 FIND v(dout1_32) AT=830.025n

* CHECK dout1_33 Vdout1_33ck165 = 0.9 time = 830
.meas tran vdout1_33ck165 FIND v(dout1_33) AT=830.025n

* CHECK dout1_34 Vdout1_34ck165 = 0.9 time = 830
.meas tran vdout1_34ck165 FIND v(dout1_34) AT=830.025n

* CHECK dout1_35 Vdout1_35ck165 = 0.9 time = 830
.meas tran vdout1_35ck165 FIND v(dout1_35) AT=830.025n

* CHECK dout1_36 Vdout1_36ck165 = 0 time = 830
.meas tran vdout1_36ck165 FIND v(dout1_36) AT=830.025n

* CHECK dout1_37 Vdout1_37ck165 = 0.9 time = 830
.meas tran vdout1_37ck165 FIND v(dout1_37) AT=830.025n

* CHECK dout1_38 Vdout1_38ck165 = 0.9 time = 830
.meas tran vdout1_38ck165 FIND v(dout1_38) AT=830.025n

* CHECK dout1_39 Vdout1_39ck165 = 0 time = 830
.meas tran vdout1_39ck165 FIND v(dout1_39) AT=830.025n

* CHECK dout1_40 Vdout1_40ck165 = 0.9 time = 830
.meas tran vdout1_40ck165 FIND v(dout1_40) AT=830.025n

* CHECK dout1_41 Vdout1_41ck165 = 0 time = 830
.meas tran vdout1_41ck165 FIND v(dout1_41) AT=830.025n

* CHECK dout1_42 Vdout1_42ck165 = 0.9 time = 830
.meas tran vdout1_42ck165 FIND v(dout1_42) AT=830.025n

* CHECK dout1_43 Vdout1_43ck165 = 0.9 time = 830
.meas tran vdout1_43ck165 FIND v(dout1_43) AT=830.025n

* CHECK dout1_44 Vdout1_44ck165 = 0 time = 830
.meas tran vdout1_44ck165 FIND v(dout1_44) AT=830.025n

* CHECK dout1_45 Vdout1_45ck165 = 0.9 time = 830
.meas tran vdout1_45ck165 FIND v(dout1_45) AT=830.025n

* CHECK dout1_46 Vdout1_46ck165 = 0.9 time = 830
.meas tran vdout1_46ck165 FIND v(dout1_46) AT=830.025n

* CHECK dout1_47 Vdout1_47ck165 = 0.9 time = 830
.meas tran vdout1_47ck165 FIND v(dout1_47) AT=830.025n

* CHECK dout1_48 Vdout1_48ck165 = 0 time = 830
.meas tran vdout1_48ck165 FIND v(dout1_48) AT=830.025n

* CHECK dout1_49 Vdout1_49ck165 = 0.9 time = 830
.meas tran vdout1_49ck165 FIND v(dout1_49) AT=830.025n

* CHECK dout1_50 Vdout1_50ck165 = 0 time = 830
.meas tran vdout1_50ck165 FIND v(dout1_50) AT=830.025n

* CHECK dout1_51 Vdout1_51ck165 = 0.9 time = 830
.meas tran vdout1_51ck165 FIND v(dout1_51) AT=830.025n

* CHECK dout1_52 Vdout1_52ck165 = 0 time = 830
.meas tran vdout1_52ck165 FIND v(dout1_52) AT=830.025n

* CHECK dout1_53 Vdout1_53ck165 = 0.9 time = 830
.meas tran vdout1_53ck165 FIND v(dout1_53) AT=830.025n

* CHECK dout1_54 Vdout1_54ck165 = 0.9 time = 830
.meas tran vdout1_54ck165 FIND v(dout1_54) AT=830.025n

* CHECK dout1_55 Vdout1_55ck165 = 0.9 time = 830
.meas tran vdout1_55ck165 FIND v(dout1_55) AT=830.025n

* CHECK dout1_56 Vdout1_56ck165 = 0.9 time = 830
.meas tran vdout1_56ck165 FIND v(dout1_56) AT=830.025n

* CHECK dout1_57 Vdout1_57ck165 = 0 time = 830
.meas tran vdout1_57ck165 FIND v(dout1_57) AT=830.025n

* CHECK dout1_58 Vdout1_58ck165 = 0 time = 830
.meas tran vdout1_58ck165 FIND v(dout1_58) AT=830.025n

* CHECK dout1_59 Vdout1_59ck165 = 0 time = 830
.meas tran vdout1_59ck165 FIND v(dout1_59) AT=830.025n

* CHECK dout1_60 Vdout1_60ck165 = 0.9 time = 830
.meas tran vdout1_60ck165 FIND v(dout1_60) AT=830.025n

* CHECK dout1_61 Vdout1_61ck165 = 0 time = 830
.meas tran vdout1_61ck165 FIND v(dout1_61) AT=830.025n

* CHECK dout1_62 Vdout1_62ck165 = 0 time = 830
.meas tran vdout1_62ck165 FIND v(dout1_62) AT=830.025n

* CHECK dout1_63 Vdout1_63ck165 = 0 time = 830
.meas tran vdout1_63ck165 FIND v(dout1_63) AT=830.025n

* CHECK dout1_64 Vdout1_64ck165 = 0.9 time = 830
.meas tran vdout1_64ck165 FIND v(dout1_64) AT=830.025n

* CHECK dout1_65 Vdout1_65ck165 = 0 time = 830
.meas tran vdout1_65ck165 FIND v(dout1_65) AT=830.025n

* CHECK dout1_66 Vdout1_66ck165 = 0 time = 830
.meas tran vdout1_66ck165 FIND v(dout1_66) AT=830.025n

* CHECK dout1_67 Vdout1_67ck165 = 0.9 time = 830
.meas tran vdout1_67ck165 FIND v(dout1_67) AT=830.025n

* CHECK dout1_68 Vdout1_68ck165 = 0 time = 830
.meas tran vdout1_68ck165 FIND v(dout1_68) AT=830.025n

* CHECK dout1_69 Vdout1_69ck165 = 0 time = 830
.meas tran vdout1_69ck165 FIND v(dout1_69) AT=830.025n

* CHECK dout1_70 Vdout1_70ck165 = 0.9 time = 830
.meas tran vdout1_70ck165 FIND v(dout1_70) AT=830.025n

* CHECK dout1_71 Vdout1_71ck165 = 0 time = 830
.meas tran vdout1_71ck165 FIND v(dout1_71) AT=830.025n

* CHECK dout1_0 Vdout1_0ck167 = 0.9 time = 840
.meas tran vdout1_0ck167 FIND v(dout1_0) AT=840.025n

* CHECK dout1_1 Vdout1_1ck167 = 0 time = 840
.meas tran vdout1_1ck167 FIND v(dout1_1) AT=840.025n

* CHECK dout1_2 Vdout1_2ck167 = 0.9 time = 840
.meas tran vdout1_2ck167 FIND v(dout1_2) AT=840.025n

* CHECK dout1_3 Vdout1_3ck167 = 0.9 time = 840
.meas tran vdout1_3ck167 FIND v(dout1_3) AT=840.025n

* CHECK dout1_4 Vdout1_4ck167 = 0 time = 840
.meas tran vdout1_4ck167 FIND v(dout1_4) AT=840.025n

* CHECK dout1_5 Vdout1_5ck167 = 0 time = 840
.meas tran vdout1_5ck167 FIND v(dout1_5) AT=840.025n

* CHECK dout1_6 Vdout1_6ck167 = 0 time = 840
.meas tran vdout1_6ck167 FIND v(dout1_6) AT=840.025n

* CHECK dout1_7 Vdout1_7ck167 = 0.9 time = 840
.meas tran vdout1_7ck167 FIND v(dout1_7) AT=840.025n

* CHECK dout1_8 Vdout1_8ck167 = 0.9 time = 840
.meas tran vdout1_8ck167 FIND v(dout1_8) AT=840.025n

* CHECK dout1_9 Vdout1_9ck167 = 0 time = 840
.meas tran vdout1_9ck167 FIND v(dout1_9) AT=840.025n

* CHECK dout1_10 Vdout1_10ck167 = 0.9 time = 840
.meas tran vdout1_10ck167 FIND v(dout1_10) AT=840.025n

* CHECK dout1_11 Vdout1_11ck167 = 0.9 time = 840
.meas tran vdout1_11ck167 FIND v(dout1_11) AT=840.025n

* CHECK dout1_12 Vdout1_12ck167 = 0.9 time = 840
.meas tran vdout1_12ck167 FIND v(dout1_12) AT=840.025n

* CHECK dout1_13 Vdout1_13ck167 = 0.9 time = 840
.meas tran vdout1_13ck167 FIND v(dout1_13) AT=840.025n

* CHECK dout1_14 Vdout1_14ck167 = 0 time = 840
.meas tran vdout1_14ck167 FIND v(dout1_14) AT=840.025n

* CHECK dout1_15 Vdout1_15ck167 = 0.9 time = 840
.meas tran vdout1_15ck167 FIND v(dout1_15) AT=840.025n

* CHECK dout1_16 Vdout1_16ck167 = 0 time = 840
.meas tran vdout1_16ck167 FIND v(dout1_16) AT=840.025n

* CHECK dout1_17 Vdout1_17ck167 = 0.9 time = 840
.meas tran vdout1_17ck167 FIND v(dout1_17) AT=840.025n

* CHECK dout1_18 Vdout1_18ck167 = 0.9 time = 840
.meas tran vdout1_18ck167 FIND v(dout1_18) AT=840.025n

* CHECK dout1_19 Vdout1_19ck167 = 0.9 time = 840
.meas tran vdout1_19ck167 FIND v(dout1_19) AT=840.025n

* CHECK dout1_20 Vdout1_20ck167 = 0.9 time = 840
.meas tran vdout1_20ck167 FIND v(dout1_20) AT=840.025n

* CHECK dout1_21 Vdout1_21ck167 = 0 time = 840
.meas tran vdout1_21ck167 FIND v(dout1_21) AT=840.025n

* CHECK dout1_22 Vdout1_22ck167 = 0.9 time = 840
.meas tran vdout1_22ck167 FIND v(dout1_22) AT=840.025n

* CHECK dout1_23 Vdout1_23ck167 = 0.9 time = 840
.meas tran vdout1_23ck167 FIND v(dout1_23) AT=840.025n

* CHECK dout1_24 Vdout1_24ck167 = 0 time = 840
.meas tran vdout1_24ck167 FIND v(dout1_24) AT=840.025n

* CHECK dout1_25 Vdout1_25ck167 = 0 time = 840
.meas tran vdout1_25ck167 FIND v(dout1_25) AT=840.025n

* CHECK dout1_26 Vdout1_26ck167 = 0.9 time = 840
.meas tran vdout1_26ck167 FIND v(dout1_26) AT=840.025n

* CHECK dout1_27 Vdout1_27ck167 = 0.9 time = 840
.meas tran vdout1_27ck167 FIND v(dout1_27) AT=840.025n

* CHECK dout1_28 Vdout1_28ck167 = 0 time = 840
.meas tran vdout1_28ck167 FIND v(dout1_28) AT=840.025n

* CHECK dout1_29 Vdout1_29ck167 = 0.9 time = 840
.meas tran vdout1_29ck167 FIND v(dout1_29) AT=840.025n

* CHECK dout1_30 Vdout1_30ck167 = 0.9 time = 840
.meas tran vdout1_30ck167 FIND v(dout1_30) AT=840.025n

* CHECK dout1_31 Vdout1_31ck167 = 0 time = 840
.meas tran vdout1_31ck167 FIND v(dout1_31) AT=840.025n

* CHECK dout1_32 Vdout1_32ck167 = 0 time = 840
.meas tran vdout1_32ck167 FIND v(dout1_32) AT=840.025n

* CHECK dout1_33 Vdout1_33ck167 = 0 time = 840
.meas tran vdout1_33ck167 FIND v(dout1_33) AT=840.025n

* CHECK dout1_34 Vdout1_34ck167 = 0 time = 840
.meas tran vdout1_34ck167 FIND v(dout1_34) AT=840.025n

* CHECK dout1_35 Vdout1_35ck167 = 0.9 time = 840
.meas tran vdout1_35ck167 FIND v(dout1_35) AT=840.025n

* CHECK dout1_36 Vdout1_36ck167 = 0 time = 840
.meas tran vdout1_36ck167 FIND v(dout1_36) AT=840.025n

* CHECK dout1_37 Vdout1_37ck167 = 0 time = 840
.meas tran vdout1_37ck167 FIND v(dout1_37) AT=840.025n

* CHECK dout1_38 Vdout1_38ck167 = 0 time = 840
.meas tran vdout1_38ck167 FIND v(dout1_38) AT=840.025n

* CHECK dout1_39 Vdout1_39ck167 = 0 time = 840
.meas tran vdout1_39ck167 FIND v(dout1_39) AT=840.025n

* CHECK dout1_40 Vdout1_40ck167 = 0 time = 840
.meas tran vdout1_40ck167 FIND v(dout1_40) AT=840.025n

* CHECK dout1_41 Vdout1_41ck167 = 0.9 time = 840
.meas tran vdout1_41ck167 FIND v(dout1_41) AT=840.025n

* CHECK dout1_42 Vdout1_42ck167 = 0.9 time = 840
.meas tran vdout1_42ck167 FIND v(dout1_42) AT=840.025n

* CHECK dout1_43 Vdout1_43ck167 = 0.9 time = 840
.meas tran vdout1_43ck167 FIND v(dout1_43) AT=840.025n

* CHECK dout1_44 Vdout1_44ck167 = 0 time = 840
.meas tran vdout1_44ck167 FIND v(dout1_44) AT=840.025n

* CHECK dout1_45 Vdout1_45ck167 = 0.9 time = 840
.meas tran vdout1_45ck167 FIND v(dout1_45) AT=840.025n

* CHECK dout1_46 Vdout1_46ck167 = 0.9 time = 840
.meas tran vdout1_46ck167 FIND v(dout1_46) AT=840.025n

* CHECK dout1_47 Vdout1_47ck167 = 0.9 time = 840
.meas tran vdout1_47ck167 FIND v(dout1_47) AT=840.025n

* CHECK dout1_48 Vdout1_48ck167 = 0 time = 840
.meas tran vdout1_48ck167 FIND v(dout1_48) AT=840.025n

* CHECK dout1_49 Vdout1_49ck167 = 0 time = 840
.meas tran vdout1_49ck167 FIND v(dout1_49) AT=840.025n

* CHECK dout1_50 Vdout1_50ck167 = 0.9 time = 840
.meas tran vdout1_50ck167 FIND v(dout1_50) AT=840.025n

* CHECK dout1_51 Vdout1_51ck167 = 0 time = 840
.meas tran vdout1_51ck167 FIND v(dout1_51) AT=840.025n

* CHECK dout1_52 Vdout1_52ck167 = 0 time = 840
.meas tran vdout1_52ck167 FIND v(dout1_52) AT=840.025n

* CHECK dout1_53 Vdout1_53ck167 = 0.9 time = 840
.meas tran vdout1_53ck167 FIND v(dout1_53) AT=840.025n

* CHECK dout1_54 Vdout1_54ck167 = 0 time = 840
.meas tran vdout1_54ck167 FIND v(dout1_54) AT=840.025n

* CHECK dout1_55 Vdout1_55ck167 = 0.9 time = 840
.meas tran vdout1_55ck167 FIND v(dout1_55) AT=840.025n

* CHECK dout1_56 Vdout1_56ck167 = 0 time = 840
.meas tran vdout1_56ck167 FIND v(dout1_56) AT=840.025n

* CHECK dout1_57 Vdout1_57ck167 = 0.9 time = 840
.meas tran vdout1_57ck167 FIND v(dout1_57) AT=840.025n

* CHECK dout1_58 Vdout1_58ck167 = 0.9 time = 840
.meas tran vdout1_58ck167 FIND v(dout1_58) AT=840.025n

* CHECK dout1_59 Vdout1_59ck167 = 0 time = 840
.meas tran vdout1_59ck167 FIND v(dout1_59) AT=840.025n

* CHECK dout1_60 Vdout1_60ck167 = 0.9 time = 840
.meas tran vdout1_60ck167 FIND v(dout1_60) AT=840.025n

* CHECK dout1_61 Vdout1_61ck167 = 0.9 time = 840
.meas tran vdout1_61ck167 FIND v(dout1_61) AT=840.025n

* CHECK dout1_62 Vdout1_62ck167 = 0 time = 840
.meas tran vdout1_62ck167 FIND v(dout1_62) AT=840.025n

* CHECK dout1_63 Vdout1_63ck167 = 0.9 time = 840
.meas tran vdout1_63ck167 FIND v(dout1_63) AT=840.025n

* CHECK dout1_64 Vdout1_64ck167 = 0.9 time = 840
.meas tran vdout1_64ck167 FIND v(dout1_64) AT=840.025n

* CHECK dout1_65 Vdout1_65ck167 = 0.9 time = 840
.meas tran vdout1_65ck167 FIND v(dout1_65) AT=840.025n

* CHECK dout1_66 Vdout1_66ck167 = 0.9 time = 840
.meas tran vdout1_66ck167 FIND v(dout1_66) AT=840.025n

* CHECK dout1_67 Vdout1_67ck167 = 0.9 time = 840
.meas tran vdout1_67ck167 FIND v(dout1_67) AT=840.025n

* CHECK dout1_68 Vdout1_68ck167 = 0 time = 840
.meas tran vdout1_68ck167 FIND v(dout1_68) AT=840.025n

* CHECK dout1_69 Vdout1_69ck167 = 0.9 time = 840
.meas tran vdout1_69ck167 FIND v(dout1_69) AT=840.025n

* CHECK dout1_70 Vdout1_70ck167 = 0.9 time = 840
.meas tran vdout1_70ck167 FIND v(dout1_70) AT=840.025n

* CHECK dout1_71 Vdout1_71ck167 = 0 time = 840
.meas tran vdout1_71ck167 FIND v(dout1_71) AT=840.025n

* CHECK dout1_0 Vdout1_0ck168 = 0.9 time = 845
.meas tran vdout1_0ck168 FIND v(dout1_0) AT=845.025n

* CHECK dout1_1 Vdout1_1ck168 = 0 time = 845
.meas tran vdout1_1ck168 FIND v(dout1_1) AT=845.025n

* CHECK dout1_2 Vdout1_2ck168 = 0.9 time = 845
.meas tran vdout1_2ck168 FIND v(dout1_2) AT=845.025n

* CHECK dout1_3 Vdout1_3ck168 = 0.9 time = 845
.meas tran vdout1_3ck168 FIND v(dout1_3) AT=845.025n

* CHECK dout1_4 Vdout1_4ck168 = 0 time = 845
.meas tran vdout1_4ck168 FIND v(dout1_4) AT=845.025n

* CHECK dout1_5 Vdout1_5ck168 = 0 time = 845
.meas tran vdout1_5ck168 FIND v(dout1_5) AT=845.025n

* CHECK dout1_6 Vdout1_6ck168 = 0 time = 845
.meas tran vdout1_6ck168 FIND v(dout1_6) AT=845.025n

* CHECK dout1_7 Vdout1_7ck168 = 0.9 time = 845
.meas tran vdout1_7ck168 FIND v(dout1_7) AT=845.025n

* CHECK dout1_8 Vdout1_8ck168 = 0.9 time = 845
.meas tran vdout1_8ck168 FIND v(dout1_8) AT=845.025n

* CHECK dout1_9 Vdout1_9ck168 = 0 time = 845
.meas tran vdout1_9ck168 FIND v(dout1_9) AT=845.025n

* CHECK dout1_10 Vdout1_10ck168 = 0.9 time = 845
.meas tran vdout1_10ck168 FIND v(dout1_10) AT=845.025n

* CHECK dout1_11 Vdout1_11ck168 = 0.9 time = 845
.meas tran vdout1_11ck168 FIND v(dout1_11) AT=845.025n

* CHECK dout1_12 Vdout1_12ck168 = 0.9 time = 845
.meas tran vdout1_12ck168 FIND v(dout1_12) AT=845.025n

* CHECK dout1_13 Vdout1_13ck168 = 0.9 time = 845
.meas tran vdout1_13ck168 FIND v(dout1_13) AT=845.025n

* CHECK dout1_14 Vdout1_14ck168 = 0 time = 845
.meas tran vdout1_14ck168 FIND v(dout1_14) AT=845.025n

* CHECK dout1_15 Vdout1_15ck168 = 0.9 time = 845
.meas tran vdout1_15ck168 FIND v(dout1_15) AT=845.025n

* CHECK dout1_16 Vdout1_16ck168 = 0 time = 845
.meas tran vdout1_16ck168 FIND v(dout1_16) AT=845.025n

* CHECK dout1_17 Vdout1_17ck168 = 0.9 time = 845
.meas tran vdout1_17ck168 FIND v(dout1_17) AT=845.025n

* CHECK dout1_18 Vdout1_18ck168 = 0.9 time = 845
.meas tran vdout1_18ck168 FIND v(dout1_18) AT=845.025n

* CHECK dout1_19 Vdout1_19ck168 = 0.9 time = 845
.meas tran vdout1_19ck168 FIND v(dout1_19) AT=845.025n

* CHECK dout1_20 Vdout1_20ck168 = 0.9 time = 845
.meas tran vdout1_20ck168 FIND v(dout1_20) AT=845.025n

* CHECK dout1_21 Vdout1_21ck168 = 0 time = 845
.meas tran vdout1_21ck168 FIND v(dout1_21) AT=845.025n

* CHECK dout1_22 Vdout1_22ck168 = 0.9 time = 845
.meas tran vdout1_22ck168 FIND v(dout1_22) AT=845.025n

* CHECK dout1_23 Vdout1_23ck168 = 0.9 time = 845
.meas tran vdout1_23ck168 FIND v(dout1_23) AT=845.025n

* CHECK dout1_24 Vdout1_24ck168 = 0 time = 845
.meas tran vdout1_24ck168 FIND v(dout1_24) AT=845.025n

* CHECK dout1_25 Vdout1_25ck168 = 0 time = 845
.meas tran vdout1_25ck168 FIND v(dout1_25) AT=845.025n

* CHECK dout1_26 Vdout1_26ck168 = 0.9 time = 845
.meas tran vdout1_26ck168 FIND v(dout1_26) AT=845.025n

* CHECK dout1_27 Vdout1_27ck168 = 0.9 time = 845
.meas tran vdout1_27ck168 FIND v(dout1_27) AT=845.025n

* CHECK dout1_28 Vdout1_28ck168 = 0 time = 845
.meas tran vdout1_28ck168 FIND v(dout1_28) AT=845.025n

* CHECK dout1_29 Vdout1_29ck168 = 0.9 time = 845
.meas tran vdout1_29ck168 FIND v(dout1_29) AT=845.025n

* CHECK dout1_30 Vdout1_30ck168 = 0.9 time = 845
.meas tran vdout1_30ck168 FIND v(dout1_30) AT=845.025n

* CHECK dout1_31 Vdout1_31ck168 = 0 time = 845
.meas tran vdout1_31ck168 FIND v(dout1_31) AT=845.025n

* CHECK dout1_32 Vdout1_32ck168 = 0 time = 845
.meas tran vdout1_32ck168 FIND v(dout1_32) AT=845.025n

* CHECK dout1_33 Vdout1_33ck168 = 0 time = 845
.meas tran vdout1_33ck168 FIND v(dout1_33) AT=845.025n

* CHECK dout1_34 Vdout1_34ck168 = 0 time = 845
.meas tran vdout1_34ck168 FIND v(dout1_34) AT=845.025n

* CHECK dout1_35 Vdout1_35ck168 = 0.9 time = 845
.meas tran vdout1_35ck168 FIND v(dout1_35) AT=845.025n

* CHECK dout1_36 Vdout1_36ck168 = 0 time = 845
.meas tran vdout1_36ck168 FIND v(dout1_36) AT=845.025n

* CHECK dout1_37 Vdout1_37ck168 = 0 time = 845
.meas tran vdout1_37ck168 FIND v(dout1_37) AT=845.025n

* CHECK dout1_38 Vdout1_38ck168 = 0 time = 845
.meas tran vdout1_38ck168 FIND v(dout1_38) AT=845.025n

* CHECK dout1_39 Vdout1_39ck168 = 0 time = 845
.meas tran vdout1_39ck168 FIND v(dout1_39) AT=845.025n

* CHECK dout1_40 Vdout1_40ck168 = 0 time = 845
.meas tran vdout1_40ck168 FIND v(dout1_40) AT=845.025n

* CHECK dout1_41 Vdout1_41ck168 = 0.9 time = 845
.meas tran vdout1_41ck168 FIND v(dout1_41) AT=845.025n

* CHECK dout1_42 Vdout1_42ck168 = 0.9 time = 845
.meas tran vdout1_42ck168 FIND v(dout1_42) AT=845.025n

* CHECK dout1_43 Vdout1_43ck168 = 0.9 time = 845
.meas tran vdout1_43ck168 FIND v(dout1_43) AT=845.025n

* CHECK dout1_44 Vdout1_44ck168 = 0 time = 845
.meas tran vdout1_44ck168 FIND v(dout1_44) AT=845.025n

* CHECK dout1_45 Vdout1_45ck168 = 0.9 time = 845
.meas tran vdout1_45ck168 FIND v(dout1_45) AT=845.025n

* CHECK dout1_46 Vdout1_46ck168 = 0.9 time = 845
.meas tran vdout1_46ck168 FIND v(dout1_46) AT=845.025n

* CHECK dout1_47 Vdout1_47ck168 = 0.9 time = 845
.meas tran vdout1_47ck168 FIND v(dout1_47) AT=845.025n

* CHECK dout1_48 Vdout1_48ck168 = 0 time = 845
.meas tran vdout1_48ck168 FIND v(dout1_48) AT=845.025n

* CHECK dout1_49 Vdout1_49ck168 = 0 time = 845
.meas tran vdout1_49ck168 FIND v(dout1_49) AT=845.025n

* CHECK dout1_50 Vdout1_50ck168 = 0.9 time = 845
.meas tran vdout1_50ck168 FIND v(dout1_50) AT=845.025n

* CHECK dout1_51 Vdout1_51ck168 = 0 time = 845
.meas tran vdout1_51ck168 FIND v(dout1_51) AT=845.025n

* CHECK dout1_52 Vdout1_52ck168 = 0 time = 845
.meas tran vdout1_52ck168 FIND v(dout1_52) AT=845.025n

* CHECK dout1_53 Vdout1_53ck168 = 0.9 time = 845
.meas tran vdout1_53ck168 FIND v(dout1_53) AT=845.025n

* CHECK dout1_54 Vdout1_54ck168 = 0 time = 845
.meas tran vdout1_54ck168 FIND v(dout1_54) AT=845.025n

* CHECK dout1_55 Vdout1_55ck168 = 0.9 time = 845
.meas tran vdout1_55ck168 FIND v(dout1_55) AT=845.025n

* CHECK dout1_56 Vdout1_56ck168 = 0 time = 845
.meas tran vdout1_56ck168 FIND v(dout1_56) AT=845.025n

* CHECK dout1_57 Vdout1_57ck168 = 0.9 time = 845
.meas tran vdout1_57ck168 FIND v(dout1_57) AT=845.025n

* CHECK dout1_58 Vdout1_58ck168 = 0.9 time = 845
.meas tran vdout1_58ck168 FIND v(dout1_58) AT=845.025n

* CHECK dout1_59 Vdout1_59ck168 = 0 time = 845
.meas tran vdout1_59ck168 FIND v(dout1_59) AT=845.025n

* CHECK dout1_60 Vdout1_60ck168 = 0.9 time = 845
.meas tran vdout1_60ck168 FIND v(dout1_60) AT=845.025n

* CHECK dout1_61 Vdout1_61ck168 = 0.9 time = 845
.meas tran vdout1_61ck168 FIND v(dout1_61) AT=845.025n

* CHECK dout1_62 Vdout1_62ck168 = 0 time = 845
.meas tran vdout1_62ck168 FIND v(dout1_62) AT=845.025n

* CHECK dout1_63 Vdout1_63ck168 = 0.9 time = 845
.meas tran vdout1_63ck168 FIND v(dout1_63) AT=845.025n

* CHECK dout1_64 Vdout1_64ck168 = 0.9 time = 845
.meas tran vdout1_64ck168 FIND v(dout1_64) AT=845.025n

* CHECK dout1_65 Vdout1_65ck168 = 0.9 time = 845
.meas tran vdout1_65ck168 FIND v(dout1_65) AT=845.025n

* CHECK dout1_66 Vdout1_66ck168 = 0.9 time = 845
.meas tran vdout1_66ck168 FIND v(dout1_66) AT=845.025n

* CHECK dout1_67 Vdout1_67ck168 = 0.9 time = 845
.meas tran vdout1_67ck168 FIND v(dout1_67) AT=845.025n

* CHECK dout1_68 Vdout1_68ck168 = 0 time = 845
.meas tran vdout1_68ck168 FIND v(dout1_68) AT=845.025n

* CHECK dout1_69 Vdout1_69ck168 = 0.9 time = 845
.meas tran vdout1_69ck168 FIND v(dout1_69) AT=845.025n

* CHECK dout1_70 Vdout1_70ck168 = 0.9 time = 845
.meas tran vdout1_70ck168 FIND v(dout1_70) AT=845.025n

* CHECK dout1_71 Vdout1_71ck168 = 0 time = 845
.meas tran vdout1_71ck168 FIND v(dout1_71) AT=845.025n

* CHECK dout1_0 Vdout1_0ck169 = 0.9 time = 850
.meas tran vdout1_0ck169 FIND v(dout1_0) AT=850.025n

* CHECK dout1_1 Vdout1_1ck169 = 0 time = 850
.meas tran vdout1_1ck169 FIND v(dout1_1) AT=850.025n

* CHECK dout1_2 Vdout1_2ck169 = 0 time = 850
.meas tran vdout1_2ck169 FIND v(dout1_2) AT=850.025n

* CHECK dout1_3 Vdout1_3ck169 = 0 time = 850
.meas tran vdout1_3ck169 FIND v(dout1_3) AT=850.025n

* CHECK dout1_4 Vdout1_4ck169 = 0 time = 850
.meas tran vdout1_4ck169 FIND v(dout1_4) AT=850.025n

* CHECK dout1_5 Vdout1_5ck169 = 0.9 time = 850
.meas tran vdout1_5ck169 FIND v(dout1_5) AT=850.025n

* CHECK dout1_6 Vdout1_6ck169 = 0.9 time = 850
.meas tran vdout1_6ck169 FIND v(dout1_6) AT=850.025n

* CHECK dout1_7 Vdout1_7ck169 = 0.9 time = 850
.meas tran vdout1_7ck169 FIND v(dout1_7) AT=850.025n

* CHECK dout1_8 Vdout1_8ck169 = 0 time = 850
.meas tran vdout1_8ck169 FIND v(dout1_8) AT=850.025n

* CHECK dout1_9 Vdout1_9ck169 = 0 time = 850
.meas tran vdout1_9ck169 FIND v(dout1_9) AT=850.025n

* CHECK dout1_10 Vdout1_10ck169 = 0.9 time = 850
.meas tran vdout1_10ck169 FIND v(dout1_10) AT=850.025n

* CHECK dout1_11 Vdout1_11ck169 = 0.9 time = 850
.meas tran vdout1_11ck169 FIND v(dout1_11) AT=850.025n

* CHECK dout1_12 Vdout1_12ck169 = 0.9 time = 850
.meas tran vdout1_12ck169 FIND v(dout1_12) AT=850.025n

* CHECK dout1_13 Vdout1_13ck169 = 0 time = 850
.meas tran vdout1_13ck169 FIND v(dout1_13) AT=850.025n

* CHECK dout1_14 Vdout1_14ck169 = 0.9 time = 850
.meas tran vdout1_14ck169 FIND v(dout1_14) AT=850.025n

* CHECK dout1_15 Vdout1_15ck169 = 0 time = 850
.meas tran vdout1_15ck169 FIND v(dout1_15) AT=850.025n

* CHECK dout1_16 Vdout1_16ck169 = 0 time = 850
.meas tran vdout1_16ck169 FIND v(dout1_16) AT=850.025n

* CHECK dout1_17 Vdout1_17ck169 = 0 time = 850
.meas tran vdout1_17ck169 FIND v(dout1_17) AT=850.025n

* CHECK dout1_18 Vdout1_18ck169 = 0 time = 850
.meas tran vdout1_18ck169 FIND v(dout1_18) AT=850.025n

* CHECK dout1_19 Vdout1_19ck169 = 0 time = 850
.meas tran vdout1_19ck169 FIND v(dout1_19) AT=850.025n

* CHECK dout1_20 Vdout1_20ck169 = 0 time = 850
.meas tran vdout1_20ck169 FIND v(dout1_20) AT=850.025n

* CHECK dout1_21 Vdout1_21ck169 = 0.9 time = 850
.meas tran vdout1_21ck169 FIND v(dout1_21) AT=850.025n

* CHECK dout1_22 Vdout1_22ck169 = 0.9 time = 850
.meas tran vdout1_22ck169 FIND v(dout1_22) AT=850.025n

* CHECK dout1_23 Vdout1_23ck169 = 0.9 time = 850
.meas tran vdout1_23ck169 FIND v(dout1_23) AT=850.025n

* CHECK dout1_24 Vdout1_24ck169 = 0 time = 850
.meas tran vdout1_24ck169 FIND v(dout1_24) AT=850.025n

* CHECK dout1_25 Vdout1_25ck169 = 0.9 time = 850
.meas tran vdout1_25ck169 FIND v(dout1_25) AT=850.025n

* CHECK dout1_26 Vdout1_26ck169 = 0.9 time = 850
.meas tran vdout1_26ck169 FIND v(dout1_26) AT=850.025n

* CHECK dout1_27 Vdout1_27ck169 = 0.9 time = 850
.meas tran vdout1_27ck169 FIND v(dout1_27) AT=850.025n

* CHECK dout1_28 Vdout1_28ck169 = 0 time = 850
.meas tran vdout1_28ck169 FIND v(dout1_28) AT=850.025n

* CHECK dout1_29 Vdout1_29ck169 = 0 time = 850
.meas tran vdout1_29ck169 FIND v(dout1_29) AT=850.025n

* CHECK dout1_30 Vdout1_30ck169 = 0.9 time = 850
.meas tran vdout1_30ck169 FIND v(dout1_30) AT=850.025n

* CHECK dout1_31 Vdout1_31ck169 = 0 time = 850
.meas tran vdout1_31ck169 FIND v(dout1_31) AT=850.025n

* CHECK dout1_32 Vdout1_32ck169 = 0.9 time = 850
.meas tran vdout1_32ck169 FIND v(dout1_32) AT=850.025n

* CHECK dout1_33 Vdout1_33ck169 = 0.9 time = 850
.meas tran vdout1_33ck169 FIND v(dout1_33) AT=850.025n

* CHECK dout1_34 Vdout1_34ck169 = 0.9 time = 850
.meas tran vdout1_34ck169 FIND v(dout1_34) AT=850.025n

* CHECK dout1_35 Vdout1_35ck169 = 0 time = 850
.meas tran vdout1_35ck169 FIND v(dout1_35) AT=850.025n

* CHECK dout1_36 Vdout1_36ck169 = 0 time = 850
.meas tran vdout1_36ck169 FIND v(dout1_36) AT=850.025n

* CHECK dout1_37 Vdout1_37ck169 = 0 time = 850
.meas tran vdout1_37ck169 FIND v(dout1_37) AT=850.025n

* CHECK dout1_38 Vdout1_38ck169 = 0.9 time = 850
.meas tran vdout1_38ck169 FIND v(dout1_38) AT=850.025n

* CHECK dout1_39 Vdout1_39ck169 = 0.9 time = 850
.meas tran vdout1_39ck169 FIND v(dout1_39) AT=850.025n

* CHECK dout1_40 Vdout1_40ck169 = 0.9 time = 850
.meas tran vdout1_40ck169 FIND v(dout1_40) AT=850.025n

* CHECK dout1_41 Vdout1_41ck169 = 0.9 time = 850
.meas tran vdout1_41ck169 FIND v(dout1_41) AT=850.025n

* CHECK dout1_42 Vdout1_42ck169 = 0 time = 850
.meas tran vdout1_42ck169 FIND v(dout1_42) AT=850.025n

* CHECK dout1_43 Vdout1_43ck169 = 0 time = 850
.meas tran vdout1_43ck169 FIND v(dout1_43) AT=850.025n

* CHECK dout1_44 Vdout1_44ck169 = 0.9 time = 850
.meas tran vdout1_44ck169 FIND v(dout1_44) AT=850.025n

* CHECK dout1_45 Vdout1_45ck169 = 0 time = 850
.meas tran vdout1_45ck169 FIND v(dout1_45) AT=850.025n

* CHECK dout1_46 Vdout1_46ck169 = 0.9 time = 850
.meas tran vdout1_46ck169 FIND v(dout1_46) AT=850.025n

* CHECK dout1_47 Vdout1_47ck169 = 0.9 time = 850
.meas tran vdout1_47ck169 FIND v(dout1_47) AT=850.025n

* CHECK dout1_48 Vdout1_48ck169 = 0 time = 850
.meas tran vdout1_48ck169 FIND v(dout1_48) AT=850.025n

* CHECK dout1_49 Vdout1_49ck169 = 0.9 time = 850
.meas tran vdout1_49ck169 FIND v(dout1_49) AT=850.025n

* CHECK dout1_50 Vdout1_50ck169 = 0 time = 850
.meas tran vdout1_50ck169 FIND v(dout1_50) AT=850.025n

* CHECK dout1_51 Vdout1_51ck169 = 0 time = 850
.meas tran vdout1_51ck169 FIND v(dout1_51) AT=850.025n

* CHECK dout1_52 Vdout1_52ck169 = 0.9 time = 850
.meas tran vdout1_52ck169 FIND v(dout1_52) AT=850.025n

* CHECK dout1_53 Vdout1_53ck169 = 0.9 time = 850
.meas tran vdout1_53ck169 FIND v(dout1_53) AT=850.025n

* CHECK dout1_54 Vdout1_54ck169 = 0.9 time = 850
.meas tran vdout1_54ck169 FIND v(dout1_54) AT=850.025n

* CHECK dout1_55 Vdout1_55ck169 = 0 time = 850
.meas tran vdout1_55ck169 FIND v(dout1_55) AT=850.025n

* CHECK dout1_56 Vdout1_56ck169 = 0 time = 850
.meas tran vdout1_56ck169 FIND v(dout1_56) AT=850.025n

* CHECK dout1_57 Vdout1_57ck169 = 0 time = 850
.meas tran vdout1_57ck169 FIND v(dout1_57) AT=850.025n

* CHECK dout1_58 Vdout1_58ck169 = 0.9 time = 850
.meas tran vdout1_58ck169 FIND v(dout1_58) AT=850.025n

* CHECK dout1_59 Vdout1_59ck169 = 0 time = 850
.meas tran vdout1_59ck169 FIND v(dout1_59) AT=850.025n

* CHECK dout1_60 Vdout1_60ck169 = 0.9 time = 850
.meas tran vdout1_60ck169 FIND v(dout1_60) AT=850.025n

* CHECK dout1_61 Vdout1_61ck169 = 0 time = 850
.meas tran vdout1_61ck169 FIND v(dout1_61) AT=850.025n

* CHECK dout1_62 Vdout1_62ck169 = 0.9 time = 850
.meas tran vdout1_62ck169 FIND v(dout1_62) AT=850.025n

* CHECK dout1_63 Vdout1_63ck169 = 0 time = 850
.meas tran vdout1_63ck169 FIND v(dout1_63) AT=850.025n

* CHECK dout1_64 Vdout1_64ck169 = 0 time = 850
.meas tran vdout1_64ck169 FIND v(dout1_64) AT=850.025n

* CHECK dout1_65 Vdout1_65ck169 = 0.9 time = 850
.meas tran vdout1_65ck169 FIND v(dout1_65) AT=850.025n

* CHECK dout1_66 Vdout1_66ck169 = 0 time = 850
.meas tran vdout1_66ck169 FIND v(dout1_66) AT=850.025n

* CHECK dout1_67 Vdout1_67ck169 = 0 time = 850
.meas tran vdout1_67ck169 FIND v(dout1_67) AT=850.025n

* CHECK dout1_68 Vdout1_68ck169 = 0.9 time = 850
.meas tran vdout1_68ck169 FIND v(dout1_68) AT=850.025n

* CHECK dout1_69 Vdout1_69ck169 = 0 time = 850
.meas tran vdout1_69ck169 FIND v(dout1_69) AT=850.025n

* CHECK dout1_70 Vdout1_70ck169 = 0.9 time = 850
.meas tran vdout1_70ck169 FIND v(dout1_70) AT=850.025n

* CHECK dout1_71 Vdout1_71ck169 = 0.9 time = 850
.meas tran vdout1_71ck169 FIND v(dout1_71) AT=850.025n

* CHECK dout1_0 Vdout1_0ck170 = 0.9 time = 855
.meas tran vdout1_0ck170 FIND v(dout1_0) AT=855.025n

* CHECK dout1_1 Vdout1_1ck170 = 0 time = 855
.meas tran vdout1_1ck170 FIND v(dout1_1) AT=855.025n

* CHECK dout1_2 Vdout1_2ck170 = 0 time = 855
.meas tran vdout1_2ck170 FIND v(dout1_2) AT=855.025n

* CHECK dout1_3 Vdout1_3ck170 = 0 time = 855
.meas tran vdout1_3ck170 FIND v(dout1_3) AT=855.025n

* CHECK dout1_4 Vdout1_4ck170 = 0 time = 855
.meas tran vdout1_4ck170 FIND v(dout1_4) AT=855.025n

* CHECK dout1_5 Vdout1_5ck170 = 0.9 time = 855
.meas tran vdout1_5ck170 FIND v(dout1_5) AT=855.025n

* CHECK dout1_6 Vdout1_6ck170 = 0.9 time = 855
.meas tran vdout1_6ck170 FIND v(dout1_6) AT=855.025n

* CHECK dout1_7 Vdout1_7ck170 = 0.9 time = 855
.meas tran vdout1_7ck170 FIND v(dout1_7) AT=855.025n

* CHECK dout1_8 Vdout1_8ck170 = 0 time = 855
.meas tran vdout1_8ck170 FIND v(dout1_8) AT=855.025n

* CHECK dout1_9 Vdout1_9ck170 = 0 time = 855
.meas tran vdout1_9ck170 FIND v(dout1_9) AT=855.025n

* CHECK dout1_10 Vdout1_10ck170 = 0.9 time = 855
.meas tran vdout1_10ck170 FIND v(dout1_10) AT=855.025n

* CHECK dout1_11 Vdout1_11ck170 = 0.9 time = 855
.meas tran vdout1_11ck170 FIND v(dout1_11) AT=855.025n

* CHECK dout1_12 Vdout1_12ck170 = 0.9 time = 855
.meas tran vdout1_12ck170 FIND v(dout1_12) AT=855.025n

* CHECK dout1_13 Vdout1_13ck170 = 0 time = 855
.meas tran vdout1_13ck170 FIND v(dout1_13) AT=855.025n

* CHECK dout1_14 Vdout1_14ck170 = 0.9 time = 855
.meas tran vdout1_14ck170 FIND v(dout1_14) AT=855.025n

* CHECK dout1_15 Vdout1_15ck170 = 0 time = 855
.meas tran vdout1_15ck170 FIND v(dout1_15) AT=855.025n

* CHECK dout1_16 Vdout1_16ck170 = 0 time = 855
.meas tran vdout1_16ck170 FIND v(dout1_16) AT=855.025n

* CHECK dout1_17 Vdout1_17ck170 = 0 time = 855
.meas tran vdout1_17ck170 FIND v(dout1_17) AT=855.025n

* CHECK dout1_18 Vdout1_18ck170 = 0 time = 855
.meas tran vdout1_18ck170 FIND v(dout1_18) AT=855.025n

* CHECK dout1_19 Vdout1_19ck170 = 0 time = 855
.meas tran vdout1_19ck170 FIND v(dout1_19) AT=855.025n

* CHECK dout1_20 Vdout1_20ck170 = 0 time = 855
.meas tran vdout1_20ck170 FIND v(dout1_20) AT=855.025n

* CHECK dout1_21 Vdout1_21ck170 = 0.9 time = 855
.meas tran vdout1_21ck170 FIND v(dout1_21) AT=855.025n

* CHECK dout1_22 Vdout1_22ck170 = 0.9 time = 855
.meas tran vdout1_22ck170 FIND v(dout1_22) AT=855.025n

* CHECK dout1_23 Vdout1_23ck170 = 0.9 time = 855
.meas tran vdout1_23ck170 FIND v(dout1_23) AT=855.025n

* CHECK dout1_24 Vdout1_24ck170 = 0 time = 855
.meas tran vdout1_24ck170 FIND v(dout1_24) AT=855.025n

* CHECK dout1_25 Vdout1_25ck170 = 0.9 time = 855
.meas tran vdout1_25ck170 FIND v(dout1_25) AT=855.025n

* CHECK dout1_26 Vdout1_26ck170 = 0.9 time = 855
.meas tran vdout1_26ck170 FIND v(dout1_26) AT=855.025n

* CHECK dout1_27 Vdout1_27ck170 = 0.9 time = 855
.meas tran vdout1_27ck170 FIND v(dout1_27) AT=855.025n

* CHECK dout1_28 Vdout1_28ck170 = 0 time = 855
.meas tran vdout1_28ck170 FIND v(dout1_28) AT=855.025n

* CHECK dout1_29 Vdout1_29ck170 = 0 time = 855
.meas tran vdout1_29ck170 FIND v(dout1_29) AT=855.025n

* CHECK dout1_30 Vdout1_30ck170 = 0.9 time = 855
.meas tran vdout1_30ck170 FIND v(dout1_30) AT=855.025n

* CHECK dout1_31 Vdout1_31ck170 = 0 time = 855
.meas tran vdout1_31ck170 FIND v(dout1_31) AT=855.025n

* CHECK dout1_32 Vdout1_32ck170 = 0.9 time = 855
.meas tran vdout1_32ck170 FIND v(dout1_32) AT=855.025n

* CHECK dout1_33 Vdout1_33ck170 = 0.9 time = 855
.meas tran vdout1_33ck170 FIND v(dout1_33) AT=855.025n

* CHECK dout1_34 Vdout1_34ck170 = 0.9 time = 855
.meas tran vdout1_34ck170 FIND v(dout1_34) AT=855.025n

* CHECK dout1_35 Vdout1_35ck170 = 0 time = 855
.meas tran vdout1_35ck170 FIND v(dout1_35) AT=855.025n

* CHECK dout1_36 Vdout1_36ck170 = 0 time = 855
.meas tran vdout1_36ck170 FIND v(dout1_36) AT=855.025n

* CHECK dout1_37 Vdout1_37ck170 = 0 time = 855
.meas tran vdout1_37ck170 FIND v(dout1_37) AT=855.025n

* CHECK dout1_38 Vdout1_38ck170 = 0.9 time = 855
.meas tran vdout1_38ck170 FIND v(dout1_38) AT=855.025n

* CHECK dout1_39 Vdout1_39ck170 = 0.9 time = 855
.meas tran vdout1_39ck170 FIND v(dout1_39) AT=855.025n

* CHECK dout1_40 Vdout1_40ck170 = 0.9 time = 855
.meas tran vdout1_40ck170 FIND v(dout1_40) AT=855.025n

* CHECK dout1_41 Vdout1_41ck170 = 0.9 time = 855
.meas tran vdout1_41ck170 FIND v(dout1_41) AT=855.025n

* CHECK dout1_42 Vdout1_42ck170 = 0 time = 855
.meas tran vdout1_42ck170 FIND v(dout1_42) AT=855.025n

* CHECK dout1_43 Vdout1_43ck170 = 0 time = 855
.meas tran vdout1_43ck170 FIND v(dout1_43) AT=855.025n

* CHECK dout1_44 Vdout1_44ck170 = 0.9 time = 855
.meas tran vdout1_44ck170 FIND v(dout1_44) AT=855.025n

* CHECK dout1_45 Vdout1_45ck170 = 0 time = 855
.meas tran vdout1_45ck170 FIND v(dout1_45) AT=855.025n

* CHECK dout1_46 Vdout1_46ck170 = 0.9 time = 855
.meas tran vdout1_46ck170 FIND v(dout1_46) AT=855.025n

* CHECK dout1_47 Vdout1_47ck170 = 0.9 time = 855
.meas tran vdout1_47ck170 FIND v(dout1_47) AT=855.025n

* CHECK dout1_48 Vdout1_48ck170 = 0 time = 855
.meas tran vdout1_48ck170 FIND v(dout1_48) AT=855.025n

* CHECK dout1_49 Vdout1_49ck170 = 0.9 time = 855
.meas tran vdout1_49ck170 FIND v(dout1_49) AT=855.025n

* CHECK dout1_50 Vdout1_50ck170 = 0 time = 855
.meas tran vdout1_50ck170 FIND v(dout1_50) AT=855.025n

* CHECK dout1_51 Vdout1_51ck170 = 0 time = 855
.meas tran vdout1_51ck170 FIND v(dout1_51) AT=855.025n

* CHECK dout1_52 Vdout1_52ck170 = 0.9 time = 855
.meas tran vdout1_52ck170 FIND v(dout1_52) AT=855.025n

* CHECK dout1_53 Vdout1_53ck170 = 0.9 time = 855
.meas tran vdout1_53ck170 FIND v(dout1_53) AT=855.025n

* CHECK dout1_54 Vdout1_54ck170 = 0.9 time = 855
.meas tran vdout1_54ck170 FIND v(dout1_54) AT=855.025n

* CHECK dout1_55 Vdout1_55ck170 = 0 time = 855
.meas tran vdout1_55ck170 FIND v(dout1_55) AT=855.025n

* CHECK dout1_56 Vdout1_56ck170 = 0 time = 855
.meas tran vdout1_56ck170 FIND v(dout1_56) AT=855.025n

* CHECK dout1_57 Vdout1_57ck170 = 0 time = 855
.meas tran vdout1_57ck170 FIND v(dout1_57) AT=855.025n

* CHECK dout1_58 Vdout1_58ck170 = 0.9 time = 855
.meas tran vdout1_58ck170 FIND v(dout1_58) AT=855.025n

* CHECK dout1_59 Vdout1_59ck170 = 0 time = 855
.meas tran vdout1_59ck170 FIND v(dout1_59) AT=855.025n

* CHECK dout1_60 Vdout1_60ck170 = 0.9 time = 855
.meas tran vdout1_60ck170 FIND v(dout1_60) AT=855.025n

* CHECK dout1_61 Vdout1_61ck170 = 0 time = 855
.meas tran vdout1_61ck170 FIND v(dout1_61) AT=855.025n

* CHECK dout1_62 Vdout1_62ck170 = 0.9 time = 855
.meas tran vdout1_62ck170 FIND v(dout1_62) AT=855.025n

* CHECK dout1_63 Vdout1_63ck170 = 0 time = 855
.meas tran vdout1_63ck170 FIND v(dout1_63) AT=855.025n

* CHECK dout1_64 Vdout1_64ck170 = 0 time = 855
.meas tran vdout1_64ck170 FIND v(dout1_64) AT=855.025n

* CHECK dout1_65 Vdout1_65ck170 = 0.9 time = 855
.meas tran vdout1_65ck170 FIND v(dout1_65) AT=855.025n

* CHECK dout1_66 Vdout1_66ck170 = 0 time = 855
.meas tran vdout1_66ck170 FIND v(dout1_66) AT=855.025n

* CHECK dout1_67 Vdout1_67ck170 = 0 time = 855
.meas tran vdout1_67ck170 FIND v(dout1_67) AT=855.025n

* CHECK dout1_68 Vdout1_68ck170 = 0.9 time = 855
.meas tran vdout1_68ck170 FIND v(dout1_68) AT=855.025n

* CHECK dout1_69 Vdout1_69ck170 = 0 time = 855
.meas tran vdout1_69ck170 FIND v(dout1_69) AT=855.025n

* CHECK dout1_70 Vdout1_70ck170 = 0.9 time = 855
.meas tran vdout1_70ck170 FIND v(dout1_70) AT=855.025n

* CHECK dout1_71 Vdout1_71ck170 = 0.9 time = 855
.meas tran vdout1_71ck170 FIND v(dout1_71) AT=855.025n

* CHECK dout1_0 Vdout1_0ck172 = 0 time = 865
.meas tran vdout1_0ck172 FIND v(dout1_0) AT=865.025n

* CHECK dout1_1 Vdout1_1ck172 = 0 time = 865
.meas tran vdout1_1ck172 FIND v(dout1_1) AT=865.025n

* CHECK dout1_2 Vdout1_2ck172 = 0 time = 865
.meas tran vdout1_2ck172 FIND v(dout1_2) AT=865.025n

* CHECK dout1_3 Vdout1_3ck172 = 0.9 time = 865
.meas tran vdout1_3ck172 FIND v(dout1_3) AT=865.025n

* CHECK dout1_4 Vdout1_4ck172 = 0 time = 865
.meas tran vdout1_4ck172 FIND v(dout1_4) AT=865.025n

* CHECK dout1_5 Vdout1_5ck172 = 0 time = 865
.meas tran vdout1_5ck172 FIND v(dout1_5) AT=865.025n

* CHECK dout1_6 Vdout1_6ck172 = 0 time = 865
.meas tran vdout1_6ck172 FIND v(dout1_6) AT=865.025n

* CHECK dout1_7 Vdout1_7ck172 = 0.9 time = 865
.meas tran vdout1_7ck172 FIND v(dout1_7) AT=865.025n

* CHECK dout1_8 Vdout1_8ck172 = 0.9 time = 865
.meas tran vdout1_8ck172 FIND v(dout1_8) AT=865.025n

* CHECK dout1_9 Vdout1_9ck172 = 0 time = 865
.meas tran vdout1_9ck172 FIND v(dout1_9) AT=865.025n

* CHECK dout1_10 Vdout1_10ck172 = 0.9 time = 865
.meas tran vdout1_10ck172 FIND v(dout1_10) AT=865.025n

* CHECK dout1_11 Vdout1_11ck172 = 0.9 time = 865
.meas tran vdout1_11ck172 FIND v(dout1_11) AT=865.025n

* CHECK dout1_12 Vdout1_12ck172 = 0.9 time = 865
.meas tran vdout1_12ck172 FIND v(dout1_12) AT=865.025n

* CHECK dout1_13 Vdout1_13ck172 = 0 time = 865
.meas tran vdout1_13ck172 FIND v(dout1_13) AT=865.025n

* CHECK dout1_14 Vdout1_14ck172 = 0 time = 865
.meas tran vdout1_14ck172 FIND v(dout1_14) AT=865.025n

* CHECK dout1_15 Vdout1_15ck172 = 0 time = 865
.meas tran vdout1_15ck172 FIND v(dout1_15) AT=865.025n

* CHECK dout1_16 Vdout1_16ck172 = 0.9 time = 865
.meas tran vdout1_16ck172 FIND v(dout1_16) AT=865.025n

* CHECK dout1_17 Vdout1_17ck172 = 0 time = 865
.meas tran vdout1_17ck172 FIND v(dout1_17) AT=865.025n

* CHECK dout1_18 Vdout1_18ck172 = 0 time = 865
.meas tran vdout1_18ck172 FIND v(dout1_18) AT=865.025n

* CHECK dout1_19 Vdout1_19ck172 = 0 time = 865
.meas tran vdout1_19ck172 FIND v(dout1_19) AT=865.025n

* CHECK dout1_20 Vdout1_20ck172 = 0.9 time = 865
.meas tran vdout1_20ck172 FIND v(dout1_20) AT=865.025n

* CHECK dout1_21 Vdout1_21ck172 = 0 time = 865
.meas tran vdout1_21ck172 FIND v(dout1_21) AT=865.025n

* CHECK dout1_22 Vdout1_22ck172 = 0.9 time = 865
.meas tran vdout1_22ck172 FIND v(dout1_22) AT=865.025n

* CHECK dout1_23 Vdout1_23ck172 = 0 time = 865
.meas tran vdout1_23ck172 FIND v(dout1_23) AT=865.025n

* CHECK dout1_24 Vdout1_24ck172 = 0 time = 865
.meas tran vdout1_24ck172 FIND v(dout1_24) AT=865.025n

* CHECK dout1_25 Vdout1_25ck172 = 0 time = 865
.meas tran vdout1_25ck172 FIND v(dout1_25) AT=865.025n

* CHECK dout1_26 Vdout1_26ck172 = 0 time = 865
.meas tran vdout1_26ck172 FIND v(dout1_26) AT=865.025n

* CHECK dout1_27 Vdout1_27ck172 = 0.9 time = 865
.meas tran vdout1_27ck172 FIND v(dout1_27) AT=865.025n

* CHECK dout1_28 Vdout1_28ck172 = 0 time = 865
.meas tran vdout1_28ck172 FIND v(dout1_28) AT=865.025n

* CHECK dout1_29 Vdout1_29ck172 = 0 time = 865
.meas tran vdout1_29ck172 FIND v(dout1_29) AT=865.025n

* CHECK dout1_30 Vdout1_30ck172 = 0.9 time = 865
.meas tran vdout1_30ck172 FIND v(dout1_30) AT=865.025n

* CHECK dout1_31 Vdout1_31ck172 = 0 time = 865
.meas tran vdout1_31ck172 FIND v(dout1_31) AT=865.025n

* CHECK dout1_32 Vdout1_32ck172 = 0 time = 865
.meas tran vdout1_32ck172 FIND v(dout1_32) AT=865.025n

* CHECK dout1_33 Vdout1_33ck172 = 0.9 time = 865
.meas tran vdout1_33ck172 FIND v(dout1_33) AT=865.025n

* CHECK dout1_34 Vdout1_34ck172 = 0 time = 865
.meas tran vdout1_34ck172 FIND v(dout1_34) AT=865.025n

* CHECK dout1_35 Vdout1_35ck172 = 0.9 time = 865
.meas tran vdout1_35ck172 FIND v(dout1_35) AT=865.025n

* CHECK dout1_36 Vdout1_36ck172 = 0 time = 865
.meas tran vdout1_36ck172 FIND v(dout1_36) AT=865.025n

* CHECK dout1_37 Vdout1_37ck172 = 0 time = 865
.meas tran vdout1_37ck172 FIND v(dout1_37) AT=865.025n

* CHECK dout1_38 Vdout1_38ck172 = 0 time = 865
.meas tran vdout1_38ck172 FIND v(dout1_38) AT=865.025n

* CHECK dout1_39 Vdout1_39ck172 = 0.9 time = 865
.meas tran vdout1_39ck172 FIND v(dout1_39) AT=865.025n

* CHECK dout1_40 Vdout1_40ck172 = 0.9 time = 865
.meas tran vdout1_40ck172 FIND v(dout1_40) AT=865.025n

* CHECK dout1_41 Vdout1_41ck172 = 0.9 time = 865
.meas tran vdout1_41ck172 FIND v(dout1_41) AT=865.025n

* CHECK dout1_42 Vdout1_42ck172 = 0 time = 865
.meas tran vdout1_42ck172 FIND v(dout1_42) AT=865.025n

* CHECK dout1_43 Vdout1_43ck172 = 0.9 time = 865
.meas tran vdout1_43ck172 FIND v(dout1_43) AT=865.025n

* CHECK dout1_44 Vdout1_44ck172 = 0.9 time = 865
.meas tran vdout1_44ck172 FIND v(dout1_44) AT=865.025n

* CHECK dout1_45 Vdout1_45ck172 = 0 time = 865
.meas tran vdout1_45ck172 FIND v(dout1_45) AT=865.025n

* CHECK dout1_46 Vdout1_46ck172 = 0.9 time = 865
.meas tran vdout1_46ck172 FIND v(dout1_46) AT=865.025n

* CHECK dout1_47 Vdout1_47ck172 = 0.9 time = 865
.meas tran vdout1_47ck172 FIND v(dout1_47) AT=865.025n

* CHECK dout1_48 Vdout1_48ck172 = 0 time = 865
.meas tran vdout1_48ck172 FIND v(dout1_48) AT=865.025n

* CHECK dout1_49 Vdout1_49ck172 = 0 time = 865
.meas tran vdout1_49ck172 FIND v(dout1_49) AT=865.025n

* CHECK dout1_50 Vdout1_50ck172 = 0 time = 865
.meas tran vdout1_50ck172 FIND v(dout1_50) AT=865.025n

* CHECK dout1_51 Vdout1_51ck172 = 0 time = 865
.meas tran vdout1_51ck172 FIND v(dout1_51) AT=865.025n

* CHECK dout1_52 Vdout1_52ck172 = 0 time = 865
.meas tran vdout1_52ck172 FIND v(dout1_52) AT=865.025n

* CHECK dout1_53 Vdout1_53ck172 = 0 time = 865
.meas tran vdout1_53ck172 FIND v(dout1_53) AT=865.025n

* CHECK dout1_54 Vdout1_54ck172 = 0 time = 865
.meas tran vdout1_54ck172 FIND v(dout1_54) AT=865.025n

* CHECK dout1_55 Vdout1_55ck172 = 0.9 time = 865
.meas tran vdout1_55ck172 FIND v(dout1_55) AT=865.025n

* CHECK dout1_56 Vdout1_56ck172 = 0 time = 865
.meas tran vdout1_56ck172 FIND v(dout1_56) AT=865.025n

* CHECK dout1_57 Vdout1_57ck172 = 0 time = 865
.meas tran vdout1_57ck172 FIND v(dout1_57) AT=865.025n

* CHECK dout1_58 Vdout1_58ck172 = 0 time = 865
.meas tran vdout1_58ck172 FIND v(dout1_58) AT=865.025n

* CHECK dout1_59 Vdout1_59ck172 = 0 time = 865
.meas tran vdout1_59ck172 FIND v(dout1_59) AT=865.025n

* CHECK dout1_60 Vdout1_60ck172 = 0 time = 865
.meas tran vdout1_60ck172 FIND v(dout1_60) AT=865.025n

* CHECK dout1_61 Vdout1_61ck172 = 0.9 time = 865
.meas tran vdout1_61ck172 FIND v(dout1_61) AT=865.025n

* CHECK dout1_62 Vdout1_62ck172 = 0 time = 865
.meas tran vdout1_62ck172 FIND v(dout1_62) AT=865.025n

* CHECK dout1_63 Vdout1_63ck172 = 0 time = 865
.meas tran vdout1_63ck172 FIND v(dout1_63) AT=865.025n

* CHECK dout1_64 Vdout1_64ck172 = 0 time = 865
.meas tran vdout1_64ck172 FIND v(dout1_64) AT=865.025n

* CHECK dout1_65 Vdout1_65ck172 = 0 time = 865
.meas tran vdout1_65ck172 FIND v(dout1_65) AT=865.025n

* CHECK dout1_66 Vdout1_66ck172 = 0.9 time = 865
.meas tran vdout1_66ck172 FIND v(dout1_66) AT=865.025n

* CHECK dout1_67 Vdout1_67ck172 = 0.9 time = 865
.meas tran vdout1_67ck172 FIND v(dout1_67) AT=865.025n

* CHECK dout1_68 Vdout1_68ck172 = 0 time = 865
.meas tran vdout1_68ck172 FIND v(dout1_68) AT=865.025n

* CHECK dout1_69 Vdout1_69ck172 = 0.9 time = 865
.meas tran vdout1_69ck172 FIND v(dout1_69) AT=865.025n

* CHECK dout1_70 Vdout1_70ck172 = 0 time = 865
.meas tran vdout1_70ck172 FIND v(dout1_70) AT=865.025n

* CHECK dout1_71 Vdout1_71ck172 = 0.9 time = 865
.meas tran vdout1_71ck172 FIND v(dout1_71) AT=865.025n

* CHECK dout1_0 Vdout1_0ck173 = 0 time = 870
.meas tran vdout1_0ck173 FIND v(dout1_0) AT=870.025n

* CHECK dout1_1 Vdout1_1ck173 = 0.9 time = 870
.meas tran vdout1_1ck173 FIND v(dout1_1) AT=870.025n

* CHECK dout1_2 Vdout1_2ck173 = 0 time = 870
.meas tran vdout1_2ck173 FIND v(dout1_2) AT=870.025n

* CHECK dout1_3 Vdout1_3ck173 = 0.9 time = 870
.meas tran vdout1_3ck173 FIND v(dout1_3) AT=870.025n

* CHECK dout1_4 Vdout1_4ck173 = 0 time = 870
.meas tran vdout1_4ck173 FIND v(dout1_4) AT=870.025n

* CHECK dout1_5 Vdout1_5ck173 = 0 time = 870
.meas tran vdout1_5ck173 FIND v(dout1_5) AT=870.025n

* CHECK dout1_6 Vdout1_6ck173 = 0 time = 870
.meas tran vdout1_6ck173 FIND v(dout1_6) AT=870.025n

* CHECK dout1_7 Vdout1_7ck173 = 0 time = 870
.meas tran vdout1_7ck173 FIND v(dout1_7) AT=870.025n

* CHECK dout1_8 Vdout1_8ck173 = 0 time = 870
.meas tran vdout1_8ck173 FIND v(dout1_8) AT=870.025n

* CHECK dout1_9 Vdout1_9ck173 = 0.9 time = 870
.meas tran vdout1_9ck173 FIND v(dout1_9) AT=870.025n

* CHECK dout1_10 Vdout1_10ck173 = 0 time = 870
.meas tran vdout1_10ck173 FIND v(dout1_10) AT=870.025n

* CHECK dout1_11 Vdout1_11ck173 = 0.9 time = 870
.meas tran vdout1_11ck173 FIND v(dout1_11) AT=870.025n

* CHECK dout1_12 Vdout1_12ck173 = 0.9 time = 870
.meas tran vdout1_12ck173 FIND v(dout1_12) AT=870.025n

* CHECK dout1_13 Vdout1_13ck173 = 0 time = 870
.meas tran vdout1_13ck173 FIND v(dout1_13) AT=870.025n

* CHECK dout1_14 Vdout1_14ck173 = 0 time = 870
.meas tran vdout1_14ck173 FIND v(dout1_14) AT=870.025n

* CHECK dout1_15 Vdout1_15ck173 = 0 time = 870
.meas tran vdout1_15ck173 FIND v(dout1_15) AT=870.025n

* CHECK dout1_16 Vdout1_16ck173 = 0.9 time = 870
.meas tran vdout1_16ck173 FIND v(dout1_16) AT=870.025n

* CHECK dout1_17 Vdout1_17ck173 = 0.9 time = 870
.meas tran vdout1_17ck173 FIND v(dout1_17) AT=870.025n

* CHECK dout1_18 Vdout1_18ck173 = 0.9 time = 870
.meas tran vdout1_18ck173 FIND v(dout1_18) AT=870.025n

* CHECK dout1_19 Vdout1_19ck173 = 0.9 time = 870
.meas tran vdout1_19ck173 FIND v(dout1_19) AT=870.025n

* CHECK dout1_20 Vdout1_20ck173 = 0 time = 870
.meas tran vdout1_20ck173 FIND v(dout1_20) AT=870.025n

* CHECK dout1_21 Vdout1_21ck173 = 0 time = 870
.meas tran vdout1_21ck173 FIND v(dout1_21) AT=870.025n

* CHECK dout1_22 Vdout1_22ck173 = 0 time = 870
.meas tran vdout1_22ck173 FIND v(dout1_22) AT=870.025n

* CHECK dout1_23 Vdout1_23ck173 = 0.9 time = 870
.meas tran vdout1_23ck173 FIND v(dout1_23) AT=870.025n

* CHECK dout1_24 Vdout1_24ck173 = 0 time = 870
.meas tran vdout1_24ck173 FIND v(dout1_24) AT=870.025n

* CHECK dout1_25 Vdout1_25ck173 = 0 time = 870
.meas tran vdout1_25ck173 FIND v(dout1_25) AT=870.025n

* CHECK dout1_26 Vdout1_26ck173 = 0.9 time = 870
.meas tran vdout1_26ck173 FIND v(dout1_26) AT=870.025n

* CHECK dout1_27 Vdout1_27ck173 = 0.9 time = 870
.meas tran vdout1_27ck173 FIND v(dout1_27) AT=870.025n

* CHECK dout1_28 Vdout1_28ck173 = 0.9 time = 870
.meas tran vdout1_28ck173 FIND v(dout1_28) AT=870.025n

* CHECK dout1_29 Vdout1_29ck173 = 0.9 time = 870
.meas tran vdout1_29ck173 FIND v(dout1_29) AT=870.025n

* CHECK dout1_30 Vdout1_30ck173 = 0 time = 870
.meas tran vdout1_30ck173 FIND v(dout1_30) AT=870.025n

* CHECK dout1_31 Vdout1_31ck173 = 0 time = 870
.meas tran vdout1_31ck173 FIND v(dout1_31) AT=870.025n

* CHECK dout1_32 Vdout1_32ck173 = 0 time = 870
.meas tran vdout1_32ck173 FIND v(dout1_32) AT=870.025n

* CHECK dout1_33 Vdout1_33ck173 = 0 time = 870
.meas tran vdout1_33ck173 FIND v(dout1_33) AT=870.025n

* CHECK dout1_34 Vdout1_34ck173 = 0.9 time = 870
.meas tran vdout1_34ck173 FIND v(dout1_34) AT=870.025n

* CHECK dout1_35 Vdout1_35ck173 = 0.9 time = 870
.meas tran vdout1_35ck173 FIND v(dout1_35) AT=870.025n

* CHECK dout1_36 Vdout1_36ck173 = 0.9 time = 870
.meas tran vdout1_36ck173 FIND v(dout1_36) AT=870.025n

* CHECK dout1_37 Vdout1_37ck173 = 0 time = 870
.meas tran vdout1_37ck173 FIND v(dout1_37) AT=870.025n

* CHECK dout1_38 Vdout1_38ck173 = 0.9 time = 870
.meas tran vdout1_38ck173 FIND v(dout1_38) AT=870.025n

* CHECK dout1_39 Vdout1_39ck173 = 0 time = 870
.meas tran vdout1_39ck173 FIND v(dout1_39) AT=870.025n

* CHECK dout1_40 Vdout1_40ck173 = 0 time = 870
.meas tran vdout1_40ck173 FIND v(dout1_40) AT=870.025n

* CHECK dout1_41 Vdout1_41ck173 = 0 time = 870
.meas tran vdout1_41ck173 FIND v(dout1_41) AT=870.025n

* CHECK dout1_42 Vdout1_42ck173 = 0.9 time = 870
.meas tran vdout1_42ck173 FIND v(dout1_42) AT=870.025n

* CHECK dout1_43 Vdout1_43ck173 = 0 time = 870
.meas tran vdout1_43ck173 FIND v(dout1_43) AT=870.025n

* CHECK dout1_44 Vdout1_44ck173 = 0.9 time = 870
.meas tran vdout1_44ck173 FIND v(dout1_44) AT=870.025n

* CHECK dout1_45 Vdout1_45ck173 = 0.9 time = 870
.meas tran vdout1_45ck173 FIND v(dout1_45) AT=870.025n

* CHECK dout1_46 Vdout1_46ck173 = 0.9 time = 870
.meas tran vdout1_46ck173 FIND v(dout1_46) AT=870.025n

* CHECK dout1_47 Vdout1_47ck173 = 0 time = 870
.meas tran vdout1_47ck173 FIND v(dout1_47) AT=870.025n

* CHECK dout1_48 Vdout1_48ck173 = 0 time = 870
.meas tran vdout1_48ck173 FIND v(dout1_48) AT=870.025n

* CHECK dout1_49 Vdout1_49ck173 = 0.9 time = 870
.meas tran vdout1_49ck173 FIND v(dout1_49) AT=870.025n

* CHECK dout1_50 Vdout1_50ck173 = 0 time = 870
.meas tran vdout1_50ck173 FIND v(dout1_50) AT=870.025n

* CHECK dout1_51 Vdout1_51ck173 = 0 time = 870
.meas tran vdout1_51ck173 FIND v(dout1_51) AT=870.025n

* CHECK dout1_52 Vdout1_52ck173 = 0.9 time = 870
.meas tran vdout1_52ck173 FIND v(dout1_52) AT=870.025n

* CHECK dout1_53 Vdout1_53ck173 = 0 time = 870
.meas tran vdout1_53ck173 FIND v(dout1_53) AT=870.025n

* CHECK dout1_54 Vdout1_54ck173 = 0 time = 870
.meas tran vdout1_54ck173 FIND v(dout1_54) AT=870.025n

* CHECK dout1_55 Vdout1_55ck173 = 0.9 time = 870
.meas tran vdout1_55ck173 FIND v(dout1_55) AT=870.025n

* CHECK dout1_56 Vdout1_56ck173 = 0 time = 870
.meas tran vdout1_56ck173 FIND v(dout1_56) AT=870.025n

* CHECK dout1_57 Vdout1_57ck173 = 0 time = 870
.meas tran vdout1_57ck173 FIND v(dout1_57) AT=870.025n

* CHECK dout1_58 Vdout1_58ck173 = 0 time = 870
.meas tran vdout1_58ck173 FIND v(dout1_58) AT=870.025n

* CHECK dout1_59 Vdout1_59ck173 = 0.9 time = 870
.meas tran vdout1_59ck173 FIND v(dout1_59) AT=870.025n

* CHECK dout1_60 Vdout1_60ck173 = 0.9 time = 870
.meas tran vdout1_60ck173 FIND v(dout1_60) AT=870.025n

* CHECK dout1_61 Vdout1_61ck173 = 0.9 time = 870
.meas tran vdout1_61ck173 FIND v(dout1_61) AT=870.025n

* CHECK dout1_62 Vdout1_62ck173 = 0 time = 870
.meas tran vdout1_62ck173 FIND v(dout1_62) AT=870.025n

* CHECK dout1_63 Vdout1_63ck173 = 0 time = 870
.meas tran vdout1_63ck173 FIND v(dout1_63) AT=870.025n

* CHECK dout1_64 Vdout1_64ck173 = 0.9 time = 870
.meas tran vdout1_64ck173 FIND v(dout1_64) AT=870.025n

* CHECK dout1_65 Vdout1_65ck173 = 0 time = 870
.meas tran vdout1_65ck173 FIND v(dout1_65) AT=870.025n

* CHECK dout1_66 Vdout1_66ck173 = 0 time = 870
.meas tran vdout1_66ck173 FIND v(dout1_66) AT=870.025n

* CHECK dout1_67 Vdout1_67ck173 = 0.9 time = 870
.meas tran vdout1_67ck173 FIND v(dout1_67) AT=870.025n

* CHECK dout1_68 Vdout1_68ck173 = 0 time = 870
.meas tran vdout1_68ck173 FIND v(dout1_68) AT=870.025n

* CHECK dout1_69 Vdout1_69ck173 = 0.9 time = 870
.meas tran vdout1_69ck173 FIND v(dout1_69) AT=870.025n

* CHECK dout1_70 Vdout1_70ck173 = 0.9 time = 870
.meas tran vdout1_70ck173 FIND v(dout1_70) AT=870.025n

* CHECK dout1_71 Vdout1_71ck173 = 0 time = 870
.meas tran vdout1_71ck173 FIND v(dout1_71) AT=870.025n

* CHECK dout1_0 Vdout1_0ck174 = 0 time = 875
.meas tran vdout1_0ck174 FIND v(dout1_0) AT=875.025n

* CHECK dout1_1 Vdout1_1ck174 = 0.9 time = 875
.meas tran vdout1_1ck174 FIND v(dout1_1) AT=875.025n

* CHECK dout1_2 Vdout1_2ck174 = 0 time = 875
.meas tran vdout1_2ck174 FIND v(dout1_2) AT=875.025n

* CHECK dout1_3 Vdout1_3ck174 = 0.9 time = 875
.meas tran vdout1_3ck174 FIND v(dout1_3) AT=875.025n

* CHECK dout1_4 Vdout1_4ck174 = 0 time = 875
.meas tran vdout1_4ck174 FIND v(dout1_4) AT=875.025n

* CHECK dout1_5 Vdout1_5ck174 = 0 time = 875
.meas tran vdout1_5ck174 FIND v(dout1_5) AT=875.025n

* CHECK dout1_6 Vdout1_6ck174 = 0 time = 875
.meas tran vdout1_6ck174 FIND v(dout1_6) AT=875.025n

* CHECK dout1_7 Vdout1_7ck174 = 0 time = 875
.meas tran vdout1_7ck174 FIND v(dout1_7) AT=875.025n

* CHECK dout1_8 Vdout1_8ck174 = 0 time = 875
.meas tran vdout1_8ck174 FIND v(dout1_8) AT=875.025n

* CHECK dout1_9 Vdout1_9ck174 = 0.9 time = 875
.meas tran vdout1_9ck174 FIND v(dout1_9) AT=875.025n

* CHECK dout1_10 Vdout1_10ck174 = 0 time = 875
.meas tran vdout1_10ck174 FIND v(dout1_10) AT=875.025n

* CHECK dout1_11 Vdout1_11ck174 = 0.9 time = 875
.meas tran vdout1_11ck174 FIND v(dout1_11) AT=875.025n

* CHECK dout1_12 Vdout1_12ck174 = 0.9 time = 875
.meas tran vdout1_12ck174 FIND v(dout1_12) AT=875.025n

* CHECK dout1_13 Vdout1_13ck174 = 0 time = 875
.meas tran vdout1_13ck174 FIND v(dout1_13) AT=875.025n

* CHECK dout1_14 Vdout1_14ck174 = 0 time = 875
.meas tran vdout1_14ck174 FIND v(dout1_14) AT=875.025n

* CHECK dout1_15 Vdout1_15ck174 = 0 time = 875
.meas tran vdout1_15ck174 FIND v(dout1_15) AT=875.025n

* CHECK dout1_16 Vdout1_16ck174 = 0.9 time = 875
.meas tran vdout1_16ck174 FIND v(dout1_16) AT=875.025n

* CHECK dout1_17 Vdout1_17ck174 = 0.9 time = 875
.meas tran vdout1_17ck174 FIND v(dout1_17) AT=875.025n

* CHECK dout1_18 Vdout1_18ck174 = 0.9 time = 875
.meas tran vdout1_18ck174 FIND v(dout1_18) AT=875.025n

* CHECK dout1_19 Vdout1_19ck174 = 0.9 time = 875
.meas tran vdout1_19ck174 FIND v(dout1_19) AT=875.025n

* CHECK dout1_20 Vdout1_20ck174 = 0 time = 875
.meas tran vdout1_20ck174 FIND v(dout1_20) AT=875.025n

* CHECK dout1_21 Vdout1_21ck174 = 0 time = 875
.meas tran vdout1_21ck174 FIND v(dout1_21) AT=875.025n

* CHECK dout1_22 Vdout1_22ck174 = 0 time = 875
.meas tran vdout1_22ck174 FIND v(dout1_22) AT=875.025n

* CHECK dout1_23 Vdout1_23ck174 = 0.9 time = 875
.meas tran vdout1_23ck174 FIND v(dout1_23) AT=875.025n

* CHECK dout1_24 Vdout1_24ck174 = 0 time = 875
.meas tran vdout1_24ck174 FIND v(dout1_24) AT=875.025n

* CHECK dout1_25 Vdout1_25ck174 = 0 time = 875
.meas tran vdout1_25ck174 FIND v(dout1_25) AT=875.025n

* CHECK dout1_26 Vdout1_26ck174 = 0.9 time = 875
.meas tran vdout1_26ck174 FIND v(dout1_26) AT=875.025n

* CHECK dout1_27 Vdout1_27ck174 = 0.9 time = 875
.meas tran vdout1_27ck174 FIND v(dout1_27) AT=875.025n

* CHECK dout1_28 Vdout1_28ck174 = 0.9 time = 875
.meas tran vdout1_28ck174 FIND v(dout1_28) AT=875.025n

* CHECK dout1_29 Vdout1_29ck174 = 0.9 time = 875
.meas tran vdout1_29ck174 FIND v(dout1_29) AT=875.025n

* CHECK dout1_30 Vdout1_30ck174 = 0 time = 875
.meas tran vdout1_30ck174 FIND v(dout1_30) AT=875.025n

* CHECK dout1_31 Vdout1_31ck174 = 0 time = 875
.meas tran vdout1_31ck174 FIND v(dout1_31) AT=875.025n

* CHECK dout1_32 Vdout1_32ck174 = 0 time = 875
.meas tran vdout1_32ck174 FIND v(dout1_32) AT=875.025n

* CHECK dout1_33 Vdout1_33ck174 = 0 time = 875
.meas tran vdout1_33ck174 FIND v(dout1_33) AT=875.025n

* CHECK dout1_34 Vdout1_34ck174 = 0.9 time = 875
.meas tran vdout1_34ck174 FIND v(dout1_34) AT=875.025n

* CHECK dout1_35 Vdout1_35ck174 = 0.9 time = 875
.meas tran vdout1_35ck174 FIND v(dout1_35) AT=875.025n

* CHECK dout1_36 Vdout1_36ck174 = 0.9 time = 875
.meas tran vdout1_36ck174 FIND v(dout1_36) AT=875.025n

* CHECK dout1_37 Vdout1_37ck174 = 0 time = 875
.meas tran vdout1_37ck174 FIND v(dout1_37) AT=875.025n

* CHECK dout1_38 Vdout1_38ck174 = 0.9 time = 875
.meas tran vdout1_38ck174 FIND v(dout1_38) AT=875.025n

* CHECK dout1_39 Vdout1_39ck174 = 0 time = 875
.meas tran vdout1_39ck174 FIND v(dout1_39) AT=875.025n

* CHECK dout1_40 Vdout1_40ck174 = 0 time = 875
.meas tran vdout1_40ck174 FIND v(dout1_40) AT=875.025n

* CHECK dout1_41 Vdout1_41ck174 = 0 time = 875
.meas tran vdout1_41ck174 FIND v(dout1_41) AT=875.025n

* CHECK dout1_42 Vdout1_42ck174 = 0.9 time = 875
.meas tran vdout1_42ck174 FIND v(dout1_42) AT=875.025n

* CHECK dout1_43 Vdout1_43ck174 = 0 time = 875
.meas tran vdout1_43ck174 FIND v(dout1_43) AT=875.025n

* CHECK dout1_44 Vdout1_44ck174 = 0.9 time = 875
.meas tran vdout1_44ck174 FIND v(dout1_44) AT=875.025n

* CHECK dout1_45 Vdout1_45ck174 = 0.9 time = 875
.meas tran vdout1_45ck174 FIND v(dout1_45) AT=875.025n

* CHECK dout1_46 Vdout1_46ck174 = 0.9 time = 875
.meas tran vdout1_46ck174 FIND v(dout1_46) AT=875.025n

* CHECK dout1_47 Vdout1_47ck174 = 0 time = 875
.meas tran vdout1_47ck174 FIND v(dout1_47) AT=875.025n

* CHECK dout1_48 Vdout1_48ck174 = 0 time = 875
.meas tran vdout1_48ck174 FIND v(dout1_48) AT=875.025n

* CHECK dout1_49 Vdout1_49ck174 = 0.9 time = 875
.meas tran vdout1_49ck174 FIND v(dout1_49) AT=875.025n

* CHECK dout1_50 Vdout1_50ck174 = 0 time = 875
.meas tran vdout1_50ck174 FIND v(dout1_50) AT=875.025n

* CHECK dout1_51 Vdout1_51ck174 = 0 time = 875
.meas tran vdout1_51ck174 FIND v(dout1_51) AT=875.025n

* CHECK dout1_52 Vdout1_52ck174 = 0.9 time = 875
.meas tran vdout1_52ck174 FIND v(dout1_52) AT=875.025n

* CHECK dout1_53 Vdout1_53ck174 = 0 time = 875
.meas tran vdout1_53ck174 FIND v(dout1_53) AT=875.025n

* CHECK dout1_54 Vdout1_54ck174 = 0 time = 875
.meas tran vdout1_54ck174 FIND v(dout1_54) AT=875.025n

* CHECK dout1_55 Vdout1_55ck174 = 0.9 time = 875
.meas tran vdout1_55ck174 FIND v(dout1_55) AT=875.025n

* CHECK dout1_56 Vdout1_56ck174 = 0 time = 875
.meas tran vdout1_56ck174 FIND v(dout1_56) AT=875.025n

* CHECK dout1_57 Vdout1_57ck174 = 0 time = 875
.meas tran vdout1_57ck174 FIND v(dout1_57) AT=875.025n

* CHECK dout1_58 Vdout1_58ck174 = 0 time = 875
.meas tran vdout1_58ck174 FIND v(dout1_58) AT=875.025n

* CHECK dout1_59 Vdout1_59ck174 = 0.9 time = 875
.meas tran vdout1_59ck174 FIND v(dout1_59) AT=875.025n

* CHECK dout1_60 Vdout1_60ck174 = 0.9 time = 875
.meas tran vdout1_60ck174 FIND v(dout1_60) AT=875.025n

* CHECK dout1_61 Vdout1_61ck174 = 0.9 time = 875
.meas tran vdout1_61ck174 FIND v(dout1_61) AT=875.025n

* CHECK dout1_62 Vdout1_62ck174 = 0 time = 875
.meas tran vdout1_62ck174 FIND v(dout1_62) AT=875.025n

* CHECK dout1_63 Vdout1_63ck174 = 0 time = 875
.meas tran vdout1_63ck174 FIND v(dout1_63) AT=875.025n

* CHECK dout1_64 Vdout1_64ck174 = 0.9 time = 875
.meas tran vdout1_64ck174 FIND v(dout1_64) AT=875.025n

* CHECK dout1_65 Vdout1_65ck174 = 0 time = 875
.meas tran vdout1_65ck174 FIND v(dout1_65) AT=875.025n

* CHECK dout1_66 Vdout1_66ck174 = 0 time = 875
.meas tran vdout1_66ck174 FIND v(dout1_66) AT=875.025n

* CHECK dout1_67 Vdout1_67ck174 = 0.9 time = 875
.meas tran vdout1_67ck174 FIND v(dout1_67) AT=875.025n

* CHECK dout1_68 Vdout1_68ck174 = 0 time = 875
.meas tran vdout1_68ck174 FIND v(dout1_68) AT=875.025n

* CHECK dout1_69 Vdout1_69ck174 = 0.9 time = 875
.meas tran vdout1_69ck174 FIND v(dout1_69) AT=875.025n

* CHECK dout1_70 Vdout1_70ck174 = 0.9 time = 875
.meas tran vdout1_70ck174 FIND v(dout1_70) AT=875.025n

* CHECK dout1_71 Vdout1_71ck174 = 0 time = 875
.meas tran vdout1_71ck174 FIND v(dout1_71) AT=875.025n

* CHECK dout1_0 Vdout1_0ck178 = 0.9 time = 895
.meas tran vdout1_0ck178 FIND v(dout1_0) AT=895.025n

* CHECK dout1_1 Vdout1_1ck178 = 0 time = 895
.meas tran vdout1_1ck178 FIND v(dout1_1) AT=895.025n

* CHECK dout1_2 Vdout1_2ck178 = 0.9 time = 895
.meas tran vdout1_2ck178 FIND v(dout1_2) AT=895.025n

* CHECK dout1_3 Vdout1_3ck178 = 0 time = 895
.meas tran vdout1_3ck178 FIND v(dout1_3) AT=895.025n

* CHECK dout1_4 Vdout1_4ck178 = 0.9 time = 895
.meas tran vdout1_4ck178 FIND v(dout1_4) AT=895.025n

* CHECK dout1_5 Vdout1_5ck178 = 0 time = 895
.meas tran vdout1_5ck178 FIND v(dout1_5) AT=895.025n

* CHECK dout1_6 Vdout1_6ck178 = 0 time = 895
.meas tran vdout1_6ck178 FIND v(dout1_6) AT=895.025n

* CHECK dout1_7 Vdout1_7ck178 = 0.9 time = 895
.meas tran vdout1_7ck178 FIND v(dout1_7) AT=895.025n

* CHECK dout1_8 Vdout1_8ck178 = 0 time = 895
.meas tran vdout1_8ck178 FIND v(dout1_8) AT=895.025n

* CHECK dout1_9 Vdout1_9ck178 = 0 time = 895
.meas tran vdout1_9ck178 FIND v(dout1_9) AT=895.025n

* CHECK dout1_10 Vdout1_10ck178 = 0.9 time = 895
.meas tran vdout1_10ck178 FIND v(dout1_10) AT=895.025n

* CHECK dout1_11 Vdout1_11ck178 = 0.9 time = 895
.meas tran vdout1_11ck178 FIND v(dout1_11) AT=895.025n

* CHECK dout1_12 Vdout1_12ck178 = 0.9 time = 895
.meas tran vdout1_12ck178 FIND v(dout1_12) AT=895.025n

* CHECK dout1_13 Vdout1_13ck178 = 0 time = 895
.meas tran vdout1_13ck178 FIND v(dout1_13) AT=895.025n

* CHECK dout1_14 Vdout1_14ck178 = 0 time = 895
.meas tran vdout1_14ck178 FIND v(dout1_14) AT=895.025n

* CHECK dout1_15 Vdout1_15ck178 = 0.9 time = 895
.meas tran vdout1_15ck178 FIND v(dout1_15) AT=895.025n

* CHECK dout1_16 Vdout1_16ck178 = 0 time = 895
.meas tran vdout1_16ck178 FIND v(dout1_16) AT=895.025n

* CHECK dout1_17 Vdout1_17ck178 = 0 time = 895
.meas tran vdout1_17ck178 FIND v(dout1_17) AT=895.025n

* CHECK dout1_18 Vdout1_18ck178 = 0.9 time = 895
.meas tran vdout1_18ck178 FIND v(dout1_18) AT=895.025n

* CHECK dout1_19 Vdout1_19ck178 = 0 time = 895
.meas tran vdout1_19ck178 FIND v(dout1_19) AT=895.025n

* CHECK dout1_20 Vdout1_20ck178 = 0 time = 895
.meas tran vdout1_20ck178 FIND v(dout1_20) AT=895.025n

* CHECK dout1_21 Vdout1_21ck178 = 0 time = 895
.meas tran vdout1_21ck178 FIND v(dout1_21) AT=895.025n

* CHECK dout1_22 Vdout1_22ck178 = 0.9 time = 895
.meas tran vdout1_22ck178 FIND v(dout1_22) AT=895.025n

* CHECK dout1_23 Vdout1_23ck178 = 0.9 time = 895
.meas tran vdout1_23ck178 FIND v(dout1_23) AT=895.025n

* CHECK dout1_24 Vdout1_24ck178 = 0 time = 895
.meas tran vdout1_24ck178 FIND v(dout1_24) AT=895.025n

* CHECK dout1_25 Vdout1_25ck178 = 0.9 time = 895
.meas tran vdout1_25ck178 FIND v(dout1_25) AT=895.025n

* CHECK dout1_26 Vdout1_26ck178 = 0 time = 895
.meas tran vdout1_26ck178 FIND v(dout1_26) AT=895.025n

* CHECK dout1_27 Vdout1_27ck178 = 0.9 time = 895
.meas tran vdout1_27ck178 FIND v(dout1_27) AT=895.025n

* CHECK dout1_28 Vdout1_28ck178 = 0 time = 895
.meas tran vdout1_28ck178 FIND v(dout1_28) AT=895.025n

* CHECK dout1_29 Vdout1_29ck178 = 0.9 time = 895
.meas tran vdout1_29ck178 FIND v(dout1_29) AT=895.025n

* CHECK dout1_30 Vdout1_30ck178 = 0 time = 895
.meas tran vdout1_30ck178 FIND v(dout1_30) AT=895.025n

* CHECK dout1_31 Vdout1_31ck178 = 0 time = 895
.meas tran vdout1_31ck178 FIND v(dout1_31) AT=895.025n

* CHECK dout1_32 Vdout1_32ck178 = 0.9 time = 895
.meas tran vdout1_32ck178 FIND v(dout1_32) AT=895.025n

* CHECK dout1_33 Vdout1_33ck178 = 0 time = 895
.meas tran vdout1_33ck178 FIND v(dout1_33) AT=895.025n

* CHECK dout1_34 Vdout1_34ck178 = 0.9 time = 895
.meas tran vdout1_34ck178 FIND v(dout1_34) AT=895.025n

* CHECK dout1_35 Vdout1_35ck178 = 0 time = 895
.meas tran vdout1_35ck178 FIND v(dout1_35) AT=895.025n

* CHECK dout1_36 Vdout1_36ck178 = 0 time = 895
.meas tran vdout1_36ck178 FIND v(dout1_36) AT=895.025n

* CHECK dout1_37 Vdout1_37ck178 = 0.9 time = 895
.meas tran vdout1_37ck178 FIND v(dout1_37) AT=895.025n

* CHECK dout1_38 Vdout1_38ck178 = 0.9 time = 895
.meas tran vdout1_38ck178 FIND v(dout1_38) AT=895.025n

* CHECK dout1_39 Vdout1_39ck178 = 0 time = 895
.meas tran vdout1_39ck178 FIND v(dout1_39) AT=895.025n

* CHECK dout1_40 Vdout1_40ck178 = 0.9 time = 895
.meas tran vdout1_40ck178 FIND v(dout1_40) AT=895.025n

* CHECK dout1_41 Vdout1_41ck178 = 0.9 time = 895
.meas tran vdout1_41ck178 FIND v(dout1_41) AT=895.025n

* CHECK dout1_42 Vdout1_42ck178 = 0.9 time = 895
.meas tran vdout1_42ck178 FIND v(dout1_42) AT=895.025n

* CHECK dout1_43 Vdout1_43ck178 = 0 time = 895
.meas tran vdout1_43ck178 FIND v(dout1_43) AT=895.025n

* CHECK dout1_44 Vdout1_44ck178 = 0.9 time = 895
.meas tran vdout1_44ck178 FIND v(dout1_44) AT=895.025n

* CHECK dout1_45 Vdout1_45ck178 = 0.9 time = 895
.meas tran vdout1_45ck178 FIND v(dout1_45) AT=895.025n

* CHECK dout1_46 Vdout1_46ck178 = 0 time = 895
.meas tran vdout1_46ck178 FIND v(dout1_46) AT=895.025n

* CHECK dout1_47 Vdout1_47ck178 = 0.9 time = 895
.meas tran vdout1_47ck178 FIND v(dout1_47) AT=895.025n

* CHECK dout1_48 Vdout1_48ck178 = 0 time = 895
.meas tran vdout1_48ck178 FIND v(dout1_48) AT=895.025n

* CHECK dout1_49 Vdout1_49ck178 = 0 time = 895
.meas tran vdout1_49ck178 FIND v(dout1_49) AT=895.025n

* CHECK dout1_50 Vdout1_50ck178 = 0.9 time = 895
.meas tran vdout1_50ck178 FIND v(dout1_50) AT=895.025n

* CHECK dout1_51 Vdout1_51ck178 = 0 time = 895
.meas tran vdout1_51ck178 FIND v(dout1_51) AT=895.025n

* CHECK dout1_52 Vdout1_52ck178 = 0 time = 895
.meas tran vdout1_52ck178 FIND v(dout1_52) AT=895.025n

* CHECK dout1_53 Vdout1_53ck178 = 0 time = 895
.meas tran vdout1_53ck178 FIND v(dout1_53) AT=895.025n

* CHECK dout1_54 Vdout1_54ck178 = 0.9 time = 895
.meas tran vdout1_54ck178 FIND v(dout1_54) AT=895.025n

* CHECK dout1_55 Vdout1_55ck178 = 0.9 time = 895
.meas tran vdout1_55ck178 FIND v(dout1_55) AT=895.025n

* CHECK dout1_56 Vdout1_56ck178 = 0 time = 895
.meas tran vdout1_56ck178 FIND v(dout1_56) AT=895.025n

* CHECK dout1_57 Vdout1_57ck178 = 0 time = 895
.meas tran vdout1_57ck178 FIND v(dout1_57) AT=895.025n

* CHECK dout1_58 Vdout1_58ck178 = 0 time = 895
.meas tran vdout1_58ck178 FIND v(dout1_58) AT=895.025n

* CHECK dout1_59 Vdout1_59ck178 = 0.9 time = 895
.meas tran vdout1_59ck178 FIND v(dout1_59) AT=895.025n

* CHECK dout1_60 Vdout1_60ck178 = 0.9 time = 895
.meas tran vdout1_60ck178 FIND v(dout1_60) AT=895.025n

* CHECK dout1_61 Vdout1_61ck178 = 0.9 time = 895
.meas tran vdout1_61ck178 FIND v(dout1_61) AT=895.025n

* CHECK dout1_62 Vdout1_62ck178 = 0 time = 895
.meas tran vdout1_62ck178 FIND v(dout1_62) AT=895.025n

* CHECK dout1_63 Vdout1_63ck178 = 0.9 time = 895
.meas tran vdout1_63ck178 FIND v(dout1_63) AT=895.025n

* CHECK dout1_64 Vdout1_64ck178 = 0.9 time = 895
.meas tran vdout1_64ck178 FIND v(dout1_64) AT=895.025n

* CHECK dout1_65 Vdout1_65ck178 = 0.9 time = 895
.meas tran vdout1_65ck178 FIND v(dout1_65) AT=895.025n

* CHECK dout1_66 Vdout1_66ck178 = 0.9 time = 895
.meas tran vdout1_66ck178 FIND v(dout1_66) AT=895.025n

* CHECK dout1_67 Vdout1_67ck178 = 0 time = 895
.meas tran vdout1_67ck178 FIND v(dout1_67) AT=895.025n

* CHECK dout1_68 Vdout1_68ck178 = 0 time = 895
.meas tran vdout1_68ck178 FIND v(dout1_68) AT=895.025n

* CHECK dout1_69 Vdout1_69ck178 = 0.9 time = 895
.meas tran vdout1_69ck178 FIND v(dout1_69) AT=895.025n

* CHECK dout1_70 Vdout1_70ck178 = 0 time = 895
.meas tran vdout1_70ck178 FIND v(dout1_70) AT=895.025n

* CHECK dout1_71 Vdout1_71ck178 = 0 time = 895
.meas tran vdout1_71ck178 FIND v(dout1_71) AT=895.025n

* CHECK dout1_0 Vdout1_0ck179 = 0.9 time = 900
.meas tran vdout1_0ck179 FIND v(dout1_0) AT=900.025n

* CHECK dout1_1 Vdout1_1ck179 = 0 time = 900
.meas tran vdout1_1ck179 FIND v(dout1_1) AT=900.025n

* CHECK dout1_2 Vdout1_2ck179 = 0.9 time = 900
.meas tran vdout1_2ck179 FIND v(dout1_2) AT=900.025n

* CHECK dout1_3 Vdout1_3ck179 = 0 time = 900
.meas tran vdout1_3ck179 FIND v(dout1_3) AT=900.025n

* CHECK dout1_4 Vdout1_4ck179 = 0.9 time = 900
.meas tran vdout1_4ck179 FIND v(dout1_4) AT=900.025n

* CHECK dout1_5 Vdout1_5ck179 = 0 time = 900
.meas tran vdout1_5ck179 FIND v(dout1_5) AT=900.025n

* CHECK dout1_6 Vdout1_6ck179 = 0 time = 900
.meas tran vdout1_6ck179 FIND v(dout1_6) AT=900.025n

* CHECK dout1_7 Vdout1_7ck179 = 0.9 time = 900
.meas tran vdout1_7ck179 FIND v(dout1_7) AT=900.025n

* CHECK dout1_8 Vdout1_8ck179 = 0 time = 900
.meas tran vdout1_8ck179 FIND v(dout1_8) AT=900.025n

* CHECK dout1_9 Vdout1_9ck179 = 0 time = 900
.meas tran vdout1_9ck179 FIND v(dout1_9) AT=900.025n

* CHECK dout1_10 Vdout1_10ck179 = 0.9 time = 900
.meas tran vdout1_10ck179 FIND v(dout1_10) AT=900.025n

* CHECK dout1_11 Vdout1_11ck179 = 0.9 time = 900
.meas tran vdout1_11ck179 FIND v(dout1_11) AT=900.025n

* CHECK dout1_12 Vdout1_12ck179 = 0.9 time = 900
.meas tran vdout1_12ck179 FIND v(dout1_12) AT=900.025n

* CHECK dout1_13 Vdout1_13ck179 = 0 time = 900
.meas tran vdout1_13ck179 FIND v(dout1_13) AT=900.025n

* CHECK dout1_14 Vdout1_14ck179 = 0 time = 900
.meas tran vdout1_14ck179 FIND v(dout1_14) AT=900.025n

* CHECK dout1_15 Vdout1_15ck179 = 0.9 time = 900
.meas tran vdout1_15ck179 FIND v(dout1_15) AT=900.025n

* CHECK dout1_16 Vdout1_16ck179 = 0 time = 900
.meas tran vdout1_16ck179 FIND v(dout1_16) AT=900.025n

* CHECK dout1_17 Vdout1_17ck179 = 0 time = 900
.meas tran vdout1_17ck179 FIND v(dout1_17) AT=900.025n

* CHECK dout1_18 Vdout1_18ck179 = 0.9 time = 900
.meas tran vdout1_18ck179 FIND v(dout1_18) AT=900.025n

* CHECK dout1_19 Vdout1_19ck179 = 0 time = 900
.meas tran vdout1_19ck179 FIND v(dout1_19) AT=900.025n

* CHECK dout1_20 Vdout1_20ck179 = 0 time = 900
.meas tran vdout1_20ck179 FIND v(dout1_20) AT=900.025n

* CHECK dout1_21 Vdout1_21ck179 = 0 time = 900
.meas tran vdout1_21ck179 FIND v(dout1_21) AT=900.025n

* CHECK dout1_22 Vdout1_22ck179 = 0.9 time = 900
.meas tran vdout1_22ck179 FIND v(dout1_22) AT=900.025n

* CHECK dout1_23 Vdout1_23ck179 = 0.9 time = 900
.meas tran vdout1_23ck179 FIND v(dout1_23) AT=900.025n

* CHECK dout1_24 Vdout1_24ck179 = 0 time = 900
.meas tran vdout1_24ck179 FIND v(dout1_24) AT=900.025n

* CHECK dout1_25 Vdout1_25ck179 = 0.9 time = 900
.meas tran vdout1_25ck179 FIND v(dout1_25) AT=900.025n

* CHECK dout1_26 Vdout1_26ck179 = 0 time = 900
.meas tran vdout1_26ck179 FIND v(dout1_26) AT=900.025n

* CHECK dout1_27 Vdout1_27ck179 = 0.9 time = 900
.meas tran vdout1_27ck179 FIND v(dout1_27) AT=900.025n

* CHECK dout1_28 Vdout1_28ck179 = 0 time = 900
.meas tran vdout1_28ck179 FIND v(dout1_28) AT=900.025n

* CHECK dout1_29 Vdout1_29ck179 = 0.9 time = 900
.meas tran vdout1_29ck179 FIND v(dout1_29) AT=900.025n

* CHECK dout1_30 Vdout1_30ck179 = 0 time = 900
.meas tran vdout1_30ck179 FIND v(dout1_30) AT=900.025n

* CHECK dout1_31 Vdout1_31ck179 = 0 time = 900
.meas tran vdout1_31ck179 FIND v(dout1_31) AT=900.025n

* CHECK dout1_32 Vdout1_32ck179 = 0.9 time = 900
.meas tran vdout1_32ck179 FIND v(dout1_32) AT=900.025n

* CHECK dout1_33 Vdout1_33ck179 = 0 time = 900
.meas tran vdout1_33ck179 FIND v(dout1_33) AT=900.025n

* CHECK dout1_34 Vdout1_34ck179 = 0.9 time = 900
.meas tran vdout1_34ck179 FIND v(dout1_34) AT=900.025n

* CHECK dout1_35 Vdout1_35ck179 = 0 time = 900
.meas tran vdout1_35ck179 FIND v(dout1_35) AT=900.025n

* CHECK dout1_36 Vdout1_36ck179 = 0 time = 900
.meas tran vdout1_36ck179 FIND v(dout1_36) AT=900.025n

* CHECK dout1_37 Vdout1_37ck179 = 0.9 time = 900
.meas tran vdout1_37ck179 FIND v(dout1_37) AT=900.025n

* CHECK dout1_38 Vdout1_38ck179 = 0.9 time = 900
.meas tran vdout1_38ck179 FIND v(dout1_38) AT=900.025n

* CHECK dout1_39 Vdout1_39ck179 = 0 time = 900
.meas tran vdout1_39ck179 FIND v(dout1_39) AT=900.025n

* CHECK dout1_40 Vdout1_40ck179 = 0.9 time = 900
.meas tran vdout1_40ck179 FIND v(dout1_40) AT=900.025n

* CHECK dout1_41 Vdout1_41ck179 = 0.9 time = 900
.meas tran vdout1_41ck179 FIND v(dout1_41) AT=900.025n

* CHECK dout1_42 Vdout1_42ck179 = 0.9 time = 900
.meas tran vdout1_42ck179 FIND v(dout1_42) AT=900.025n

* CHECK dout1_43 Vdout1_43ck179 = 0 time = 900
.meas tran vdout1_43ck179 FIND v(dout1_43) AT=900.025n

* CHECK dout1_44 Vdout1_44ck179 = 0.9 time = 900
.meas tran vdout1_44ck179 FIND v(dout1_44) AT=900.025n

* CHECK dout1_45 Vdout1_45ck179 = 0.9 time = 900
.meas tran vdout1_45ck179 FIND v(dout1_45) AT=900.025n

* CHECK dout1_46 Vdout1_46ck179 = 0 time = 900
.meas tran vdout1_46ck179 FIND v(dout1_46) AT=900.025n

* CHECK dout1_47 Vdout1_47ck179 = 0.9 time = 900
.meas tran vdout1_47ck179 FIND v(dout1_47) AT=900.025n

* CHECK dout1_48 Vdout1_48ck179 = 0 time = 900
.meas tran vdout1_48ck179 FIND v(dout1_48) AT=900.025n

* CHECK dout1_49 Vdout1_49ck179 = 0 time = 900
.meas tran vdout1_49ck179 FIND v(dout1_49) AT=900.025n

* CHECK dout1_50 Vdout1_50ck179 = 0.9 time = 900
.meas tran vdout1_50ck179 FIND v(dout1_50) AT=900.025n

* CHECK dout1_51 Vdout1_51ck179 = 0 time = 900
.meas tran vdout1_51ck179 FIND v(dout1_51) AT=900.025n

* CHECK dout1_52 Vdout1_52ck179 = 0 time = 900
.meas tran vdout1_52ck179 FIND v(dout1_52) AT=900.025n

* CHECK dout1_53 Vdout1_53ck179 = 0 time = 900
.meas tran vdout1_53ck179 FIND v(dout1_53) AT=900.025n

* CHECK dout1_54 Vdout1_54ck179 = 0.9 time = 900
.meas tran vdout1_54ck179 FIND v(dout1_54) AT=900.025n

* CHECK dout1_55 Vdout1_55ck179 = 0.9 time = 900
.meas tran vdout1_55ck179 FIND v(dout1_55) AT=900.025n

* CHECK dout1_56 Vdout1_56ck179 = 0 time = 900
.meas tran vdout1_56ck179 FIND v(dout1_56) AT=900.025n

* CHECK dout1_57 Vdout1_57ck179 = 0 time = 900
.meas tran vdout1_57ck179 FIND v(dout1_57) AT=900.025n

* CHECK dout1_58 Vdout1_58ck179 = 0 time = 900
.meas tran vdout1_58ck179 FIND v(dout1_58) AT=900.025n

* CHECK dout1_59 Vdout1_59ck179 = 0.9 time = 900
.meas tran vdout1_59ck179 FIND v(dout1_59) AT=900.025n

* CHECK dout1_60 Vdout1_60ck179 = 0.9 time = 900
.meas tran vdout1_60ck179 FIND v(dout1_60) AT=900.025n

* CHECK dout1_61 Vdout1_61ck179 = 0.9 time = 900
.meas tran vdout1_61ck179 FIND v(dout1_61) AT=900.025n

* CHECK dout1_62 Vdout1_62ck179 = 0 time = 900
.meas tran vdout1_62ck179 FIND v(dout1_62) AT=900.025n

* CHECK dout1_63 Vdout1_63ck179 = 0.9 time = 900
.meas tran vdout1_63ck179 FIND v(dout1_63) AT=900.025n

* CHECK dout1_64 Vdout1_64ck179 = 0.9 time = 900
.meas tran vdout1_64ck179 FIND v(dout1_64) AT=900.025n

* CHECK dout1_65 Vdout1_65ck179 = 0.9 time = 900
.meas tran vdout1_65ck179 FIND v(dout1_65) AT=900.025n

* CHECK dout1_66 Vdout1_66ck179 = 0.9 time = 900
.meas tran vdout1_66ck179 FIND v(dout1_66) AT=900.025n

* CHECK dout1_67 Vdout1_67ck179 = 0 time = 900
.meas tran vdout1_67ck179 FIND v(dout1_67) AT=900.025n

* CHECK dout1_68 Vdout1_68ck179 = 0 time = 900
.meas tran vdout1_68ck179 FIND v(dout1_68) AT=900.025n

* CHECK dout1_69 Vdout1_69ck179 = 0.9 time = 900
.meas tran vdout1_69ck179 FIND v(dout1_69) AT=900.025n

* CHECK dout1_70 Vdout1_70ck179 = 0 time = 900
.meas tran vdout1_70ck179 FIND v(dout1_70) AT=900.025n

* CHECK dout1_71 Vdout1_71ck179 = 0 time = 900
.meas tran vdout1_71ck179 FIND v(dout1_71) AT=900.025n

* CHECK dout1_0 Vdout1_0ck180 = 0 time = 905
.meas tran vdout1_0ck180 FIND v(dout1_0) AT=905.025n

* CHECK dout1_1 Vdout1_1ck180 = 0 time = 905
.meas tran vdout1_1ck180 FIND v(dout1_1) AT=905.025n

* CHECK dout1_2 Vdout1_2ck180 = 0.9 time = 905
.meas tran vdout1_2ck180 FIND v(dout1_2) AT=905.025n

* CHECK dout1_3 Vdout1_3ck180 = 0.9 time = 905
.meas tran vdout1_3ck180 FIND v(dout1_3) AT=905.025n

* CHECK dout1_4 Vdout1_4ck180 = 0 time = 905
.meas tran vdout1_4ck180 FIND v(dout1_4) AT=905.025n

* CHECK dout1_5 Vdout1_5ck180 = 0 time = 905
.meas tran vdout1_5ck180 FIND v(dout1_5) AT=905.025n

* CHECK dout1_6 Vdout1_6ck180 = 0.9 time = 905
.meas tran vdout1_6ck180 FIND v(dout1_6) AT=905.025n

* CHECK dout1_7 Vdout1_7ck180 = 0 time = 905
.meas tran vdout1_7ck180 FIND v(dout1_7) AT=905.025n

* CHECK dout1_8 Vdout1_8ck180 = 0.9 time = 905
.meas tran vdout1_8ck180 FIND v(dout1_8) AT=905.025n

* CHECK dout1_9 Vdout1_9ck180 = 0 time = 905
.meas tran vdout1_9ck180 FIND v(dout1_9) AT=905.025n

* CHECK dout1_10 Vdout1_10ck180 = 0 time = 905
.meas tran vdout1_10ck180 FIND v(dout1_10) AT=905.025n

* CHECK dout1_11 Vdout1_11ck180 = 0 time = 905
.meas tran vdout1_11ck180 FIND v(dout1_11) AT=905.025n

* CHECK dout1_12 Vdout1_12ck180 = 0 time = 905
.meas tran vdout1_12ck180 FIND v(dout1_12) AT=905.025n

* CHECK dout1_13 Vdout1_13ck180 = 0.9 time = 905
.meas tran vdout1_13ck180 FIND v(dout1_13) AT=905.025n

* CHECK dout1_14 Vdout1_14ck180 = 0 time = 905
.meas tran vdout1_14ck180 FIND v(dout1_14) AT=905.025n

* CHECK dout1_15 Vdout1_15ck180 = 0.9 time = 905
.meas tran vdout1_15ck180 FIND v(dout1_15) AT=905.025n

* CHECK dout1_16 Vdout1_16ck180 = 0 time = 905
.meas tran vdout1_16ck180 FIND v(dout1_16) AT=905.025n

* CHECK dout1_17 Vdout1_17ck180 = 0 time = 905
.meas tran vdout1_17ck180 FIND v(dout1_17) AT=905.025n

* CHECK dout1_18 Vdout1_18ck180 = 0.9 time = 905
.meas tran vdout1_18ck180 FIND v(dout1_18) AT=905.025n

* CHECK dout1_19 Vdout1_19ck180 = 0.9 time = 905
.meas tran vdout1_19ck180 FIND v(dout1_19) AT=905.025n

* CHECK dout1_20 Vdout1_20ck180 = 0 time = 905
.meas tran vdout1_20ck180 FIND v(dout1_20) AT=905.025n

* CHECK dout1_21 Vdout1_21ck180 = 0 time = 905
.meas tran vdout1_21ck180 FIND v(dout1_21) AT=905.025n

* CHECK dout1_22 Vdout1_22ck180 = 0 time = 905
.meas tran vdout1_22ck180 FIND v(dout1_22) AT=905.025n

* CHECK dout1_23 Vdout1_23ck180 = 0 time = 905
.meas tran vdout1_23ck180 FIND v(dout1_23) AT=905.025n

* CHECK dout1_24 Vdout1_24ck180 = 0 time = 905
.meas tran vdout1_24ck180 FIND v(dout1_24) AT=905.025n

* CHECK dout1_25 Vdout1_25ck180 = 0.9 time = 905
.meas tran vdout1_25ck180 FIND v(dout1_25) AT=905.025n

* CHECK dout1_26 Vdout1_26ck180 = 0.9 time = 905
.meas tran vdout1_26ck180 FIND v(dout1_26) AT=905.025n

* CHECK dout1_27 Vdout1_27ck180 = 0.9 time = 905
.meas tran vdout1_27ck180 FIND v(dout1_27) AT=905.025n

* CHECK dout1_28 Vdout1_28ck180 = 0.9 time = 905
.meas tran vdout1_28ck180 FIND v(dout1_28) AT=905.025n

* CHECK dout1_29 Vdout1_29ck180 = 0 time = 905
.meas tran vdout1_29ck180 FIND v(dout1_29) AT=905.025n

* CHECK dout1_30 Vdout1_30ck180 = 0.9 time = 905
.meas tran vdout1_30ck180 FIND v(dout1_30) AT=905.025n

* CHECK dout1_31 Vdout1_31ck180 = 0.9 time = 905
.meas tran vdout1_31ck180 FIND v(dout1_31) AT=905.025n

* CHECK dout1_32 Vdout1_32ck180 = 0.9 time = 905
.meas tran vdout1_32ck180 FIND v(dout1_32) AT=905.025n

* CHECK dout1_33 Vdout1_33ck180 = 0 time = 905
.meas tran vdout1_33ck180 FIND v(dout1_33) AT=905.025n

* CHECK dout1_34 Vdout1_34ck180 = 0 time = 905
.meas tran vdout1_34ck180 FIND v(dout1_34) AT=905.025n

* CHECK dout1_35 Vdout1_35ck180 = 0.9 time = 905
.meas tran vdout1_35ck180 FIND v(dout1_35) AT=905.025n

* CHECK dout1_36 Vdout1_36ck180 = 0.9 time = 905
.meas tran vdout1_36ck180 FIND v(dout1_36) AT=905.025n

* CHECK dout1_37 Vdout1_37ck180 = 0.9 time = 905
.meas tran vdout1_37ck180 FIND v(dout1_37) AT=905.025n

* CHECK dout1_38 Vdout1_38ck180 = 0 time = 905
.meas tran vdout1_38ck180 FIND v(dout1_38) AT=905.025n

* CHECK dout1_39 Vdout1_39ck180 = 0.9 time = 905
.meas tran vdout1_39ck180 FIND v(dout1_39) AT=905.025n

* CHECK dout1_40 Vdout1_40ck180 = 0 time = 905
.meas tran vdout1_40ck180 FIND v(dout1_40) AT=905.025n

* CHECK dout1_41 Vdout1_41ck180 = 0 time = 905
.meas tran vdout1_41ck180 FIND v(dout1_41) AT=905.025n

* CHECK dout1_42 Vdout1_42ck180 = 0 time = 905
.meas tran vdout1_42ck180 FIND v(dout1_42) AT=905.025n

* CHECK dout1_43 Vdout1_43ck180 = 0 time = 905
.meas tran vdout1_43ck180 FIND v(dout1_43) AT=905.025n

* CHECK dout1_44 Vdout1_44ck180 = 0.9 time = 905
.meas tran vdout1_44ck180 FIND v(dout1_44) AT=905.025n

* CHECK dout1_45 Vdout1_45ck180 = 0 time = 905
.meas tran vdout1_45ck180 FIND v(dout1_45) AT=905.025n

* CHECK dout1_46 Vdout1_46ck180 = 0 time = 905
.meas tran vdout1_46ck180 FIND v(dout1_46) AT=905.025n

* CHECK dout1_47 Vdout1_47ck180 = 0.9 time = 905
.meas tran vdout1_47ck180 FIND v(dout1_47) AT=905.025n

* CHECK dout1_48 Vdout1_48ck180 = 0 time = 905
.meas tran vdout1_48ck180 FIND v(dout1_48) AT=905.025n

* CHECK dout1_49 Vdout1_49ck180 = 0 time = 905
.meas tran vdout1_49ck180 FIND v(dout1_49) AT=905.025n

* CHECK dout1_50 Vdout1_50ck180 = 0.9 time = 905
.meas tran vdout1_50ck180 FIND v(dout1_50) AT=905.025n

* CHECK dout1_51 Vdout1_51ck180 = 0.9 time = 905
.meas tran vdout1_51ck180 FIND v(dout1_51) AT=905.025n

* CHECK dout1_52 Vdout1_52ck180 = 0.9 time = 905
.meas tran vdout1_52ck180 FIND v(dout1_52) AT=905.025n

* CHECK dout1_53 Vdout1_53ck180 = 0 time = 905
.meas tran vdout1_53ck180 FIND v(dout1_53) AT=905.025n

* CHECK dout1_54 Vdout1_54ck180 = 0 time = 905
.meas tran vdout1_54ck180 FIND v(dout1_54) AT=905.025n

* CHECK dout1_55 Vdout1_55ck180 = 0.9 time = 905
.meas tran vdout1_55ck180 FIND v(dout1_55) AT=905.025n

* CHECK dout1_56 Vdout1_56ck180 = 0 time = 905
.meas tran vdout1_56ck180 FIND v(dout1_56) AT=905.025n

* CHECK dout1_57 Vdout1_57ck180 = 0.9 time = 905
.meas tran vdout1_57ck180 FIND v(dout1_57) AT=905.025n

* CHECK dout1_58 Vdout1_58ck180 = 0 time = 905
.meas tran vdout1_58ck180 FIND v(dout1_58) AT=905.025n

* CHECK dout1_59 Vdout1_59ck180 = 0.9 time = 905
.meas tran vdout1_59ck180 FIND v(dout1_59) AT=905.025n

* CHECK dout1_60 Vdout1_60ck180 = 0.9 time = 905
.meas tran vdout1_60ck180 FIND v(dout1_60) AT=905.025n

* CHECK dout1_61 Vdout1_61ck180 = 0.9 time = 905
.meas tran vdout1_61ck180 FIND v(dout1_61) AT=905.025n

* CHECK dout1_62 Vdout1_62ck180 = 0 time = 905
.meas tran vdout1_62ck180 FIND v(dout1_62) AT=905.025n

* CHECK dout1_63 Vdout1_63ck180 = 0.9 time = 905
.meas tran vdout1_63ck180 FIND v(dout1_63) AT=905.025n

* CHECK dout1_64 Vdout1_64ck180 = 0.9 time = 905
.meas tran vdout1_64ck180 FIND v(dout1_64) AT=905.025n

* CHECK dout1_65 Vdout1_65ck180 = 0.9 time = 905
.meas tran vdout1_65ck180 FIND v(dout1_65) AT=905.025n

* CHECK dout1_66 Vdout1_66ck180 = 0.9 time = 905
.meas tran vdout1_66ck180 FIND v(dout1_66) AT=905.025n

* CHECK dout1_67 Vdout1_67ck180 = 0.9 time = 905
.meas tran vdout1_67ck180 FIND v(dout1_67) AT=905.025n

* CHECK dout1_68 Vdout1_68ck180 = 0.9 time = 905
.meas tran vdout1_68ck180 FIND v(dout1_68) AT=905.025n

* CHECK dout1_69 Vdout1_69ck180 = 0.9 time = 905
.meas tran vdout1_69ck180 FIND v(dout1_69) AT=905.025n

* CHECK dout1_70 Vdout1_70ck180 = 0.9 time = 905
.meas tran vdout1_70ck180 FIND v(dout1_70) AT=905.025n

* CHECK dout1_71 Vdout1_71ck180 = 0 time = 905
.meas tran vdout1_71ck180 FIND v(dout1_71) AT=905.025n

* CHECK dout1_0 Vdout1_0ck190 = 0 time = 955
.meas tran vdout1_0ck190 FIND v(dout1_0) AT=955.025n

* CHECK dout1_1 Vdout1_1ck190 = 0 time = 955
.meas tran vdout1_1ck190 FIND v(dout1_1) AT=955.025n

* CHECK dout1_2 Vdout1_2ck190 = 0 time = 955
.meas tran vdout1_2ck190 FIND v(dout1_2) AT=955.025n

* CHECK dout1_3 Vdout1_3ck190 = 0.9 time = 955
.meas tran vdout1_3ck190 FIND v(dout1_3) AT=955.025n

* CHECK dout1_4 Vdout1_4ck190 = 0.9 time = 955
.meas tran vdout1_4ck190 FIND v(dout1_4) AT=955.025n

* CHECK dout1_5 Vdout1_5ck190 = 0.9 time = 955
.meas tran vdout1_5ck190 FIND v(dout1_5) AT=955.025n

* CHECK dout1_6 Vdout1_6ck190 = 0.9 time = 955
.meas tran vdout1_6ck190 FIND v(dout1_6) AT=955.025n

* CHECK dout1_7 Vdout1_7ck190 = 0 time = 955
.meas tran vdout1_7ck190 FIND v(dout1_7) AT=955.025n

* CHECK dout1_8 Vdout1_8ck190 = 0 time = 955
.meas tran vdout1_8ck190 FIND v(dout1_8) AT=955.025n

* CHECK dout1_9 Vdout1_9ck190 = 0.9 time = 955
.meas tran vdout1_9ck190 FIND v(dout1_9) AT=955.025n

* CHECK dout1_10 Vdout1_10ck190 = 0.9 time = 955
.meas tran vdout1_10ck190 FIND v(dout1_10) AT=955.025n

* CHECK dout1_11 Vdout1_11ck190 = 0.9 time = 955
.meas tran vdout1_11ck190 FIND v(dout1_11) AT=955.025n

* CHECK dout1_12 Vdout1_12ck190 = 0.9 time = 955
.meas tran vdout1_12ck190 FIND v(dout1_12) AT=955.025n

* CHECK dout1_13 Vdout1_13ck190 = 0.9 time = 955
.meas tran vdout1_13ck190 FIND v(dout1_13) AT=955.025n

* CHECK dout1_14 Vdout1_14ck190 = 0 time = 955
.meas tran vdout1_14ck190 FIND v(dout1_14) AT=955.025n

* CHECK dout1_15 Vdout1_15ck190 = 0 time = 955
.meas tran vdout1_15ck190 FIND v(dout1_15) AT=955.025n

* CHECK dout1_16 Vdout1_16ck190 = 0 time = 955
.meas tran vdout1_16ck190 FIND v(dout1_16) AT=955.025n

* CHECK dout1_17 Vdout1_17ck190 = 0.9 time = 955
.meas tran vdout1_17ck190 FIND v(dout1_17) AT=955.025n

* CHECK dout1_18 Vdout1_18ck190 = 0 time = 955
.meas tran vdout1_18ck190 FIND v(dout1_18) AT=955.025n

* CHECK dout1_19 Vdout1_19ck190 = 0 time = 955
.meas tran vdout1_19ck190 FIND v(dout1_19) AT=955.025n

* CHECK dout1_20 Vdout1_20ck190 = 0.9 time = 955
.meas tran vdout1_20ck190 FIND v(dout1_20) AT=955.025n

* CHECK dout1_21 Vdout1_21ck190 = 0.9 time = 955
.meas tran vdout1_21ck190 FIND v(dout1_21) AT=955.025n

* CHECK dout1_22 Vdout1_22ck190 = 0 time = 955
.meas tran vdout1_22ck190 FIND v(dout1_22) AT=955.025n

* CHECK dout1_23 Vdout1_23ck190 = 0.9 time = 955
.meas tran vdout1_23ck190 FIND v(dout1_23) AT=955.025n

* CHECK dout1_24 Vdout1_24ck190 = 0.9 time = 955
.meas tran vdout1_24ck190 FIND v(dout1_24) AT=955.025n

* CHECK dout1_25 Vdout1_25ck190 = 0 time = 955
.meas tran vdout1_25ck190 FIND v(dout1_25) AT=955.025n

* CHECK dout1_26 Vdout1_26ck190 = 0 time = 955
.meas tran vdout1_26ck190 FIND v(dout1_26) AT=955.025n

* CHECK dout1_27 Vdout1_27ck190 = 0.9 time = 955
.meas tran vdout1_27ck190 FIND v(dout1_27) AT=955.025n

* CHECK dout1_28 Vdout1_28ck190 = 0 time = 955
.meas tran vdout1_28ck190 FIND v(dout1_28) AT=955.025n

* CHECK dout1_29 Vdout1_29ck190 = 0 time = 955
.meas tran vdout1_29ck190 FIND v(dout1_29) AT=955.025n

* CHECK dout1_30 Vdout1_30ck190 = 0.9 time = 955
.meas tran vdout1_30ck190 FIND v(dout1_30) AT=955.025n

* CHECK dout1_31 Vdout1_31ck190 = 0 time = 955
.meas tran vdout1_31ck190 FIND v(dout1_31) AT=955.025n

* CHECK dout1_32 Vdout1_32ck190 = 0 time = 955
.meas tran vdout1_32ck190 FIND v(dout1_32) AT=955.025n

* CHECK dout1_33 Vdout1_33ck190 = 0 time = 955
.meas tran vdout1_33ck190 FIND v(dout1_33) AT=955.025n

* CHECK dout1_34 Vdout1_34ck190 = 0.9 time = 955
.meas tran vdout1_34ck190 FIND v(dout1_34) AT=955.025n

* CHECK dout1_35 Vdout1_35ck190 = 0 time = 955
.meas tran vdout1_35ck190 FIND v(dout1_35) AT=955.025n

* CHECK dout1_36 Vdout1_36ck190 = 0 time = 955
.meas tran vdout1_36ck190 FIND v(dout1_36) AT=955.025n

* CHECK dout1_37 Vdout1_37ck190 = 0.9 time = 955
.meas tran vdout1_37ck190 FIND v(dout1_37) AT=955.025n

* CHECK dout1_38 Vdout1_38ck190 = 0 time = 955
.meas tran vdout1_38ck190 FIND v(dout1_38) AT=955.025n

* CHECK dout1_39 Vdout1_39ck190 = 0.9 time = 955
.meas tran vdout1_39ck190 FIND v(dout1_39) AT=955.025n

* CHECK dout1_40 Vdout1_40ck190 = 0 time = 955
.meas tran vdout1_40ck190 FIND v(dout1_40) AT=955.025n

* CHECK dout1_41 Vdout1_41ck190 = 0 time = 955
.meas tran vdout1_41ck190 FIND v(dout1_41) AT=955.025n

* CHECK dout1_42 Vdout1_42ck190 = 0 time = 955
.meas tran vdout1_42ck190 FIND v(dout1_42) AT=955.025n

* CHECK dout1_43 Vdout1_43ck190 = 0.9 time = 955
.meas tran vdout1_43ck190 FIND v(dout1_43) AT=955.025n

* CHECK dout1_44 Vdout1_44ck190 = 0.9 time = 955
.meas tran vdout1_44ck190 FIND v(dout1_44) AT=955.025n

* CHECK dout1_45 Vdout1_45ck190 = 0 time = 955
.meas tran vdout1_45ck190 FIND v(dout1_45) AT=955.025n

* CHECK dout1_46 Vdout1_46ck190 = 0.9 time = 955
.meas tran vdout1_46ck190 FIND v(dout1_46) AT=955.025n

* CHECK dout1_47 Vdout1_47ck190 = 0 time = 955
.meas tran vdout1_47ck190 FIND v(dout1_47) AT=955.025n

* CHECK dout1_48 Vdout1_48ck190 = 0.9 time = 955
.meas tran vdout1_48ck190 FIND v(dout1_48) AT=955.025n

* CHECK dout1_49 Vdout1_49ck190 = 0 time = 955
.meas tran vdout1_49ck190 FIND v(dout1_49) AT=955.025n

* CHECK dout1_50 Vdout1_50ck190 = 0 time = 955
.meas tran vdout1_50ck190 FIND v(dout1_50) AT=955.025n

* CHECK dout1_51 Vdout1_51ck190 = 0 time = 955
.meas tran vdout1_51ck190 FIND v(dout1_51) AT=955.025n

* CHECK dout1_52 Vdout1_52ck190 = 0 time = 955
.meas tran vdout1_52ck190 FIND v(dout1_52) AT=955.025n

* CHECK dout1_53 Vdout1_53ck190 = 0.9 time = 955
.meas tran vdout1_53ck190 FIND v(dout1_53) AT=955.025n

* CHECK dout1_54 Vdout1_54ck190 = 0 time = 955
.meas tran vdout1_54ck190 FIND v(dout1_54) AT=955.025n

* CHECK dout1_55 Vdout1_55ck190 = 0.9 time = 955
.meas tran vdout1_55ck190 FIND v(dout1_55) AT=955.025n

* CHECK dout1_56 Vdout1_56ck190 = 0 time = 955
.meas tran vdout1_56ck190 FIND v(dout1_56) AT=955.025n

* CHECK dout1_57 Vdout1_57ck190 = 0 time = 955
.meas tran vdout1_57ck190 FIND v(dout1_57) AT=955.025n

* CHECK dout1_58 Vdout1_58ck190 = 0.9 time = 955
.meas tran vdout1_58ck190 FIND v(dout1_58) AT=955.025n

* CHECK dout1_59 Vdout1_59ck190 = 0 time = 955
.meas tran vdout1_59ck190 FIND v(dout1_59) AT=955.025n

* CHECK dout1_60 Vdout1_60ck190 = 0.9 time = 955
.meas tran vdout1_60ck190 FIND v(dout1_60) AT=955.025n

* CHECK dout1_61 Vdout1_61ck190 = 0 time = 955
.meas tran vdout1_61ck190 FIND v(dout1_61) AT=955.025n

* CHECK dout1_62 Vdout1_62ck190 = 0.9 time = 955
.meas tran vdout1_62ck190 FIND v(dout1_62) AT=955.025n

* CHECK dout1_63 Vdout1_63ck190 = 0 time = 955
.meas tran vdout1_63ck190 FIND v(dout1_63) AT=955.025n

* CHECK dout1_64 Vdout1_64ck190 = 0 time = 955
.meas tran vdout1_64ck190 FIND v(dout1_64) AT=955.025n

* CHECK dout1_65 Vdout1_65ck190 = 0 time = 955
.meas tran vdout1_65ck190 FIND v(dout1_65) AT=955.025n

* CHECK dout1_66 Vdout1_66ck190 = 0 time = 955
.meas tran vdout1_66ck190 FIND v(dout1_66) AT=955.025n

* CHECK dout1_67 Vdout1_67ck190 = 0.9 time = 955
.meas tran vdout1_67ck190 FIND v(dout1_67) AT=955.025n

* CHECK dout1_68 Vdout1_68ck190 = 0 time = 955
.meas tran vdout1_68ck190 FIND v(dout1_68) AT=955.025n

* CHECK dout1_69 Vdout1_69ck190 = 0 time = 955
.meas tran vdout1_69ck190 FIND v(dout1_69) AT=955.025n

* CHECK dout1_70 Vdout1_70ck190 = 0 time = 955
.meas tran vdout1_70ck190 FIND v(dout1_70) AT=955.025n

* CHECK dout1_71 Vdout1_71ck190 = 0.9 time = 955
.meas tran vdout1_71ck190 FIND v(dout1_71) AT=955.025n

* CHECK dout1_0 Vdout1_0ck193 = 0 time = 970
.meas tran vdout1_0ck193 FIND v(dout1_0) AT=970.025n

* CHECK dout1_1 Vdout1_1ck193 = 0 time = 970
.meas tran vdout1_1ck193 FIND v(dout1_1) AT=970.025n

* CHECK dout1_2 Vdout1_2ck193 = 0 time = 970
.meas tran vdout1_2ck193 FIND v(dout1_2) AT=970.025n

* CHECK dout1_3 Vdout1_3ck193 = 0.9 time = 970
.meas tran vdout1_3ck193 FIND v(dout1_3) AT=970.025n

* CHECK dout1_4 Vdout1_4ck193 = 0.9 time = 970
.meas tran vdout1_4ck193 FIND v(dout1_4) AT=970.025n

* CHECK dout1_5 Vdout1_5ck193 = 0.9 time = 970
.meas tran vdout1_5ck193 FIND v(dout1_5) AT=970.025n

* CHECK dout1_6 Vdout1_6ck193 = 0.9 time = 970
.meas tran vdout1_6ck193 FIND v(dout1_6) AT=970.025n

* CHECK dout1_7 Vdout1_7ck193 = 0 time = 970
.meas tran vdout1_7ck193 FIND v(dout1_7) AT=970.025n

* CHECK dout1_8 Vdout1_8ck193 = 0 time = 970
.meas tran vdout1_8ck193 FIND v(dout1_8) AT=970.025n

* CHECK dout1_9 Vdout1_9ck193 = 0.9 time = 970
.meas tran vdout1_9ck193 FIND v(dout1_9) AT=970.025n

* CHECK dout1_10 Vdout1_10ck193 = 0.9 time = 970
.meas tran vdout1_10ck193 FIND v(dout1_10) AT=970.025n

* CHECK dout1_11 Vdout1_11ck193 = 0.9 time = 970
.meas tran vdout1_11ck193 FIND v(dout1_11) AT=970.025n

* CHECK dout1_12 Vdout1_12ck193 = 0.9 time = 970
.meas tran vdout1_12ck193 FIND v(dout1_12) AT=970.025n

* CHECK dout1_13 Vdout1_13ck193 = 0.9 time = 970
.meas tran vdout1_13ck193 FIND v(dout1_13) AT=970.025n

* CHECK dout1_14 Vdout1_14ck193 = 0 time = 970
.meas tran vdout1_14ck193 FIND v(dout1_14) AT=970.025n

* CHECK dout1_15 Vdout1_15ck193 = 0 time = 970
.meas tran vdout1_15ck193 FIND v(dout1_15) AT=970.025n

* CHECK dout1_16 Vdout1_16ck193 = 0 time = 970
.meas tran vdout1_16ck193 FIND v(dout1_16) AT=970.025n

* CHECK dout1_17 Vdout1_17ck193 = 0.9 time = 970
.meas tran vdout1_17ck193 FIND v(dout1_17) AT=970.025n

* CHECK dout1_18 Vdout1_18ck193 = 0 time = 970
.meas tran vdout1_18ck193 FIND v(dout1_18) AT=970.025n

* CHECK dout1_19 Vdout1_19ck193 = 0 time = 970
.meas tran vdout1_19ck193 FIND v(dout1_19) AT=970.025n

* CHECK dout1_20 Vdout1_20ck193 = 0.9 time = 970
.meas tran vdout1_20ck193 FIND v(dout1_20) AT=970.025n

* CHECK dout1_21 Vdout1_21ck193 = 0.9 time = 970
.meas tran vdout1_21ck193 FIND v(dout1_21) AT=970.025n

* CHECK dout1_22 Vdout1_22ck193 = 0 time = 970
.meas tran vdout1_22ck193 FIND v(dout1_22) AT=970.025n

* CHECK dout1_23 Vdout1_23ck193 = 0.9 time = 970
.meas tran vdout1_23ck193 FIND v(dout1_23) AT=970.025n

* CHECK dout1_24 Vdout1_24ck193 = 0.9 time = 970
.meas tran vdout1_24ck193 FIND v(dout1_24) AT=970.025n

* CHECK dout1_25 Vdout1_25ck193 = 0 time = 970
.meas tran vdout1_25ck193 FIND v(dout1_25) AT=970.025n

* CHECK dout1_26 Vdout1_26ck193 = 0 time = 970
.meas tran vdout1_26ck193 FIND v(dout1_26) AT=970.025n

* CHECK dout1_27 Vdout1_27ck193 = 0.9 time = 970
.meas tran vdout1_27ck193 FIND v(dout1_27) AT=970.025n

* CHECK dout1_28 Vdout1_28ck193 = 0 time = 970
.meas tran vdout1_28ck193 FIND v(dout1_28) AT=970.025n

* CHECK dout1_29 Vdout1_29ck193 = 0 time = 970
.meas tran vdout1_29ck193 FIND v(dout1_29) AT=970.025n

* CHECK dout1_30 Vdout1_30ck193 = 0.9 time = 970
.meas tran vdout1_30ck193 FIND v(dout1_30) AT=970.025n

* CHECK dout1_31 Vdout1_31ck193 = 0 time = 970
.meas tran vdout1_31ck193 FIND v(dout1_31) AT=970.025n

* CHECK dout1_32 Vdout1_32ck193 = 0 time = 970
.meas tran vdout1_32ck193 FIND v(dout1_32) AT=970.025n

* CHECK dout1_33 Vdout1_33ck193 = 0 time = 970
.meas tran vdout1_33ck193 FIND v(dout1_33) AT=970.025n

* CHECK dout1_34 Vdout1_34ck193 = 0.9 time = 970
.meas tran vdout1_34ck193 FIND v(dout1_34) AT=970.025n

* CHECK dout1_35 Vdout1_35ck193 = 0 time = 970
.meas tran vdout1_35ck193 FIND v(dout1_35) AT=970.025n

* CHECK dout1_36 Vdout1_36ck193 = 0 time = 970
.meas tran vdout1_36ck193 FIND v(dout1_36) AT=970.025n

* CHECK dout1_37 Vdout1_37ck193 = 0.9 time = 970
.meas tran vdout1_37ck193 FIND v(dout1_37) AT=970.025n

* CHECK dout1_38 Vdout1_38ck193 = 0 time = 970
.meas tran vdout1_38ck193 FIND v(dout1_38) AT=970.025n

* CHECK dout1_39 Vdout1_39ck193 = 0.9 time = 970
.meas tran vdout1_39ck193 FIND v(dout1_39) AT=970.025n

* CHECK dout1_40 Vdout1_40ck193 = 0 time = 970
.meas tran vdout1_40ck193 FIND v(dout1_40) AT=970.025n

* CHECK dout1_41 Vdout1_41ck193 = 0 time = 970
.meas tran vdout1_41ck193 FIND v(dout1_41) AT=970.025n

* CHECK dout1_42 Vdout1_42ck193 = 0 time = 970
.meas tran vdout1_42ck193 FIND v(dout1_42) AT=970.025n

* CHECK dout1_43 Vdout1_43ck193 = 0.9 time = 970
.meas tran vdout1_43ck193 FIND v(dout1_43) AT=970.025n

* CHECK dout1_44 Vdout1_44ck193 = 0.9 time = 970
.meas tran vdout1_44ck193 FIND v(dout1_44) AT=970.025n

* CHECK dout1_45 Vdout1_45ck193 = 0 time = 970
.meas tran vdout1_45ck193 FIND v(dout1_45) AT=970.025n

* CHECK dout1_46 Vdout1_46ck193 = 0.9 time = 970
.meas tran vdout1_46ck193 FIND v(dout1_46) AT=970.025n

* CHECK dout1_47 Vdout1_47ck193 = 0 time = 970
.meas tran vdout1_47ck193 FIND v(dout1_47) AT=970.025n

* CHECK dout1_48 Vdout1_48ck193 = 0.9 time = 970
.meas tran vdout1_48ck193 FIND v(dout1_48) AT=970.025n

* CHECK dout1_49 Vdout1_49ck193 = 0 time = 970
.meas tran vdout1_49ck193 FIND v(dout1_49) AT=970.025n

* CHECK dout1_50 Vdout1_50ck193 = 0 time = 970
.meas tran vdout1_50ck193 FIND v(dout1_50) AT=970.025n

* CHECK dout1_51 Vdout1_51ck193 = 0 time = 970
.meas tran vdout1_51ck193 FIND v(dout1_51) AT=970.025n

* CHECK dout1_52 Vdout1_52ck193 = 0 time = 970
.meas tran vdout1_52ck193 FIND v(dout1_52) AT=970.025n

* CHECK dout1_53 Vdout1_53ck193 = 0.9 time = 970
.meas tran vdout1_53ck193 FIND v(dout1_53) AT=970.025n

* CHECK dout1_54 Vdout1_54ck193 = 0 time = 970
.meas tran vdout1_54ck193 FIND v(dout1_54) AT=970.025n

* CHECK dout1_55 Vdout1_55ck193 = 0.9 time = 970
.meas tran vdout1_55ck193 FIND v(dout1_55) AT=970.025n

* CHECK dout1_56 Vdout1_56ck193 = 0 time = 970
.meas tran vdout1_56ck193 FIND v(dout1_56) AT=970.025n

* CHECK dout1_57 Vdout1_57ck193 = 0 time = 970
.meas tran vdout1_57ck193 FIND v(dout1_57) AT=970.025n

* CHECK dout1_58 Vdout1_58ck193 = 0.9 time = 970
.meas tran vdout1_58ck193 FIND v(dout1_58) AT=970.025n

* CHECK dout1_59 Vdout1_59ck193 = 0 time = 970
.meas tran vdout1_59ck193 FIND v(dout1_59) AT=970.025n

* CHECK dout1_60 Vdout1_60ck193 = 0.9 time = 970
.meas tran vdout1_60ck193 FIND v(dout1_60) AT=970.025n

* CHECK dout1_61 Vdout1_61ck193 = 0 time = 970
.meas tran vdout1_61ck193 FIND v(dout1_61) AT=970.025n

* CHECK dout1_62 Vdout1_62ck193 = 0.9 time = 970
.meas tran vdout1_62ck193 FIND v(dout1_62) AT=970.025n

* CHECK dout1_63 Vdout1_63ck193 = 0 time = 970
.meas tran vdout1_63ck193 FIND v(dout1_63) AT=970.025n

* CHECK dout1_64 Vdout1_64ck193 = 0 time = 970
.meas tran vdout1_64ck193 FIND v(dout1_64) AT=970.025n

* CHECK dout1_65 Vdout1_65ck193 = 0 time = 970
.meas tran vdout1_65ck193 FIND v(dout1_65) AT=970.025n

* CHECK dout1_66 Vdout1_66ck193 = 0 time = 970
.meas tran vdout1_66ck193 FIND v(dout1_66) AT=970.025n

* CHECK dout1_67 Vdout1_67ck193 = 0.9 time = 970
.meas tran vdout1_67ck193 FIND v(dout1_67) AT=970.025n

* CHECK dout1_68 Vdout1_68ck193 = 0 time = 970
.meas tran vdout1_68ck193 FIND v(dout1_68) AT=970.025n

* CHECK dout1_69 Vdout1_69ck193 = 0 time = 970
.meas tran vdout1_69ck193 FIND v(dout1_69) AT=970.025n

* CHECK dout1_70 Vdout1_70ck193 = 0 time = 970
.meas tran vdout1_70ck193 FIND v(dout1_70) AT=970.025n

* CHECK dout1_71 Vdout1_71ck193 = 0.9 time = 970
.meas tran vdout1_71ck193 FIND v(dout1_71) AT=970.025n

* CHECK dout1_0 Vdout1_0ck196 = 0 time = 985
.meas tran vdout1_0ck196 FIND v(dout1_0) AT=985.025n

* CHECK dout1_1 Vdout1_1ck196 = 0 time = 985
.meas tran vdout1_1ck196 FIND v(dout1_1) AT=985.025n

* CHECK dout1_2 Vdout1_2ck196 = 0 time = 985
.meas tran vdout1_2ck196 FIND v(dout1_2) AT=985.025n

* CHECK dout1_3 Vdout1_3ck196 = 0.9 time = 985
.meas tran vdout1_3ck196 FIND v(dout1_3) AT=985.025n

* CHECK dout1_4 Vdout1_4ck196 = 0.9 time = 985
.meas tran vdout1_4ck196 FIND v(dout1_4) AT=985.025n

* CHECK dout1_5 Vdout1_5ck196 = 0.9 time = 985
.meas tran vdout1_5ck196 FIND v(dout1_5) AT=985.025n

* CHECK dout1_6 Vdout1_6ck196 = 0.9 time = 985
.meas tran vdout1_6ck196 FIND v(dout1_6) AT=985.025n

* CHECK dout1_7 Vdout1_7ck196 = 0 time = 985
.meas tran vdout1_7ck196 FIND v(dout1_7) AT=985.025n

* CHECK dout1_8 Vdout1_8ck196 = 0.9 time = 985
.meas tran vdout1_8ck196 FIND v(dout1_8) AT=985.025n

* CHECK dout1_9 Vdout1_9ck196 = 0.9 time = 985
.meas tran vdout1_9ck196 FIND v(dout1_9) AT=985.025n

* CHECK dout1_10 Vdout1_10ck196 = 0.9 time = 985
.meas tran vdout1_10ck196 FIND v(dout1_10) AT=985.025n

* CHECK dout1_11 Vdout1_11ck196 = 0.9 time = 985
.meas tran vdout1_11ck196 FIND v(dout1_11) AT=985.025n

* CHECK dout1_12 Vdout1_12ck196 = 0.9 time = 985
.meas tran vdout1_12ck196 FIND v(dout1_12) AT=985.025n

* CHECK dout1_13 Vdout1_13ck196 = 0 time = 985
.meas tran vdout1_13ck196 FIND v(dout1_13) AT=985.025n

* CHECK dout1_14 Vdout1_14ck196 = 0 time = 985
.meas tran vdout1_14ck196 FIND v(dout1_14) AT=985.025n

* CHECK dout1_15 Vdout1_15ck196 = 0.9 time = 985
.meas tran vdout1_15ck196 FIND v(dout1_15) AT=985.025n

* CHECK dout1_16 Vdout1_16ck196 = 0 time = 985
.meas tran vdout1_16ck196 FIND v(dout1_16) AT=985.025n

* CHECK dout1_17 Vdout1_17ck196 = 0.9 time = 985
.meas tran vdout1_17ck196 FIND v(dout1_17) AT=985.025n

* CHECK dout1_18 Vdout1_18ck196 = 0.9 time = 985
.meas tran vdout1_18ck196 FIND v(dout1_18) AT=985.025n

* CHECK dout1_19 Vdout1_19ck196 = 0.9 time = 985
.meas tran vdout1_19ck196 FIND v(dout1_19) AT=985.025n

* CHECK dout1_20 Vdout1_20ck196 = 0.9 time = 985
.meas tran vdout1_20ck196 FIND v(dout1_20) AT=985.025n

* CHECK dout1_21 Vdout1_21ck196 = 0 time = 985
.meas tran vdout1_21ck196 FIND v(dout1_21) AT=985.025n

* CHECK dout1_22 Vdout1_22ck196 = 0.9 time = 985
.meas tran vdout1_22ck196 FIND v(dout1_22) AT=985.025n

* CHECK dout1_23 Vdout1_23ck196 = 0 time = 985
.meas tran vdout1_23ck196 FIND v(dout1_23) AT=985.025n

* CHECK dout1_24 Vdout1_24ck196 = 0.9 time = 985
.meas tran vdout1_24ck196 FIND v(dout1_24) AT=985.025n

* CHECK dout1_25 Vdout1_25ck196 = 0.9 time = 985
.meas tran vdout1_25ck196 FIND v(dout1_25) AT=985.025n

* CHECK dout1_26 Vdout1_26ck196 = 0.9 time = 985
.meas tran vdout1_26ck196 FIND v(dout1_26) AT=985.025n

* CHECK dout1_27 Vdout1_27ck196 = 0 time = 985
.meas tran vdout1_27ck196 FIND v(dout1_27) AT=985.025n

* CHECK dout1_28 Vdout1_28ck196 = 0 time = 985
.meas tran vdout1_28ck196 FIND v(dout1_28) AT=985.025n

* CHECK dout1_29 Vdout1_29ck196 = 0 time = 985
.meas tran vdout1_29ck196 FIND v(dout1_29) AT=985.025n

* CHECK dout1_30 Vdout1_30ck196 = 0.9 time = 985
.meas tran vdout1_30ck196 FIND v(dout1_30) AT=985.025n

* CHECK dout1_31 Vdout1_31ck196 = 0.9 time = 985
.meas tran vdout1_31ck196 FIND v(dout1_31) AT=985.025n

* CHECK dout1_32 Vdout1_32ck196 = 0 time = 985
.meas tran vdout1_32ck196 FIND v(dout1_32) AT=985.025n

* CHECK dout1_33 Vdout1_33ck196 = 0.9 time = 985
.meas tran vdout1_33ck196 FIND v(dout1_33) AT=985.025n

* CHECK dout1_34 Vdout1_34ck196 = 0 time = 985
.meas tran vdout1_34ck196 FIND v(dout1_34) AT=985.025n

* CHECK dout1_35 Vdout1_35ck196 = 0 time = 985
.meas tran vdout1_35ck196 FIND v(dout1_35) AT=985.025n

* CHECK dout1_36 Vdout1_36ck196 = 0 time = 985
.meas tran vdout1_36ck196 FIND v(dout1_36) AT=985.025n

* CHECK dout1_37 Vdout1_37ck196 = 0 time = 985
.meas tran vdout1_37ck196 FIND v(dout1_37) AT=985.025n

* CHECK dout1_38 Vdout1_38ck196 = 0.9 time = 985
.meas tran vdout1_38ck196 FIND v(dout1_38) AT=985.025n

* CHECK dout1_39 Vdout1_39ck196 = 0 time = 985
.meas tran vdout1_39ck196 FIND v(dout1_39) AT=985.025n

* CHECK dout1_40 Vdout1_40ck196 = 0.9 time = 985
.meas tran vdout1_40ck196 FIND v(dout1_40) AT=985.025n

* CHECK dout1_41 Vdout1_41ck196 = 0 time = 985
.meas tran vdout1_41ck196 FIND v(dout1_41) AT=985.025n

* CHECK dout1_42 Vdout1_42ck196 = 0 time = 985
.meas tran vdout1_42ck196 FIND v(dout1_42) AT=985.025n

* CHECK dout1_43 Vdout1_43ck196 = 0 time = 985
.meas tran vdout1_43ck196 FIND v(dout1_43) AT=985.025n

* CHECK dout1_44 Vdout1_44ck196 = 0.9 time = 985
.meas tran vdout1_44ck196 FIND v(dout1_44) AT=985.025n

* CHECK dout1_45 Vdout1_45ck196 = 0.9 time = 985
.meas tran vdout1_45ck196 FIND v(dout1_45) AT=985.025n

* CHECK dout1_46 Vdout1_46ck196 = 0 time = 985
.meas tran vdout1_46ck196 FIND v(dout1_46) AT=985.025n

* CHECK dout1_47 Vdout1_47ck196 = 0 time = 985
.meas tran vdout1_47ck196 FIND v(dout1_47) AT=985.025n

* CHECK dout1_48 Vdout1_48ck196 = 0.9 time = 985
.meas tran vdout1_48ck196 FIND v(dout1_48) AT=985.025n

* CHECK dout1_49 Vdout1_49ck196 = 0.9 time = 985
.meas tran vdout1_49ck196 FIND v(dout1_49) AT=985.025n

* CHECK dout1_50 Vdout1_50ck196 = 0 time = 985
.meas tran vdout1_50ck196 FIND v(dout1_50) AT=985.025n

* CHECK dout1_51 Vdout1_51ck196 = 0.9 time = 985
.meas tran vdout1_51ck196 FIND v(dout1_51) AT=985.025n

* CHECK dout1_52 Vdout1_52ck196 = 0 time = 985
.meas tran vdout1_52ck196 FIND v(dout1_52) AT=985.025n

* CHECK dout1_53 Vdout1_53ck196 = 0 time = 985
.meas tran vdout1_53ck196 FIND v(dout1_53) AT=985.025n

* CHECK dout1_54 Vdout1_54ck196 = 0 time = 985
.meas tran vdout1_54ck196 FIND v(dout1_54) AT=985.025n

* CHECK dout1_55 Vdout1_55ck196 = 0.9 time = 985
.meas tran vdout1_55ck196 FIND v(dout1_55) AT=985.025n

* CHECK dout1_56 Vdout1_56ck196 = 0.9 time = 985
.meas tran vdout1_56ck196 FIND v(dout1_56) AT=985.025n

* CHECK dout1_57 Vdout1_57ck196 = 0 time = 985
.meas tran vdout1_57ck196 FIND v(dout1_57) AT=985.025n

* CHECK dout1_58 Vdout1_58ck196 = 0.9 time = 985
.meas tran vdout1_58ck196 FIND v(dout1_58) AT=985.025n

* CHECK dout1_59 Vdout1_59ck196 = 0 time = 985
.meas tran vdout1_59ck196 FIND v(dout1_59) AT=985.025n

* CHECK dout1_60 Vdout1_60ck196 = 0.9 time = 985
.meas tran vdout1_60ck196 FIND v(dout1_60) AT=985.025n

* CHECK dout1_61 Vdout1_61ck196 = 0.9 time = 985
.meas tran vdout1_61ck196 FIND v(dout1_61) AT=985.025n

* CHECK dout1_62 Vdout1_62ck196 = 0.9 time = 985
.meas tran vdout1_62ck196 FIND v(dout1_62) AT=985.025n

* CHECK dout1_63 Vdout1_63ck196 = 0 time = 985
.meas tran vdout1_63ck196 FIND v(dout1_63) AT=985.025n

* CHECK dout1_64 Vdout1_64ck196 = 0 time = 985
.meas tran vdout1_64ck196 FIND v(dout1_64) AT=985.025n

* CHECK dout1_65 Vdout1_65ck196 = 0.9 time = 985
.meas tran vdout1_65ck196 FIND v(dout1_65) AT=985.025n

* CHECK dout1_66 Vdout1_66ck196 = 0 time = 985
.meas tran vdout1_66ck196 FIND v(dout1_66) AT=985.025n

* CHECK dout1_67 Vdout1_67ck196 = 0 time = 985
.meas tran vdout1_67ck196 FIND v(dout1_67) AT=985.025n

* CHECK dout1_68 Vdout1_68ck196 = 0 time = 985
.meas tran vdout1_68ck196 FIND v(dout1_68) AT=985.025n

* CHECK dout1_69 Vdout1_69ck196 = 0 time = 985
.meas tran vdout1_69ck196 FIND v(dout1_69) AT=985.025n

* CHECK dout1_70 Vdout1_70ck196 = 0 time = 985
.meas tran vdout1_70ck196 FIND v(dout1_70) AT=985.025n

* CHECK dout1_71 Vdout1_71ck196 = 0 time = 985
.meas tran vdout1_71ck196 FIND v(dout1_71) AT=985.025n

* CHECK dout1_0 Vdout1_0ck198 = 0.9 time = 995
.meas tran vdout1_0ck198 FIND v(dout1_0) AT=995.025n

* CHECK dout1_1 Vdout1_1ck198 = 0.9 time = 995
.meas tran vdout1_1ck198 FIND v(dout1_1) AT=995.025n

* CHECK dout1_2 Vdout1_2ck198 = 0.9 time = 995
.meas tran vdout1_2ck198 FIND v(dout1_2) AT=995.025n

* CHECK dout1_3 Vdout1_3ck198 = 0 time = 995
.meas tran vdout1_3ck198 FIND v(dout1_3) AT=995.025n

* CHECK dout1_4 Vdout1_4ck198 = 0.9 time = 995
.meas tran vdout1_4ck198 FIND v(dout1_4) AT=995.025n

* CHECK dout1_5 Vdout1_5ck198 = 0 time = 995
.meas tran vdout1_5ck198 FIND v(dout1_5) AT=995.025n

* CHECK dout1_6 Vdout1_6ck198 = 0 time = 995
.meas tran vdout1_6ck198 FIND v(dout1_6) AT=995.025n

* CHECK dout1_7 Vdout1_7ck198 = 0 time = 995
.meas tran vdout1_7ck198 FIND v(dout1_7) AT=995.025n

* CHECK dout1_8 Vdout1_8ck198 = 0.9 time = 995
.meas tran vdout1_8ck198 FIND v(dout1_8) AT=995.025n

* CHECK dout1_9 Vdout1_9ck198 = 0 time = 995
.meas tran vdout1_9ck198 FIND v(dout1_9) AT=995.025n

* CHECK dout1_10 Vdout1_10ck198 = 0 time = 995
.meas tran vdout1_10ck198 FIND v(dout1_10) AT=995.025n

* CHECK dout1_11 Vdout1_11ck198 = 0 time = 995
.meas tran vdout1_11ck198 FIND v(dout1_11) AT=995.025n

* CHECK dout1_12 Vdout1_12ck198 = 0 time = 995
.meas tran vdout1_12ck198 FIND v(dout1_12) AT=995.025n

* CHECK dout1_13 Vdout1_13ck198 = 0 time = 995
.meas tran vdout1_13ck198 FIND v(dout1_13) AT=995.025n

* CHECK dout1_14 Vdout1_14ck198 = 0.9 time = 995
.meas tran vdout1_14ck198 FIND v(dout1_14) AT=995.025n

* CHECK dout1_15 Vdout1_15ck198 = 0.9 time = 995
.meas tran vdout1_15ck198 FIND v(dout1_15) AT=995.025n

* CHECK dout1_16 Vdout1_16ck198 = 0.9 time = 995
.meas tran vdout1_16ck198 FIND v(dout1_16) AT=995.025n

* CHECK dout1_17 Vdout1_17ck198 = 0.9 time = 995
.meas tran vdout1_17ck198 FIND v(dout1_17) AT=995.025n

* CHECK dout1_18 Vdout1_18ck198 = 0.9 time = 995
.meas tran vdout1_18ck198 FIND v(dout1_18) AT=995.025n

* CHECK dout1_19 Vdout1_19ck198 = 0 time = 995
.meas tran vdout1_19ck198 FIND v(dout1_19) AT=995.025n

* CHECK dout1_20 Vdout1_20ck198 = 0 time = 995
.meas tran vdout1_20ck198 FIND v(dout1_20) AT=995.025n

* CHECK dout1_21 Vdout1_21ck198 = 0.9 time = 995
.meas tran vdout1_21ck198 FIND v(dout1_21) AT=995.025n

* CHECK dout1_22 Vdout1_22ck198 = 0 time = 995
.meas tran vdout1_22ck198 FIND v(dout1_22) AT=995.025n

* CHECK dout1_23 Vdout1_23ck198 = 0 time = 995
.meas tran vdout1_23ck198 FIND v(dout1_23) AT=995.025n

* CHECK dout1_24 Vdout1_24ck198 = 0 time = 995
.meas tran vdout1_24ck198 FIND v(dout1_24) AT=995.025n

* CHECK dout1_25 Vdout1_25ck198 = 0 time = 995
.meas tran vdout1_25ck198 FIND v(dout1_25) AT=995.025n

* CHECK dout1_26 Vdout1_26ck198 = 0.9 time = 995
.meas tran vdout1_26ck198 FIND v(dout1_26) AT=995.025n

* CHECK dout1_27 Vdout1_27ck198 = 0 time = 995
.meas tran vdout1_27ck198 FIND v(dout1_27) AT=995.025n

* CHECK dout1_28 Vdout1_28ck198 = 0.9 time = 995
.meas tran vdout1_28ck198 FIND v(dout1_28) AT=995.025n

* CHECK dout1_29 Vdout1_29ck198 = 0 time = 995
.meas tran vdout1_29ck198 FIND v(dout1_29) AT=995.025n

* CHECK dout1_30 Vdout1_30ck198 = 0 time = 995
.meas tran vdout1_30ck198 FIND v(dout1_30) AT=995.025n

* CHECK dout1_31 Vdout1_31ck198 = 0 time = 995
.meas tran vdout1_31ck198 FIND v(dout1_31) AT=995.025n

* CHECK dout1_32 Vdout1_32ck198 = 0 time = 995
.meas tran vdout1_32ck198 FIND v(dout1_32) AT=995.025n

* CHECK dout1_33 Vdout1_33ck198 = 0.9 time = 995
.meas tran vdout1_33ck198 FIND v(dout1_33) AT=995.025n

* CHECK dout1_34 Vdout1_34ck198 = 0.9 time = 995
.meas tran vdout1_34ck198 FIND v(dout1_34) AT=995.025n

* CHECK dout1_35 Vdout1_35ck198 = 0 time = 995
.meas tran vdout1_35ck198 FIND v(dout1_35) AT=995.025n

* CHECK dout1_36 Vdout1_36ck198 = 0.9 time = 995
.meas tran vdout1_36ck198 FIND v(dout1_36) AT=995.025n

* CHECK dout1_37 Vdout1_37ck198 = 0 time = 995
.meas tran vdout1_37ck198 FIND v(dout1_37) AT=995.025n

* CHECK dout1_38 Vdout1_38ck198 = 0.9 time = 995
.meas tran vdout1_38ck198 FIND v(dout1_38) AT=995.025n

* CHECK dout1_39 Vdout1_39ck198 = 0 time = 995
.meas tran vdout1_39ck198 FIND v(dout1_39) AT=995.025n

* CHECK dout1_40 Vdout1_40ck198 = 0 time = 995
.meas tran vdout1_40ck198 FIND v(dout1_40) AT=995.025n

* CHECK dout1_41 Vdout1_41ck198 = 0 time = 995
.meas tran vdout1_41ck198 FIND v(dout1_41) AT=995.025n

* CHECK dout1_42 Vdout1_42ck198 = 0 time = 995
.meas tran vdout1_42ck198 FIND v(dout1_42) AT=995.025n

* CHECK dout1_43 Vdout1_43ck198 = 0.9 time = 995
.meas tran vdout1_43ck198 FIND v(dout1_43) AT=995.025n

* CHECK dout1_44 Vdout1_44ck198 = 0.9 time = 995
.meas tran vdout1_44ck198 FIND v(dout1_44) AT=995.025n

* CHECK dout1_45 Vdout1_45ck198 = 0.9 time = 995
.meas tran vdout1_45ck198 FIND v(dout1_45) AT=995.025n

* CHECK dout1_46 Vdout1_46ck198 = 0.9 time = 995
.meas tran vdout1_46ck198 FIND v(dout1_46) AT=995.025n

* CHECK dout1_47 Vdout1_47ck198 = 0 time = 995
.meas tran vdout1_47ck198 FIND v(dout1_47) AT=995.025n

* CHECK dout1_48 Vdout1_48ck198 = 0 time = 995
.meas tran vdout1_48ck198 FIND v(dout1_48) AT=995.025n

* CHECK dout1_49 Vdout1_49ck198 = 0 time = 995
.meas tran vdout1_49ck198 FIND v(dout1_49) AT=995.025n

* CHECK dout1_50 Vdout1_50ck198 = 0.9 time = 995
.meas tran vdout1_50ck198 FIND v(dout1_50) AT=995.025n

* CHECK dout1_51 Vdout1_51ck198 = 0.9 time = 995
.meas tran vdout1_51ck198 FIND v(dout1_51) AT=995.025n

* CHECK dout1_52 Vdout1_52ck198 = 0 time = 995
.meas tran vdout1_52ck198 FIND v(dout1_52) AT=995.025n

* CHECK dout1_53 Vdout1_53ck198 = 0 time = 995
.meas tran vdout1_53ck198 FIND v(dout1_53) AT=995.025n

* CHECK dout1_54 Vdout1_54ck198 = 0 time = 995
.meas tran vdout1_54ck198 FIND v(dout1_54) AT=995.025n

* CHECK dout1_55 Vdout1_55ck198 = 0.9 time = 995
.meas tran vdout1_55ck198 FIND v(dout1_55) AT=995.025n

* CHECK dout1_56 Vdout1_56ck198 = 0 time = 995
.meas tran vdout1_56ck198 FIND v(dout1_56) AT=995.025n

* CHECK dout1_57 Vdout1_57ck198 = 0.9 time = 995
.meas tran vdout1_57ck198 FIND v(dout1_57) AT=995.025n

* CHECK dout1_58 Vdout1_58ck198 = 0.9 time = 995
.meas tran vdout1_58ck198 FIND v(dout1_58) AT=995.025n

* CHECK dout1_59 Vdout1_59ck198 = 0.9 time = 995
.meas tran vdout1_59ck198 FIND v(dout1_59) AT=995.025n

* CHECK dout1_60 Vdout1_60ck198 = 0.9 time = 995
.meas tran vdout1_60ck198 FIND v(dout1_60) AT=995.025n

* CHECK dout1_61 Vdout1_61ck198 = 0.9 time = 995
.meas tran vdout1_61ck198 FIND v(dout1_61) AT=995.025n

* CHECK dout1_62 Vdout1_62ck198 = 0.9 time = 995
.meas tran vdout1_62ck198 FIND v(dout1_62) AT=995.025n

* CHECK dout1_63 Vdout1_63ck198 = 0 time = 995
.meas tran vdout1_63ck198 FIND v(dout1_63) AT=995.025n

* CHECK dout1_64 Vdout1_64ck198 = 0 time = 995
.meas tran vdout1_64ck198 FIND v(dout1_64) AT=995.025n

* CHECK dout1_65 Vdout1_65ck198 = 0 time = 995
.meas tran vdout1_65ck198 FIND v(dout1_65) AT=995.025n

* CHECK dout1_66 Vdout1_66ck198 = 0.9 time = 995
.meas tran vdout1_66ck198 FIND v(dout1_66) AT=995.025n

* CHECK dout1_67 Vdout1_67ck198 = 0 time = 995
.meas tran vdout1_67ck198 FIND v(dout1_67) AT=995.025n

* CHECK dout1_68 Vdout1_68ck198 = 0.9 time = 995
.meas tran vdout1_68ck198 FIND v(dout1_68) AT=995.025n

* CHECK dout1_69 Vdout1_69ck198 = 0 time = 995
.meas tran vdout1_69ck198 FIND v(dout1_69) AT=995.025n

* CHECK dout1_70 Vdout1_70ck198 = 0.9 time = 995
.meas tran vdout1_70ck198 FIND v(dout1_70) AT=995.025n

* CHECK dout1_71 Vdout1_71ck198 = 0.9 time = 995
.meas tran vdout1_71ck198 FIND v(dout1_71) AT=995.025n

* CHECK dout1_0 Vdout1_0ck199 = 0.9 time = 1000
.meas tran vdout1_0ck199 FIND v(dout1_0) AT=1000.025n

* CHECK dout1_1 Vdout1_1ck199 = 0.9 time = 1000
.meas tran vdout1_1ck199 FIND v(dout1_1) AT=1000.025n

* CHECK dout1_2 Vdout1_2ck199 = 0.9 time = 1000
.meas tran vdout1_2ck199 FIND v(dout1_2) AT=1000.025n

* CHECK dout1_3 Vdout1_3ck199 = 0 time = 1000
.meas tran vdout1_3ck199 FIND v(dout1_3) AT=1000.025n

* CHECK dout1_4 Vdout1_4ck199 = 0.9 time = 1000
.meas tran vdout1_4ck199 FIND v(dout1_4) AT=1000.025n

* CHECK dout1_5 Vdout1_5ck199 = 0 time = 1000
.meas tran vdout1_5ck199 FIND v(dout1_5) AT=1000.025n

* CHECK dout1_6 Vdout1_6ck199 = 0 time = 1000
.meas tran vdout1_6ck199 FIND v(dout1_6) AT=1000.025n

* CHECK dout1_7 Vdout1_7ck199 = 0 time = 1000
.meas tran vdout1_7ck199 FIND v(dout1_7) AT=1000.025n

* CHECK dout1_8 Vdout1_8ck199 = 0.9 time = 1000
.meas tran vdout1_8ck199 FIND v(dout1_8) AT=1000.025n

* CHECK dout1_9 Vdout1_9ck199 = 0 time = 1000
.meas tran vdout1_9ck199 FIND v(dout1_9) AT=1000.025n

* CHECK dout1_10 Vdout1_10ck199 = 0 time = 1000
.meas tran vdout1_10ck199 FIND v(dout1_10) AT=1000.025n

* CHECK dout1_11 Vdout1_11ck199 = 0 time = 1000
.meas tran vdout1_11ck199 FIND v(dout1_11) AT=1000.025n

* CHECK dout1_12 Vdout1_12ck199 = 0 time = 1000
.meas tran vdout1_12ck199 FIND v(dout1_12) AT=1000.025n

* CHECK dout1_13 Vdout1_13ck199 = 0 time = 1000
.meas tran vdout1_13ck199 FIND v(dout1_13) AT=1000.025n

* CHECK dout1_14 Vdout1_14ck199 = 0.9 time = 1000
.meas tran vdout1_14ck199 FIND v(dout1_14) AT=1000.025n

* CHECK dout1_15 Vdout1_15ck199 = 0.9 time = 1000
.meas tran vdout1_15ck199 FIND v(dout1_15) AT=1000.025n

* CHECK dout1_16 Vdout1_16ck199 = 0.9 time = 1000
.meas tran vdout1_16ck199 FIND v(dout1_16) AT=1000.025n

* CHECK dout1_17 Vdout1_17ck199 = 0.9 time = 1000
.meas tran vdout1_17ck199 FIND v(dout1_17) AT=1000.025n

* CHECK dout1_18 Vdout1_18ck199 = 0.9 time = 1000
.meas tran vdout1_18ck199 FIND v(dout1_18) AT=1000.025n

* CHECK dout1_19 Vdout1_19ck199 = 0 time = 1000
.meas tran vdout1_19ck199 FIND v(dout1_19) AT=1000.025n

* CHECK dout1_20 Vdout1_20ck199 = 0 time = 1000
.meas tran vdout1_20ck199 FIND v(dout1_20) AT=1000.025n

* CHECK dout1_21 Vdout1_21ck199 = 0.9 time = 1000
.meas tran vdout1_21ck199 FIND v(dout1_21) AT=1000.025n

* CHECK dout1_22 Vdout1_22ck199 = 0 time = 1000
.meas tran vdout1_22ck199 FIND v(dout1_22) AT=1000.025n

* CHECK dout1_23 Vdout1_23ck199 = 0 time = 1000
.meas tran vdout1_23ck199 FIND v(dout1_23) AT=1000.025n

* CHECK dout1_24 Vdout1_24ck199 = 0 time = 1000
.meas tran vdout1_24ck199 FIND v(dout1_24) AT=1000.025n

* CHECK dout1_25 Vdout1_25ck199 = 0 time = 1000
.meas tran vdout1_25ck199 FIND v(dout1_25) AT=1000.025n

* CHECK dout1_26 Vdout1_26ck199 = 0.9 time = 1000
.meas tran vdout1_26ck199 FIND v(dout1_26) AT=1000.025n

* CHECK dout1_27 Vdout1_27ck199 = 0 time = 1000
.meas tran vdout1_27ck199 FIND v(dout1_27) AT=1000.025n

* CHECK dout1_28 Vdout1_28ck199 = 0.9 time = 1000
.meas tran vdout1_28ck199 FIND v(dout1_28) AT=1000.025n

* CHECK dout1_29 Vdout1_29ck199 = 0 time = 1000
.meas tran vdout1_29ck199 FIND v(dout1_29) AT=1000.025n

* CHECK dout1_30 Vdout1_30ck199 = 0 time = 1000
.meas tran vdout1_30ck199 FIND v(dout1_30) AT=1000.025n

* CHECK dout1_31 Vdout1_31ck199 = 0 time = 1000
.meas tran vdout1_31ck199 FIND v(dout1_31) AT=1000.025n

* CHECK dout1_32 Vdout1_32ck199 = 0 time = 1000
.meas tran vdout1_32ck199 FIND v(dout1_32) AT=1000.025n

* CHECK dout1_33 Vdout1_33ck199 = 0.9 time = 1000
.meas tran vdout1_33ck199 FIND v(dout1_33) AT=1000.025n

* CHECK dout1_34 Vdout1_34ck199 = 0.9 time = 1000
.meas tran vdout1_34ck199 FIND v(dout1_34) AT=1000.025n

* CHECK dout1_35 Vdout1_35ck199 = 0 time = 1000
.meas tran vdout1_35ck199 FIND v(dout1_35) AT=1000.025n

* CHECK dout1_36 Vdout1_36ck199 = 0.9 time = 1000
.meas tran vdout1_36ck199 FIND v(dout1_36) AT=1000.025n

* CHECK dout1_37 Vdout1_37ck199 = 0 time = 1000
.meas tran vdout1_37ck199 FIND v(dout1_37) AT=1000.025n

* CHECK dout1_38 Vdout1_38ck199 = 0.9 time = 1000
.meas tran vdout1_38ck199 FIND v(dout1_38) AT=1000.025n

* CHECK dout1_39 Vdout1_39ck199 = 0 time = 1000
.meas tran vdout1_39ck199 FIND v(dout1_39) AT=1000.025n

* CHECK dout1_40 Vdout1_40ck199 = 0 time = 1000
.meas tran vdout1_40ck199 FIND v(dout1_40) AT=1000.025n

* CHECK dout1_41 Vdout1_41ck199 = 0 time = 1000
.meas tran vdout1_41ck199 FIND v(dout1_41) AT=1000.025n

* CHECK dout1_42 Vdout1_42ck199 = 0 time = 1000
.meas tran vdout1_42ck199 FIND v(dout1_42) AT=1000.025n

* CHECK dout1_43 Vdout1_43ck199 = 0.9 time = 1000
.meas tran vdout1_43ck199 FIND v(dout1_43) AT=1000.025n

* CHECK dout1_44 Vdout1_44ck199 = 0.9 time = 1000
.meas tran vdout1_44ck199 FIND v(dout1_44) AT=1000.025n

* CHECK dout1_45 Vdout1_45ck199 = 0.9 time = 1000
.meas tran vdout1_45ck199 FIND v(dout1_45) AT=1000.025n

* CHECK dout1_46 Vdout1_46ck199 = 0.9 time = 1000
.meas tran vdout1_46ck199 FIND v(dout1_46) AT=1000.025n

* CHECK dout1_47 Vdout1_47ck199 = 0 time = 1000
.meas tran vdout1_47ck199 FIND v(dout1_47) AT=1000.025n

* CHECK dout1_48 Vdout1_48ck199 = 0 time = 1000
.meas tran vdout1_48ck199 FIND v(dout1_48) AT=1000.025n

* CHECK dout1_49 Vdout1_49ck199 = 0 time = 1000
.meas tran vdout1_49ck199 FIND v(dout1_49) AT=1000.025n

* CHECK dout1_50 Vdout1_50ck199 = 0.9 time = 1000
.meas tran vdout1_50ck199 FIND v(dout1_50) AT=1000.025n

* CHECK dout1_51 Vdout1_51ck199 = 0.9 time = 1000
.meas tran vdout1_51ck199 FIND v(dout1_51) AT=1000.025n

* CHECK dout1_52 Vdout1_52ck199 = 0 time = 1000
.meas tran vdout1_52ck199 FIND v(dout1_52) AT=1000.025n

* CHECK dout1_53 Vdout1_53ck199 = 0 time = 1000
.meas tran vdout1_53ck199 FIND v(dout1_53) AT=1000.025n

* CHECK dout1_54 Vdout1_54ck199 = 0 time = 1000
.meas tran vdout1_54ck199 FIND v(dout1_54) AT=1000.025n

* CHECK dout1_55 Vdout1_55ck199 = 0.9 time = 1000
.meas tran vdout1_55ck199 FIND v(dout1_55) AT=1000.025n

* CHECK dout1_56 Vdout1_56ck199 = 0 time = 1000
.meas tran vdout1_56ck199 FIND v(dout1_56) AT=1000.025n

* CHECK dout1_57 Vdout1_57ck199 = 0.9 time = 1000
.meas tran vdout1_57ck199 FIND v(dout1_57) AT=1000.025n

* CHECK dout1_58 Vdout1_58ck199 = 0.9 time = 1000
.meas tran vdout1_58ck199 FIND v(dout1_58) AT=1000.025n

* CHECK dout1_59 Vdout1_59ck199 = 0.9 time = 1000
.meas tran vdout1_59ck199 FIND v(dout1_59) AT=1000.025n

* CHECK dout1_60 Vdout1_60ck199 = 0.9 time = 1000
.meas tran vdout1_60ck199 FIND v(dout1_60) AT=1000.025n

* CHECK dout1_61 Vdout1_61ck199 = 0.9 time = 1000
.meas tran vdout1_61ck199 FIND v(dout1_61) AT=1000.025n

* CHECK dout1_62 Vdout1_62ck199 = 0.9 time = 1000
.meas tran vdout1_62ck199 FIND v(dout1_62) AT=1000.025n

* CHECK dout1_63 Vdout1_63ck199 = 0 time = 1000
.meas tran vdout1_63ck199 FIND v(dout1_63) AT=1000.025n

* CHECK dout1_64 Vdout1_64ck199 = 0 time = 1000
.meas tran vdout1_64ck199 FIND v(dout1_64) AT=1000.025n

* CHECK dout1_65 Vdout1_65ck199 = 0 time = 1000
.meas tran vdout1_65ck199 FIND v(dout1_65) AT=1000.025n

* CHECK dout1_66 Vdout1_66ck199 = 0.9 time = 1000
.meas tran vdout1_66ck199 FIND v(dout1_66) AT=1000.025n

* CHECK dout1_67 Vdout1_67ck199 = 0 time = 1000
.meas tran vdout1_67ck199 FIND v(dout1_67) AT=1000.025n

* CHECK dout1_68 Vdout1_68ck199 = 0.9 time = 1000
.meas tran vdout1_68ck199 FIND v(dout1_68) AT=1000.025n

* CHECK dout1_69 Vdout1_69ck199 = 0 time = 1000
.meas tran vdout1_69ck199 FIND v(dout1_69) AT=1000.025n

* CHECK dout1_70 Vdout1_70ck199 = 0.9 time = 1000
.meas tran vdout1_70ck199 FIND v(dout1_70) AT=1000.025n

* CHECK dout1_71 Vdout1_71ck199 = 0.9 time = 1000
.meas tran vdout1_71ck199 FIND v(dout1_71) AT=1000.025n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
