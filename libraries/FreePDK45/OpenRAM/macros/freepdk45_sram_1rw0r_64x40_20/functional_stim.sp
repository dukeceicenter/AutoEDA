* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "freepdk45_sram_1rw0r_64x40_20.sp"

* Global Power Supplies
Vvdd vdd 0 0.9

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xfreepdk45_sram_1rw0r_64x40_20 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 CSB0 WEB0 clk0 WMASK0_0 WMASK0_1 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout0_32 dout0_33 dout0_34 dout0_35 dout0_36 dout0_37 dout0_38 dout0_39 vdd gnd freepdk45_sram_1rw0r_64x40_20

* SRAM output loads
CD00 dout0_0  0 0.8364f
CD01 dout0_1  0 0.8364f
CD02 dout0_2  0 0.8364f
CD03 dout0_3  0 0.8364f
CD04 dout0_4  0 0.8364f
CD05 dout0_5  0 0.8364f
CD06 dout0_6  0 0.8364f
CD07 dout0_7  0 0.8364f
CD08 dout0_8  0 0.8364f
CD09 dout0_9  0 0.8364f
CD010 dout0_10  0 0.8364f
CD011 dout0_11  0 0.8364f
CD012 dout0_12  0 0.8364f
CD013 dout0_13  0 0.8364f
CD014 dout0_14  0 0.8364f
CD015 dout0_15  0 0.8364f
CD016 dout0_16  0 0.8364f
CD017 dout0_17  0 0.8364f
CD018 dout0_18  0 0.8364f
CD019 dout0_19  0 0.8364f
CD020 dout0_20  0 0.8364f
CD021 dout0_21  0 0.8364f
CD022 dout0_22  0 0.8364f
CD023 dout0_23  0 0.8364f
CD024 dout0_24  0 0.8364f
CD025 dout0_25  0 0.8364f
CD026 dout0_26  0 0.8364f
CD027 dout0_27  0 0.8364f
CD028 dout0_28  0 0.8364f
CD029 dout0_29  0 0.8364f
CD030 dout0_30  0 0.8364f
CD031 dout0_31  0 0.8364f
CD032 dout0_32  0 0.8364f
CD033 dout0_33  0 0.8364f
CD034 dout0_34  0 0.8364f
CD035 dout0_35  0 0.8364f
CD036 dout0_36  0 0.8364f
CD037 dout0_37  0 0.8364f
CD038 dout0_38  0 0.8364f
CD039 dout0_39  0 0.8364f

* Important signals for debug
* bl:	xfreepdk45_sram_1rw0r_64x40_20.xbank0.bl_0_0
* br:	xfreepdk45_sram_1rw0r_64x40_20.xbank0.br_0_0
* s_en:	xfreepdk45_sram_1rw0r_64x40_20.s_en
* q:	xfreepdk45_sram_1rw0r_64x40_20.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xfreepdk45_sram_1rw0r_64x40_20.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 1100000100101100010010010000110111111000  to  address 111110 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 1000111101111100101110101010101111100111  to  address 000000 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 0000001010110011101110010110000111010010  to  address 000000 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 1100000100101100010010010000110111111000 from address 111110 (from port 0) during cycle 4 (20ns - 25ns)
*	Writing (partial) 1010111010110101001101100111001111110000  to  address 000000 with mask bit 01 (from port 0) during cycle 5 (25ns - 30ns)
*	Reading 1100000100101100010010010000110111111000 from address 111110 (from port 0) during cycle 6 (30ns - 35ns)
*	Writing 0010101000011110011110101011010101010100  to  address 111101 (from port 0) during cycle 7 (35ns - 40ns)
*	Writing 1001100110101011101011010110010001110111  to  address 000000 (from port 0) during cycle 8 (40ns - 45ns)
*	Writing 1110101010100010011001001101111011111000  to  address 000000 (from port 0) during cycle 9 (45ns - 50ns)
*	Writing (partial) 0111101110011101010011100000000100000001  to  address 111101 with mask bit 01 (from port 0) during cycle 10 (50ns - 55ns)
*	Reading 1100000100101100010010010000110111111000 from address 111110 (from port 0) during cycle 13 (65ns - 70ns)
*	Reading 1110101010100010011001001101111011111000 from address 000000 (from port 0) during cycle 14 (70ns - 75ns)
*	Reading 1100000100101100010010010000110111111000 from address 111110 (from port 0) during cycle 15 (75ns - 80ns)
*	Writing (partial) 1101001001100111011011000001100011000001  to  address 000000 with mask bit 01 (from port 0) during cycle 16 (80ns - 85ns)
*	Reading 1100000100101100010010010000110111111000 from address 111110 (from port 0) during cycle 17 (85ns - 90ns)
*	Writing 1000010100010100110001111110110011001111  to  address 000000 (from port 0) during cycle 18 (90ns - 95ns)
*	Reading 0010101000011110011111100000000100000001 from address 111101 (from port 0) during cycle 19 (95ns - 100ns)
*	Reading 0010101000011110011111100000000100000001 from address 111101 (from port 0) during cycle 20 (100ns - 105ns)
*	Writing 0111101000011011110011001101001100011101  to  address 111101 (from port 0) during cycle 21 (105ns - 110ns)
*	Reading 0111101000011011110011001101001100011101 from address 111101 (from port 0) during cycle 23 (115ns - 120ns)
*	Writing (partial) 0110111101010010111001010000001001100000  to  address 111101 with mask bit 10 (from port 0) during cycle 24 (120ns - 125ns)
*	Writing (partial) 1101001000001111100011000010001110000111  to  address 111101 with mask bit 01 (from port 0) during cycle 26 (130ns - 135ns)
*	Reading 1100000100101100010010010000110111111000 from address 111110 (from port 0) during cycle 27 (135ns - 140ns)
*	Writing 1000011111101100011100010011101000100111  to  address 000000 (from port 0) during cycle 28 (140ns - 145ns)
*	Reading 0110111101010010111011000010001110000111 from address 111101 (from port 0) during cycle 29 (145ns - 150ns)
*	Reading 1000011111101100011100010011101000100111 from address 000000 (from port 0) during cycle 30 (150ns - 155ns)
*	Writing (partial) 1110110011111011100100111101110011111101  to  address 000000 with mask bit 01 (from port 0) during cycle 31 (155ns - 160ns)
*	Reading 1100000100101100010010010000110111111000 from address 111110 (from port 0) during cycle 32 (160ns - 165ns)
*	Writing 0000101110111010011111101101001110101110  to  address 111101 (from port 0) during cycle 33 (165ns - 170ns)
*	Reading 0000101110111010011111101101001110101110 from address 111101 (from port 0) during cycle 34 (170ns - 175ns)
*	Writing (partial) 0010111101010100110011100111110011010010  to  address 111101 with mask bit 01 (from port 0) during cycle 35 (175ns - 180ns)
*	Reading 0000101110111010011111100111110011010010 from address 111101 (from port 0) during cycle 36 (180ns - 185ns)
*	Writing (partial) 1010110110111000001000111000000010100110  to  address 111101 with mask bit 01 (from port 0) during cycle 38 (190ns - 195ns)
*	Writing 0100010101110000111000001100010011100110  to  address 111110 (from port 0) during cycle 39 (195ns - 200ns)
*	Writing 1010100011010111001100110011101010100001  to  address 111110 (from port 0) during cycle 40 (200ns - 205ns)
*	Writing (partial) 1101101010000000011100001011001100100011  to  address 111101 with mask bit 10 (from port 0) during cycle 41 (205ns - 210ns)
*	Writing 1000101110100101010000101100110101001000  to  address 111110 (from port 0) during cycle 42 (210ns - 215ns)
*	Reading 1101101010000000011100111000000010100110 from address 111101 (from port 0) during cycle 44 (220ns - 225ns)
*	Writing 0100100010011100100001000011010000110100  to  address 111110 (from port 0) during cycle 45 (225ns - 230ns)
*	Reading 1101101010000000011100111000000010100110 from address 111101 (from port 0) during cycle 46 (230ns - 235ns)
*	Writing 1100110000010110101000100001001000000000  to  address 111101 (from port 0) during cycle 47 (235ns - 240ns)
*	Reading 0100100010011100100001000011010000110100 from address 111110 (from port 0) during cycle 50 (250ns - 255ns)
*	Reading 1000011111101100011100111101110011111101 from address 000000 (from port 0) during cycle 52 (260ns - 265ns)
*	Reading 1100110000010110101000100001001000000000 from address 111101 (from port 0) during cycle 53 (265ns - 270ns)
*	Writing (partial) 1010010010000110101101100000101011110111  to  address 000000 with mask bit 10 (from port 0) during cycle 54 (270ns - 275ns)
*	Writing 0001100011011010000010010010011010110000  to  address 000000 (from port 0) during cycle 56 (280ns - 285ns)
*	Reading 1100110000010110101000100001001000000000 from address 111101 (from port 0) during cycle 57 (285ns - 290ns)
*	Writing (partial) 1110011101011110000111110100100100100010  to  address 000000 with mask bit 01 (from port 0) during cycle 58 (290ns - 295ns)
*	Writing 1101000100101100010101001100101000100100  to  address 000001 (from port 0) during cycle 59 (295ns - 300ns)
*	Writing (partial) 0000100101110010010110010001000001000101  to  address 000001 with mask bit 10 (from port 0) during cycle 60 (300ns - 305ns)
*	Reading 0000100101110010010101001100101000100100 from address 000001 (from port 0) during cycle 61 (305ns - 310ns)
*	Reading 0000100101110010010101001100101000100100 from address 000001 (from port 0) during cycle 62 (310ns - 315ns)
*	Writing 1110100001100101111101101110001000111001  to  address 000001 (from port 0) during cycle 63 (315ns - 320ns)
*	Writing (partial) 0001111011010111110110000110100010000110  to  address 111101 with mask bit 10 (from port 0) during cycle 64 (320ns - 325ns)
*	Writing 1000001001001001111100100001001001100000  to  address 000001 (from port 0) during cycle 65 (325ns - 330ns)
*	Reading 0001111011010111110100100001001000000000 from address 111101 (from port 0) during cycle 66 (330ns - 335ns)
*	Writing 1100011111110101011110001100100001010011  to  address 000001 (from port 0) during cycle 67 (335ns - 340ns)
*	Reading 0001100011011010000011110100100100100010 from address 000000 (from port 0) during cycle 70 (350ns - 355ns)
*	Reading 1100011111110101011110001100100001010011 from address 000001 (from port 0) during cycle 71 (355ns - 360ns)
*	Writing 0101111011100011001100000010010001110100  to  address 000001 (from port 0) during cycle 73 (365ns - 370ns)
*	Writing (partial) 1101000000011011100001001011111111000011  to  address 111101 with mask bit 10 (from port 0) during cycle 74 (370ns - 375ns)
*	Reading 0101111011100011001100000010010001110100 from address 000001 (from port 0) during cycle 75 (375ns - 380ns)
*	Writing 1100011000101000010111101111101110011001  to  address 000001 (from port 0) during cycle 76 (380ns - 385ns)
*	Writing 0111101001000111101000001100001110100000  to  address 000000 (from port 0) during cycle 77 (385ns - 390ns)
*	Reading 0111101001000111101000001100001110100000 from address 000000 (from port 0) during cycle 79 (395ns - 400ns)
*	Reading 0111101001000111101000001100001110100000 from address 000000 (from port 0) during cycle 80 (400ns - 405ns)
*	Reading 1101000000011011100000100001001000000000 from address 111101 (from port 0) during cycle 81 (405ns - 410ns)
*	Writing (partial) 0000111111011011100111010101010111100100  to  address 000000 with mask bit 01 (from port 0) during cycle 82 (410ns - 415ns)
*	Writing (partial) 1001111000100011101110111001011110100001  to  address 000000 with mask bit 01 (from port 0) during cycle 83 (415ns - 420ns)
*	Writing 1100011011011011111001110111010101111011  to  address 000001 (from port 0) during cycle 84 (420ns - 425ns)
*	Writing 1000111011100001000111010011101000010111  to  address 111101 (from port 0) during cycle 85 (425ns - 430ns)
*	Reading 0100100010011100100001000011010000110100 from address 111110 (from port 0) during cycle 86 (430ns - 435ns)
*	Writing 0001001101101100000011110000111101011111  to  address 000000 (from port 0) during cycle 87 (435ns - 440ns)
*	Writing (partial) 1111011000010110010101011011100001011001  to  address 000000 with mask bit 10 (from port 0) during cycle 89 (445ns - 450ns)
*	Writing (partial) 0011100100111110000000001000101110101101  to  address 000001 with mask bit 10 (from port 0) during cycle 90 (450ns - 455ns)
*	Reading 1111011000010110010111110000111101011111 from address 000000 (from port 0) during cycle 91 (455ns - 460ns)
*	Reading 0011100100111110000001110111010101111011 from address 000001 (from port 0) during cycle 92 (460ns - 465ns)
*	Reading 1111011000010110010111110000111101011111 from address 000000 (from port 0) during cycle 93 (465ns - 470ns)
*	Writing (partial) 0100101010000101111101110101001001111011  to  address 111110 with mask bit 10 (from port 0) during cycle 94 (470ns - 475ns)
*	Reading 1111011000010110010111110000111101011111 from address 000000 (from port 0) during cycle 95 (475ns - 480ns)
*	Writing 0100101011010111001011011010100001100111  to  address 111110 (from port 0) during cycle 96 (480ns - 485ns)
*	Reading 1111011000010110010111110000111101011111 from address 000000 (from port 0) during cycle 98 (490ns - 495ns)
*	Writing 0000001000001100101101001010111001011101  to  address 000001 (from port 0) during cycle 100 (500ns - 505ns)
*	Reading 1000111011100001000111010011101000010111 from address 111101 (from port 0) during cycle 101 (505ns - 510ns)
*	Reading 1111011000010110010111110000111101011111 from address 000000 (from port 0) during cycle 102 (510ns - 515ns)
*	Reading 1111011000010110010111110000111101011111 from address 000000 (from port 0) during cycle 103 (515ns - 520ns)
*	Writing (partial) 0001101010101101110011111010101111000110  to  address 000001 with mask bit 01 (from port 0) during cycle 104 (520ns - 525ns)
*	Reading 1111011000010110010111110000111101011111 from address 000000 (from port 0) during cycle 105 (525ns - 530ns)
*	Writing (partial) 0001101111001001101100100110010001000010  to  address 000000 with mask bit 01 (from port 0) during cycle 106 (530ns - 535ns)
*	Reading 0000001000001100101111111010101111000110 from address 000001 (from port 0) during cycle 107 (535ns - 540ns)
*	Reading 1000111011100001000111010011101000010111 from address 111101 (from port 0) during cycle 109 (545ns - 550ns)
*	Writing (partial) 0001101010111100010010001011100101001100  to  address 000001 with mask bit 01 (from port 0) during cycle 110 (550ns - 555ns)
*	Reading 0100101011010111001011011010100001100111 from address 111110 (from port 0) during cycle 111 (555ns - 560ns)
*	Reading 0100101011010111001011011010100001100111 from address 111110 (from port 0) during cycle 112 (560ns - 565ns)
*	Writing 1001100111000100000101010010101011001100  to  address 000001 (from port 0) during cycle 113 (565ns - 570ns)
*	Writing (partial) 1011110011001111111111111011111010101010  to  address 111101 with mask bit 10 (from port 0) during cycle 115 (575ns - 580ns)
*	Writing (partial) 1001101111111100011100100010000000001101  to  address 111101 with mask bit 10 (from port 0) during cycle 116 (580ns - 585ns)
*	Writing 0000101100011110101111000010100000110110  to  address 111101 (from port 0) during cycle 117 (585ns - 590ns)
*	Reading 1111011000010110010100100110010001000010 from address 000000 (from port 0) during cycle 118 (590ns - 595ns)
*	Reading 1111011000010110010100100110010001000010 from address 000000 (from port 0) during cycle 119 (595ns - 600ns)
*	Reading 0100101011010111001011011010100001100111 from address 111110 (from port 0) during cycle 121 (605ns - 610ns)
*	Reading 1001100111000100000101010010101011001100 from address 000001 (from port 0) during cycle 123 (615ns - 620ns)
*	Writing (partial) 1110001100100111111110000001110100001000  to  address 000001 with mask bit 10 (from port 0) during cycle 124 (620ns - 625ns)
*	Reading 0000101100011110101111000010100000110110 from address 111101 (from port 0) during cycle 125 (625ns - 630ns)
*	Writing 0101010110001001100101110101111000111100  to  address 000000 (from port 0) during cycle 126 (630ns - 635ns)
*	Writing 1111010110100001111000100110110010111110  to  address 000001 (from port 0) during cycle 127 (635ns - 640ns)
*	Writing 0000010111111110100110010110010111001111  to  address 111101 (from port 0) during cycle 128 (640ns - 645ns)
*	Reading 0000010111111110100110010110010111001111 from address 111101 (from port 0) during cycle 129 (645ns - 650ns)
*	Writing 0110101100101001011000110100010000010110  to  address 111110 (from port 0) during cycle 130 (650ns - 655ns)
*	Writing (partial) 0111010010111101101100101100101010100111  to  address 000000 with mask bit 10 (from port 0) during cycle 131 (655ns - 660ns)
*	Writing 1000011000011111001110100101001110011110  to  address 111110 (from port 0) during cycle 132 (660ns - 665ns)
*	Reading 1111010110100001111000100110110010111110 from address 000001 (from port 0) during cycle 133 (665ns - 670ns)
*	Writing (partial) 0011101100011001111000110101101110101110  to  address 000001 with mask bit 01 (from port 0) during cycle 134 (670ns - 675ns)
*	Writing (partial) 0000101101111001101001101101011101001001  to  address 000001 with mask bit 01 (from port 0) during cycle 135 (675ns - 680ns)
*	Writing 1010111010000100011011011111001111100001  to  address 000000 (from port 0) during cycle 137 (685ns - 690ns)
*	Reading 1010111010000100011011011111001111100001 from address 000000 (from port 0) during cycle 138 (690ns - 695ns)
*	Reading 1111010110100001111001101101011101001001 from address 000001 (from port 0) during cycle 140 (700ns - 705ns)
*	Writing (partial) 1011100001111011100011101110100000001011  to  address 111110 with mask bit 01 (from port 0) during cycle 141 (705ns - 710ns)
*	Reading 1000011000011111001111101110100000001011 from address 111110 (from port 0) during cycle 142 (710ns - 715ns)
*	Reading 1000011000011111001111101110100000001011 from address 111110 (from port 0) during cycle 143 (715ns - 720ns)
*	Writing 0001001111110010101011010100110011011111  to  address 000001 (from port 0) during cycle 144 (720ns - 725ns)
*	Writing 1111010111010010101100111011110111001101  to  address 111110 (from port 0) during cycle 148 (740ns - 745ns)
*	Writing (partial) 1111011100000000111101110111010000101100  to  address 000000 with mask bit 01 (from port 0) during cycle 149 (745ns - 750ns)
*	Reading 0000010111111110100110010110010111001111 from address 111101 (from port 0) during cycle 150 (750ns - 755ns)
*	Reading 1111010111010010101100111011110111001101 from address 111110 (from port 0) during cycle 151 (755ns - 760ns)
*	Reading 1010111010000100011001110111010000101100 from address 000000 (from port 0) during cycle 152 (760ns - 765ns)
*	Writing (partial) 1000001111101110000100100010011101110100  to  address 000001 with mask bit 01 (from port 0) during cycle 154 (770ns - 775ns)
*	Writing 1100110010110110101101100111011111101101  to  address 111101 (from port 0) during cycle 155 (775ns - 780ns)
*	Reading 1111010111010010101100111011110111001101 from address 111110 (from port 0) during cycle 156 (780ns - 785ns)
*	Writing (partial) 1001000011111101010000010000100101110000  to  address 111110 with mask bit 01 (from port 0) during cycle 157 (785ns - 790ns)
*	Reading 1111010111010010101100010000100101110000 from address 111110 (from port 0) during cycle 158 (790ns - 795ns)
*	Writing 0001000000111000111011111011011101001101  to  address 111101 (from port 0) during cycle 159 (795ns - 800ns)
*	Writing (partial) 0010110100110000000100011110000110111001  to  address 111110 with mask bit 10 (from port 0) during cycle 161 (805ns - 810ns)
*	Reading 1010111010000100011001110111010000101100 from address 000000 (from port 0) during cycle 162 (810ns - 815ns)
*	Reading 1010111010000100011001110111010000101100 from address 000000 (from port 0) during cycle 163 (815ns - 820ns)
*	Reading 0001000000111000111011111011011101001101 from address 111101 (from port 0) during cycle 164 (820ns - 825ns)
*	Writing 0110011010111011010111100100000100100011  to  address 000000 (from port 0) during cycle 165 (825ns - 830ns)
*	Reading 0001000000111000111011111011011101001101 from address 111101 (from port 0) during cycle 166 (830ns - 835ns)
*	Writing 0101111101111000001000000011111110010101  to  address 111110 (from port 0) during cycle 168 (840ns - 845ns)
*	Reading 0110011010111011010111100100000100100011 from address 000000 (from port 0) during cycle 169 (845ns - 850ns)
*	Writing 0100111111001101111100011011000110111111  to  address 111110 (from port 0) during cycle 171 (855ns - 860ns)
*	Writing 1110101100110010101111001101010110010010  to  address 111101 (from port 0) during cycle 172 (860ns - 865ns)
*	Reading 1110101100110010101111001101010110010010 from address 111101 (from port 0) during cycle 173 (865ns - 870ns)
*	Writing (partial) 0110101001101101001111000111001110000101  to  address 000000 with mask bit 10 (from port 0) during cycle 174 (870ns - 875ns)
*	Reading 0001001111110010101000100010011101110100 from address 000001 (from port 0) during cycle 175 (875ns - 880ns)
*	Reading 0110101001101101001111100100000100100011 from address 000000 (from port 0) during cycle 176 (880ns - 885ns)
*	Writing (partial) 1101110010111110110001011011110001001110  to  address 111110 with mask bit 01 (from port 0) during cycle 178 (890ns - 895ns)
*	Writing 1011000111001100110111101011011001110100  to  address 111101 (from port 0) during cycle 179 (895ns - 900ns)
*	Reading 0001001111110010101000100010011101110100 from address 000001 (from port 0) during cycle 180 (900ns - 905ns)
*	Reading 0001001111110010101000100010011101110100 from address 000001 (from port 0) during cycle 181 (905ns - 910ns)
*	Writing 0001000010110010011010000010000101010011  to  address 000001 (from port 0) during cycle 182 (910ns - 915ns)
*	Writing (partial) 1100010000110010110101110110110111110001  to  address 111110 with mask bit 01 (from port 0) during cycle 184 (920ns - 925ns)
*	Reading 0100111111001101111101110110110111110001 from address 111110 (from port 0) during cycle 185 (925ns - 930ns)
*	Reading 1011000111001100110111101011011001110100 from address 111101 (from port 0) during cycle 186 (930ns - 935ns)
*	Reading 0110101001101101001111100100000100100011 from address 000000 (from port 0) during cycle 188 (940ns - 945ns)
*	Reading 0110101001101101001111100100000100100011 from address 000000 (from port 0) during cycle 189 (945ns - 950ns)
*	Reading 0001000010110010011010000010000101010011 from address 000001 (from port 0) during cycle 190 (950ns - 955ns)
*	Writing 1001011111111011000100011101111110111100  to  address 000000 (from port 0) during cycle 191 (955ns - 960ns)
*	Writing 1010000110111110011110000100110111100001  to  address 000001 (from port 0) during cycle 192 (960ns - 965ns)
*	Writing 1010111010110010001110000001011000001011  to  address 111101 (from port 0) during cycle 193 (965ns - 970ns)
*	Writing (partial) 0011000001100001101001000100000101000001  to  address 111110 with mask bit 01 (from port 0) during cycle 194 (970ns - 975ns)
*	Reading 0100111111001101111101000100000101000001 from address 111110 (from port 0) during cycle 195 (975ns - 980ns)
*	Reading 1010111010110010001110000001011000001011 from address 111101 (from port 0) during cycle 196 (980ns - 985ns)
*	Reading 0100111111001101111101000100000101000001 from address 111110 (from port 0) during cycle 197 (985ns - 990ns)
*	Reading 0100111111001101111101000100000101000001 from address 111110 (from port 0) during cycle 198 (990ns - 995ns)
*	Writing (partial) 0011110101010001000111111000110111101100  to  address 000000 with mask bit 01 (from port 0) during cycle 199 (995ns - 1000ns)
*	Reading 1010111010110010001110000001011000001011 from address 111101 (from port 0) during cycle 200 (1000ns - 1005ns)
*	Writing 0011110000111110111100000111111100111001  to  address 111110 (from port 0) during cycle 202 (1010ns - 1015ns)
*	Writing 0000010110111001100111001010100011001111  to  address 111110 (from port 0) during cycle 203 (1015ns - 1020ns)
*	Writing 0100010001001111000110000001111111101101  to  address 000000 (from port 0) during cycle 204 (1020ns - 1025ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 1), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 0), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 1), (935, 1), (940, 0), (945, 0), (950, 1), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 1), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 1), (70, 0), (75, 1), (80, 0), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 1), (25, 0), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 1), (25, 0), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 1), (25, 0), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 1), (25, 0), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 1), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 1), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 0), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 0), (125, 1), (130, 0), (135, 1), (140, 0), (145, 1), (150, 1), (155, 0), (160, 1), (165, 0), (170, 1), (175, 0), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 0), (230, 1), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 1), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 1), (685, 0), (690, 1), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 0), (790, 1), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 1)]
VWEB0 WEB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )

* Generation of wmask signals
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWMASK0_0  WMASK0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWMASK0_1  WMASK0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 0 time = 25
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=25.025n

* CHECK dout0_1 Vdout0_1ck4 = 0 time = 25
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=25.025n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 25
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=25.025n

* CHECK dout0_3 Vdout0_3ck4 = 0.9 time = 25
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=25.025n

* CHECK dout0_4 Vdout0_4ck4 = 0.9 time = 25
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=25.025n

* CHECK dout0_5 Vdout0_5ck4 = 0.9 time = 25
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=25.025n

* CHECK dout0_6 Vdout0_6ck4 = 0.9 time = 25
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=25.025n

* CHECK dout0_7 Vdout0_7ck4 = 0.9 time = 25
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=25.025n

* CHECK dout0_8 Vdout0_8ck4 = 0.9 time = 25
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=25.025n

* CHECK dout0_9 Vdout0_9ck4 = 0 time = 25
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=25.025n

* CHECK dout0_10 Vdout0_10ck4 = 0.9 time = 25
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=25.025n

* CHECK dout0_11 Vdout0_11ck4 = 0.9 time = 25
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=25.025n

* CHECK dout0_12 Vdout0_12ck4 = 0 time = 25
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=25.025n

* CHECK dout0_13 Vdout0_13ck4 = 0 time = 25
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=25.025n

* CHECK dout0_14 Vdout0_14ck4 = 0 time = 25
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=25.025n

* CHECK dout0_15 Vdout0_15ck4 = 0 time = 25
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=25.025n

* CHECK dout0_16 Vdout0_16ck4 = 0.9 time = 25
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=25.025n

* CHECK dout0_17 Vdout0_17ck4 = 0 time = 25
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=25.025n

* CHECK dout0_18 Vdout0_18ck4 = 0 time = 25
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=25.025n

* CHECK dout0_19 Vdout0_19ck4 = 0.9 time = 25
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=25.025n

* CHECK dout0_20 Vdout0_20ck4 = 0 time = 25
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=25.025n

* CHECK dout0_21 Vdout0_21ck4 = 0 time = 25
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=25.025n

* CHECK dout0_22 Vdout0_22ck4 = 0.9 time = 25
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=25.025n

* CHECK dout0_23 Vdout0_23ck4 = 0 time = 25
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=25.025n

* CHECK dout0_24 Vdout0_24ck4 = 0 time = 25
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=25.025n

* CHECK dout0_25 Vdout0_25ck4 = 0 time = 25
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=25.025n

* CHECK dout0_26 Vdout0_26ck4 = 0.9 time = 25
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=25.025n

* CHECK dout0_27 Vdout0_27ck4 = 0.9 time = 25
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=25.025n

* CHECK dout0_28 Vdout0_28ck4 = 0 time = 25
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=25.025n

* CHECK dout0_29 Vdout0_29ck4 = 0.9 time = 25
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=25.025n

* CHECK dout0_30 Vdout0_30ck4 = 0 time = 25
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=25.025n

* CHECK dout0_31 Vdout0_31ck4 = 0 time = 25
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=25.025n

* CHECK dout0_32 Vdout0_32ck4 = 0.9 time = 25
.meas tran vdout0_32ck4 FIND v(dout0_32) AT=25.025n

* CHECK dout0_33 Vdout0_33ck4 = 0 time = 25
.meas tran vdout0_33ck4 FIND v(dout0_33) AT=25.025n

* CHECK dout0_34 Vdout0_34ck4 = 0 time = 25
.meas tran vdout0_34ck4 FIND v(dout0_34) AT=25.025n

* CHECK dout0_35 Vdout0_35ck4 = 0 time = 25
.meas tran vdout0_35ck4 FIND v(dout0_35) AT=25.025n

* CHECK dout0_36 Vdout0_36ck4 = 0 time = 25
.meas tran vdout0_36ck4 FIND v(dout0_36) AT=25.025n

* CHECK dout0_37 Vdout0_37ck4 = 0 time = 25
.meas tran vdout0_37ck4 FIND v(dout0_37) AT=25.025n

* CHECK dout0_38 Vdout0_38ck4 = 0.9 time = 25
.meas tran vdout0_38ck4 FIND v(dout0_38) AT=25.025n

* CHECK dout0_39 Vdout0_39ck4 = 0.9 time = 25
.meas tran vdout0_39ck4 FIND v(dout0_39) AT=25.025n

* CHECK dout0_0 Vdout0_0ck6 = 0 time = 35
.meas tran vdout0_0ck6 FIND v(dout0_0) AT=35.025n

* CHECK dout0_1 Vdout0_1ck6 = 0 time = 35
.meas tran vdout0_1ck6 FIND v(dout0_1) AT=35.025n

* CHECK dout0_2 Vdout0_2ck6 = 0 time = 35
.meas tran vdout0_2ck6 FIND v(dout0_2) AT=35.025n

* CHECK dout0_3 Vdout0_3ck6 = 0.9 time = 35
.meas tran vdout0_3ck6 FIND v(dout0_3) AT=35.025n

* CHECK dout0_4 Vdout0_4ck6 = 0.9 time = 35
.meas tran vdout0_4ck6 FIND v(dout0_4) AT=35.025n

* CHECK dout0_5 Vdout0_5ck6 = 0.9 time = 35
.meas tran vdout0_5ck6 FIND v(dout0_5) AT=35.025n

* CHECK dout0_6 Vdout0_6ck6 = 0.9 time = 35
.meas tran vdout0_6ck6 FIND v(dout0_6) AT=35.025n

* CHECK dout0_7 Vdout0_7ck6 = 0.9 time = 35
.meas tran vdout0_7ck6 FIND v(dout0_7) AT=35.025n

* CHECK dout0_8 Vdout0_8ck6 = 0.9 time = 35
.meas tran vdout0_8ck6 FIND v(dout0_8) AT=35.025n

* CHECK dout0_9 Vdout0_9ck6 = 0 time = 35
.meas tran vdout0_9ck6 FIND v(dout0_9) AT=35.025n

* CHECK dout0_10 Vdout0_10ck6 = 0.9 time = 35
.meas tran vdout0_10ck6 FIND v(dout0_10) AT=35.025n

* CHECK dout0_11 Vdout0_11ck6 = 0.9 time = 35
.meas tran vdout0_11ck6 FIND v(dout0_11) AT=35.025n

* CHECK dout0_12 Vdout0_12ck6 = 0 time = 35
.meas tran vdout0_12ck6 FIND v(dout0_12) AT=35.025n

* CHECK dout0_13 Vdout0_13ck6 = 0 time = 35
.meas tran vdout0_13ck6 FIND v(dout0_13) AT=35.025n

* CHECK dout0_14 Vdout0_14ck6 = 0 time = 35
.meas tran vdout0_14ck6 FIND v(dout0_14) AT=35.025n

* CHECK dout0_15 Vdout0_15ck6 = 0 time = 35
.meas tran vdout0_15ck6 FIND v(dout0_15) AT=35.025n

* CHECK dout0_16 Vdout0_16ck6 = 0.9 time = 35
.meas tran vdout0_16ck6 FIND v(dout0_16) AT=35.025n

* CHECK dout0_17 Vdout0_17ck6 = 0 time = 35
.meas tran vdout0_17ck6 FIND v(dout0_17) AT=35.025n

* CHECK dout0_18 Vdout0_18ck6 = 0 time = 35
.meas tran vdout0_18ck6 FIND v(dout0_18) AT=35.025n

* CHECK dout0_19 Vdout0_19ck6 = 0.9 time = 35
.meas tran vdout0_19ck6 FIND v(dout0_19) AT=35.025n

* CHECK dout0_20 Vdout0_20ck6 = 0 time = 35
.meas tran vdout0_20ck6 FIND v(dout0_20) AT=35.025n

* CHECK dout0_21 Vdout0_21ck6 = 0 time = 35
.meas tran vdout0_21ck6 FIND v(dout0_21) AT=35.025n

* CHECK dout0_22 Vdout0_22ck6 = 0.9 time = 35
.meas tran vdout0_22ck6 FIND v(dout0_22) AT=35.025n

* CHECK dout0_23 Vdout0_23ck6 = 0 time = 35
.meas tran vdout0_23ck6 FIND v(dout0_23) AT=35.025n

* CHECK dout0_24 Vdout0_24ck6 = 0 time = 35
.meas tran vdout0_24ck6 FIND v(dout0_24) AT=35.025n

* CHECK dout0_25 Vdout0_25ck6 = 0 time = 35
.meas tran vdout0_25ck6 FIND v(dout0_25) AT=35.025n

* CHECK dout0_26 Vdout0_26ck6 = 0.9 time = 35
.meas tran vdout0_26ck6 FIND v(dout0_26) AT=35.025n

* CHECK dout0_27 Vdout0_27ck6 = 0.9 time = 35
.meas tran vdout0_27ck6 FIND v(dout0_27) AT=35.025n

* CHECK dout0_28 Vdout0_28ck6 = 0 time = 35
.meas tran vdout0_28ck6 FIND v(dout0_28) AT=35.025n

* CHECK dout0_29 Vdout0_29ck6 = 0.9 time = 35
.meas tran vdout0_29ck6 FIND v(dout0_29) AT=35.025n

* CHECK dout0_30 Vdout0_30ck6 = 0 time = 35
.meas tran vdout0_30ck6 FIND v(dout0_30) AT=35.025n

* CHECK dout0_31 Vdout0_31ck6 = 0 time = 35
.meas tran vdout0_31ck6 FIND v(dout0_31) AT=35.025n

* CHECK dout0_32 Vdout0_32ck6 = 0.9 time = 35
.meas tran vdout0_32ck6 FIND v(dout0_32) AT=35.025n

* CHECK dout0_33 Vdout0_33ck6 = 0 time = 35
.meas tran vdout0_33ck6 FIND v(dout0_33) AT=35.025n

* CHECK dout0_34 Vdout0_34ck6 = 0 time = 35
.meas tran vdout0_34ck6 FIND v(dout0_34) AT=35.025n

* CHECK dout0_35 Vdout0_35ck6 = 0 time = 35
.meas tran vdout0_35ck6 FIND v(dout0_35) AT=35.025n

* CHECK dout0_36 Vdout0_36ck6 = 0 time = 35
.meas tran vdout0_36ck6 FIND v(dout0_36) AT=35.025n

* CHECK dout0_37 Vdout0_37ck6 = 0 time = 35
.meas tran vdout0_37ck6 FIND v(dout0_37) AT=35.025n

* CHECK dout0_38 Vdout0_38ck6 = 0.9 time = 35
.meas tran vdout0_38ck6 FIND v(dout0_38) AT=35.025n

* CHECK dout0_39 Vdout0_39ck6 = 0.9 time = 35
.meas tran vdout0_39ck6 FIND v(dout0_39) AT=35.025n

* CHECK dout0_0 Vdout0_0ck13 = 0 time = 70
.meas tran vdout0_0ck13 FIND v(dout0_0) AT=70.025n

* CHECK dout0_1 Vdout0_1ck13 = 0 time = 70
.meas tran vdout0_1ck13 FIND v(dout0_1) AT=70.025n

* CHECK dout0_2 Vdout0_2ck13 = 0 time = 70
.meas tran vdout0_2ck13 FIND v(dout0_2) AT=70.025n

* CHECK dout0_3 Vdout0_3ck13 = 0.9 time = 70
.meas tran vdout0_3ck13 FIND v(dout0_3) AT=70.025n

* CHECK dout0_4 Vdout0_4ck13 = 0.9 time = 70
.meas tran vdout0_4ck13 FIND v(dout0_4) AT=70.025n

* CHECK dout0_5 Vdout0_5ck13 = 0.9 time = 70
.meas tran vdout0_5ck13 FIND v(dout0_5) AT=70.025n

* CHECK dout0_6 Vdout0_6ck13 = 0.9 time = 70
.meas tran vdout0_6ck13 FIND v(dout0_6) AT=70.025n

* CHECK dout0_7 Vdout0_7ck13 = 0.9 time = 70
.meas tran vdout0_7ck13 FIND v(dout0_7) AT=70.025n

* CHECK dout0_8 Vdout0_8ck13 = 0.9 time = 70
.meas tran vdout0_8ck13 FIND v(dout0_8) AT=70.025n

* CHECK dout0_9 Vdout0_9ck13 = 0 time = 70
.meas tran vdout0_9ck13 FIND v(dout0_9) AT=70.025n

* CHECK dout0_10 Vdout0_10ck13 = 0.9 time = 70
.meas tran vdout0_10ck13 FIND v(dout0_10) AT=70.025n

* CHECK dout0_11 Vdout0_11ck13 = 0.9 time = 70
.meas tran vdout0_11ck13 FIND v(dout0_11) AT=70.025n

* CHECK dout0_12 Vdout0_12ck13 = 0 time = 70
.meas tran vdout0_12ck13 FIND v(dout0_12) AT=70.025n

* CHECK dout0_13 Vdout0_13ck13 = 0 time = 70
.meas tran vdout0_13ck13 FIND v(dout0_13) AT=70.025n

* CHECK dout0_14 Vdout0_14ck13 = 0 time = 70
.meas tran vdout0_14ck13 FIND v(dout0_14) AT=70.025n

* CHECK dout0_15 Vdout0_15ck13 = 0 time = 70
.meas tran vdout0_15ck13 FIND v(dout0_15) AT=70.025n

* CHECK dout0_16 Vdout0_16ck13 = 0.9 time = 70
.meas tran vdout0_16ck13 FIND v(dout0_16) AT=70.025n

* CHECK dout0_17 Vdout0_17ck13 = 0 time = 70
.meas tran vdout0_17ck13 FIND v(dout0_17) AT=70.025n

* CHECK dout0_18 Vdout0_18ck13 = 0 time = 70
.meas tran vdout0_18ck13 FIND v(dout0_18) AT=70.025n

* CHECK dout0_19 Vdout0_19ck13 = 0.9 time = 70
.meas tran vdout0_19ck13 FIND v(dout0_19) AT=70.025n

* CHECK dout0_20 Vdout0_20ck13 = 0 time = 70
.meas tran vdout0_20ck13 FIND v(dout0_20) AT=70.025n

* CHECK dout0_21 Vdout0_21ck13 = 0 time = 70
.meas tran vdout0_21ck13 FIND v(dout0_21) AT=70.025n

* CHECK dout0_22 Vdout0_22ck13 = 0.9 time = 70
.meas tran vdout0_22ck13 FIND v(dout0_22) AT=70.025n

* CHECK dout0_23 Vdout0_23ck13 = 0 time = 70
.meas tran vdout0_23ck13 FIND v(dout0_23) AT=70.025n

* CHECK dout0_24 Vdout0_24ck13 = 0 time = 70
.meas tran vdout0_24ck13 FIND v(dout0_24) AT=70.025n

* CHECK dout0_25 Vdout0_25ck13 = 0 time = 70
.meas tran vdout0_25ck13 FIND v(dout0_25) AT=70.025n

* CHECK dout0_26 Vdout0_26ck13 = 0.9 time = 70
.meas tran vdout0_26ck13 FIND v(dout0_26) AT=70.025n

* CHECK dout0_27 Vdout0_27ck13 = 0.9 time = 70
.meas tran vdout0_27ck13 FIND v(dout0_27) AT=70.025n

* CHECK dout0_28 Vdout0_28ck13 = 0 time = 70
.meas tran vdout0_28ck13 FIND v(dout0_28) AT=70.025n

* CHECK dout0_29 Vdout0_29ck13 = 0.9 time = 70
.meas tran vdout0_29ck13 FIND v(dout0_29) AT=70.025n

* CHECK dout0_30 Vdout0_30ck13 = 0 time = 70
.meas tran vdout0_30ck13 FIND v(dout0_30) AT=70.025n

* CHECK dout0_31 Vdout0_31ck13 = 0 time = 70
.meas tran vdout0_31ck13 FIND v(dout0_31) AT=70.025n

* CHECK dout0_32 Vdout0_32ck13 = 0.9 time = 70
.meas tran vdout0_32ck13 FIND v(dout0_32) AT=70.025n

* CHECK dout0_33 Vdout0_33ck13 = 0 time = 70
.meas tran vdout0_33ck13 FIND v(dout0_33) AT=70.025n

* CHECK dout0_34 Vdout0_34ck13 = 0 time = 70
.meas tran vdout0_34ck13 FIND v(dout0_34) AT=70.025n

* CHECK dout0_35 Vdout0_35ck13 = 0 time = 70
.meas tran vdout0_35ck13 FIND v(dout0_35) AT=70.025n

* CHECK dout0_36 Vdout0_36ck13 = 0 time = 70
.meas tran vdout0_36ck13 FIND v(dout0_36) AT=70.025n

* CHECK dout0_37 Vdout0_37ck13 = 0 time = 70
.meas tran vdout0_37ck13 FIND v(dout0_37) AT=70.025n

* CHECK dout0_38 Vdout0_38ck13 = 0.9 time = 70
.meas tran vdout0_38ck13 FIND v(dout0_38) AT=70.025n

* CHECK dout0_39 Vdout0_39ck13 = 0.9 time = 70
.meas tran vdout0_39ck13 FIND v(dout0_39) AT=70.025n

* CHECK dout0_0 Vdout0_0ck14 = 0 time = 75
.meas tran vdout0_0ck14 FIND v(dout0_0) AT=75.025n

* CHECK dout0_1 Vdout0_1ck14 = 0 time = 75
.meas tran vdout0_1ck14 FIND v(dout0_1) AT=75.025n

* CHECK dout0_2 Vdout0_2ck14 = 0 time = 75
.meas tran vdout0_2ck14 FIND v(dout0_2) AT=75.025n

* CHECK dout0_3 Vdout0_3ck14 = 0.9 time = 75
.meas tran vdout0_3ck14 FIND v(dout0_3) AT=75.025n

* CHECK dout0_4 Vdout0_4ck14 = 0.9 time = 75
.meas tran vdout0_4ck14 FIND v(dout0_4) AT=75.025n

* CHECK dout0_5 Vdout0_5ck14 = 0.9 time = 75
.meas tran vdout0_5ck14 FIND v(dout0_5) AT=75.025n

* CHECK dout0_6 Vdout0_6ck14 = 0.9 time = 75
.meas tran vdout0_6ck14 FIND v(dout0_6) AT=75.025n

* CHECK dout0_7 Vdout0_7ck14 = 0.9 time = 75
.meas tran vdout0_7ck14 FIND v(dout0_7) AT=75.025n

* CHECK dout0_8 Vdout0_8ck14 = 0 time = 75
.meas tran vdout0_8ck14 FIND v(dout0_8) AT=75.025n

* CHECK dout0_9 Vdout0_9ck14 = 0.9 time = 75
.meas tran vdout0_9ck14 FIND v(dout0_9) AT=75.025n

* CHECK dout0_10 Vdout0_10ck14 = 0.9 time = 75
.meas tran vdout0_10ck14 FIND v(dout0_10) AT=75.025n

* CHECK dout0_11 Vdout0_11ck14 = 0.9 time = 75
.meas tran vdout0_11ck14 FIND v(dout0_11) AT=75.025n

* CHECK dout0_12 Vdout0_12ck14 = 0.9 time = 75
.meas tran vdout0_12ck14 FIND v(dout0_12) AT=75.025n

* CHECK dout0_13 Vdout0_13ck14 = 0 time = 75
.meas tran vdout0_13ck14 FIND v(dout0_13) AT=75.025n

* CHECK dout0_14 Vdout0_14ck14 = 0.9 time = 75
.meas tran vdout0_14ck14 FIND v(dout0_14) AT=75.025n

* CHECK dout0_15 Vdout0_15ck14 = 0.9 time = 75
.meas tran vdout0_15ck14 FIND v(dout0_15) AT=75.025n

* CHECK dout0_16 Vdout0_16ck14 = 0 time = 75
.meas tran vdout0_16ck14 FIND v(dout0_16) AT=75.025n

* CHECK dout0_17 Vdout0_17ck14 = 0 time = 75
.meas tran vdout0_17ck14 FIND v(dout0_17) AT=75.025n

* CHECK dout0_18 Vdout0_18ck14 = 0.9 time = 75
.meas tran vdout0_18ck14 FIND v(dout0_18) AT=75.025n

* CHECK dout0_19 Vdout0_19ck14 = 0 time = 75
.meas tran vdout0_19ck14 FIND v(dout0_19) AT=75.025n

* CHECK dout0_20 Vdout0_20ck14 = 0 time = 75
.meas tran vdout0_20ck14 FIND v(dout0_20) AT=75.025n

* CHECK dout0_21 Vdout0_21ck14 = 0.9 time = 75
.meas tran vdout0_21ck14 FIND v(dout0_21) AT=75.025n

* CHECK dout0_22 Vdout0_22ck14 = 0.9 time = 75
.meas tran vdout0_22ck14 FIND v(dout0_22) AT=75.025n

* CHECK dout0_23 Vdout0_23ck14 = 0 time = 75
.meas tran vdout0_23ck14 FIND v(dout0_23) AT=75.025n

* CHECK dout0_24 Vdout0_24ck14 = 0 time = 75
.meas tran vdout0_24ck14 FIND v(dout0_24) AT=75.025n

* CHECK dout0_25 Vdout0_25ck14 = 0.9 time = 75
.meas tran vdout0_25ck14 FIND v(dout0_25) AT=75.025n

* CHECK dout0_26 Vdout0_26ck14 = 0 time = 75
.meas tran vdout0_26ck14 FIND v(dout0_26) AT=75.025n

* CHECK dout0_27 Vdout0_27ck14 = 0 time = 75
.meas tran vdout0_27ck14 FIND v(dout0_27) AT=75.025n

* CHECK dout0_28 Vdout0_28ck14 = 0 time = 75
.meas tran vdout0_28ck14 FIND v(dout0_28) AT=75.025n

* CHECK dout0_29 Vdout0_29ck14 = 0.9 time = 75
.meas tran vdout0_29ck14 FIND v(dout0_29) AT=75.025n

* CHECK dout0_30 Vdout0_30ck14 = 0 time = 75
.meas tran vdout0_30ck14 FIND v(dout0_30) AT=75.025n

* CHECK dout0_31 Vdout0_31ck14 = 0.9 time = 75
.meas tran vdout0_31ck14 FIND v(dout0_31) AT=75.025n

* CHECK dout0_32 Vdout0_32ck14 = 0 time = 75
.meas tran vdout0_32ck14 FIND v(dout0_32) AT=75.025n

* CHECK dout0_33 Vdout0_33ck14 = 0.9 time = 75
.meas tran vdout0_33ck14 FIND v(dout0_33) AT=75.025n

* CHECK dout0_34 Vdout0_34ck14 = 0 time = 75
.meas tran vdout0_34ck14 FIND v(dout0_34) AT=75.025n

* CHECK dout0_35 Vdout0_35ck14 = 0.9 time = 75
.meas tran vdout0_35ck14 FIND v(dout0_35) AT=75.025n

* CHECK dout0_36 Vdout0_36ck14 = 0 time = 75
.meas tran vdout0_36ck14 FIND v(dout0_36) AT=75.025n

* CHECK dout0_37 Vdout0_37ck14 = 0.9 time = 75
.meas tran vdout0_37ck14 FIND v(dout0_37) AT=75.025n

* CHECK dout0_38 Vdout0_38ck14 = 0.9 time = 75
.meas tran vdout0_38ck14 FIND v(dout0_38) AT=75.025n

* CHECK dout0_39 Vdout0_39ck14 = 0.9 time = 75
.meas tran vdout0_39ck14 FIND v(dout0_39) AT=75.025n

* CHECK dout0_0 Vdout0_0ck15 = 0 time = 80
.meas tran vdout0_0ck15 FIND v(dout0_0) AT=80.025n

* CHECK dout0_1 Vdout0_1ck15 = 0 time = 80
.meas tran vdout0_1ck15 FIND v(dout0_1) AT=80.025n

* CHECK dout0_2 Vdout0_2ck15 = 0 time = 80
.meas tran vdout0_2ck15 FIND v(dout0_2) AT=80.025n

* CHECK dout0_3 Vdout0_3ck15 = 0.9 time = 80
.meas tran vdout0_3ck15 FIND v(dout0_3) AT=80.025n

* CHECK dout0_4 Vdout0_4ck15 = 0.9 time = 80
.meas tran vdout0_4ck15 FIND v(dout0_4) AT=80.025n

* CHECK dout0_5 Vdout0_5ck15 = 0.9 time = 80
.meas tran vdout0_5ck15 FIND v(dout0_5) AT=80.025n

* CHECK dout0_6 Vdout0_6ck15 = 0.9 time = 80
.meas tran vdout0_6ck15 FIND v(dout0_6) AT=80.025n

* CHECK dout0_7 Vdout0_7ck15 = 0.9 time = 80
.meas tran vdout0_7ck15 FIND v(dout0_7) AT=80.025n

* CHECK dout0_8 Vdout0_8ck15 = 0.9 time = 80
.meas tran vdout0_8ck15 FIND v(dout0_8) AT=80.025n

* CHECK dout0_9 Vdout0_9ck15 = 0 time = 80
.meas tran vdout0_9ck15 FIND v(dout0_9) AT=80.025n

* CHECK dout0_10 Vdout0_10ck15 = 0.9 time = 80
.meas tran vdout0_10ck15 FIND v(dout0_10) AT=80.025n

* CHECK dout0_11 Vdout0_11ck15 = 0.9 time = 80
.meas tran vdout0_11ck15 FIND v(dout0_11) AT=80.025n

* CHECK dout0_12 Vdout0_12ck15 = 0 time = 80
.meas tran vdout0_12ck15 FIND v(dout0_12) AT=80.025n

* CHECK dout0_13 Vdout0_13ck15 = 0 time = 80
.meas tran vdout0_13ck15 FIND v(dout0_13) AT=80.025n

* CHECK dout0_14 Vdout0_14ck15 = 0 time = 80
.meas tran vdout0_14ck15 FIND v(dout0_14) AT=80.025n

* CHECK dout0_15 Vdout0_15ck15 = 0 time = 80
.meas tran vdout0_15ck15 FIND v(dout0_15) AT=80.025n

* CHECK dout0_16 Vdout0_16ck15 = 0.9 time = 80
.meas tran vdout0_16ck15 FIND v(dout0_16) AT=80.025n

* CHECK dout0_17 Vdout0_17ck15 = 0 time = 80
.meas tran vdout0_17ck15 FIND v(dout0_17) AT=80.025n

* CHECK dout0_18 Vdout0_18ck15 = 0 time = 80
.meas tran vdout0_18ck15 FIND v(dout0_18) AT=80.025n

* CHECK dout0_19 Vdout0_19ck15 = 0.9 time = 80
.meas tran vdout0_19ck15 FIND v(dout0_19) AT=80.025n

* CHECK dout0_20 Vdout0_20ck15 = 0 time = 80
.meas tran vdout0_20ck15 FIND v(dout0_20) AT=80.025n

* CHECK dout0_21 Vdout0_21ck15 = 0 time = 80
.meas tran vdout0_21ck15 FIND v(dout0_21) AT=80.025n

* CHECK dout0_22 Vdout0_22ck15 = 0.9 time = 80
.meas tran vdout0_22ck15 FIND v(dout0_22) AT=80.025n

* CHECK dout0_23 Vdout0_23ck15 = 0 time = 80
.meas tran vdout0_23ck15 FIND v(dout0_23) AT=80.025n

* CHECK dout0_24 Vdout0_24ck15 = 0 time = 80
.meas tran vdout0_24ck15 FIND v(dout0_24) AT=80.025n

* CHECK dout0_25 Vdout0_25ck15 = 0 time = 80
.meas tran vdout0_25ck15 FIND v(dout0_25) AT=80.025n

* CHECK dout0_26 Vdout0_26ck15 = 0.9 time = 80
.meas tran vdout0_26ck15 FIND v(dout0_26) AT=80.025n

* CHECK dout0_27 Vdout0_27ck15 = 0.9 time = 80
.meas tran vdout0_27ck15 FIND v(dout0_27) AT=80.025n

* CHECK dout0_28 Vdout0_28ck15 = 0 time = 80
.meas tran vdout0_28ck15 FIND v(dout0_28) AT=80.025n

* CHECK dout0_29 Vdout0_29ck15 = 0.9 time = 80
.meas tran vdout0_29ck15 FIND v(dout0_29) AT=80.025n

* CHECK dout0_30 Vdout0_30ck15 = 0 time = 80
.meas tran vdout0_30ck15 FIND v(dout0_30) AT=80.025n

* CHECK dout0_31 Vdout0_31ck15 = 0 time = 80
.meas tran vdout0_31ck15 FIND v(dout0_31) AT=80.025n

* CHECK dout0_32 Vdout0_32ck15 = 0.9 time = 80
.meas tran vdout0_32ck15 FIND v(dout0_32) AT=80.025n

* CHECK dout0_33 Vdout0_33ck15 = 0 time = 80
.meas tran vdout0_33ck15 FIND v(dout0_33) AT=80.025n

* CHECK dout0_34 Vdout0_34ck15 = 0 time = 80
.meas tran vdout0_34ck15 FIND v(dout0_34) AT=80.025n

* CHECK dout0_35 Vdout0_35ck15 = 0 time = 80
.meas tran vdout0_35ck15 FIND v(dout0_35) AT=80.025n

* CHECK dout0_36 Vdout0_36ck15 = 0 time = 80
.meas tran vdout0_36ck15 FIND v(dout0_36) AT=80.025n

* CHECK dout0_37 Vdout0_37ck15 = 0 time = 80
.meas tran vdout0_37ck15 FIND v(dout0_37) AT=80.025n

* CHECK dout0_38 Vdout0_38ck15 = 0.9 time = 80
.meas tran vdout0_38ck15 FIND v(dout0_38) AT=80.025n

* CHECK dout0_39 Vdout0_39ck15 = 0.9 time = 80
.meas tran vdout0_39ck15 FIND v(dout0_39) AT=80.025n

* CHECK dout0_0 Vdout0_0ck17 = 0 time = 90
.meas tran vdout0_0ck17 FIND v(dout0_0) AT=90.025n

* CHECK dout0_1 Vdout0_1ck17 = 0 time = 90
.meas tran vdout0_1ck17 FIND v(dout0_1) AT=90.025n

* CHECK dout0_2 Vdout0_2ck17 = 0 time = 90
.meas tran vdout0_2ck17 FIND v(dout0_2) AT=90.025n

* CHECK dout0_3 Vdout0_3ck17 = 0.9 time = 90
.meas tran vdout0_3ck17 FIND v(dout0_3) AT=90.025n

* CHECK dout0_4 Vdout0_4ck17 = 0.9 time = 90
.meas tran vdout0_4ck17 FIND v(dout0_4) AT=90.025n

* CHECK dout0_5 Vdout0_5ck17 = 0.9 time = 90
.meas tran vdout0_5ck17 FIND v(dout0_5) AT=90.025n

* CHECK dout0_6 Vdout0_6ck17 = 0.9 time = 90
.meas tran vdout0_6ck17 FIND v(dout0_6) AT=90.025n

* CHECK dout0_7 Vdout0_7ck17 = 0.9 time = 90
.meas tran vdout0_7ck17 FIND v(dout0_7) AT=90.025n

* CHECK dout0_8 Vdout0_8ck17 = 0.9 time = 90
.meas tran vdout0_8ck17 FIND v(dout0_8) AT=90.025n

* CHECK dout0_9 Vdout0_9ck17 = 0 time = 90
.meas tran vdout0_9ck17 FIND v(dout0_9) AT=90.025n

* CHECK dout0_10 Vdout0_10ck17 = 0.9 time = 90
.meas tran vdout0_10ck17 FIND v(dout0_10) AT=90.025n

* CHECK dout0_11 Vdout0_11ck17 = 0.9 time = 90
.meas tran vdout0_11ck17 FIND v(dout0_11) AT=90.025n

* CHECK dout0_12 Vdout0_12ck17 = 0 time = 90
.meas tran vdout0_12ck17 FIND v(dout0_12) AT=90.025n

* CHECK dout0_13 Vdout0_13ck17 = 0 time = 90
.meas tran vdout0_13ck17 FIND v(dout0_13) AT=90.025n

* CHECK dout0_14 Vdout0_14ck17 = 0 time = 90
.meas tran vdout0_14ck17 FIND v(dout0_14) AT=90.025n

* CHECK dout0_15 Vdout0_15ck17 = 0 time = 90
.meas tran vdout0_15ck17 FIND v(dout0_15) AT=90.025n

* CHECK dout0_16 Vdout0_16ck17 = 0.9 time = 90
.meas tran vdout0_16ck17 FIND v(dout0_16) AT=90.025n

* CHECK dout0_17 Vdout0_17ck17 = 0 time = 90
.meas tran vdout0_17ck17 FIND v(dout0_17) AT=90.025n

* CHECK dout0_18 Vdout0_18ck17 = 0 time = 90
.meas tran vdout0_18ck17 FIND v(dout0_18) AT=90.025n

* CHECK dout0_19 Vdout0_19ck17 = 0.9 time = 90
.meas tran vdout0_19ck17 FIND v(dout0_19) AT=90.025n

* CHECK dout0_20 Vdout0_20ck17 = 0 time = 90
.meas tran vdout0_20ck17 FIND v(dout0_20) AT=90.025n

* CHECK dout0_21 Vdout0_21ck17 = 0 time = 90
.meas tran vdout0_21ck17 FIND v(dout0_21) AT=90.025n

* CHECK dout0_22 Vdout0_22ck17 = 0.9 time = 90
.meas tran vdout0_22ck17 FIND v(dout0_22) AT=90.025n

* CHECK dout0_23 Vdout0_23ck17 = 0 time = 90
.meas tran vdout0_23ck17 FIND v(dout0_23) AT=90.025n

* CHECK dout0_24 Vdout0_24ck17 = 0 time = 90
.meas tran vdout0_24ck17 FIND v(dout0_24) AT=90.025n

* CHECK dout0_25 Vdout0_25ck17 = 0 time = 90
.meas tran vdout0_25ck17 FIND v(dout0_25) AT=90.025n

* CHECK dout0_26 Vdout0_26ck17 = 0.9 time = 90
.meas tran vdout0_26ck17 FIND v(dout0_26) AT=90.025n

* CHECK dout0_27 Vdout0_27ck17 = 0.9 time = 90
.meas tran vdout0_27ck17 FIND v(dout0_27) AT=90.025n

* CHECK dout0_28 Vdout0_28ck17 = 0 time = 90
.meas tran vdout0_28ck17 FIND v(dout0_28) AT=90.025n

* CHECK dout0_29 Vdout0_29ck17 = 0.9 time = 90
.meas tran vdout0_29ck17 FIND v(dout0_29) AT=90.025n

* CHECK dout0_30 Vdout0_30ck17 = 0 time = 90
.meas tran vdout0_30ck17 FIND v(dout0_30) AT=90.025n

* CHECK dout0_31 Vdout0_31ck17 = 0 time = 90
.meas tran vdout0_31ck17 FIND v(dout0_31) AT=90.025n

* CHECK dout0_32 Vdout0_32ck17 = 0.9 time = 90
.meas tran vdout0_32ck17 FIND v(dout0_32) AT=90.025n

* CHECK dout0_33 Vdout0_33ck17 = 0 time = 90
.meas tran vdout0_33ck17 FIND v(dout0_33) AT=90.025n

* CHECK dout0_34 Vdout0_34ck17 = 0 time = 90
.meas tran vdout0_34ck17 FIND v(dout0_34) AT=90.025n

* CHECK dout0_35 Vdout0_35ck17 = 0 time = 90
.meas tran vdout0_35ck17 FIND v(dout0_35) AT=90.025n

* CHECK dout0_36 Vdout0_36ck17 = 0 time = 90
.meas tran vdout0_36ck17 FIND v(dout0_36) AT=90.025n

* CHECK dout0_37 Vdout0_37ck17 = 0 time = 90
.meas tran vdout0_37ck17 FIND v(dout0_37) AT=90.025n

* CHECK dout0_38 Vdout0_38ck17 = 0.9 time = 90
.meas tran vdout0_38ck17 FIND v(dout0_38) AT=90.025n

* CHECK dout0_39 Vdout0_39ck17 = 0.9 time = 90
.meas tran vdout0_39ck17 FIND v(dout0_39) AT=90.025n

* CHECK dout0_0 Vdout0_0ck19 = 0.9 time = 100
.meas tran vdout0_0ck19 FIND v(dout0_0) AT=100.025n

* CHECK dout0_1 Vdout0_1ck19 = 0 time = 100
.meas tran vdout0_1ck19 FIND v(dout0_1) AT=100.025n

* CHECK dout0_2 Vdout0_2ck19 = 0 time = 100
.meas tran vdout0_2ck19 FIND v(dout0_2) AT=100.025n

* CHECK dout0_3 Vdout0_3ck19 = 0 time = 100
.meas tran vdout0_3ck19 FIND v(dout0_3) AT=100.025n

* CHECK dout0_4 Vdout0_4ck19 = 0 time = 100
.meas tran vdout0_4ck19 FIND v(dout0_4) AT=100.025n

* CHECK dout0_5 Vdout0_5ck19 = 0 time = 100
.meas tran vdout0_5ck19 FIND v(dout0_5) AT=100.025n

* CHECK dout0_6 Vdout0_6ck19 = 0 time = 100
.meas tran vdout0_6ck19 FIND v(dout0_6) AT=100.025n

* CHECK dout0_7 Vdout0_7ck19 = 0 time = 100
.meas tran vdout0_7ck19 FIND v(dout0_7) AT=100.025n

* CHECK dout0_8 Vdout0_8ck19 = 0.9 time = 100
.meas tran vdout0_8ck19 FIND v(dout0_8) AT=100.025n

* CHECK dout0_9 Vdout0_9ck19 = 0 time = 100
.meas tran vdout0_9ck19 FIND v(dout0_9) AT=100.025n

* CHECK dout0_10 Vdout0_10ck19 = 0 time = 100
.meas tran vdout0_10ck19 FIND v(dout0_10) AT=100.025n

* CHECK dout0_11 Vdout0_11ck19 = 0 time = 100
.meas tran vdout0_11ck19 FIND v(dout0_11) AT=100.025n

* CHECK dout0_12 Vdout0_12ck19 = 0 time = 100
.meas tran vdout0_12ck19 FIND v(dout0_12) AT=100.025n

* CHECK dout0_13 Vdout0_13ck19 = 0 time = 100
.meas tran vdout0_13ck19 FIND v(dout0_13) AT=100.025n

* CHECK dout0_14 Vdout0_14ck19 = 0 time = 100
.meas tran vdout0_14ck19 FIND v(dout0_14) AT=100.025n

* CHECK dout0_15 Vdout0_15ck19 = 0 time = 100
.meas tran vdout0_15ck19 FIND v(dout0_15) AT=100.025n

* CHECK dout0_16 Vdout0_16ck19 = 0 time = 100
.meas tran vdout0_16ck19 FIND v(dout0_16) AT=100.025n

* CHECK dout0_17 Vdout0_17ck19 = 0.9 time = 100
.meas tran vdout0_17ck19 FIND v(dout0_17) AT=100.025n

* CHECK dout0_18 Vdout0_18ck19 = 0.9 time = 100
.meas tran vdout0_18ck19 FIND v(dout0_18) AT=100.025n

* CHECK dout0_19 Vdout0_19ck19 = 0.9 time = 100
.meas tran vdout0_19ck19 FIND v(dout0_19) AT=100.025n

* CHECK dout0_20 Vdout0_20ck19 = 0.9 time = 100
.meas tran vdout0_20ck19 FIND v(dout0_20) AT=100.025n

* CHECK dout0_21 Vdout0_21ck19 = 0.9 time = 100
.meas tran vdout0_21ck19 FIND v(dout0_21) AT=100.025n

* CHECK dout0_22 Vdout0_22ck19 = 0.9 time = 100
.meas tran vdout0_22ck19 FIND v(dout0_22) AT=100.025n

* CHECK dout0_23 Vdout0_23ck19 = 0 time = 100
.meas tran vdout0_23ck19 FIND v(dout0_23) AT=100.025n

* CHECK dout0_24 Vdout0_24ck19 = 0 time = 100
.meas tran vdout0_24ck19 FIND v(dout0_24) AT=100.025n

* CHECK dout0_25 Vdout0_25ck19 = 0.9 time = 100
.meas tran vdout0_25ck19 FIND v(dout0_25) AT=100.025n

* CHECK dout0_26 Vdout0_26ck19 = 0.9 time = 100
.meas tran vdout0_26ck19 FIND v(dout0_26) AT=100.025n

* CHECK dout0_27 Vdout0_27ck19 = 0.9 time = 100
.meas tran vdout0_27ck19 FIND v(dout0_27) AT=100.025n

* CHECK dout0_28 Vdout0_28ck19 = 0.9 time = 100
.meas tran vdout0_28ck19 FIND v(dout0_28) AT=100.025n

* CHECK dout0_29 Vdout0_29ck19 = 0 time = 100
.meas tran vdout0_29ck19 FIND v(dout0_29) AT=100.025n

* CHECK dout0_30 Vdout0_30ck19 = 0 time = 100
.meas tran vdout0_30ck19 FIND v(dout0_30) AT=100.025n

* CHECK dout0_31 Vdout0_31ck19 = 0 time = 100
.meas tran vdout0_31ck19 FIND v(dout0_31) AT=100.025n

* CHECK dout0_32 Vdout0_32ck19 = 0 time = 100
.meas tran vdout0_32ck19 FIND v(dout0_32) AT=100.025n

* CHECK dout0_33 Vdout0_33ck19 = 0.9 time = 100
.meas tran vdout0_33ck19 FIND v(dout0_33) AT=100.025n

* CHECK dout0_34 Vdout0_34ck19 = 0 time = 100
.meas tran vdout0_34ck19 FIND v(dout0_34) AT=100.025n

* CHECK dout0_35 Vdout0_35ck19 = 0.9 time = 100
.meas tran vdout0_35ck19 FIND v(dout0_35) AT=100.025n

* CHECK dout0_36 Vdout0_36ck19 = 0 time = 100
.meas tran vdout0_36ck19 FIND v(dout0_36) AT=100.025n

* CHECK dout0_37 Vdout0_37ck19 = 0.9 time = 100
.meas tran vdout0_37ck19 FIND v(dout0_37) AT=100.025n

* CHECK dout0_38 Vdout0_38ck19 = 0 time = 100
.meas tran vdout0_38ck19 FIND v(dout0_38) AT=100.025n

* CHECK dout0_39 Vdout0_39ck19 = 0 time = 100
.meas tran vdout0_39ck19 FIND v(dout0_39) AT=100.025n

* CHECK dout0_0 Vdout0_0ck20 = 0.9 time = 105
.meas tran vdout0_0ck20 FIND v(dout0_0) AT=105.025n

* CHECK dout0_1 Vdout0_1ck20 = 0 time = 105
.meas tran vdout0_1ck20 FIND v(dout0_1) AT=105.025n

* CHECK dout0_2 Vdout0_2ck20 = 0 time = 105
.meas tran vdout0_2ck20 FIND v(dout0_2) AT=105.025n

* CHECK dout0_3 Vdout0_3ck20 = 0 time = 105
.meas tran vdout0_3ck20 FIND v(dout0_3) AT=105.025n

* CHECK dout0_4 Vdout0_4ck20 = 0 time = 105
.meas tran vdout0_4ck20 FIND v(dout0_4) AT=105.025n

* CHECK dout0_5 Vdout0_5ck20 = 0 time = 105
.meas tran vdout0_5ck20 FIND v(dout0_5) AT=105.025n

* CHECK dout0_6 Vdout0_6ck20 = 0 time = 105
.meas tran vdout0_6ck20 FIND v(dout0_6) AT=105.025n

* CHECK dout0_7 Vdout0_7ck20 = 0 time = 105
.meas tran vdout0_7ck20 FIND v(dout0_7) AT=105.025n

* CHECK dout0_8 Vdout0_8ck20 = 0.9 time = 105
.meas tran vdout0_8ck20 FIND v(dout0_8) AT=105.025n

* CHECK dout0_9 Vdout0_9ck20 = 0 time = 105
.meas tran vdout0_9ck20 FIND v(dout0_9) AT=105.025n

* CHECK dout0_10 Vdout0_10ck20 = 0 time = 105
.meas tran vdout0_10ck20 FIND v(dout0_10) AT=105.025n

* CHECK dout0_11 Vdout0_11ck20 = 0 time = 105
.meas tran vdout0_11ck20 FIND v(dout0_11) AT=105.025n

* CHECK dout0_12 Vdout0_12ck20 = 0 time = 105
.meas tran vdout0_12ck20 FIND v(dout0_12) AT=105.025n

* CHECK dout0_13 Vdout0_13ck20 = 0 time = 105
.meas tran vdout0_13ck20 FIND v(dout0_13) AT=105.025n

* CHECK dout0_14 Vdout0_14ck20 = 0 time = 105
.meas tran vdout0_14ck20 FIND v(dout0_14) AT=105.025n

* CHECK dout0_15 Vdout0_15ck20 = 0 time = 105
.meas tran vdout0_15ck20 FIND v(dout0_15) AT=105.025n

* CHECK dout0_16 Vdout0_16ck20 = 0 time = 105
.meas tran vdout0_16ck20 FIND v(dout0_16) AT=105.025n

* CHECK dout0_17 Vdout0_17ck20 = 0.9 time = 105
.meas tran vdout0_17ck20 FIND v(dout0_17) AT=105.025n

* CHECK dout0_18 Vdout0_18ck20 = 0.9 time = 105
.meas tran vdout0_18ck20 FIND v(dout0_18) AT=105.025n

* CHECK dout0_19 Vdout0_19ck20 = 0.9 time = 105
.meas tran vdout0_19ck20 FIND v(dout0_19) AT=105.025n

* CHECK dout0_20 Vdout0_20ck20 = 0.9 time = 105
.meas tran vdout0_20ck20 FIND v(dout0_20) AT=105.025n

* CHECK dout0_21 Vdout0_21ck20 = 0.9 time = 105
.meas tran vdout0_21ck20 FIND v(dout0_21) AT=105.025n

* CHECK dout0_22 Vdout0_22ck20 = 0.9 time = 105
.meas tran vdout0_22ck20 FIND v(dout0_22) AT=105.025n

* CHECK dout0_23 Vdout0_23ck20 = 0 time = 105
.meas tran vdout0_23ck20 FIND v(dout0_23) AT=105.025n

* CHECK dout0_24 Vdout0_24ck20 = 0 time = 105
.meas tran vdout0_24ck20 FIND v(dout0_24) AT=105.025n

* CHECK dout0_25 Vdout0_25ck20 = 0.9 time = 105
.meas tran vdout0_25ck20 FIND v(dout0_25) AT=105.025n

* CHECK dout0_26 Vdout0_26ck20 = 0.9 time = 105
.meas tran vdout0_26ck20 FIND v(dout0_26) AT=105.025n

* CHECK dout0_27 Vdout0_27ck20 = 0.9 time = 105
.meas tran vdout0_27ck20 FIND v(dout0_27) AT=105.025n

* CHECK dout0_28 Vdout0_28ck20 = 0.9 time = 105
.meas tran vdout0_28ck20 FIND v(dout0_28) AT=105.025n

* CHECK dout0_29 Vdout0_29ck20 = 0 time = 105
.meas tran vdout0_29ck20 FIND v(dout0_29) AT=105.025n

* CHECK dout0_30 Vdout0_30ck20 = 0 time = 105
.meas tran vdout0_30ck20 FIND v(dout0_30) AT=105.025n

* CHECK dout0_31 Vdout0_31ck20 = 0 time = 105
.meas tran vdout0_31ck20 FIND v(dout0_31) AT=105.025n

* CHECK dout0_32 Vdout0_32ck20 = 0 time = 105
.meas tran vdout0_32ck20 FIND v(dout0_32) AT=105.025n

* CHECK dout0_33 Vdout0_33ck20 = 0.9 time = 105
.meas tran vdout0_33ck20 FIND v(dout0_33) AT=105.025n

* CHECK dout0_34 Vdout0_34ck20 = 0 time = 105
.meas tran vdout0_34ck20 FIND v(dout0_34) AT=105.025n

* CHECK dout0_35 Vdout0_35ck20 = 0.9 time = 105
.meas tran vdout0_35ck20 FIND v(dout0_35) AT=105.025n

* CHECK dout0_36 Vdout0_36ck20 = 0 time = 105
.meas tran vdout0_36ck20 FIND v(dout0_36) AT=105.025n

* CHECK dout0_37 Vdout0_37ck20 = 0.9 time = 105
.meas tran vdout0_37ck20 FIND v(dout0_37) AT=105.025n

* CHECK dout0_38 Vdout0_38ck20 = 0 time = 105
.meas tran vdout0_38ck20 FIND v(dout0_38) AT=105.025n

* CHECK dout0_39 Vdout0_39ck20 = 0 time = 105
.meas tran vdout0_39ck20 FIND v(dout0_39) AT=105.025n

* CHECK dout0_0 Vdout0_0ck23 = 0.9 time = 120
.meas tran vdout0_0ck23 FIND v(dout0_0) AT=120.025n

* CHECK dout0_1 Vdout0_1ck23 = 0 time = 120
.meas tran vdout0_1ck23 FIND v(dout0_1) AT=120.025n

* CHECK dout0_2 Vdout0_2ck23 = 0.9 time = 120
.meas tran vdout0_2ck23 FIND v(dout0_2) AT=120.025n

* CHECK dout0_3 Vdout0_3ck23 = 0.9 time = 120
.meas tran vdout0_3ck23 FIND v(dout0_3) AT=120.025n

* CHECK dout0_4 Vdout0_4ck23 = 0.9 time = 120
.meas tran vdout0_4ck23 FIND v(dout0_4) AT=120.025n

* CHECK dout0_5 Vdout0_5ck23 = 0 time = 120
.meas tran vdout0_5ck23 FIND v(dout0_5) AT=120.025n

* CHECK dout0_6 Vdout0_6ck23 = 0 time = 120
.meas tran vdout0_6ck23 FIND v(dout0_6) AT=120.025n

* CHECK dout0_7 Vdout0_7ck23 = 0 time = 120
.meas tran vdout0_7ck23 FIND v(dout0_7) AT=120.025n

* CHECK dout0_8 Vdout0_8ck23 = 0.9 time = 120
.meas tran vdout0_8ck23 FIND v(dout0_8) AT=120.025n

* CHECK dout0_9 Vdout0_9ck23 = 0.9 time = 120
.meas tran vdout0_9ck23 FIND v(dout0_9) AT=120.025n

* CHECK dout0_10 Vdout0_10ck23 = 0 time = 120
.meas tran vdout0_10ck23 FIND v(dout0_10) AT=120.025n

* CHECK dout0_11 Vdout0_11ck23 = 0 time = 120
.meas tran vdout0_11ck23 FIND v(dout0_11) AT=120.025n

* CHECK dout0_12 Vdout0_12ck23 = 0.9 time = 120
.meas tran vdout0_12ck23 FIND v(dout0_12) AT=120.025n

* CHECK dout0_13 Vdout0_13ck23 = 0 time = 120
.meas tran vdout0_13ck23 FIND v(dout0_13) AT=120.025n

* CHECK dout0_14 Vdout0_14ck23 = 0.9 time = 120
.meas tran vdout0_14ck23 FIND v(dout0_14) AT=120.025n

* CHECK dout0_15 Vdout0_15ck23 = 0.9 time = 120
.meas tran vdout0_15ck23 FIND v(dout0_15) AT=120.025n

* CHECK dout0_16 Vdout0_16ck23 = 0 time = 120
.meas tran vdout0_16ck23 FIND v(dout0_16) AT=120.025n

* CHECK dout0_17 Vdout0_17ck23 = 0 time = 120
.meas tran vdout0_17ck23 FIND v(dout0_17) AT=120.025n

* CHECK dout0_18 Vdout0_18ck23 = 0.9 time = 120
.meas tran vdout0_18ck23 FIND v(dout0_18) AT=120.025n

* CHECK dout0_19 Vdout0_19ck23 = 0.9 time = 120
.meas tran vdout0_19ck23 FIND v(dout0_19) AT=120.025n

* CHECK dout0_20 Vdout0_20ck23 = 0 time = 120
.meas tran vdout0_20ck23 FIND v(dout0_20) AT=120.025n

* CHECK dout0_21 Vdout0_21ck23 = 0 time = 120
.meas tran vdout0_21ck23 FIND v(dout0_21) AT=120.025n

* CHECK dout0_22 Vdout0_22ck23 = 0.9 time = 120
.meas tran vdout0_22ck23 FIND v(dout0_22) AT=120.025n

* CHECK dout0_23 Vdout0_23ck23 = 0.9 time = 120
.meas tran vdout0_23ck23 FIND v(dout0_23) AT=120.025n

* CHECK dout0_24 Vdout0_24ck23 = 0.9 time = 120
.meas tran vdout0_24ck23 FIND v(dout0_24) AT=120.025n

* CHECK dout0_25 Vdout0_25ck23 = 0.9 time = 120
.meas tran vdout0_25ck23 FIND v(dout0_25) AT=120.025n

* CHECK dout0_26 Vdout0_26ck23 = 0 time = 120
.meas tran vdout0_26ck23 FIND v(dout0_26) AT=120.025n

* CHECK dout0_27 Vdout0_27ck23 = 0.9 time = 120
.meas tran vdout0_27ck23 FIND v(dout0_27) AT=120.025n

* CHECK dout0_28 Vdout0_28ck23 = 0.9 time = 120
.meas tran vdout0_28ck23 FIND v(dout0_28) AT=120.025n

* CHECK dout0_29 Vdout0_29ck23 = 0 time = 120
.meas tran vdout0_29ck23 FIND v(dout0_29) AT=120.025n

* CHECK dout0_30 Vdout0_30ck23 = 0 time = 120
.meas tran vdout0_30ck23 FIND v(dout0_30) AT=120.025n

* CHECK dout0_31 Vdout0_31ck23 = 0 time = 120
.meas tran vdout0_31ck23 FIND v(dout0_31) AT=120.025n

* CHECK dout0_32 Vdout0_32ck23 = 0 time = 120
.meas tran vdout0_32ck23 FIND v(dout0_32) AT=120.025n

* CHECK dout0_33 Vdout0_33ck23 = 0.9 time = 120
.meas tran vdout0_33ck23 FIND v(dout0_33) AT=120.025n

* CHECK dout0_34 Vdout0_34ck23 = 0 time = 120
.meas tran vdout0_34ck23 FIND v(dout0_34) AT=120.025n

* CHECK dout0_35 Vdout0_35ck23 = 0.9 time = 120
.meas tran vdout0_35ck23 FIND v(dout0_35) AT=120.025n

* CHECK dout0_36 Vdout0_36ck23 = 0.9 time = 120
.meas tran vdout0_36ck23 FIND v(dout0_36) AT=120.025n

* CHECK dout0_37 Vdout0_37ck23 = 0.9 time = 120
.meas tran vdout0_37ck23 FIND v(dout0_37) AT=120.025n

* CHECK dout0_38 Vdout0_38ck23 = 0.9 time = 120
.meas tran vdout0_38ck23 FIND v(dout0_38) AT=120.025n

* CHECK dout0_39 Vdout0_39ck23 = 0 time = 120
.meas tran vdout0_39ck23 FIND v(dout0_39) AT=120.025n

* CHECK dout0_0 Vdout0_0ck27 = 0 time = 140
.meas tran vdout0_0ck27 FIND v(dout0_0) AT=140.025n

* CHECK dout0_1 Vdout0_1ck27 = 0 time = 140
.meas tran vdout0_1ck27 FIND v(dout0_1) AT=140.025n

* CHECK dout0_2 Vdout0_2ck27 = 0 time = 140
.meas tran vdout0_2ck27 FIND v(dout0_2) AT=140.025n

* CHECK dout0_3 Vdout0_3ck27 = 0.9 time = 140
.meas tran vdout0_3ck27 FIND v(dout0_3) AT=140.025n

* CHECK dout0_4 Vdout0_4ck27 = 0.9 time = 140
.meas tran vdout0_4ck27 FIND v(dout0_4) AT=140.025n

* CHECK dout0_5 Vdout0_5ck27 = 0.9 time = 140
.meas tran vdout0_5ck27 FIND v(dout0_5) AT=140.025n

* CHECK dout0_6 Vdout0_6ck27 = 0.9 time = 140
.meas tran vdout0_6ck27 FIND v(dout0_6) AT=140.025n

* CHECK dout0_7 Vdout0_7ck27 = 0.9 time = 140
.meas tran vdout0_7ck27 FIND v(dout0_7) AT=140.025n

* CHECK dout0_8 Vdout0_8ck27 = 0.9 time = 140
.meas tran vdout0_8ck27 FIND v(dout0_8) AT=140.025n

* CHECK dout0_9 Vdout0_9ck27 = 0 time = 140
.meas tran vdout0_9ck27 FIND v(dout0_9) AT=140.025n

* CHECK dout0_10 Vdout0_10ck27 = 0.9 time = 140
.meas tran vdout0_10ck27 FIND v(dout0_10) AT=140.025n

* CHECK dout0_11 Vdout0_11ck27 = 0.9 time = 140
.meas tran vdout0_11ck27 FIND v(dout0_11) AT=140.025n

* CHECK dout0_12 Vdout0_12ck27 = 0 time = 140
.meas tran vdout0_12ck27 FIND v(dout0_12) AT=140.025n

* CHECK dout0_13 Vdout0_13ck27 = 0 time = 140
.meas tran vdout0_13ck27 FIND v(dout0_13) AT=140.025n

* CHECK dout0_14 Vdout0_14ck27 = 0 time = 140
.meas tran vdout0_14ck27 FIND v(dout0_14) AT=140.025n

* CHECK dout0_15 Vdout0_15ck27 = 0 time = 140
.meas tran vdout0_15ck27 FIND v(dout0_15) AT=140.025n

* CHECK dout0_16 Vdout0_16ck27 = 0.9 time = 140
.meas tran vdout0_16ck27 FIND v(dout0_16) AT=140.025n

* CHECK dout0_17 Vdout0_17ck27 = 0 time = 140
.meas tran vdout0_17ck27 FIND v(dout0_17) AT=140.025n

* CHECK dout0_18 Vdout0_18ck27 = 0 time = 140
.meas tran vdout0_18ck27 FIND v(dout0_18) AT=140.025n

* CHECK dout0_19 Vdout0_19ck27 = 0.9 time = 140
.meas tran vdout0_19ck27 FIND v(dout0_19) AT=140.025n

* CHECK dout0_20 Vdout0_20ck27 = 0 time = 140
.meas tran vdout0_20ck27 FIND v(dout0_20) AT=140.025n

* CHECK dout0_21 Vdout0_21ck27 = 0 time = 140
.meas tran vdout0_21ck27 FIND v(dout0_21) AT=140.025n

* CHECK dout0_22 Vdout0_22ck27 = 0.9 time = 140
.meas tran vdout0_22ck27 FIND v(dout0_22) AT=140.025n

* CHECK dout0_23 Vdout0_23ck27 = 0 time = 140
.meas tran vdout0_23ck27 FIND v(dout0_23) AT=140.025n

* CHECK dout0_24 Vdout0_24ck27 = 0 time = 140
.meas tran vdout0_24ck27 FIND v(dout0_24) AT=140.025n

* CHECK dout0_25 Vdout0_25ck27 = 0 time = 140
.meas tran vdout0_25ck27 FIND v(dout0_25) AT=140.025n

* CHECK dout0_26 Vdout0_26ck27 = 0.9 time = 140
.meas tran vdout0_26ck27 FIND v(dout0_26) AT=140.025n

* CHECK dout0_27 Vdout0_27ck27 = 0.9 time = 140
.meas tran vdout0_27ck27 FIND v(dout0_27) AT=140.025n

* CHECK dout0_28 Vdout0_28ck27 = 0 time = 140
.meas tran vdout0_28ck27 FIND v(dout0_28) AT=140.025n

* CHECK dout0_29 Vdout0_29ck27 = 0.9 time = 140
.meas tran vdout0_29ck27 FIND v(dout0_29) AT=140.025n

* CHECK dout0_30 Vdout0_30ck27 = 0 time = 140
.meas tran vdout0_30ck27 FIND v(dout0_30) AT=140.025n

* CHECK dout0_31 Vdout0_31ck27 = 0 time = 140
.meas tran vdout0_31ck27 FIND v(dout0_31) AT=140.025n

* CHECK dout0_32 Vdout0_32ck27 = 0.9 time = 140
.meas tran vdout0_32ck27 FIND v(dout0_32) AT=140.025n

* CHECK dout0_33 Vdout0_33ck27 = 0 time = 140
.meas tran vdout0_33ck27 FIND v(dout0_33) AT=140.025n

* CHECK dout0_34 Vdout0_34ck27 = 0 time = 140
.meas tran vdout0_34ck27 FIND v(dout0_34) AT=140.025n

* CHECK dout0_35 Vdout0_35ck27 = 0 time = 140
.meas tran vdout0_35ck27 FIND v(dout0_35) AT=140.025n

* CHECK dout0_36 Vdout0_36ck27 = 0 time = 140
.meas tran vdout0_36ck27 FIND v(dout0_36) AT=140.025n

* CHECK dout0_37 Vdout0_37ck27 = 0 time = 140
.meas tran vdout0_37ck27 FIND v(dout0_37) AT=140.025n

* CHECK dout0_38 Vdout0_38ck27 = 0.9 time = 140
.meas tran vdout0_38ck27 FIND v(dout0_38) AT=140.025n

* CHECK dout0_39 Vdout0_39ck27 = 0.9 time = 140
.meas tran vdout0_39ck27 FIND v(dout0_39) AT=140.025n

* CHECK dout0_0 Vdout0_0ck29 = 0.9 time = 150
.meas tran vdout0_0ck29 FIND v(dout0_0) AT=150.025n

* CHECK dout0_1 Vdout0_1ck29 = 0.9 time = 150
.meas tran vdout0_1ck29 FIND v(dout0_1) AT=150.025n

* CHECK dout0_2 Vdout0_2ck29 = 0.9 time = 150
.meas tran vdout0_2ck29 FIND v(dout0_2) AT=150.025n

* CHECK dout0_3 Vdout0_3ck29 = 0 time = 150
.meas tran vdout0_3ck29 FIND v(dout0_3) AT=150.025n

* CHECK dout0_4 Vdout0_4ck29 = 0 time = 150
.meas tran vdout0_4ck29 FIND v(dout0_4) AT=150.025n

* CHECK dout0_5 Vdout0_5ck29 = 0 time = 150
.meas tran vdout0_5ck29 FIND v(dout0_5) AT=150.025n

* CHECK dout0_6 Vdout0_6ck29 = 0 time = 150
.meas tran vdout0_6ck29 FIND v(dout0_6) AT=150.025n

* CHECK dout0_7 Vdout0_7ck29 = 0.9 time = 150
.meas tran vdout0_7ck29 FIND v(dout0_7) AT=150.025n

* CHECK dout0_8 Vdout0_8ck29 = 0.9 time = 150
.meas tran vdout0_8ck29 FIND v(dout0_8) AT=150.025n

* CHECK dout0_9 Vdout0_9ck29 = 0.9 time = 150
.meas tran vdout0_9ck29 FIND v(dout0_9) AT=150.025n

* CHECK dout0_10 Vdout0_10ck29 = 0 time = 150
.meas tran vdout0_10ck29 FIND v(dout0_10) AT=150.025n

* CHECK dout0_11 Vdout0_11ck29 = 0 time = 150
.meas tran vdout0_11ck29 FIND v(dout0_11) AT=150.025n

* CHECK dout0_12 Vdout0_12ck29 = 0 time = 150
.meas tran vdout0_12ck29 FIND v(dout0_12) AT=150.025n

* CHECK dout0_13 Vdout0_13ck29 = 0.9 time = 150
.meas tran vdout0_13ck29 FIND v(dout0_13) AT=150.025n

* CHECK dout0_14 Vdout0_14ck29 = 0 time = 150
.meas tran vdout0_14ck29 FIND v(dout0_14) AT=150.025n

* CHECK dout0_15 Vdout0_15ck29 = 0 time = 150
.meas tran vdout0_15ck29 FIND v(dout0_15) AT=150.025n

* CHECK dout0_16 Vdout0_16ck29 = 0 time = 150
.meas tran vdout0_16ck29 FIND v(dout0_16) AT=150.025n

* CHECK dout0_17 Vdout0_17ck29 = 0 time = 150
.meas tran vdout0_17ck29 FIND v(dout0_17) AT=150.025n

* CHECK dout0_18 Vdout0_18ck29 = 0.9 time = 150
.meas tran vdout0_18ck29 FIND v(dout0_18) AT=150.025n

* CHECK dout0_19 Vdout0_19ck29 = 0.9 time = 150
.meas tran vdout0_19ck29 FIND v(dout0_19) AT=150.025n

* CHECK dout0_20 Vdout0_20ck29 = 0 time = 150
.meas tran vdout0_20ck29 FIND v(dout0_20) AT=150.025n

* CHECK dout0_21 Vdout0_21ck29 = 0.9 time = 150
.meas tran vdout0_21ck29 FIND v(dout0_21) AT=150.025n

* CHECK dout0_22 Vdout0_22ck29 = 0.9 time = 150
.meas tran vdout0_22ck29 FIND v(dout0_22) AT=150.025n

* CHECK dout0_23 Vdout0_23ck29 = 0.9 time = 150
.meas tran vdout0_23ck29 FIND v(dout0_23) AT=150.025n

* CHECK dout0_24 Vdout0_24ck29 = 0 time = 150
.meas tran vdout0_24ck29 FIND v(dout0_24) AT=150.025n

* CHECK dout0_25 Vdout0_25ck29 = 0.9 time = 150
.meas tran vdout0_25ck29 FIND v(dout0_25) AT=150.025n

* CHECK dout0_26 Vdout0_26ck29 = 0 time = 150
.meas tran vdout0_26ck29 FIND v(dout0_26) AT=150.025n

* CHECK dout0_27 Vdout0_27ck29 = 0 time = 150
.meas tran vdout0_27ck29 FIND v(dout0_27) AT=150.025n

* CHECK dout0_28 Vdout0_28ck29 = 0.9 time = 150
.meas tran vdout0_28ck29 FIND v(dout0_28) AT=150.025n

* CHECK dout0_29 Vdout0_29ck29 = 0 time = 150
.meas tran vdout0_29ck29 FIND v(dout0_29) AT=150.025n

* CHECK dout0_30 Vdout0_30ck29 = 0.9 time = 150
.meas tran vdout0_30ck29 FIND v(dout0_30) AT=150.025n

* CHECK dout0_31 Vdout0_31ck29 = 0 time = 150
.meas tran vdout0_31ck29 FIND v(dout0_31) AT=150.025n

* CHECK dout0_32 Vdout0_32ck29 = 0.9 time = 150
.meas tran vdout0_32ck29 FIND v(dout0_32) AT=150.025n

* CHECK dout0_33 Vdout0_33ck29 = 0.9 time = 150
.meas tran vdout0_33ck29 FIND v(dout0_33) AT=150.025n

* CHECK dout0_34 Vdout0_34ck29 = 0.9 time = 150
.meas tran vdout0_34ck29 FIND v(dout0_34) AT=150.025n

* CHECK dout0_35 Vdout0_35ck29 = 0.9 time = 150
.meas tran vdout0_35ck29 FIND v(dout0_35) AT=150.025n

* CHECK dout0_36 Vdout0_36ck29 = 0 time = 150
.meas tran vdout0_36ck29 FIND v(dout0_36) AT=150.025n

* CHECK dout0_37 Vdout0_37ck29 = 0.9 time = 150
.meas tran vdout0_37ck29 FIND v(dout0_37) AT=150.025n

* CHECK dout0_38 Vdout0_38ck29 = 0.9 time = 150
.meas tran vdout0_38ck29 FIND v(dout0_38) AT=150.025n

* CHECK dout0_39 Vdout0_39ck29 = 0 time = 150
.meas tran vdout0_39ck29 FIND v(dout0_39) AT=150.025n

* CHECK dout0_0 Vdout0_0ck30 = 0.9 time = 155
.meas tran vdout0_0ck30 FIND v(dout0_0) AT=155.025n

* CHECK dout0_1 Vdout0_1ck30 = 0.9 time = 155
.meas tran vdout0_1ck30 FIND v(dout0_1) AT=155.025n

* CHECK dout0_2 Vdout0_2ck30 = 0.9 time = 155
.meas tran vdout0_2ck30 FIND v(dout0_2) AT=155.025n

* CHECK dout0_3 Vdout0_3ck30 = 0 time = 155
.meas tran vdout0_3ck30 FIND v(dout0_3) AT=155.025n

* CHECK dout0_4 Vdout0_4ck30 = 0 time = 155
.meas tran vdout0_4ck30 FIND v(dout0_4) AT=155.025n

* CHECK dout0_5 Vdout0_5ck30 = 0.9 time = 155
.meas tran vdout0_5ck30 FIND v(dout0_5) AT=155.025n

* CHECK dout0_6 Vdout0_6ck30 = 0 time = 155
.meas tran vdout0_6ck30 FIND v(dout0_6) AT=155.025n

* CHECK dout0_7 Vdout0_7ck30 = 0 time = 155
.meas tran vdout0_7ck30 FIND v(dout0_7) AT=155.025n

* CHECK dout0_8 Vdout0_8ck30 = 0 time = 155
.meas tran vdout0_8ck30 FIND v(dout0_8) AT=155.025n

* CHECK dout0_9 Vdout0_9ck30 = 0.9 time = 155
.meas tran vdout0_9ck30 FIND v(dout0_9) AT=155.025n

* CHECK dout0_10 Vdout0_10ck30 = 0 time = 155
.meas tran vdout0_10ck30 FIND v(dout0_10) AT=155.025n

* CHECK dout0_11 Vdout0_11ck30 = 0.9 time = 155
.meas tran vdout0_11ck30 FIND v(dout0_11) AT=155.025n

* CHECK dout0_12 Vdout0_12ck30 = 0.9 time = 155
.meas tran vdout0_12ck30 FIND v(dout0_12) AT=155.025n

* CHECK dout0_13 Vdout0_13ck30 = 0.9 time = 155
.meas tran vdout0_13ck30 FIND v(dout0_13) AT=155.025n

* CHECK dout0_14 Vdout0_14ck30 = 0 time = 155
.meas tran vdout0_14ck30 FIND v(dout0_14) AT=155.025n

* CHECK dout0_15 Vdout0_15ck30 = 0 time = 155
.meas tran vdout0_15ck30 FIND v(dout0_15) AT=155.025n

* CHECK dout0_16 Vdout0_16ck30 = 0.9 time = 155
.meas tran vdout0_16ck30 FIND v(dout0_16) AT=155.025n

* CHECK dout0_17 Vdout0_17ck30 = 0 time = 155
.meas tran vdout0_17ck30 FIND v(dout0_17) AT=155.025n

* CHECK dout0_18 Vdout0_18ck30 = 0 time = 155
.meas tran vdout0_18ck30 FIND v(dout0_18) AT=155.025n

* CHECK dout0_19 Vdout0_19ck30 = 0 time = 155
.meas tran vdout0_19ck30 FIND v(dout0_19) AT=155.025n

* CHECK dout0_20 Vdout0_20ck30 = 0.9 time = 155
.meas tran vdout0_20ck30 FIND v(dout0_20) AT=155.025n

* CHECK dout0_21 Vdout0_21ck30 = 0.9 time = 155
.meas tran vdout0_21ck30 FIND v(dout0_21) AT=155.025n

* CHECK dout0_22 Vdout0_22ck30 = 0.9 time = 155
.meas tran vdout0_22ck30 FIND v(dout0_22) AT=155.025n

* CHECK dout0_23 Vdout0_23ck30 = 0 time = 155
.meas tran vdout0_23ck30 FIND v(dout0_23) AT=155.025n

* CHECK dout0_24 Vdout0_24ck30 = 0 time = 155
.meas tran vdout0_24ck30 FIND v(dout0_24) AT=155.025n

* CHECK dout0_25 Vdout0_25ck30 = 0 time = 155
.meas tran vdout0_25ck30 FIND v(dout0_25) AT=155.025n

* CHECK dout0_26 Vdout0_26ck30 = 0.9 time = 155
.meas tran vdout0_26ck30 FIND v(dout0_26) AT=155.025n

* CHECK dout0_27 Vdout0_27ck30 = 0.9 time = 155
.meas tran vdout0_27ck30 FIND v(dout0_27) AT=155.025n

* CHECK dout0_28 Vdout0_28ck30 = 0 time = 155
.meas tran vdout0_28ck30 FIND v(dout0_28) AT=155.025n

* CHECK dout0_29 Vdout0_29ck30 = 0.9 time = 155
.meas tran vdout0_29ck30 FIND v(dout0_29) AT=155.025n

* CHECK dout0_30 Vdout0_30ck30 = 0.9 time = 155
.meas tran vdout0_30ck30 FIND v(dout0_30) AT=155.025n

* CHECK dout0_31 Vdout0_31ck30 = 0.9 time = 155
.meas tran vdout0_31ck30 FIND v(dout0_31) AT=155.025n

* CHECK dout0_32 Vdout0_32ck30 = 0.9 time = 155
.meas tran vdout0_32ck30 FIND v(dout0_32) AT=155.025n

* CHECK dout0_33 Vdout0_33ck30 = 0.9 time = 155
.meas tran vdout0_33ck30 FIND v(dout0_33) AT=155.025n

* CHECK dout0_34 Vdout0_34ck30 = 0.9 time = 155
.meas tran vdout0_34ck30 FIND v(dout0_34) AT=155.025n

* CHECK dout0_35 Vdout0_35ck30 = 0 time = 155
.meas tran vdout0_35ck30 FIND v(dout0_35) AT=155.025n

* CHECK dout0_36 Vdout0_36ck30 = 0 time = 155
.meas tran vdout0_36ck30 FIND v(dout0_36) AT=155.025n

* CHECK dout0_37 Vdout0_37ck30 = 0 time = 155
.meas tran vdout0_37ck30 FIND v(dout0_37) AT=155.025n

* CHECK dout0_38 Vdout0_38ck30 = 0 time = 155
.meas tran vdout0_38ck30 FIND v(dout0_38) AT=155.025n

* CHECK dout0_39 Vdout0_39ck30 = 0.9 time = 155
.meas tran vdout0_39ck30 FIND v(dout0_39) AT=155.025n

* CHECK dout0_0 Vdout0_0ck32 = 0 time = 165
.meas tran vdout0_0ck32 FIND v(dout0_0) AT=165.025n

* CHECK dout0_1 Vdout0_1ck32 = 0 time = 165
.meas tran vdout0_1ck32 FIND v(dout0_1) AT=165.025n

* CHECK dout0_2 Vdout0_2ck32 = 0 time = 165
.meas tran vdout0_2ck32 FIND v(dout0_2) AT=165.025n

* CHECK dout0_3 Vdout0_3ck32 = 0.9 time = 165
.meas tran vdout0_3ck32 FIND v(dout0_3) AT=165.025n

* CHECK dout0_4 Vdout0_4ck32 = 0.9 time = 165
.meas tran vdout0_4ck32 FIND v(dout0_4) AT=165.025n

* CHECK dout0_5 Vdout0_5ck32 = 0.9 time = 165
.meas tran vdout0_5ck32 FIND v(dout0_5) AT=165.025n

* CHECK dout0_6 Vdout0_6ck32 = 0.9 time = 165
.meas tran vdout0_6ck32 FIND v(dout0_6) AT=165.025n

* CHECK dout0_7 Vdout0_7ck32 = 0.9 time = 165
.meas tran vdout0_7ck32 FIND v(dout0_7) AT=165.025n

* CHECK dout0_8 Vdout0_8ck32 = 0.9 time = 165
.meas tran vdout0_8ck32 FIND v(dout0_8) AT=165.025n

* CHECK dout0_9 Vdout0_9ck32 = 0 time = 165
.meas tran vdout0_9ck32 FIND v(dout0_9) AT=165.025n

* CHECK dout0_10 Vdout0_10ck32 = 0.9 time = 165
.meas tran vdout0_10ck32 FIND v(dout0_10) AT=165.025n

* CHECK dout0_11 Vdout0_11ck32 = 0.9 time = 165
.meas tran vdout0_11ck32 FIND v(dout0_11) AT=165.025n

* CHECK dout0_12 Vdout0_12ck32 = 0 time = 165
.meas tran vdout0_12ck32 FIND v(dout0_12) AT=165.025n

* CHECK dout0_13 Vdout0_13ck32 = 0 time = 165
.meas tran vdout0_13ck32 FIND v(dout0_13) AT=165.025n

* CHECK dout0_14 Vdout0_14ck32 = 0 time = 165
.meas tran vdout0_14ck32 FIND v(dout0_14) AT=165.025n

* CHECK dout0_15 Vdout0_15ck32 = 0 time = 165
.meas tran vdout0_15ck32 FIND v(dout0_15) AT=165.025n

* CHECK dout0_16 Vdout0_16ck32 = 0.9 time = 165
.meas tran vdout0_16ck32 FIND v(dout0_16) AT=165.025n

* CHECK dout0_17 Vdout0_17ck32 = 0 time = 165
.meas tran vdout0_17ck32 FIND v(dout0_17) AT=165.025n

* CHECK dout0_18 Vdout0_18ck32 = 0 time = 165
.meas tran vdout0_18ck32 FIND v(dout0_18) AT=165.025n

* CHECK dout0_19 Vdout0_19ck32 = 0.9 time = 165
.meas tran vdout0_19ck32 FIND v(dout0_19) AT=165.025n

* CHECK dout0_20 Vdout0_20ck32 = 0 time = 165
.meas tran vdout0_20ck32 FIND v(dout0_20) AT=165.025n

* CHECK dout0_21 Vdout0_21ck32 = 0 time = 165
.meas tran vdout0_21ck32 FIND v(dout0_21) AT=165.025n

* CHECK dout0_22 Vdout0_22ck32 = 0.9 time = 165
.meas tran vdout0_22ck32 FIND v(dout0_22) AT=165.025n

* CHECK dout0_23 Vdout0_23ck32 = 0 time = 165
.meas tran vdout0_23ck32 FIND v(dout0_23) AT=165.025n

* CHECK dout0_24 Vdout0_24ck32 = 0 time = 165
.meas tran vdout0_24ck32 FIND v(dout0_24) AT=165.025n

* CHECK dout0_25 Vdout0_25ck32 = 0 time = 165
.meas tran vdout0_25ck32 FIND v(dout0_25) AT=165.025n

* CHECK dout0_26 Vdout0_26ck32 = 0.9 time = 165
.meas tran vdout0_26ck32 FIND v(dout0_26) AT=165.025n

* CHECK dout0_27 Vdout0_27ck32 = 0.9 time = 165
.meas tran vdout0_27ck32 FIND v(dout0_27) AT=165.025n

* CHECK dout0_28 Vdout0_28ck32 = 0 time = 165
.meas tran vdout0_28ck32 FIND v(dout0_28) AT=165.025n

* CHECK dout0_29 Vdout0_29ck32 = 0.9 time = 165
.meas tran vdout0_29ck32 FIND v(dout0_29) AT=165.025n

* CHECK dout0_30 Vdout0_30ck32 = 0 time = 165
.meas tran vdout0_30ck32 FIND v(dout0_30) AT=165.025n

* CHECK dout0_31 Vdout0_31ck32 = 0 time = 165
.meas tran vdout0_31ck32 FIND v(dout0_31) AT=165.025n

* CHECK dout0_32 Vdout0_32ck32 = 0.9 time = 165
.meas tran vdout0_32ck32 FIND v(dout0_32) AT=165.025n

* CHECK dout0_33 Vdout0_33ck32 = 0 time = 165
.meas tran vdout0_33ck32 FIND v(dout0_33) AT=165.025n

* CHECK dout0_34 Vdout0_34ck32 = 0 time = 165
.meas tran vdout0_34ck32 FIND v(dout0_34) AT=165.025n

* CHECK dout0_35 Vdout0_35ck32 = 0 time = 165
.meas tran vdout0_35ck32 FIND v(dout0_35) AT=165.025n

* CHECK dout0_36 Vdout0_36ck32 = 0 time = 165
.meas tran vdout0_36ck32 FIND v(dout0_36) AT=165.025n

* CHECK dout0_37 Vdout0_37ck32 = 0 time = 165
.meas tran vdout0_37ck32 FIND v(dout0_37) AT=165.025n

* CHECK dout0_38 Vdout0_38ck32 = 0.9 time = 165
.meas tran vdout0_38ck32 FIND v(dout0_38) AT=165.025n

* CHECK dout0_39 Vdout0_39ck32 = 0.9 time = 165
.meas tran vdout0_39ck32 FIND v(dout0_39) AT=165.025n

* CHECK dout0_0 Vdout0_0ck34 = 0 time = 175
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=175.025n

* CHECK dout0_1 Vdout0_1ck34 = 0.9 time = 175
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=175.025n

* CHECK dout0_2 Vdout0_2ck34 = 0.9 time = 175
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=175.025n

* CHECK dout0_3 Vdout0_3ck34 = 0.9 time = 175
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=175.025n

* CHECK dout0_4 Vdout0_4ck34 = 0 time = 175
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=175.025n

* CHECK dout0_5 Vdout0_5ck34 = 0.9 time = 175
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=175.025n

* CHECK dout0_6 Vdout0_6ck34 = 0 time = 175
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=175.025n

* CHECK dout0_7 Vdout0_7ck34 = 0.9 time = 175
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=175.025n

* CHECK dout0_8 Vdout0_8ck34 = 0.9 time = 175
.meas tran vdout0_8ck34 FIND v(dout0_8) AT=175.025n

* CHECK dout0_9 Vdout0_9ck34 = 0.9 time = 175
.meas tran vdout0_9ck34 FIND v(dout0_9) AT=175.025n

* CHECK dout0_10 Vdout0_10ck34 = 0 time = 175
.meas tran vdout0_10ck34 FIND v(dout0_10) AT=175.025n

* CHECK dout0_11 Vdout0_11ck34 = 0 time = 175
.meas tran vdout0_11ck34 FIND v(dout0_11) AT=175.025n

* CHECK dout0_12 Vdout0_12ck34 = 0.9 time = 175
.meas tran vdout0_12ck34 FIND v(dout0_12) AT=175.025n

* CHECK dout0_13 Vdout0_13ck34 = 0 time = 175
.meas tran vdout0_13ck34 FIND v(dout0_13) AT=175.025n

* CHECK dout0_14 Vdout0_14ck34 = 0.9 time = 175
.meas tran vdout0_14ck34 FIND v(dout0_14) AT=175.025n

* CHECK dout0_15 Vdout0_15ck34 = 0.9 time = 175
.meas tran vdout0_15ck34 FIND v(dout0_15) AT=175.025n

* CHECK dout0_16 Vdout0_16ck34 = 0 time = 175
.meas tran vdout0_16ck34 FIND v(dout0_16) AT=175.025n

* CHECK dout0_17 Vdout0_17ck34 = 0.9 time = 175
.meas tran vdout0_17ck34 FIND v(dout0_17) AT=175.025n

* CHECK dout0_18 Vdout0_18ck34 = 0.9 time = 175
.meas tran vdout0_18ck34 FIND v(dout0_18) AT=175.025n

* CHECK dout0_19 Vdout0_19ck34 = 0.9 time = 175
.meas tran vdout0_19ck34 FIND v(dout0_19) AT=175.025n

* CHECK dout0_20 Vdout0_20ck34 = 0.9 time = 175
.meas tran vdout0_20ck34 FIND v(dout0_20) AT=175.025n

* CHECK dout0_21 Vdout0_21ck34 = 0.9 time = 175
.meas tran vdout0_21ck34 FIND v(dout0_21) AT=175.025n

* CHECK dout0_22 Vdout0_22ck34 = 0.9 time = 175
.meas tran vdout0_22ck34 FIND v(dout0_22) AT=175.025n

* CHECK dout0_23 Vdout0_23ck34 = 0 time = 175
.meas tran vdout0_23ck34 FIND v(dout0_23) AT=175.025n

* CHECK dout0_24 Vdout0_24ck34 = 0 time = 175
.meas tran vdout0_24ck34 FIND v(dout0_24) AT=175.025n

* CHECK dout0_25 Vdout0_25ck34 = 0.9 time = 175
.meas tran vdout0_25ck34 FIND v(dout0_25) AT=175.025n

* CHECK dout0_26 Vdout0_26ck34 = 0 time = 175
.meas tran vdout0_26ck34 FIND v(dout0_26) AT=175.025n

* CHECK dout0_27 Vdout0_27ck34 = 0.9 time = 175
.meas tran vdout0_27ck34 FIND v(dout0_27) AT=175.025n

* CHECK dout0_28 Vdout0_28ck34 = 0.9 time = 175
.meas tran vdout0_28ck34 FIND v(dout0_28) AT=175.025n

* CHECK dout0_29 Vdout0_29ck34 = 0.9 time = 175
.meas tran vdout0_29ck34 FIND v(dout0_29) AT=175.025n

* CHECK dout0_30 Vdout0_30ck34 = 0 time = 175
.meas tran vdout0_30ck34 FIND v(dout0_30) AT=175.025n

* CHECK dout0_31 Vdout0_31ck34 = 0.9 time = 175
.meas tran vdout0_31ck34 FIND v(dout0_31) AT=175.025n

* CHECK dout0_32 Vdout0_32ck34 = 0.9 time = 175
.meas tran vdout0_32ck34 FIND v(dout0_32) AT=175.025n

* CHECK dout0_33 Vdout0_33ck34 = 0.9 time = 175
.meas tran vdout0_33ck34 FIND v(dout0_33) AT=175.025n

* CHECK dout0_34 Vdout0_34ck34 = 0 time = 175
.meas tran vdout0_34ck34 FIND v(dout0_34) AT=175.025n

* CHECK dout0_35 Vdout0_35ck34 = 0.9 time = 175
.meas tran vdout0_35ck34 FIND v(dout0_35) AT=175.025n

* CHECK dout0_36 Vdout0_36ck34 = 0 time = 175
.meas tran vdout0_36ck34 FIND v(dout0_36) AT=175.025n

* CHECK dout0_37 Vdout0_37ck34 = 0 time = 175
.meas tran vdout0_37ck34 FIND v(dout0_37) AT=175.025n

* CHECK dout0_38 Vdout0_38ck34 = 0 time = 175
.meas tran vdout0_38ck34 FIND v(dout0_38) AT=175.025n

* CHECK dout0_39 Vdout0_39ck34 = 0 time = 175
.meas tran vdout0_39ck34 FIND v(dout0_39) AT=175.025n

* CHECK dout0_0 Vdout0_0ck36 = 0 time = 185
.meas tran vdout0_0ck36 FIND v(dout0_0) AT=185.025n

* CHECK dout0_1 Vdout0_1ck36 = 0.9 time = 185
.meas tran vdout0_1ck36 FIND v(dout0_1) AT=185.025n

* CHECK dout0_2 Vdout0_2ck36 = 0 time = 185
.meas tran vdout0_2ck36 FIND v(dout0_2) AT=185.025n

* CHECK dout0_3 Vdout0_3ck36 = 0 time = 185
.meas tran vdout0_3ck36 FIND v(dout0_3) AT=185.025n

* CHECK dout0_4 Vdout0_4ck36 = 0.9 time = 185
.meas tran vdout0_4ck36 FIND v(dout0_4) AT=185.025n

* CHECK dout0_5 Vdout0_5ck36 = 0 time = 185
.meas tran vdout0_5ck36 FIND v(dout0_5) AT=185.025n

* CHECK dout0_6 Vdout0_6ck36 = 0.9 time = 185
.meas tran vdout0_6ck36 FIND v(dout0_6) AT=185.025n

* CHECK dout0_7 Vdout0_7ck36 = 0.9 time = 185
.meas tran vdout0_7ck36 FIND v(dout0_7) AT=185.025n

* CHECK dout0_8 Vdout0_8ck36 = 0 time = 185
.meas tran vdout0_8ck36 FIND v(dout0_8) AT=185.025n

* CHECK dout0_9 Vdout0_9ck36 = 0 time = 185
.meas tran vdout0_9ck36 FIND v(dout0_9) AT=185.025n

* CHECK dout0_10 Vdout0_10ck36 = 0.9 time = 185
.meas tran vdout0_10ck36 FIND v(dout0_10) AT=185.025n

* CHECK dout0_11 Vdout0_11ck36 = 0.9 time = 185
.meas tran vdout0_11ck36 FIND v(dout0_11) AT=185.025n

* CHECK dout0_12 Vdout0_12ck36 = 0.9 time = 185
.meas tran vdout0_12ck36 FIND v(dout0_12) AT=185.025n

* CHECK dout0_13 Vdout0_13ck36 = 0.9 time = 185
.meas tran vdout0_13ck36 FIND v(dout0_13) AT=185.025n

* CHECK dout0_14 Vdout0_14ck36 = 0.9 time = 185
.meas tran vdout0_14ck36 FIND v(dout0_14) AT=185.025n

* CHECK dout0_15 Vdout0_15ck36 = 0 time = 185
.meas tran vdout0_15ck36 FIND v(dout0_15) AT=185.025n

* CHECK dout0_16 Vdout0_16ck36 = 0 time = 185
.meas tran vdout0_16ck36 FIND v(dout0_16) AT=185.025n

* CHECK dout0_17 Vdout0_17ck36 = 0.9 time = 185
.meas tran vdout0_17ck36 FIND v(dout0_17) AT=185.025n

* CHECK dout0_18 Vdout0_18ck36 = 0.9 time = 185
.meas tran vdout0_18ck36 FIND v(dout0_18) AT=185.025n

* CHECK dout0_19 Vdout0_19ck36 = 0.9 time = 185
.meas tran vdout0_19ck36 FIND v(dout0_19) AT=185.025n

* CHECK dout0_20 Vdout0_20ck36 = 0.9 time = 185
.meas tran vdout0_20ck36 FIND v(dout0_20) AT=185.025n

* CHECK dout0_21 Vdout0_21ck36 = 0.9 time = 185
.meas tran vdout0_21ck36 FIND v(dout0_21) AT=185.025n

* CHECK dout0_22 Vdout0_22ck36 = 0.9 time = 185
.meas tran vdout0_22ck36 FIND v(dout0_22) AT=185.025n

* CHECK dout0_23 Vdout0_23ck36 = 0 time = 185
.meas tran vdout0_23ck36 FIND v(dout0_23) AT=185.025n

* CHECK dout0_24 Vdout0_24ck36 = 0 time = 185
.meas tran vdout0_24ck36 FIND v(dout0_24) AT=185.025n

* CHECK dout0_25 Vdout0_25ck36 = 0.9 time = 185
.meas tran vdout0_25ck36 FIND v(dout0_25) AT=185.025n

* CHECK dout0_26 Vdout0_26ck36 = 0 time = 185
.meas tran vdout0_26ck36 FIND v(dout0_26) AT=185.025n

* CHECK dout0_27 Vdout0_27ck36 = 0.9 time = 185
.meas tran vdout0_27ck36 FIND v(dout0_27) AT=185.025n

* CHECK dout0_28 Vdout0_28ck36 = 0.9 time = 185
.meas tran vdout0_28ck36 FIND v(dout0_28) AT=185.025n

* CHECK dout0_29 Vdout0_29ck36 = 0.9 time = 185
.meas tran vdout0_29ck36 FIND v(dout0_29) AT=185.025n

* CHECK dout0_30 Vdout0_30ck36 = 0 time = 185
.meas tran vdout0_30ck36 FIND v(dout0_30) AT=185.025n

* CHECK dout0_31 Vdout0_31ck36 = 0.9 time = 185
.meas tran vdout0_31ck36 FIND v(dout0_31) AT=185.025n

* CHECK dout0_32 Vdout0_32ck36 = 0.9 time = 185
.meas tran vdout0_32ck36 FIND v(dout0_32) AT=185.025n

* CHECK dout0_33 Vdout0_33ck36 = 0.9 time = 185
.meas tran vdout0_33ck36 FIND v(dout0_33) AT=185.025n

* CHECK dout0_34 Vdout0_34ck36 = 0 time = 185
.meas tran vdout0_34ck36 FIND v(dout0_34) AT=185.025n

* CHECK dout0_35 Vdout0_35ck36 = 0.9 time = 185
.meas tran vdout0_35ck36 FIND v(dout0_35) AT=185.025n

* CHECK dout0_36 Vdout0_36ck36 = 0 time = 185
.meas tran vdout0_36ck36 FIND v(dout0_36) AT=185.025n

* CHECK dout0_37 Vdout0_37ck36 = 0 time = 185
.meas tran vdout0_37ck36 FIND v(dout0_37) AT=185.025n

* CHECK dout0_38 Vdout0_38ck36 = 0 time = 185
.meas tran vdout0_38ck36 FIND v(dout0_38) AT=185.025n

* CHECK dout0_39 Vdout0_39ck36 = 0 time = 185
.meas tran vdout0_39ck36 FIND v(dout0_39) AT=185.025n

* CHECK dout0_0 Vdout0_0ck44 = 0 time = 225
.meas tran vdout0_0ck44 FIND v(dout0_0) AT=225.025n

* CHECK dout0_1 Vdout0_1ck44 = 0.9 time = 225
.meas tran vdout0_1ck44 FIND v(dout0_1) AT=225.025n

* CHECK dout0_2 Vdout0_2ck44 = 0.9 time = 225
.meas tran vdout0_2ck44 FIND v(dout0_2) AT=225.025n

* CHECK dout0_3 Vdout0_3ck44 = 0 time = 225
.meas tran vdout0_3ck44 FIND v(dout0_3) AT=225.025n

* CHECK dout0_4 Vdout0_4ck44 = 0 time = 225
.meas tran vdout0_4ck44 FIND v(dout0_4) AT=225.025n

* CHECK dout0_5 Vdout0_5ck44 = 0.9 time = 225
.meas tran vdout0_5ck44 FIND v(dout0_5) AT=225.025n

* CHECK dout0_6 Vdout0_6ck44 = 0 time = 225
.meas tran vdout0_6ck44 FIND v(dout0_6) AT=225.025n

* CHECK dout0_7 Vdout0_7ck44 = 0.9 time = 225
.meas tran vdout0_7ck44 FIND v(dout0_7) AT=225.025n

* CHECK dout0_8 Vdout0_8ck44 = 0 time = 225
.meas tran vdout0_8ck44 FIND v(dout0_8) AT=225.025n

* CHECK dout0_9 Vdout0_9ck44 = 0 time = 225
.meas tran vdout0_9ck44 FIND v(dout0_9) AT=225.025n

* CHECK dout0_10 Vdout0_10ck44 = 0 time = 225
.meas tran vdout0_10ck44 FIND v(dout0_10) AT=225.025n

* CHECK dout0_11 Vdout0_11ck44 = 0 time = 225
.meas tran vdout0_11ck44 FIND v(dout0_11) AT=225.025n

* CHECK dout0_12 Vdout0_12ck44 = 0 time = 225
.meas tran vdout0_12ck44 FIND v(dout0_12) AT=225.025n

* CHECK dout0_13 Vdout0_13ck44 = 0 time = 225
.meas tran vdout0_13ck44 FIND v(dout0_13) AT=225.025n

* CHECK dout0_14 Vdout0_14ck44 = 0 time = 225
.meas tran vdout0_14ck44 FIND v(dout0_14) AT=225.025n

* CHECK dout0_15 Vdout0_15ck44 = 0.9 time = 225
.meas tran vdout0_15ck44 FIND v(dout0_15) AT=225.025n

* CHECK dout0_16 Vdout0_16ck44 = 0.9 time = 225
.meas tran vdout0_16ck44 FIND v(dout0_16) AT=225.025n

* CHECK dout0_17 Vdout0_17ck44 = 0.9 time = 225
.meas tran vdout0_17ck44 FIND v(dout0_17) AT=225.025n

* CHECK dout0_18 Vdout0_18ck44 = 0 time = 225
.meas tran vdout0_18ck44 FIND v(dout0_18) AT=225.025n

* CHECK dout0_19 Vdout0_19ck44 = 0 time = 225
.meas tran vdout0_19ck44 FIND v(dout0_19) AT=225.025n

* CHECK dout0_20 Vdout0_20ck44 = 0.9 time = 225
.meas tran vdout0_20ck44 FIND v(dout0_20) AT=225.025n

* CHECK dout0_21 Vdout0_21ck44 = 0.9 time = 225
.meas tran vdout0_21ck44 FIND v(dout0_21) AT=225.025n

* CHECK dout0_22 Vdout0_22ck44 = 0.9 time = 225
.meas tran vdout0_22ck44 FIND v(dout0_22) AT=225.025n

* CHECK dout0_23 Vdout0_23ck44 = 0 time = 225
.meas tran vdout0_23ck44 FIND v(dout0_23) AT=225.025n

* CHECK dout0_24 Vdout0_24ck44 = 0 time = 225
.meas tran vdout0_24ck44 FIND v(dout0_24) AT=225.025n

* CHECK dout0_25 Vdout0_25ck44 = 0 time = 225
.meas tran vdout0_25ck44 FIND v(dout0_25) AT=225.025n

* CHECK dout0_26 Vdout0_26ck44 = 0 time = 225
.meas tran vdout0_26ck44 FIND v(dout0_26) AT=225.025n

* CHECK dout0_27 Vdout0_27ck44 = 0 time = 225
.meas tran vdout0_27ck44 FIND v(dout0_27) AT=225.025n

* CHECK dout0_28 Vdout0_28ck44 = 0 time = 225
.meas tran vdout0_28ck44 FIND v(dout0_28) AT=225.025n

* CHECK dout0_29 Vdout0_29ck44 = 0 time = 225
.meas tran vdout0_29ck44 FIND v(dout0_29) AT=225.025n

* CHECK dout0_30 Vdout0_30ck44 = 0 time = 225
.meas tran vdout0_30ck44 FIND v(dout0_30) AT=225.025n

* CHECK dout0_31 Vdout0_31ck44 = 0.9 time = 225
.meas tran vdout0_31ck44 FIND v(dout0_31) AT=225.025n

* CHECK dout0_32 Vdout0_32ck44 = 0 time = 225
.meas tran vdout0_32ck44 FIND v(dout0_32) AT=225.025n

* CHECK dout0_33 Vdout0_33ck44 = 0.9 time = 225
.meas tran vdout0_33ck44 FIND v(dout0_33) AT=225.025n

* CHECK dout0_34 Vdout0_34ck44 = 0 time = 225
.meas tran vdout0_34ck44 FIND v(dout0_34) AT=225.025n

* CHECK dout0_35 Vdout0_35ck44 = 0.9 time = 225
.meas tran vdout0_35ck44 FIND v(dout0_35) AT=225.025n

* CHECK dout0_36 Vdout0_36ck44 = 0.9 time = 225
.meas tran vdout0_36ck44 FIND v(dout0_36) AT=225.025n

* CHECK dout0_37 Vdout0_37ck44 = 0 time = 225
.meas tran vdout0_37ck44 FIND v(dout0_37) AT=225.025n

* CHECK dout0_38 Vdout0_38ck44 = 0.9 time = 225
.meas tran vdout0_38ck44 FIND v(dout0_38) AT=225.025n

* CHECK dout0_39 Vdout0_39ck44 = 0.9 time = 225
.meas tran vdout0_39ck44 FIND v(dout0_39) AT=225.025n

* CHECK dout0_0 Vdout0_0ck46 = 0 time = 235
.meas tran vdout0_0ck46 FIND v(dout0_0) AT=235.025n

* CHECK dout0_1 Vdout0_1ck46 = 0.9 time = 235
.meas tran vdout0_1ck46 FIND v(dout0_1) AT=235.025n

* CHECK dout0_2 Vdout0_2ck46 = 0.9 time = 235
.meas tran vdout0_2ck46 FIND v(dout0_2) AT=235.025n

* CHECK dout0_3 Vdout0_3ck46 = 0 time = 235
.meas tran vdout0_3ck46 FIND v(dout0_3) AT=235.025n

* CHECK dout0_4 Vdout0_4ck46 = 0 time = 235
.meas tran vdout0_4ck46 FIND v(dout0_4) AT=235.025n

* CHECK dout0_5 Vdout0_5ck46 = 0.9 time = 235
.meas tran vdout0_5ck46 FIND v(dout0_5) AT=235.025n

* CHECK dout0_6 Vdout0_6ck46 = 0 time = 235
.meas tran vdout0_6ck46 FIND v(dout0_6) AT=235.025n

* CHECK dout0_7 Vdout0_7ck46 = 0.9 time = 235
.meas tran vdout0_7ck46 FIND v(dout0_7) AT=235.025n

* CHECK dout0_8 Vdout0_8ck46 = 0 time = 235
.meas tran vdout0_8ck46 FIND v(dout0_8) AT=235.025n

* CHECK dout0_9 Vdout0_9ck46 = 0 time = 235
.meas tran vdout0_9ck46 FIND v(dout0_9) AT=235.025n

* CHECK dout0_10 Vdout0_10ck46 = 0 time = 235
.meas tran vdout0_10ck46 FIND v(dout0_10) AT=235.025n

* CHECK dout0_11 Vdout0_11ck46 = 0 time = 235
.meas tran vdout0_11ck46 FIND v(dout0_11) AT=235.025n

* CHECK dout0_12 Vdout0_12ck46 = 0 time = 235
.meas tran vdout0_12ck46 FIND v(dout0_12) AT=235.025n

* CHECK dout0_13 Vdout0_13ck46 = 0 time = 235
.meas tran vdout0_13ck46 FIND v(dout0_13) AT=235.025n

* CHECK dout0_14 Vdout0_14ck46 = 0 time = 235
.meas tran vdout0_14ck46 FIND v(dout0_14) AT=235.025n

* CHECK dout0_15 Vdout0_15ck46 = 0.9 time = 235
.meas tran vdout0_15ck46 FIND v(dout0_15) AT=235.025n

* CHECK dout0_16 Vdout0_16ck46 = 0.9 time = 235
.meas tran vdout0_16ck46 FIND v(dout0_16) AT=235.025n

* CHECK dout0_17 Vdout0_17ck46 = 0.9 time = 235
.meas tran vdout0_17ck46 FIND v(dout0_17) AT=235.025n

* CHECK dout0_18 Vdout0_18ck46 = 0 time = 235
.meas tran vdout0_18ck46 FIND v(dout0_18) AT=235.025n

* CHECK dout0_19 Vdout0_19ck46 = 0 time = 235
.meas tran vdout0_19ck46 FIND v(dout0_19) AT=235.025n

* CHECK dout0_20 Vdout0_20ck46 = 0.9 time = 235
.meas tran vdout0_20ck46 FIND v(dout0_20) AT=235.025n

* CHECK dout0_21 Vdout0_21ck46 = 0.9 time = 235
.meas tran vdout0_21ck46 FIND v(dout0_21) AT=235.025n

* CHECK dout0_22 Vdout0_22ck46 = 0.9 time = 235
.meas tran vdout0_22ck46 FIND v(dout0_22) AT=235.025n

* CHECK dout0_23 Vdout0_23ck46 = 0 time = 235
.meas tran vdout0_23ck46 FIND v(dout0_23) AT=235.025n

* CHECK dout0_24 Vdout0_24ck46 = 0 time = 235
.meas tran vdout0_24ck46 FIND v(dout0_24) AT=235.025n

* CHECK dout0_25 Vdout0_25ck46 = 0 time = 235
.meas tran vdout0_25ck46 FIND v(dout0_25) AT=235.025n

* CHECK dout0_26 Vdout0_26ck46 = 0 time = 235
.meas tran vdout0_26ck46 FIND v(dout0_26) AT=235.025n

* CHECK dout0_27 Vdout0_27ck46 = 0 time = 235
.meas tran vdout0_27ck46 FIND v(dout0_27) AT=235.025n

* CHECK dout0_28 Vdout0_28ck46 = 0 time = 235
.meas tran vdout0_28ck46 FIND v(dout0_28) AT=235.025n

* CHECK dout0_29 Vdout0_29ck46 = 0 time = 235
.meas tran vdout0_29ck46 FIND v(dout0_29) AT=235.025n

* CHECK dout0_30 Vdout0_30ck46 = 0 time = 235
.meas tran vdout0_30ck46 FIND v(dout0_30) AT=235.025n

* CHECK dout0_31 Vdout0_31ck46 = 0.9 time = 235
.meas tran vdout0_31ck46 FIND v(dout0_31) AT=235.025n

* CHECK dout0_32 Vdout0_32ck46 = 0 time = 235
.meas tran vdout0_32ck46 FIND v(dout0_32) AT=235.025n

* CHECK dout0_33 Vdout0_33ck46 = 0.9 time = 235
.meas tran vdout0_33ck46 FIND v(dout0_33) AT=235.025n

* CHECK dout0_34 Vdout0_34ck46 = 0 time = 235
.meas tran vdout0_34ck46 FIND v(dout0_34) AT=235.025n

* CHECK dout0_35 Vdout0_35ck46 = 0.9 time = 235
.meas tran vdout0_35ck46 FIND v(dout0_35) AT=235.025n

* CHECK dout0_36 Vdout0_36ck46 = 0.9 time = 235
.meas tran vdout0_36ck46 FIND v(dout0_36) AT=235.025n

* CHECK dout0_37 Vdout0_37ck46 = 0 time = 235
.meas tran vdout0_37ck46 FIND v(dout0_37) AT=235.025n

* CHECK dout0_38 Vdout0_38ck46 = 0.9 time = 235
.meas tran vdout0_38ck46 FIND v(dout0_38) AT=235.025n

* CHECK dout0_39 Vdout0_39ck46 = 0.9 time = 235
.meas tran vdout0_39ck46 FIND v(dout0_39) AT=235.025n

* CHECK dout0_0 Vdout0_0ck50 = 0 time = 255
.meas tran vdout0_0ck50 FIND v(dout0_0) AT=255.025n

* CHECK dout0_1 Vdout0_1ck50 = 0 time = 255
.meas tran vdout0_1ck50 FIND v(dout0_1) AT=255.025n

* CHECK dout0_2 Vdout0_2ck50 = 0.9 time = 255
.meas tran vdout0_2ck50 FIND v(dout0_2) AT=255.025n

* CHECK dout0_3 Vdout0_3ck50 = 0 time = 255
.meas tran vdout0_3ck50 FIND v(dout0_3) AT=255.025n

* CHECK dout0_4 Vdout0_4ck50 = 0.9 time = 255
.meas tran vdout0_4ck50 FIND v(dout0_4) AT=255.025n

* CHECK dout0_5 Vdout0_5ck50 = 0.9 time = 255
.meas tran vdout0_5ck50 FIND v(dout0_5) AT=255.025n

* CHECK dout0_6 Vdout0_6ck50 = 0 time = 255
.meas tran vdout0_6ck50 FIND v(dout0_6) AT=255.025n

* CHECK dout0_7 Vdout0_7ck50 = 0 time = 255
.meas tran vdout0_7ck50 FIND v(dout0_7) AT=255.025n

* CHECK dout0_8 Vdout0_8ck50 = 0 time = 255
.meas tran vdout0_8ck50 FIND v(dout0_8) AT=255.025n

* CHECK dout0_9 Vdout0_9ck50 = 0 time = 255
.meas tran vdout0_9ck50 FIND v(dout0_9) AT=255.025n

* CHECK dout0_10 Vdout0_10ck50 = 0.9 time = 255
.meas tran vdout0_10ck50 FIND v(dout0_10) AT=255.025n

* CHECK dout0_11 Vdout0_11ck50 = 0 time = 255
.meas tran vdout0_11ck50 FIND v(dout0_11) AT=255.025n

* CHECK dout0_12 Vdout0_12ck50 = 0.9 time = 255
.meas tran vdout0_12ck50 FIND v(dout0_12) AT=255.025n

* CHECK dout0_13 Vdout0_13ck50 = 0.9 time = 255
.meas tran vdout0_13ck50 FIND v(dout0_13) AT=255.025n

* CHECK dout0_14 Vdout0_14ck50 = 0 time = 255
.meas tran vdout0_14ck50 FIND v(dout0_14) AT=255.025n

* CHECK dout0_15 Vdout0_15ck50 = 0 time = 255
.meas tran vdout0_15ck50 FIND v(dout0_15) AT=255.025n

* CHECK dout0_16 Vdout0_16ck50 = 0 time = 255
.meas tran vdout0_16ck50 FIND v(dout0_16) AT=255.025n

* CHECK dout0_17 Vdout0_17ck50 = 0 time = 255
.meas tran vdout0_17ck50 FIND v(dout0_17) AT=255.025n

* CHECK dout0_18 Vdout0_18ck50 = 0.9 time = 255
.meas tran vdout0_18ck50 FIND v(dout0_18) AT=255.025n

* CHECK dout0_19 Vdout0_19ck50 = 0 time = 255
.meas tran vdout0_19ck50 FIND v(dout0_19) AT=255.025n

* CHECK dout0_20 Vdout0_20ck50 = 0 time = 255
.meas tran vdout0_20ck50 FIND v(dout0_20) AT=255.025n

* CHECK dout0_21 Vdout0_21ck50 = 0 time = 255
.meas tran vdout0_21ck50 FIND v(dout0_21) AT=255.025n

* CHECK dout0_22 Vdout0_22ck50 = 0 time = 255
.meas tran vdout0_22ck50 FIND v(dout0_22) AT=255.025n

* CHECK dout0_23 Vdout0_23ck50 = 0.9 time = 255
.meas tran vdout0_23ck50 FIND v(dout0_23) AT=255.025n

* CHECK dout0_24 Vdout0_24ck50 = 0 time = 255
.meas tran vdout0_24ck50 FIND v(dout0_24) AT=255.025n

* CHECK dout0_25 Vdout0_25ck50 = 0 time = 255
.meas tran vdout0_25ck50 FIND v(dout0_25) AT=255.025n

* CHECK dout0_26 Vdout0_26ck50 = 0.9 time = 255
.meas tran vdout0_26ck50 FIND v(dout0_26) AT=255.025n

* CHECK dout0_27 Vdout0_27ck50 = 0.9 time = 255
.meas tran vdout0_27ck50 FIND v(dout0_27) AT=255.025n

* CHECK dout0_28 Vdout0_28ck50 = 0.9 time = 255
.meas tran vdout0_28ck50 FIND v(dout0_28) AT=255.025n

* CHECK dout0_29 Vdout0_29ck50 = 0 time = 255
.meas tran vdout0_29ck50 FIND v(dout0_29) AT=255.025n

* CHECK dout0_30 Vdout0_30ck50 = 0 time = 255
.meas tran vdout0_30ck50 FIND v(dout0_30) AT=255.025n

* CHECK dout0_31 Vdout0_31ck50 = 0.9 time = 255
.meas tran vdout0_31ck50 FIND v(dout0_31) AT=255.025n

* CHECK dout0_32 Vdout0_32ck50 = 0 time = 255
.meas tran vdout0_32ck50 FIND v(dout0_32) AT=255.025n

* CHECK dout0_33 Vdout0_33ck50 = 0 time = 255
.meas tran vdout0_33ck50 FIND v(dout0_33) AT=255.025n

* CHECK dout0_34 Vdout0_34ck50 = 0 time = 255
.meas tran vdout0_34ck50 FIND v(dout0_34) AT=255.025n

* CHECK dout0_35 Vdout0_35ck50 = 0.9 time = 255
.meas tran vdout0_35ck50 FIND v(dout0_35) AT=255.025n

* CHECK dout0_36 Vdout0_36ck50 = 0 time = 255
.meas tran vdout0_36ck50 FIND v(dout0_36) AT=255.025n

* CHECK dout0_37 Vdout0_37ck50 = 0 time = 255
.meas tran vdout0_37ck50 FIND v(dout0_37) AT=255.025n

* CHECK dout0_38 Vdout0_38ck50 = 0.9 time = 255
.meas tran vdout0_38ck50 FIND v(dout0_38) AT=255.025n

* CHECK dout0_39 Vdout0_39ck50 = 0 time = 255
.meas tran vdout0_39ck50 FIND v(dout0_39) AT=255.025n

* CHECK dout0_0 Vdout0_0ck52 = 0.9 time = 265
.meas tran vdout0_0ck52 FIND v(dout0_0) AT=265.025n

* CHECK dout0_1 Vdout0_1ck52 = 0 time = 265
.meas tran vdout0_1ck52 FIND v(dout0_1) AT=265.025n

* CHECK dout0_2 Vdout0_2ck52 = 0.9 time = 265
.meas tran vdout0_2ck52 FIND v(dout0_2) AT=265.025n

* CHECK dout0_3 Vdout0_3ck52 = 0.9 time = 265
.meas tran vdout0_3ck52 FIND v(dout0_3) AT=265.025n

* CHECK dout0_4 Vdout0_4ck52 = 0.9 time = 265
.meas tran vdout0_4ck52 FIND v(dout0_4) AT=265.025n

* CHECK dout0_5 Vdout0_5ck52 = 0.9 time = 265
.meas tran vdout0_5ck52 FIND v(dout0_5) AT=265.025n

* CHECK dout0_6 Vdout0_6ck52 = 0.9 time = 265
.meas tran vdout0_6ck52 FIND v(dout0_6) AT=265.025n

* CHECK dout0_7 Vdout0_7ck52 = 0.9 time = 265
.meas tran vdout0_7ck52 FIND v(dout0_7) AT=265.025n

* CHECK dout0_8 Vdout0_8ck52 = 0 time = 265
.meas tran vdout0_8ck52 FIND v(dout0_8) AT=265.025n

* CHECK dout0_9 Vdout0_9ck52 = 0 time = 265
.meas tran vdout0_9ck52 FIND v(dout0_9) AT=265.025n

* CHECK dout0_10 Vdout0_10ck52 = 0.9 time = 265
.meas tran vdout0_10ck52 FIND v(dout0_10) AT=265.025n

* CHECK dout0_11 Vdout0_11ck52 = 0.9 time = 265
.meas tran vdout0_11ck52 FIND v(dout0_11) AT=265.025n

* CHECK dout0_12 Vdout0_12ck52 = 0.9 time = 265
.meas tran vdout0_12ck52 FIND v(dout0_12) AT=265.025n

* CHECK dout0_13 Vdout0_13ck52 = 0 time = 265
.meas tran vdout0_13ck52 FIND v(dout0_13) AT=265.025n

* CHECK dout0_14 Vdout0_14ck52 = 0.9 time = 265
.meas tran vdout0_14ck52 FIND v(dout0_14) AT=265.025n

* CHECK dout0_15 Vdout0_15ck52 = 0.9 time = 265
.meas tran vdout0_15ck52 FIND v(dout0_15) AT=265.025n

* CHECK dout0_16 Vdout0_16ck52 = 0.9 time = 265
.meas tran vdout0_16ck52 FIND v(dout0_16) AT=265.025n

* CHECK dout0_17 Vdout0_17ck52 = 0.9 time = 265
.meas tran vdout0_17ck52 FIND v(dout0_17) AT=265.025n

* CHECK dout0_18 Vdout0_18ck52 = 0 time = 265
.meas tran vdout0_18ck52 FIND v(dout0_18) AT=265.025n

* CHECK dout0_19 Vdout0_19ck52 = 0 time = 265
.meas tran vdout0_19ck52 FIND v(dout0_19) AT=265.025n

* CHECK dout0_20 Vdout0_20ck52 = 0.9 time = 265
.meas tran vdout0_20ck52 FIND v(dout0_20) AT=265.025n

* CHECK dout0_21 Vdout0_21ck52 = 0.9 time = 265
.meas tran vdout0_21ck52 FIND v(dout0_21) AT=265.025n

* CHECK dout0_22 Vdout0_22ck52 = 0.9 time = 265
.meas tran vdout0_22ck52 FIND v(dout0_22) AT=265.025n

* CHECK dout0_23 Vdout0_23ck52 = 0 time = 265
.meas tran vdout0_23ck52 FIND v(dout0_23) AT=265.025n

* CHECK dout0_24 Vdout0_24ck52 = 0 time = 265
.meas tran vdout0_24ck52 FIND v(dout0_24) AT=265.025n

* CHECK dout0_25 Vdout0_25ck52 = 0 time = 265
.meas tran vdout0_25ck52 FIND v(dout0_25) AT=265.025n

* CHECK dout0_26 Vdout0_26ck52 = 0.9 time = 265
.meas tran vdout0_26ck52 FIND v(dout0_26) AT=265.025n

* CHECK dout0_27 Vdout0_27ck52 = 0.9 time = 265
.meas tran vdout0_27ck52 FIND v(dout0_27) AT=265.025n

* CHECK dout0_28 Vdout0_28ck52 = 0 time = 265
.meas tran vdout0_28ck52 FIND v(dout0_28) AT=265.025n

* CHECK dout0_29 Vdout0_29ck52 = 0.9 time = 265
.meas tran vdout0_29ck52 FIND v(dout0_29) AT=265.025n

* CHECK dout0_30 Vdout0_30ck52 = 0.9 time = 265
.meas tran vdout0_30ck52 FIND v(dout0_30) AT=265.025n

* CHECK dout0_31 Vdout0_31ck52 = 0.9 time = 265
.meas tran vdout0_31ck52 FIND v(dout0_31) AT=265.025n

* CHECK dout0_32 Vdout0_32ck52 = 0.9 time = 265
.meas tran vdout0_32ck52 FIND v(dout0_32) AT=265.025n

* CHECK dout0_33 Vdout0_33ck52 = 0.9 time = 265
.meas tran vdout0_33ck52 FIND v(dout0_33) AT=265.025n

* CHECK dout0_34 Vdout0_34ck52 = 0.9 time = 265
.meas tran vdout0_34ck52 FIND v(dout0_34) AT=265.025n

* CHECK dout0_35 Vdout0_35ck52 = 0 time = 265
.meas tran vdout0_35ck52 FIND v(dout0_35) AT=265.025n

* CHECK dout0_36 Vdout0_36ck52 = 0 time = 265
.meas tran vdout0_36ck52 FIND v(dout0_36) AT=265.025n

* CHECK dout0_37 Vdout0_37ck52 = 0 time = 265
.meas tran vdout0_37ck52 FIND v(dout0_37) AT=265.025n

* CHECK dout0_38 Vdout0_38ck52 = 0 time = 265
.meas tran vdout0_38ck52 FIND v(dout0_38) AT=265.025n

* CHECK dout0_39 Vdout0_39ck52 = 0.9 time = 265
.meas tran vdout0_39ck52 FIND v(dout0_39) AT=265.025n

* CHECK dout0_0 Vdout0_0ck53 = 0 time = 270
.meas tran vdout0_0ck53 FIND v(dout0_0) AT=270.025n

* CHECK dout0_1 Vdout0_1ck53 = 0 time = 270
.meas tran vdout0_1ck53 FIND v(dout0_1) AT=270.025n

* CHECK dout0_2 Vdout0_2ck53 = 0 time = 270
.meas tran vdout0_2ck53 FIND v(dout0_2) AT=270.025n

* CHECK dout0_3 Vdout0_3ck53 = 0 time = 270
.meas tran vdout0_3ck53 FIND v(dout0_3) AT=270.025n

* CHECK dout0_4 Vdout0_4ck53 = 0 time = 270
.meas tran vdout0_4ck53 FIND v(dout0_4) AT=270.025n

* CHECK dout0_5 Vdout0_5ck53 = 0 time = 270
.meas tran vdout0_5ck53 FIND v(dout0_5) AT=270.025n

* CHECK dout0_6 Vdout0_6ck53 = 0 time = 270
.meas tran vdout0_6ck53 FIND v(dout0_6) AT=270.025n

* CHECK dout0_7 Vdout0_7ck53 = 0 time = 270
.meas tran vdout0_7ck53 FIND v(dout0_7) AT=270.025n

* CHECK dout0_8 Vdout0_8ck53 = 0 time = 270
.meas tran vdout0_8ck53 FIND v(dout0_8) AT=270.025n

* CHECK dout0_9 Vdout0_9ck53 = 0.9 time = 270
.meas tran vdout0_9ck53 FIND v(dout0_9) AT=270.025n

* CHECK dout0_10 Vdout0_10ck53 = 0 time = 270
.meas tran vdout0_10ck53 FIND v(dout0_10) AT=270.025n

* CHECK dout0_11 Vdout0_11ck53 = 0 time = 270
.meas tran vdout0_11ck53 FIND v(dout0_11) AT=270.025n

* CHECK dout0_12 Vdout0_12ck53 = 0.9 time = 270
.meas tran vdout0_12ck53 FIND v(dout0_12) AT=270.025n

* CHECK dout0_13 Vdout0_13ck53 = 0 time = 270
.meas tran vdout0_13ck53 FIND v(dout0_13) AT=270.025n

* CHECK dout0_14 Vdout0_14ck53 = 0 time = 270
.meas tran vdout0_14ck53 FIND v(dout0_14) AT=270.025n

* CHECK dout0_15 Vdout0_15ck53 = 0 time = 270
.meas tran vdout0_15ck53 FIND v(dout0_15) AT=270.025n

* CHECK dout0_16 Vdout0_16ck53 = 0 time = 270
.meas tran vdout0_16ck53 FIND v(dout0_16) AT=270.025n

* CHECK dout0_17 Vdout0_17ck53 = 0.9 time = 270
.meas tran vdout0_17ck53 FIND v(dout0_17) AT=270.025n

* CHECK dout0_18 Vdout0_18ck53 = 0 time = 270
.meas tran vdout0_18ck53 FIND v(dout0_18) AT=270.025n

* CHECK dout0_19 Vdout0_19ck53 = 0 time = 270
.meas tran vdout0_19ck53 FIND v(dout0_19) AT=270.025n

* CHECK dout0_20 Vdout0_20ck53 = 0 time = 270
.meas tran vdout0_20ck53 FIND v(dout0_20) AT=270.025n

* CHECK dout0_21 Vdout0_21ck53 = 0.9 time = 270
.meas tran vdout0_21ck53 FIND v(dout0_21) AT=270.025n

* CHECK dout0_22 Vdout0_22ck53 = 0 time = 270
.meas tran vdout0_22ck53 FIND v(dout0_22) AT=270.025n

* CHECK dout0_23 Vdout0_23ck53 = 0.9 time = 270
.meas tran vdout0_23ck53 FIND v(dout0_23) AT=270.025n

* CHECK dout0_24 Vdout0_24ck53 = 0 time = 270
.meas tran vdout0_24ck53 FIND v(dout0_24) AT=270.025n

* CHECK dout0_25 Vdout0_25ck53 = 0.9 time = 270
.meas tran vdout0_25ck53 FIND v(dout0_25) AT=270.025n

* CHECK dout0_26 Vdout0_26ck53 = 0.9 time = 270
.meas tran vdout0_26ck53 FIND v(dout0_26) AT=270.025n

* CHECK dout0_27 Vdout0_27ck53 = 0 time = 270
.meas tran vdout0_27ck53 FIND v(dout0_27) AT=270.025n

* CHECK dout0_28 Vdout0_28ck53 = 0.9 time = 270
.meas tran vdout0_28ck53 FIND v(dout0_28) AT=270.025n

* CHECK dout0_29 Vdout0_29ck53 = 0 time = 270
.meas tran vdout0_29ck53 FIND v(dout0_29) AT=270.025n

* CHECK dout0_30 Vdout0_30ck53 = 0 time = 270
.meas tran vdout0_30ck53 FIND v(dout0_30) AT=270.025n

* CHECK dout0_31 Vdout0_31ck53 = 0 time = 270
.meas tran vdout0_31ck53 FIND v(dout0_31) AT=270.025n

* CHECK dout0_32 Vdout0_32ck53 = 0 time = 270
.meas tran vdout0_32ck53 FIND v(dout0_32) AT=270.025n

* CHECK dout0_33 Vdout0_33ck53 = 0 time = 270
.meas tran vdout0_33ck53 FIND v(dout0_33) AT=270.025n

* CHECK dout0_34 Vdout0_34ck53 = 0.9 time = 270
.meas tran vdout0_34ck53 FIND v(dout0_34) AT=270.025n

* CHECK dout0_35 Vdout0_35ck53 = 0.9 time = 270
.meas tran vdout0_35ck53 FIND v(dout0_35) AT=270.025n

* CHECK dout0_36 Vdout0_36ck53 = 0 time = 270
.meas tran vdout0_36ck53 FIND v(dout0_36) AT=270.025n

* CHECK dout0_37 Vdout0_37ck53 = 0 time = 270
.meas tran vdout0_37ck53 FIND v(dout0_37) AT=270.025n

* CHECK dout0_38 Vdout0_38ck53 = 0.9 time = 270
.meas tran vdout0_38ck53 FIND v(dout0_38) AT=270.025n

* CHECK dout0_39 Vdout0_39ck53 = 0.9 time = 270
.meas tran vdout0_39ck53 FIND v(dout0_39) AT=270.025n

* CHECK dout0_0 Vdout0_0ck57 = 0 time = 290
.meas tran vdout0_0ck57 FIND v(dout0_0) AT=290.025n

* CHECK dout0_1 Vdout0_1ck57 = 0 time = 290
.meas tran vdout0_1ck57 FIND v(dout0_1) AT=290.025n

* CHECK dout0_2 Vdout0_2ck57 = 0 time = 290
.meas tran vdout0_2ck57 FIND v(dout0_2) AT=290.025n

* CHECK dout0_3 Vdout0_3ck57 = 0 time = 290
.meas tran vdout0_3ck57 FIND v(dout0_3) AT=290.025n

* CHECK dout0_4 Vdout0_4ck57 = 0 time = 290
.meas tran vdout0_4ck57 FIND v(dout0_4) AT=290.025n

* CHECK dout0_5 Vdout0_5ck57 = 0 time = 290
.meas tran vdout0_5ck57 FIND v(dout0_5) AT=290.025n

* CHECK dout0_6 Vdout0_6ck57 = 0 time = 290
.meas tran vdout0_6ck57 FIND v(dout0_6) AT=290.025n

* CHECK dout0_7 Vdout0_7ck57 = 0 time = 290
.meas tran vdout0_7ck57 FIND v(dout0_7) AT=290.025n

* CHECK dout0_8 Vdout0_8ck57 = 0 time = 290
.meas tran vdout0_8ck57 FIND v(dout0_8) AT=290.025n

* CHECK dout0_9 Vdout0_9ck57 = 0.9 time = 290
.meas tran vdout0_9ck57 FIND v(dout0_9) AT=290.025n

* CHECK dout0_10 Vdout0_10ck57 = 0 time = 290
.meas tran vdout0_10ck57 FIND v(dout0_10) AT=290.025n

* CHECK dout0_11 Vdout0_11ck57 = 0 time = 290
.meas tran vdout0_11ck57 FIND v(dout0_11) AT=290.025n

* CHECK dout0_12 Vdout0_12ck57 = 0.9 time = 290
.meas tran vdout0_12ck57 FIND v(dout0_12) AT=290.025n

* CHECK dout0_13 Vdout0_13ck57 = 0 time = 290
.meas tran vdout0_13ck57 FIND v(dout0_13) AT=290.025n

* CHECK dout0_14 Vdout0_14ck57 = 0 time = 290
.meas tran vdout0_14ck57 FIND v(dout0_14) AT=290.025n

* CHECK dout0_15 Vdout0_15ck57 = 0 time = 290
.meas tran vdout0_15ck57 FIND v(dout0_15) AT=290.025n

* CHECK dout0_16 Vdout0_16ck57 = 0 time = 290
.meas tran vdout0_16ck57 FIND v(dout0_16) AT=290.025n

* CHECK dout0_17 Vdout0_17ck57 = 0.9 time = 290
.meas tran vdout0_17ck57 FIND v(dout0_17) AT=290.025n

* CHECK dout0_18 Vdout0_18ck57 = 0 time = 290
.meas tran vdout0_18ck57 FIND v(dout0_18) AT=290.025n

* CHECK dout0_19 Vdout0_19ck57 = 0 time = 290
.meas tran vdout0_19ck57 FIND v(dout0_19) AT=290.025n

* CHECK dout0_20 Vdout0_20ck57 = 0 time = 290
.meas tran vdout0_20ck57 FIND v(dout0_20) AT=290.025n

* CHECK dout0_21 Vdout0_21ck57 = 0.9 time = 290
.meas tran vdout0_21ck57 FIND v(dout0_21) AT=290.025n

* CHECK dout0_22 Vdout0_22ck57 = 0 time = 290
.meas tran vdout0_22ck57 FIND v(dout0_22) AT=290.025n

* CHECK dout0_23 Vdout0_23ck57 = 0.9 time = 290
.meas tran vdout0_23ck57 FIND v(dout0_23) AT=290.025n

* CHECK dout0_24 Vdout0_24ck57 = 0 time = 290
.meas tran vdout0_24ck57 FIND v(dout0_24) AT=290.025n

* CHECK dout0_25 Vdout0_25ck57 = 0.9 time = 290
.meas tran vdout0_25ck57 FIND v(dout0_25) AT=290.025n

* CHECK dout0_26 Vdout0_26ck57 = 0.9 time = 290
.meas tran vdout0_26ck57 FIND v(dout0_26) AT=290.025n

* CHECK dout0_27 Vdout0_27ck57 = 0 time = 290
.meas tran vdout0_27ck57 FIND v(dout0_27) AT=290.025n

* CHECK dout0_28 Vdout0_28ck57 = 0.9 time = 290
.meas tran vdout0_28ck57 FIND v(dout0_28) AT=290.025n

* CHECK dout0_29 Vdout0_29ck57 = 0 time = 290
.meas tran vdout0_29ck57 FIND v(dout0_29) AT=290.025n

* CHECK dout0_30 Vdout0_30ck57 = 0 time = 290
.meas tran vdout0_30ck57 FIND v(dout0_30) AT=290.025n

* CHECK dout0_31 Vdout0_31ck57 = 0 time = 290
.meas tran vdout0_31ck57 FIND v(dout0_31) AT=290.025n

* CHECK dout0_32 Vdout0_32ck57 = 0 time = 290
.meas tran vdout0_32ck57 FIND v(dout0_32) AT=290.025n

* CHECK dout0_33 Vdout0_33ck57 = 0 time = 290
.meas tran vdout0_33ck57 FIND v(dout0_33) AT=290.025n

* CHECK dout0_34 Vdout0_34ck57 = 0.9 time = 290
.meas tran vdout0_34ck57 FIND v(dout0_34) AT=290.025n

* CHECK dout0_35 Vdout0_35ck57 = 0.9 time = 290
.meas tran vdout0_35ck57 FIND v(dout0_35) AT=290.025n

* CHECK dout0_36 Vdout0_36ck57 = 0 time = 290
.meas tran vdout0_36ck57 FIND v(dout0_36) AT=290.025n

* CHECK dout0_37 Vdout0_37ck57 = 0 time = 290
.meas tran vdout0_37ck57 FIND v(dout0_37) AT=290.025n

* CHECK dout0_38 Vdout0_38ck57 = 0.9 time = 290
.meas tran vdout0_38ck57 FIND v(dout0_38) AT=290.025n

* CHECK dout0_39 Vdout0_39ck57 = 0.9 time = 290
.meas tran vdout0_39ck57 FIND v(dout0_39) AT=290.025n

* CHECK dout0_0 Vdout0_0ck61 = 0 time = 310
.meas tran vdout0_0ck61 FIND v(dout0_0) AT=310.025n

* CHECK dout0_1 Vdout0_1ck61 = 0 time = 310
.meas tran vdout0_1ck61 FIND v(dout0_1) AT=310.025n

* CHECK dout0_2 Vdout0_2ck61 = 0.9 time = 310
.meas tran vdout0_2ck61 FIND v(dout0_2) AT=310.025n

* CHECK dout0_3 Vdout0_3ck61 = 0 time = 310
.meas tran vdout0_3ck61 FIND v(dout0_3) AT=310.025n

* CHECK dout0_4 Vdout0_4ck61 = 0 time = 310
.meas tran vdout0_4ck61 FIND v(dout0_4) AT=310.025n

* CHECK dout0_5 Vdout0_5ck61 = 0.9 time = 310
.meas tran vdout0_5ck61 FIND v(dout0_5) AT=310.025n

* CHECK dout0_6 Vdout0_6ck61 = 0 time = 310
.meas tran vdout0_6ck61 FIND v(dout0_6) AT=310.025n

* CHECK dout0_7 Vdout0_7ck61 = 0 time = 310
.meas tran vdout0_7ck61 FIND v(dout0_7) AT=310.025n

* CHECK dout0_8 Vdout0_8ck61 = 0 time = 310
.meas tran vdout0_8ck61 FIND v(dout0_8) AT=310.025n

* CHECK dout0_9 Vdout0_9ck61 = 0.9 time = 310
.meas tran vdout0_9ck61 FIND v(dout0_9) AT=310.025n

* CHECK dout0_10 Vdout0_10ck61 = 0 time = 310
.meas tran vdout0_10ck61 FIND v(dout0_10) AT=310.025n

* CHECK dout0_11 Vdout0_11ck61 = 0.9 time = 310
.meas tran vdout0_11ck61 FIND v(dout0_11) AT=310.025n

* CHECK dout0_12 Vdout0_12ck61 = 0 time = 310
.meas tran vdout0_12ck61 FIND v(dout0_12) AT=310.025n

* CHECK dout0_13 Vdout0_13ck61 = 0 time = 310
.meas tran vdout0_13ck61 FIND v(dout0_13) AT=310.025n

* CHECK dout0_14 Vdout0_14ck61 = 0.9 time = 310
.meas tran vdout0_14ck61 FIND v(dout0_14) AT=310.025n

* CHECK dout0_15 Vdout0_15ck61 = 0.9 time = 310
.meas tran vdout0_15ck61 FIND v(dout0_15) AT=310.025n

* CHECK dout0_16 Vdout0_16ck61 = 0 time = 310
.meas tran vdout0_16ck61 FIND v(dout0_16) AT=310.025n

* CHECK dout0_17 Vdout0_17ck61 = 0 time = 310
.meas tran vdout0_17ck61 FIND v(dout0_17) AT=310.025n

* CHECK dout0_18 Vdout0_18ck61 = 0.9 time = 310
.meas tran vdout0_18ck61 FIND v(dout0_18) AT=310.025n

* CHECK dout0_19 Vdout0_19ck61 = 0 time = 310
.meas tran vdout0_19ck61 FIND v(dout0_19) AT=310.025n

* CHECK dout0_20 Vdout0_20ck61 = 0.9 time = 310
.meas tran vdout0_20ck61 FIND v(dout0_20) AT=310.025n

* CHECK dout0_21 Vdout0_21ck61 = 0 time = 310
.meas tran vdout0_21ck61 FIND v(dout0_21) AT=310.025n

* CHECK dout0_22 Vdout0_22ck61 = 0.9 time = 310
.meas tran vdout0_22ck61 FIND v(dout0_22) AT=310.025n

* CHECK dout0_23 Vdout0_23ck61 = 0 time = 310
.meas tran vdout0_23ck61 FIND v(dout0_23) AT=310.025n

* CHECK dout0_24 Vdout0_24ck61 = 0 time = 310
.meas tran vdout0_24ck61 FIND v(dout0_24) AT=310.025n

* CHECK dout0_25 Vdout0_25ck61 = 0.9 time = 310
.meas tran vdout0_25ck61 FIND v(dout0_25) AT=310.025n

* CHECK dout0_26 Vdout0_26ck61 = 0 time = 310
.meas tran vdout0_26ck61 FIND v(dout0_26) AT=310.025n

* CHECK dout0_27 Vdout0_27ck61 = 0 time = 310
.meas tran vdout0_27ck61 FIND v(dout0_27) AT=310.025n

* CHECK dout0_28 Vdout0_28ck61 = 0.9 time = 310
.meas tran vdout0_28ck61 FIND v(dout0_28) AT=310.025n

* CHECK dout0_29 Vdout0_29ck61 = 0.9 time = 310
.meas tran vdout0_29ck61 FIND v(dout0_29) AT=310.025n

* CHECK dout0_30 Vdout0_30ck61 = 0.9 time = 310
.meas tran vdout0_30ck61 FIND v(dout0_30) AT=310.025n

* CHECK dout0_31 Vdout0_31ck61 = 0 time = 310
.meas tran vdout0_31ck61 FIND v(dout0_31) AT=310.025n

* CHECK dout0_32 Vdout0_32ck61 = 0.9 time = 310
.meas tran vdout0_32ck61 FIND v(dout0_32) AT=310.025n

* CHECK dout0_33 Vdout0_33ck61 = 0 time = 310
.meas tran vdout0_33ck61 FIND v(dout0_33) AT=310.025n

* CHECK dout0_34 Vdout0_34ck61 = 0 time = 310
.meas tran vdout0_34ck61 FIND v(dout0_34) AT=310.025n

* CHECK dout0_35 Vdout0_35ck61 = 0.9 time = 310
.meas tran vdout0_35ck61 FIND v(dout0_35) AT=310.025n

* CHECK dout0_36 Vdout0_36ck61 = 0 time = 310
.meas tran vdout0_36ck61 FIND v(dout0_36) AT=310.025n

* CHECK dout0_37 Vdout0_37ck61 = 0 time = 310
.meas tran vdout0_37ck61 FIND v(dout0_37) AT=310.025n

* CHECK dout0_38 Vdout0_38ck61 = 0 time = 310
.meas tran vdout0_38ck61 FIND v(dout0_38) AT=310.025n

* CHECK dout0_39 Vdout0_39ck61 = 0 time = 310
.meas tran vdout0_39ck61 FIND v(dout0_39) AT=310.025n

* CHECK dout0_0 Vdout0_0ck62 = 0 time = 315
.meas tran vdout0_0ck62 FIND v(dout0_0) AT=315.025n

* CHECK dout0_1 Vdout0_1ck62 = 0 time = 315
.meas tran vdout0_1ck62 FIND v(dout0_1) AT=315.025n

* CHECK dout0_2 Vdout0_2ck62 = 0.9 time = 315
.meas tran vdout0_2ck62 FIND v(dout0_2) AT=315.025n

* CHECK dout0_3 Vdout0_3ck62 = 0 time = 315
.meas tran vdout0_3ck62 FIND v(dout0_3) AT=315.025n

* CHECK dout0_4 Vdout0_4ck62 = 0 time = 315
.meas tran vdout0_4ck62 FIND v(dout0_4) AT=315.025n

* CHECK dout0_5 Vdout0_5ck62 = 0.9 time = 315
.meas tran vdout0_5ck62 FIND v(dout0_5) AT=315.025n

* CHECK dout0_6 Vdout0_6ck62 = 0 time = 315
.meas tran vdout0_6ck62 FIND v(dout0_6) AT=315.025n

* CHECK dout0_7 Vdout0_7ck62 = 0 time = 315
.meas tran vdout0_7ck62 FIND v(dout0_7) AT=315.025n

* CHECK dout0_8 Vdout0_8ck62 = 0 time = 315
.meas tran vdout0_8ck62 FIND v(dout0_8) AT=315.025n

* CHECK dout0_9 Vdout0_9ck62 = 0.9 time = 315
.meas tran vdout0_9ck62 FIND v(dout0_9) AT=315.025n

* CHECK dout0_10 Vdout0_10ck62 = 0 time = 315
.meas tran vdout0_10ck62 FIND v(dout0_10) AT=315.025n

* CHECK dout0_11 Vdout0_11ck62 = 0.9 time = 315
.meas tran vdout0_11ck62 FIND v(dout0_11) AT=315.025n

* CHECK dout0_12 Vdout0_12ck62 = 0 time = 315
.meas tran vdout0_12ck62 FIND v(dout0_12) AT=315.025n

* CHECK dout0_13 Vdout0_13ck62 = 0 time = 315
.meas tran vdout0_13ck62 FIND v(dout0_13) AT=315.025n

* CHECK dout0_14 Vdout0_14ck62 = 0.9 time = 315
.meas tran vdout0_14ck62 FIND v(dout0_14) AT=315.025n

* CHECK dout0_15 Vdout0_15ck62 = 0.9 time = 315
.meas tran vdout0_15ck62 FIND v(dout0_15) AT=315.025n

* CHECK dout0_16 Vdout0_16ck62 = 0 time = 315
.meas tran vdout0_16ck62 FIND v(dout0_16) AT=315.025n

* CHECK dout0_17 Vdout0_17ck62 = 0 time = 315
.meas tran vdout0_17ck62 FIND v(dout0_17) AT=315.025n

* CHECK dout0_18 Vdout0_18ck62 = 0.9 time = 315
.meas tran vdout0_18ck62 FIND v(dout0_18) AT=315.025n

* CHECK dout0_19 Vdout0_19ck62 = 0 time = 315
.meas tran vdout0_19ck62 FIND v(dout0_19) AT=315.025n

* CHECK dout0_20 Vdout0_20ck62 = 0.9 time = 315
.meas tran vdout0_20ck62 FIND v(dout0_20) AT=315.025n

* CHECK dout0_21 Vdout0_21ck62 = 0 time = 315
.meas tran vdout0_21ck62 FIND v(dout0_21) AT=315.025n

* CHECK dout0_22 Vdout0_22ck62 = 0.9 time = 315
.meas tran vdout0_22ck62 FIND v(dout0_22) AT=315.025n

* CHECK dout0_23 Vdout0_23ck62 = 0 time = 315
.meas tran vdout0_23ck62 FIND v(dout0_23) AT=315.025n

* CHECK dout0_24 Vdout0_24ck62 = 0 time = 315
.meas tran vdout0_24ck62 FIND v(dout0_24) AT=315.025n

* CHECK dout0_25 Vdout0_25ck62 = 0.9 time = 315
.meas tran vdout0_25ck62 FIND v(dout0_25) AT=315.025n

* CHECK dout0_26 Vdout0_26ck62 = 0 time = 315
.meas tran vdout0_26ck62 FIND v(dout0_26) AT=315.025n

* CHECK dout0_27 Vdout0_27ck62 = 0 time = 315
.meas tran vdout0_27ck62 FIND v(dout0_27) AT=315.025n

* CHECK dout0_28 Vdout0_28ck62 = 0.9 time = 315
.meas tran vdout0_28ck62 FIND v(dout0_28) AT=315.025n

* CHECK dout0_29 Vdout0_29ck62 = 0.9 time = 315
.meas tran vdout0_29ck62 FIND v(dout0_29) AT=315.025n

* CHECK dout0_30 Vdout0_30ck62 = 0.9 time = 315
.meas tran vdout0_30ck62 FIND v(dout0_30) AT=315.025n

* CHECK dout0_31 Vdout0_31ck62 = 0 time = 315
.meas tran vdout0_31ck62 FIND v(dout0_31) AT=315.025n

* CHECK dout0_32 Vdout0_32ck62 = 0.9 time = 315
.meas tran vdout0_32ck62 FIND v(dout0_32) AT=315.025n

* CHECK dout0_33 Vdout0_33ck62 = 0 time = 315
.meas tran vdout0_33ck62 FIND v(dout0_33) AT=315.025n

* CHECK dout0_34 Vdout0_34ck62 = 0 time = 315
.meas tran vdout0_34ck62 FIND v(dout0_34) AT=315.025n

* CHECK dout0_35 Vdout0_35ck62 = 0.9 time = 315
.meas tran vdout0_35ck62 FIND v(dout0_35) AT=315.025n

* CHECK dout0_36 Vdout0_36ck62 = 0 time = 315
.meas tran vdout0_36ck62 FIND v(dout0_36) AT=315.025n

* CHECK dout0_37 Vdout0_37ck62 = 0 time = 315
.meas tran vdout0_37ck62 FIND v(dout0_37) AT=315.025n

* CHECK dout0_38 Vdout0_38ck62 = 0 time = 315
.meas tran vdout0_38ck62 FIND v(dout0_38) AT=315.025n

* CHECK dout0_39 Vdout0_39ck62 = 0 time = 315
.meas tran vdout0_39ck62 FIND v(dout0_39) AT=315.025n

* CHECK dout0_0 Vdout0_0ck66 = 0 time = 335
.meas tran vdout0_0ck66 FIND v(dout0_0) AT=335.025n

* CHECK dout0_1 Vdout0_1ck66 = 0 time = 335
.meas tran vdout0_1ck66 FIND v(dout0_1) AT=335.025n

* CHECK dout0_2 Vdout0_2ck66 = 0 time = 335
.meas tran vdout0_2ck66 FIND v(dout0_2) AT=335.025n

* CHECK dout0_3 Vdout0_3ck66 = 0 time = 335
.meas tran vdout0_3ck66 FIND v(dout0_3) AT=335.025n

* CHECK dout0_4 Vdout0_4ck66 = 0 time = 335
.meas tran vdout0_4ck66 FIND v(dout0_4) AT=335.025n

* CHECK dout0_5 Vdout0_5ck66 = 0 time = 335
.meas tran vdout0_5ck66 FIND v(dout0_5) AT=335.025n

* CHECK dout0_6 Vdout0_6ck66 = 0 time = 335
.meas tran vdout0_6ck66 FIND v(dout0_6) AT=335.025n

* CHECK dout0_7 Vdout0_7ck66 = 0 time = 335
.meas tran vdout0_7ck66 FIND v(dout0_7) AT=335.025n

* CHECK dout0_8 Vdout0_8ck66 = 0 time = 335
.meas tran vdout0_8ck66 FIND v(dout0_8) AT=335.025n

* CHECK dout0_9 Vdout0_9ck66 = 0.9 time = 335
.meas tran vdout0_9ck66 FIND v(dout0_9) AT=335.025n

* CHECK dout0_10 Vdout0_10ck66 = 0 time = 335
.meas tran vdout0_10ck66 FIND v(dout0_10) AT=335.025n

* CHECK dout0_11 Vdout0_11ck66 = 0 time = 335
.meas tran vdout0_11ck66 FIND v(dout0_11) AT=335.025n

* CHECK dout0_12 Vdout0_12ck66 = 0.9 time = 335
.meas tran vdout0_12ck66 FIND v(dout0_12) AT=335.025n

* CHECK dout0_13 Vdout0_13ck66 = 0 time = 335
.meas tran vdout0_13ck66 FIND v(dout0_13) AT=335.025n

* CHECK dout0_14 Vdout0_14ck66 = 0 time = 335
.meas tran vdout0_14ck66 FIND v(dout0_14) AT=335.025n

* CHECK dout0_15 Vdout0_15ck66 = 0 time = 335
.meas tran vdout0_15ck66 FIND v(dout0_15) AT=335.025n

* CHECK dout0_16 Vdout0_16ck66 = 0 time = 335
.meas tran vdout0_16ck66 FIND v(dout0_16) AT=335.025n

* CHECK dout0_17 Vdout0_17ck66 = 0.9 time = 335
.meas tran vdout0_17ck66 FIND v(dout0_17) AT=335.025n

* CHECK dout0_18 Vdout0_18ck66 = 0 time = 335
.meas tran vdout0_18ck66 FIND v(dout0_18) AT=335.025n

* CHECK dout0_19 Vdout0_19ck66 = 0 time = 335
.meas tran vdout0_19ck66 FIND v(dout0_19) AT=335.025n

* CHECK dout0_20 Vdout0_20ck66 = 0.9 time = 335
.meas tran vdout0_20ck66 FIND v(dout0_20) AT=335.025n

* CHECK dout0_21 Vdout0_21ck66 = 0 time = 335
.meas tran vdout0_21ck66 FIND v(dout0_21) AT=335.025n

* CHECK dout0_22 Vdout0_22ck66 = 0.9 time = 335
.meas tran vdout0_22ck66 FIND v(dout0_22) AT=335.025n

* CHECK dout0_23 Vdout0_23ck66 = 0.9 time = 335
.meas tran vdout0_23ck66 FIND v(dout0_23) AT=335.025n

* CHECK dout0_24 Vdout0_24ck66 = 0.9 time = 335
.meas tran vdout0_24ck66 FIND v(dout0_24) AT=335.025n

* CHECK dout0_25 Vdout0_25ck66 = 0.9 time = 335
.meas tran vdout0_25ck66 FIND v(dout0_25) AT=335.025n

* CHECK dout0_26 Vdout0_26ck66 = 0.9 time = 335
.meas tran vdout0_26ck66 FIND v(dout0_26) AT=335.025n

* CHECK dout0_27 Vdout0_27ck66 = 0 time = 335
.meas tran vdout0_27ck66 FIND v(dout0_27) AT=335.025n

* CHECK dout0_28 Vdout0_28ck66 = 0.9 time = 335
.meas tran vdout0_28ck66 FIND v(dout0_28) AT=335.025n

* CHECK dout0_29 Vdout0_29ck66 = 0 time = 335
.meas tran vdout0_29ck66 FIND v(dout0_29) AT=335.025n

* CHECK dout0_30 Vdout0_30ck66 = 0.9 time = 335
.meas tran vdout0_30ck66 FIND v(dout0_30) AT=335.025n

* CHECK dout0_31 Vdout0_31ck66 = 0.9 time = 335
.meas tran vdout0_31ck66 FIND v(dout0_31) AT=335.025n

* CHECK dout0_32 Vdout0_32ck66 = 0 time = 335
.meas tran vdout0_32ck66 FIND v(dout0_32) AT=335.025n

* CHECK dout0_33 Vdout0_33ck66 = 0.9 time = 335
.meas tran vdout0_33ck66 FIND v(dout0_33) AT=335.025n

* CHECK dout0_34 Vdout0_34ck66 = 0.9 time = 335
.meas tran vdout0_34ck66 FIND v(dout0_34) AT=335.025n

* CHECK dout0_35 Vdout0_35ck66 = 0.9 time = 335
.meas tran vdout0_35ck66 FIND v(dout0_35) AT=335.025n

* CHECK dout0_36 Vdout0_36ck66 = 0.9 time = 335
.meas tran vdout0_36ck66 FIND v(dout0_36) AT=335.025n

* CHECK dout0_37 Vdout0_37ck66 = 0 time = 335
.meas tran vdout0_37ck66 FIND v(dout0_37) AT=335.025n

* CHECK dout0_38 Vdout0_38ck66 = 0 time = 335
.meas tran vdout0_38ck66 FIND v(dout0_38) AT=335.025n

* CHECK dout0_39 Vdout0_39ck66 = 0 time = 335
.meas tran vdout0_39ck66 FIND v(dout0_39) AT=335.025n

* CHECK dout0_0 Vdout0_0ck70 = 0 time = 355
.meas tran vdout0_0ck70 FIND v(dout0_0) AT=355.025n

* CHECK dout0_1 Vdout0_1ck70 = 0.9 time = 355
.meas tran vdout0_1ck70 FIND v(dout0_1) AT=355.025n

* CHECK dout0_2 Vdout0_2ck70 = 0 time = 355
.meas tran vdout0_2ck70 FIND v(dout0_2) AT=355.025n

* CHECK dout0_3 Vdout0_3ck70 = 0 time = 355
.meas tran vdout0_3ck70 FIND v(dout0_3) AT=355.025n

* CHECK dout0_4 Vdout0_4ck70 = 0 time = 355
.meas tran vdout0_4ck70 FIND v(dout0_4) AT=355.025n

* CHECK dout0_5 Vdout0_5ck70 = 0.9 time = 355
.meas tran vdout0_5ck70 FIND v(dout0_5) AT=355.025n

* CHECK dout0_6 Vdout0_6ck70 = 0 time = 355
.meas tran vdout0_6ck70 FIND v(dout0_6) AT=355.025n

* CHECK dout0_7 Vdout0_7ck70 = 0 time = 355
.meas tran vdout0_7ck70 FIND v(dout0_7) AT=355.025n

* CHECK dout0_8 Vdout0_8ck70 = 0.9 time = 355
.meas tran vdout0_8ck70 FIND v(dout0_8) AT=355.025n

* CHECK dout0_9 Vdout0_9ck70 = 0 time = 355
.meas tran vdout0_9ck70 FIND v(dout0_9) AT=355.025n

* CHECK dout0_10 Vdout0_10ck70 = 0 time = 355
.meas tran vdout0_10ck70 FIND v(dout0_10) AT=355.025n

* CHECK dout0_11 Vdout0_11ck70 = 0.9 time = 355
.meas tran vdout0_11ck70 FIND v(dout0_11) AT=355.025n

* CHECK dout0_12 Vdout0_12ck70 = 0 time = 355
.meas tran vdout0_12ck70 FIND v(dout0_12) AT=355.025n

* CHECK dout0_13 Vdout0_13ck70 = 0 time = 355
.meas tran vdout0_13ck70 FIND v(dout0_13) AT=355.025n

* CHECK dout0_14 Vdout0_14ck70 = 0.9 time = 355
.meas tran vdout0_14ck70 FIND v(dout0_14) AT=355.025n

* CHECK dout0_15 Vdout0_15ck70 = 0 time = 355
.meas tran vdout0_15ck70 FIND v(dout0_15) AT=355.025n

* CHECK dout0_16 Vdout0_16ck70 = 0.9 time = 355
.meas tran vdout0_16ck70 FIND v(dout0_16) AT=355.025n

* CHECK dout0_17 Vdout0_17ck70 = 0.9 time = 355
.meas tran vdout0_17ck70 FIND v(dout0_17) AT=355.025n

* CHECK dout0_18 Vdout0_18ck70 = 0.9 time = 355
.meas tran vdout0_18ck70 FIND v(dout0_18) AT=355.025n

* CHECK dout0_19 Vdout0_19ck70 = 0.9 time = 355
.meas tran vdout0_19ck70 FIND v(dout0_19) AT=355.025n

* CHECK dout0_20 Vdout0_20ck70 = 0 time = 355
.meas tran vdout0_20ck70 FIND v(dout0_20) AT=355.025n

* CHECK dout0_21 Vdout0_21ck70 = 0 time = 355
.meas tran vdout0_21ck70 FIND v(dout0_21) AT=355.025n

* CHECK dout0_22 Vdout0_22ck70 = 0 time = 355
.meas tran vdout0_22ck70 FIND v(dout0_22) AT=355.025n

* CHECK dout0_23 Vdout0_23ck70 = 0 time = 355
.meas tran vdout0_23ck70 FIND v(dout0_23) AT=355.025n

* CHECK dout0_24 Vdout0_24ck70 = 0 time = 355
.meas tran vdout0_24ck70 FIND v(dout0_24) AT=355.025n

* CHECK dout0_25 Vdout0_25ck70 = 0.9 time = 355
.meas tran vdout0_25ck70 FIND v(dout0_25) AT=355.025n

* CHECK dout0_26 Vdout0_26ck70 = 0 time = 355
.meas tran vdout0_26ck70 FIND v(dout0_26) AT=355.025n

* CHECK dout0_27 Vdout0_27ck70 = 0.9 time = 355
.meas tran vdout0_27ck70 FIND v(dout0_27) AT=355.025n

* CHECK dout0_28 Vdout0_28ck70 = 0.9 time = 355
.meas tran vdout0_28ck70 FIND v(dout0_28) AT=355.025n

* CHECK dout0_29 Vdout0_29ck70 = 0 time = 355
.meas tran vdout0_29ck70 FIND v(dout0_29) AT=355.025n

* CHECK dout0_30 Vdout0_30ck70 = 0.9 time = 355
.meas tran vdout0_30ck70 FIND v(dout0_30) AT=355.025n

* CHECK dout0_31 Vdout0_31ck70 = 0.9 time = 355
.meas tran vdout0_31ck70 FIND v(dout0_31) AT=355.025n

* CHECK dout0_32 Vdout0_32ck70 = 0 time = 355
.meas tran vdout0_32ck70 FIND v(dout0_32) AT=355.025n

* CHECK dout0_33 Vdout0_33ck70 = 0 time = 355
.meas tran vdout0_33ck70 FIND v(dout0_33) AT=355.025n

* CHECK dout0_34 Vdout0_34ck70 = 0 time = 355
.meas tran vdout0_34ck70 FIND v(dout0_34) AT=355.025n

* CHECK dout0_35 Vdout0_35ck70 = 0.9 time = 355
.meas tran vdout0_35ck70 FIND v(dout0_35) AT=355.025n

* CHECK dout0_36 Vdout0_36ck70 = 0.9 time = 355
.meas tran vdout0_36ck70 FIND v(dout0_36) AT=355.025n

* CHECK dout0_37 Vdout0_37ck70 = 0 time = 355
.meas tran vdout0_37ck70 FIND v(dout0_37) AT=355.025n

* CHECK dout0_38 Vdout0_38ck70 = 0 time = 355
.meas tran vdout0_38ck70 FIND v(dout0_38) AT=355.025n

* CHECK dout0_39 Vdout0_39ck70 = 0 time = 355
.meas tran vdout0_39ck70 FIND v(dout0_39) AT=355.025n

* CHECK dout0_0 Vdout0_0ck71 = 0.9 time = 360
.meas tran vdout0_0ck71 FIND v(dout0_0) AT=360.025n

* CHECK dout0_1 Vdout0_1ck71 = 0.9 time = 360
.meas tran vdout0_1ck71 FIND v(dout0_1) AT=360.025n

* CHECK dout0_2 Vdout0_2ck71 = 0 time = 360
.meas tran vdout0_2ck71 FIND v(dout0_2) AT=360.025n

* CHECK dout0_3 Vdout0_3ck71 = 0 time = 360
.meas tran vdout0_3ck71 FIND v(dout0_3) AT=360.025n

* CHECK dout0_4 Vdout0_4ck71 = 0.9 time = 360
.meas tran vdout0_4ck71 FIND v(dout0_4) AT=360.025n

* CHECK dout0_5 Vdout0_5ck71 = 0 time = 360
.meas tran vdout0_5ck71 FIND v(dout0_5) AT=360.025n

* CHECK dout0_6 Vdout0_6ck71 = 0.9 time = 360
.meas tran vdout0_6ck71 FIND v(dout0_6) AT=360.025n

* CHECK dout0_7 Vdout0_7ck71 = 0 time = 360
.meas tran vdout0_7ck71 FIND v(dout0_7) AT=360.025n

* CHECK dout0_8 Vdout0_8ck71 = 0 time = 360
.meas tran vdout0_8ck71 FIND v(dout0_8) AT=360.025n

* CHECK dout0_9 Vdout0_9ck71 = 0 time = 360
.meas tran vdout0_9ck71 FIND v(dout0_9) AT=360.025n

* CHECK dout0_10 Vdout0_10ck71 = 0 time = 360
.meas tran vdout0_10ck71 FIND v(dout0_10) AT=360.025n

* CHECK dout0_11 Vdout0_11ck71 = 0.9 time = 360
.meas tran vdout0_11ck71 FIND v(dout0_11) AT=360.025n

* CHECK dout0_12 Vdout0_12ck71 = 0 time = 360
.meas tran vdout0_12ck71 FIND v(dout0_12) AT=360.025n

* CHECK dout0_13 Vdout0_13ck71 = 0 time = 360
.meas tran vdout0_13ck71 FIND v(dout0_13) AT=360.025n

* CHECK dout0_14 Vdout0_14ck71 = 0.9 time = 360
.meas tran vdout0_14ck71 FIND v(dout0_14) AT=360.025n

* CHECK dout0_15 Vdout0_15ck71 = 0.9 time = 360
.meas tran vdout0_15ck71 FIND v(dout0_15) AT=360.025n

* CHECK dout0_16 Vdout0_16ck71 = 0 time = 360
.meas tran vdout0_16ck71 FIND v(dout0_16) AT=360.025n

* CHECK dout0_17 Vdout0_17ck71 = 0 time = 360
.meas tran vdout0_17ck71 FIND v(dout0_17) AT=360.025n

* CHECK dout0_18 Vdout0_18ck71 = 0 time = 360
.meas tran vdout0_18ck71 FIND v(dout0_18) AT=360.025n

* CHECK dout0_19 Vdout0_19ck71 = 0.9 time = 360
.meas tran vdout0_19ck71 FIND v(dout0_19) AT=360.025n

* CHECK dout0_20 Vdout0_20ck71 = 0.9 time = 360
.meas tran vdout0_20ck71 FIND v(dout0_20) AT=360.025n

* CHECK dout0_21 Vdout0_21ck71 = 0.9 time = 360
.meas tran vdout0_21ck71 FIND v(dout0_21) AT=360.025n

* CHECK dout0_22 Vdout0_22ck71 = 0.9 time = 360
.meas tran vdout0_22ck71 FIND v(dout0_22) AT=360.025n

* CHECK dout0_23 Vdout0_23ck71 = 0 time = 360
.meas tran vdout0_23ck71 FIND v(dout0_23) AT=360.025n

* CHECK dout0_24 Vdout0_24ck71 = 0.9 time = 360
.meas tran vdout0_24ck71 FIND v(dout0_24) AT=360.025n

* CHECK dout0_25 Vdout0_25ck71 = 0 time = 360
.meas tran vdout0_25ck71 FIND v(dout0_25) AT=360.025n

* CHECK dout0_26 Vdout0_26ck71 = 0.9 time = 360
.meas tran vdout0_26ck71 FIND v(dout0_26) AT=360.025n

* CHECK dout0_27 Vdout0_27ck71 = 0 time = 360
.meas tran vdout0_27ck71 FIND v(dout0_27) AT=360.025n

* CHECK dout0_28 Vdout0_28ck71 = 0.9 time = 360
.meas tran vdout0_28ck71 FIND v(dout0_28) AT=360.025n

* CHECK dout0_29 Vdout0_29ck71 = 0.9 time = 360
.meas tran vdout0_29ck71 FIND v(dout0_29) AT=360.025n

* CHECK dout0_30 Vdout0_30ck71 = 0.9 time = 360
.meas tran vdout0_30ck71 FIND v(dout0_30) AT=360.025n

* CHECK dout0_31 Vdout0_31ck71 = 0.9 time = 360
.meas tran vdout0_31ck71 FIND v(dout0_31) AT=360.025n

* CHECK dout0_32 Vdout0_32ck71 = 0.9 time = 360
.meas tran vdout0_32ck71 FIND v(dout0_32) AT=360.025n

* CHECK dout0_33 Vdout0_33ck71 = 0.9 time = 360
.meas tran vdout0_33ck71 FIND v(dout0_33) AT=360.025n

* CHECK dout0_34 Vdout0_34ck71 = 0.9 time = 360
.meas tran vdout0_34ck71 FIND v(dout0_34) AT=360.025n

* CHECK dout0_35 Vdout0_35ck71 = 0 time = 360
.meas tran vdout0_35ck71 FIND v(dout0_35) AT=360.025n

* CHECK dout0_36 Vdout0_36ck71 = 0 time = 360
.meas tran vdout0_36ck71 FIND v(dout0_36) AT=360.025n

* CHECK dout0_37 Vdout0_37ck71 = 0 time = 360
.meas tran vdout0_37ck71 FIND v(dout0_37) AT=360.025n

* CHECK dout0_38 Vdout0_38ck71 = 0.9 time = 360
.meas tran vdout0_38ck71 FIND v(dout0_38) AT=360.025n

* CHECK dout0_39 Vdout0_39ck71 = 0.9 time = 360
.meas tran vdout0_39ck71 FIND v(dout0_39) AT=360.025n

* CHECK dout0_0 Vdout0_0ck75 = 0 time = 380
.meas tran vdout0_0ck75 FIND v(dout0_0) AT=380.025n

* CHECK dout0_1 Vdout0_1ck75 = 0 time = 380
.meas tran vdout0_1ck75 FIND v(dout0_1) AT=380.025n

* CHECK dout0_2 Vdout0_2ck75 = 0.9 time = 380
.meas tran vdout0_2ck75 FIND v(dout0_2) AT=380.025n

* CHECK dout0_3 Vdout0_3ck75 = 0 time = 380
.meas tran vdout0_3ck75 FIND v(dout0_3) AT=380.025n

* CHECK dout0_4 Vdout0_4ck75 = 0.9 time = 380
.meas tran vdout0_4ck75 FIND v(dout0_4) AT=380.025n

* CHECK dout0_5 Vdout0_5ck75 = 0.9 time = 380
.meas tran vdout0_5ck75 FIND v(dout0_5) AT=380.025n

* CHECK dout0_6 Vdout0_6ck75 = 0.9 time = 380
.meas tran vdout0_6ck75 FIND v(dout0_6) AT=380.025n

* CHECK dout0_7 Vdout0_7ck75 = 0 time = 380
.meas tran vdout0_7ck75 FIND v(dout0_7) AT=380.025n

* CHECK dout0_8 Vdout0_8ck75 = 0 time = 380
.meas tran vdout0_8ck75 FIND v(dout0_8) AT=380.025n

* CHECK dout0_9 Vdout0_9ck75 = 0 time = 380
.meas tran vdout0_9ck75 FIND v(dout0_9) AT=380.025n

* CHECK dout0_10 Vdout0_10ck75 = 0.9 time = 380
.meas tran vdout0_10ck75 FIND v(dout0_10) AT=380.025n

* CHECK dout0_11 Vdout0_11ck75 = 0 time = 380
.meas tran vdout0_11ck75 FIND v(dout0_11) AT=380.025n

* CHECK dout0_12 Vdout0_12ck75 = 0 time = 380
.meas tran vdout0_12ck75 FIND v(dout0_12) AT=380.025n

* CHECK dout0_13 Vdout0_13ck75 = 0.9 time = 380
.meas tran vdout0_13ck75 FIND v(dout0_13) AT=380.025n

* CHECK dout0_14 Vdout0_14ck75 = 0 time = 380
.meas tran vdout0_14ck75 FIND v(dout0_14) AT=380.025n

* CHECK dout0_15 Vdout0_15ck75 = 0 time = 380
.meas tran vdout0_15ck75 FIND v(dout0_15) AT=380.025n

* CHECK dout0_16 Vdout0_16ck75 = 0 time = 380
.meas tran vdout0_16ck75 FIND v(dout0_16) AT=380.025n

* CHECK dout0_17 Vdout0_17ck75 = 0 time = 380
.meas tran vdout0_17ck75 FIND v(dout0_17) AT=380.025n

* CHECK dout0_18 Vdout0_18ck75 = 0 time = 380
.meas tran vdout0_18ck75 FIND v(dout0_18) AT=380.025n

* CHECK dout0_19 Vdout0_19ck75 = 0 time = 380
.meas tran vdout0_19ck75 FIND v(dout0_19) AT=380.025n

* CHECK dout0_20 Vdout0_20ck75 = 0.9 time = 380
.meas tran vdout0_20ck75 FIND v(dout0_20) AT=380.025n

* CHECK dout0_21 Vdout0_21ck75 = 0.9 time = 380
.meas tran vdout0_21ck75 FIND v(dout0_21) AT=380.025n

* CHECK dout0_22 Vdout0_22ck75 = 0 time = 380
.meas tran vdout0_22ck75 FIND v(dout0_22) AT=380.025n

* CHECK dout0_23 Vdout0_23ck75 = 0 time = 380
.meas tran vdout0_23ck75 FIND v(dout0_23) AT=380.025n

* CHECK dout0_24 Vdout0_24ck75 = 0.9 time = 380
.meas tran vdout0_24ck75 FIND v(dout0_24) AT=380.025n

* CHECK dout0_25 Vdout0_25ck75 = 0.9 time = 380
.meas tran vdout0_25ck75 FIND v(dout0_25) AT=380.025n

* CHECK dout0_26 Vdout0_26ck75 = 0 time = 380
.meas tran vdout0_26ck75 FIND v(dout0_26) AT=380.025n

* CHECK dout0_27 Vdout0_27ck75 = 0 time = 380
.meas tran vdout0_27ck75 FIND v(dout0_27) AT=380.025n

* CHECK dout0_28 Vdout0_28ck75 = 0 time = 380
.meas tran vdout0_28ck75 FIND v(dout0_28) AT=380.025n

* CHECK dout0_29 Vdout0_29ck75 = 0.9 time = 380
.meas tran vdout0_29ck75 FIND v(dout0_29) AT=380.025n

* CHECK dout0_30 Vdout0_30ck75 = 0.9 time = 380
.meas tran vdout0_30ck75 FIND v(dout0_30) AT=380.025n

* CHECK dout0_31 Vdout0_31ck75 = 0.9 time = 380
.meas tran vdout0_31ck75 FIND v(dout0_31) AT=380.025n

* CHECK dout0_32 Vdout0_32ck75 = 0 time = 380
.meas tran vdout0_32ck75 FIND v(dout0_32) AT=380.025n

* CHECK dout0_33 Vdout0_33ck75 = 0.9 time = 380
.meas tran vdout0_33ck75 FIND v(dout0_33) AT=380.025n

* CHECK dout0_34 Vdout0_34ck75 = 0.9 time = 380
.meas tran vdout0_34ck75 FIND v(dout0_34) AT=380.025n

* CHECK dout0_35 Vdout0_35ck75 = 0.9 time = 380
.meas tran vdout0_35ck75 FIND v(dout0_35) AT=380.025n

* CHECK dout0_36 Vdout0_36ck75 = 0.9 time = 380
.meas tran vdout0_36ck75 FIND v(dout0_36) AT=380.025n

* CHECK dout0_37 Vdout0_37ck75 = 0 time = 380
.meas tran vdout0_37ck75 FIND v(dout0_37) AT=380.025n

* CHECK dout0_38 Vdout0_38ck75 = 0.9 time = 380
.meas tran vdout0_38ck75 FIND v(dout0_38) AT=380.025n

* CHECK dout0_39 Vdout0_39ck75 = 0 time = 380
.meas tran vdout0_39ck75 FIND v(dout0_39) AT=380.025n

* CHECK dout0_0 Vdout0_0ck79 = 0 time = 400
.meas tran vdout0_0ck79 FIND v(dout0_0) AT=400.025n

* CHECK dout0_1 Vdout0_1ck79 = 0 time = 400
.meas tran vdout0_1ck79 FIND v(dout0_1) AT=400.025n

* CHECK dout0_2 Vdout0_2ck79 = 0 time = 400
.meas tran vdout0_2ck79 FIND v(dout0_2) AT=400.025n

* CHECK dout0_3 Vdout0_3ck79 = 0 time = 400
.meas tran vdout0_3ck79 FIND v(dout0_3) AT=400.025n

* CHECK dout0_4 Vdout0_4ck79 = 0 time = 400
.meas tran vdout0_4ck79 FIND v(dout0_4) AT=400.025n

* CHECK dout0_5 Vdout0_5ck79 = 0.9 time = 400
.meas tran vdout0_5ck79 FIND v(dout0_5) AT=400.025n

* CHECK dout0_6 Vdout0_6ck79 = 0 time = 400
.meas tran vdout0_6ck79 FIND v(dout0_6) AT=400.025n

* CHECK dout0_7 Vdout0_7ck79 = 0.9 time = 400
.meas tran vdout0_7ck79 FIND v(dout0_7) AT=400.025n

* CHECK dout0_8 Vdout0_8ck79 = 0.9 time = 400
.meas tran vdout0_8ck79 FIND v(dout0_8) AT=400.025n

* CHECK dout0_9 Vdout0_9ck79 = 0.9 time = 400
.meas tran vdout0_9ck79 FIND v(dout0_9) AT=400.025n

* CHECK dout0_10 Vdout0_10ck79 = 0 time = 400
.meas tran vdout0_10ck79 FIND v(dout0_10) AT=400.025n

* CHECK dout0_11 Vdout0_11ck79 = 0 time = 400
.meas tran vdout0_11ck79 FIND v(dout0_11) AT=400.025n

* CHECK dout0_12 Vdout0_12ck79 = 0 time = 400
.meas tran vdout0_12ck79 FIND v(dout0_12) AT=400.025n

* CHECK dout0_13 Vdout0_13ck79 = 0 time = 400
.meas tran vdout0_13ck79 FIND v(dout0_13) AT=400.025n

* CHECK dout0_14 Vdout0_14ck79 = 0.9 time = 400
.meas tran vdout0_14ck79 FIND v(dout0_14) AT=400.025n

* CHECK dout0_15 Vdout0_15ck79 = 0.9 time = 400
.meas tran vdout0_15ck79 FIND v(dout0_15) AT=400.025n

* CHECK dout0_16 Vdout0_16ck79 = 0 time = 400
.meas tran vdout0_16ck79 FIND v(dout0_16) AT=400.025n

* CHECK dout0_17 Vdout0_17ck79 = 0 time = 400
.meas tran vdout0_17ck79 FIND v(dout0_17) AT=400.025n

* CHECK dout0_18 Vdout0_18ck79 = 0 time = 400
.meas tran vdout0_18ck79 FIND v(dout0_18) AT=400.025n

* CHECK dout0_19 Vdout0_19ck79 = 0 time = 400
.meas tran vdout0_19ck79 FIND v(dout0_19) AT=400.025n

* CHECK dout0_20 Vdout0_20ck79 = 0 time = 400
.meas tran vdout0_20ck79 FIND v(dout0_20) AT=400.025n

* CHECK dout0_21 Vdout0_21ck79 = 0.9 time = 400
.meas tran vdout0_21ck79 FIND v(dout0_21) AT=400.025n

* CHECK dout0_22 Vdout0_22ck79 = 0 time = 400
.meas tran vdout0_22ck79 FIND v(dout0_22) AT=400.025n

* CHECK dout0_23 Vdout0_23ck79 = 0.9 time = 400
.meas tran vdout0_23ck79 FIND v(dout0_23) AT=400.025n

* CHECK dout0_24 Vdout0_24ck79 = 0.9 time = 400
.meas tran vdout0_24ck79 FIND v(dout0_24) AT=400.025n

* CHECK dout0_25 Vdout0_25ck79 = 0.9 time = 400
.meas tran vdout0_25ck79 FIND v(dout0_25) AT=400.025n

* CHECK dout0_26 Vdout0_26ck79 = 0.9 time = 400
.meas tran vdout0_26ck79 FIND v(dout0_26) AT=400.025n

* CHECK dout0_27 Vdout0_27ck79 = 0 time = 400
.meas tran vdout0_27ck79 FIND v(dout0_27) AT=400.025n

* CHECK dout0_28 Vdout0_28ck79 = 0 time = 400
.meas tran vdout0_28ck79 FIND v(dout0_28) AT=400.025n

* CHECK dout0_29 Vdout0_29ck79 = 0 time = 400
.meas tran vdout0_29ck79 FIND v(dout0_29) AT=400.025n

* CHECK dout0_30 Vdout0_30ck79 = 0.9 time = 400
.meas tran vdout0_30ck79 FIND v(dout0_30) AT=400.025n

* CHECK dout0_31 Vdout0_31ck79 = 0 time = 400
.meas tran vdout0_31ck79 FIND v(dout0_31) AT=400.025n

* CHECK dout0_32 Vdout0_32ck79 = 0 time = 400
.meas tran vdout0_32ck79 FIND v(dout0_32) AT=400.025n

* CHECK dout0_33 Vdout0_33ck79 = 0.9 time = 400
.meas tran vdout0_33ck79 FIND v(dout0_33) AT=400.025n

* CHECK dout0_34 Vdout0_34ck79 = 0 time = 400
.meas tran vdout0_34ck79 FIND v(dout0_34) AT=400.025n

* CHECK dout0_35 Vdout0_35ck79 = 0.9 time = 400
.meas tran vdout0_35ck79 FIND v(dout0_35) AT=400.025n

* CHECK dout0_36 Vdout0_36ck79 = 0.9 time = 400
.meas tran vdout0_36ck79 FIND v(dout0_36) AT=400.025n

* CHECK dout0_37 Vdout0_37ck79 = 0.9 time = 400
.meas tran vdout0_37ck79 FIND v(dout0_37) AT=400.025n

* CHECK dout0_38 Vdout0_38ck79 = 0.9 time = 400
.meas tran vdout0_38ck79 FIND v(dout0_38) AT=400.025n

* CHECK dout0_39 Vdout0_39ck79 = 0 time = 400
.meas tran vdout0_39ck79 FIND v(dout0_39) AT=400.025n

* CHECK dout0_0 Vdout0_0ck80 = 0 time = 405
.meas tran vdout0_0ck80 FIND v(dout0_0) AT=405.025n

* CHECK dout0_1 Vdout0_1ck80 = 0 time = 405
.meas tran vdout0_1ck80 FIND v(dout0_1) AT=405.025n

* CHECK dout0_2 Vdout0_2ck80 = 0 time = 405
.meas tran vdout0_2ck80 FIND v(dout0_2) AT=405.025n

* CHECK dout0_3 Vdout0_3ck80 = 0 time = 405
.meas tran vdout0_3ck80 FIND v(dout0_3) AT=405.025n

* CHECK dout0_4 Vdout0_4ck80 = 0 time = 405
.meas tran vdout0_4ck80 FIND v(dout0_4) AT=405.025n

* CHECK dout0_5 Vdout0_5ck80 = 0.9 time = 405
.meas tran vdout0_5ck80 FIND v(dout0_5) AT=405.025n

* CHECK dout0_6 Vdout0_6ck80 = 0 time = 405
.meas tran vdout0_6ck80 FIND v(dout0_6) AT=405.025n

* CHECK dout0_7 Vdout0_7ck80 = 0.9 time = 405
.meas tran vdout0_7ck80 FIND v(dout0_7) AT=405.025n

* CHECK dout0_8 Vdout0_8ck80 = 0.9 time = 405
.meas tran vdout0_8ck80 FIND v(dout0_8) AT=405.025n

* CHECK dout0_9 Vdout0_9ck80 = 0.9 time = 405
.meas tran vdout0_9ck80 FIND v(dout0_9) AT=405.025n

* CHECK dout0_10 Vdout0_10ck80 = 0 time = 405
.meas tran vdout0_10ck80 FIND v(dout0_10) AT=405.025n

* CHECK dout0_11 Vdout0_11ck80 = 0 time = 405
.meas tran vdout0_11ck80 FIND v(dout0_11) AT=405.025n

* CHECK dout0_12 Vdout0_12ck80 = 0 time = 405
.meas tran vdout0_12ck80 FIND v(dout0_12) AT=405.025n

* CHECK dout0_13 Vdout0_13ck80 = 0 time = 405
.meas tran vdout0_13ck80 FIND v(dout0_13) AT=405.025n

* CHECK dout0_14 Vdout0_14ck80 = 0.9 time = 405
.meas tran vdout0_14ck80 FIND v(dout0_14) AT=405.025n

* CHECK dout0_15 Vdout0_15ck80 = 0.9 time = 405
.meas tran vdout0_15ck80 FIND v(dout0_15) AT=405.025n

* CHECK dout0_16 Vdout0_16ck80 = 0 time = 405
.meas tran vdout0_16ck80 FIND v(dout0_16) AT=405.025n

* CHECK dout0_17 Vdout0_17ck80 = 0 time = 405
.meas tran vdout0_17ck80 FIND v(dout0_17) AT=405.025n

* CHECK dout0_18 Vdout0_18ck80 = 0 time = 405
.meas tran vdout0_18ck80 FIND v(dout0_18) AT=405.025n

* CHECK dout0_19 Vdout0_19ck80 = 0 time = 405
.meas tran vdout0_19ck80 FIND v(dout0_19) AT=405.025n

* CHECK dout0_20 Vdout0_20ck80 = 0 time = 405
.meas tran vdout0_20ck80 FIND v(dout0_20) AT=405.025n

* CHECK dout0_21 Vdout0_21ck80 = 0.9 time = 405
.meas tran vdout0_21ck80 FIND v(dout0_21) AT=405.025n

* CHECK dout0_22 Vdout0_22ck80 = 0 time = 405
.meas tran vdout0_22ck80 FIND v(dout0_22) AT=405.025n

* CHECK dout0_23 Vdout0_23ck80 = 0.9 time = 405
.meas tran vdout0_23ck80 FIND v(dout0_23) AT=405.025n

* CHECK dout0_24 Vdout0_24ck80 = 0.9 time = 405
.meas tran vdout0_24ck80 FIND v(dout0_24) AT=405.025n

* CHECK dout0_25 Vdout0_25ck80 = 0.9 time = 405
.meas tran vdout0_25ck80 FIND v(dout0_25) AT=405.025n

* CHECK dout0_26 Vdout0_26ck80 = 0.9 time = 405
.meas tran vdout0_26ck80 FIND v(dout0_26) AT=405.025n

* CHECK dout0_27 Vdout0_27ck80 = 0 time = 405
.meas tran vdout0_27ck80 FIND v(dout0_27) AT=405.025n

* CHECK dout0_28 Vdout0_28ck80 = 0 time = 405
.meas tran vdout0_28ck80 FIND v(dout0_28) AT=405.025n

* CHECK dout0_29 Vdout0_29ck80 = 0 time = 405
.meas tran vdout0_29ck80 FIND v(dout0_29) AT=405.025n

* CHECK dout0_30 Vdout0_30ck80 = 0.9 time = 405
.meas tran vdout0_30ck80 FIND v(dout0_30) AT=405.025n

* CHECK dout0_31 Vdout0_31ck80 = 0 time = 405
.meas tran vdout0_31ck80 FIND v(dout0_31) AT=405.025n

* CHECK dout0_32 Vdout0_32ck80 = 0 time = 405
.meas tran vdout0_32ck80 FIND v(dout0_32) AT=405.025n

* CHECK dout0_33 Vdout0_33ck80 = 0.9 time = 405
.meas tran vdout0_33ck80 FIND v(dout0_33) AT=405.025n

* CHECK dout0_34 Vdout0_34ck80 = 0 time = 405
.meas tran vdout0_34ck80 FIND v(dout0_34) AT=405.025n

* CHECK dout0_35 Vdout0_35ck80 = 0.9 time = 405
.meas tran vdout0_35ck80 FIND v(dout0_35) AT=405.025n

* CHECK dout0_36 Vdout0_36ck80 = 0.9 time = 405
.meas tran vdout0_36ck80 FIND v(dout0_36) AT=405.025n

* CHECK dout0_37 Vdout0_37ck80 = 0.9 time = 405
.meas tran vdout0_37ck80 FIND v(dout0_37) AT=405.025n

* CHECK dout0_38 Vdout0_38ck80 = 0.9 time = 405
.meas tran vdout0_38ck80 FIND v(dout0_38) AT=405.025n

* CHECK dout0_39 Vdout0_39ck80 = 0 time = 405
.meas tran vdout0_39ck80 FIND v(dout0_39) AT=405.025n

* CHECK dout0_0 Vdout0_0ck81 = 0 time = 410
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=410.025n

* CHECK dout0_1 Vdout0_1ck81 = 0 time = 410
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=410.025n

* CHECK dout0_2 Vdout0_2ck81 = 0 time = 410
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=410.025n

* CHECK dout0_3 Vdout0_3ck81 = 0 time = 410
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=410.025n

* CHECK dout0_4 Vdout0_4ck81 = 0 time = 410
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=410.025n

* CHECK dout0_5 Vdout0_5ck81 = 0 time = 410
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=410.025n

* CHECK dout0_6 Vdout0_6ck81 = 0 time = 410
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=410.025n

* CHECK dout0_7 Vdout0_7ck81 = 0 time = 410
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=410.025n

* CHECK dout0_8 Vdout0_8ck81 = 0 time = 410
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=410.025n

* CHECK dout0_9 Vdout0_9ck81 = 0.9 time = 410
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=410.025n

* CHECK dout0_10 Vdout0_10ck81 = 0 time = 410
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=410.025n

* CHECK dout0_11 Vdout0_11ck81 = 0 time = 410
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=410.025n

* CHECK dout0_12 Vdout0_12ck81 = 0.9 time = 410
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=410.025n

* CHECK dout0_13 Vdout0_13ck81 = 0 time = 410
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=410.025n

* CHECK dout0_14 Vdout0_14ck81 = 0 time = 410
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=410.025n

* CHECK dout0_15 Vdout0_15ck81 = 0 time = 410
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=410.025n

* CHECK dout0_16 Vdout0_16ck81 = 0 time = 410
.meas tran vdout0_16ck81 FIND v(dout0_16) AT=410.025n

* CHECK dout0_17 Vdout0_17ck81 = 0.9 time = 410
.meas tran vdout0_17ck81 FIND v(dout0_17) AT=410.025n

* CHECK dout0_18 Vdout0_18ck81 = 0 time = 410
.meas tran vdout0_18ck81 FIND v(dout0_18) AT=410.025n

* CHECK dout0_19 Vdout0_19ck81 = 0 time = 410
.meas tran vdout0_19ck81 FIND v(dout0_19) AT=410.025n

* CHECK dout0_20 Vdout0_20ck81 = 0 time = 410
.meas tran vdout0_20ck81 FIND v(dout0_20) AT=410.025n

* CHECK dout0_21 Vdout0_21ck81 = 0 time = 410
.meas tran vdout0_21ck81 FIND v(dout0_21) AT=410.025n

* CHECK dout0_22 Vdout0_22ck81 = 0 time = 410
.meas tran vdout0_22ck81 FIND v(dout0_22) AT=410.025n

* CHECK dout0_23 Vdout0_23ck81 = 0.9 time = 410
.meas tran vdout0_23ck81 FIND v(dout0_23) AT=410.025n

* CHECK dout0_24 Vdout0_24ck81 = 0.9 time = 410
.meas tran vdout0_24ck81 FIND v(dout0_24) AT=410.025n

* CHECK dout0_25 Vdout0_25ck81 = 0.9 time = 410
.meas tran vdout0_25ck81 FIND v(dout0_25) AT=410.025n

* CHECK dout0_26 Vdout0_26ck81 = 0 time = 410
.meas tran vdout0_26ck81 FIND v(dout0_26) AT=410.025n

* CHECK dout0_27 Vdout0_27ck81 = 0.9 time = 410
.meas tran vdout0_27ck81 FIND v(dout0_27) AT=410.025n

* CHECK dout0_28 Vdout0_28ck81 = 0.9 time = 410
.meas tran vdout0_28ck81 FIND v(dout0_28) AT=410.025n

* CHECK dout0_29 Vdout0_29ck81 = 0 time = 410
.meas tran vdout0_29ck81 FIND v(dout0_29) AT=410.025n

* CHECK dout0_30 Vdout0_30ck81 = 0 time = 410
.meas tran vdout0_30ck81 FIND v(dout0_30) AT=410.025n

* CHECK dout0_31 Vdout0_31ck81 = 0 time = 410
.meas tran vdout0_31ck81 FIND v(dout0_31) AT=410.025n

* CHECK dout0_32 Vdout0_32ck81 = 0 time = 410
.meas tran vdout0_32ck81 FIND v(dout0_32) AT=410.025n

* CHECK dout0_33 Vdout0_33ck81 = 0 time = 410
.meas tran vdout0_33ck81 FIND v(dout0_33) AT=410.025n

* CHECK dout0_34 Vdout0_34ck81 = 0 time = 410
.meas tran vdout0_34ck81 FIND v(dout0_34) AT=410.025n

* CHECK dout0_35 Vdout0_35ck81 = 0 time = 410
.meas tran vdout0_35ck81 FIND v(dout0_35) AT=410.025n

* CHECK dout0_36 Vdout0_36ck81 = 0.9 time = 410
.meas tran vdout0_36ck81 FIND v(dout0_36) AT=410.025n

* CHECK dout0_37 Vdout0_37ck81 = 0 time = 410
.meas tran vdout0_37ck81 FIND v(dout0_37) AT=410.025n

* CHECK dout0_38 Vdout0_38ck81 = 0.9 time = 410
.meas tran vdout0_38ck81 FIND v(dout0_38) AT=410.025n

* CHECK dout0_39 Vdout0_39ck81 = 0.9 time = 410
.meas tran vdout0_39ck81 FIND v(dout0_39) AT=410.025n

* CHECK dout0_0 Vdout0_0ck86 = 0 time = 435
.meas tran vdout0_0ck86 FIND v(dout0_0) AT=435.025n

* CHECK dout0_1 Vdout0_1ck86 = 0 time = 435
.meas tran vdout0_1ck86 FIND v(dout0_1) AT=435.025n

* CHECK dout0_2 Vdout0_2ck86 = 0.9 time = 435
.meas tran vdout0_2ck86 FIND v(dout0_2) AT=435.025n

* CHECK dout0_3 Vdout0_3ck86 = 0 time = 435
.meas tran vdout0_3ck86 FIND v(dout0_3) AT=435.025n

* CHECK dout0_4 Vdout0_4ck86 = 0.9 time = 435
.meas tran vdout0_4ck86 FIND v(dout0_4) AT=435.025n

* CHECK dout0_5 Vdout0_5ck86 = 0.9 time = 435
.meas tran vdout0_5ck86 FIND v(dout0_5) AT=435.025n

* CHECK dout0_6 Vdout0_6ck86 = 0 time = 435
.meas tran vdout0_6ck86 FIND v(dout0_6) AT=435.025n

* CHECK dout0_7 Vdout0_7ck86 = 0 time = 435
.meas tran vdout0_7ck86 FIND v(dout0_7) AT=435.025n

* CHECK dout0_8 Vdout0_8ck86 = 0 time = 435
.meas tran vdout0_8ck86 FIND v(dout0_8) AT=435.025n

* CHECK dout0_9 Vdout0_9ck86 = 0 time = 435
.meas tran vdout0_9ck86 FIND v(dout0_9) AT=435.025n

* CHECK dout0_10 Vdout0_10ck86 = 0.9 time = 435
.meas tran vdout0_10ck86 FIND v(dout0_10) AT=435.025n

* CHECK dout0_11 Vdout0_11ck86 = 0 time = 435
.meas tran vdout0_11ck86 FIND v(dout0_11) AT=435.025n

* CHECK dout0_12 Vdout0_12ck86 = 0.9 time = 435
.meas tran vdout0_12ck86 FIND v(dout0_12) AT=435.025n

* CHECK dout0_13 Vdout0_13ck86 = 0.9 time = 435
.meas tran vdout0_13ck86 FIND v(dout0_13) AT=435.025n

* CHECK dout0_14 Vdout0_14ck86 = 0 time = 435
.meas tran vdout0_14ck86 FIND v(dout0_14) AT=435.025n

* CHECK dout0_15 Vdout0_15ck86 = 0 time = 435
.meas tran vdout0_15ck86 FIND v(dout0_15) AT=435.025n

* CHECK dout0_16 Vdout0_16ck86 = 0 time = 435
.meas tran vdout0_16ck86 FIND v(dout0_16) AT=435.025n

* CHECK dout0_17 Vdout0_17ck86 = 0 time = 435
.meas tran vdout0_17ck86 FIND v(dout0_17) AT=435.025n

* CHECK dout0_18 Vdout0_18ck86 = 0.9 time = 435
.meas tran vdout0_18ck86 FIND v(dout0_18) AT=435.025n

* CHECK dout0_19 Vdout0_19ck86 = 0 time = 435
.meas tran vdout0_19ck86 FIND v(dout0_19) AT=435.025n

* CHECK dout0_20 Vdout0_20ck86 = 0 time = 435
.meas tran vdout0_20ck86 FIND v(dout0_20) AT=435.025n

* CHECK dout0_21 Vdout0_21ck86 = 0 time = 435
.meas tran vdout0_21ck86 FIND v(dout0_21) AT=435.025n

* CHECK dout0_22 Vdout0_22ck86 = 0 time = 435
.meas tran vdout0_22ck86 FIND v(dout0_22) AT=435.025n

* CHECK dout0_23 Vdout0_23ck86 = 0.9 time = 435
.meas tran vdout0_23ck86 FIND v(dout0_23) AT=435.025n

* CHECK dout0_24 Vdout0_24ck86 = 0 time = 435
.meas tran vdout0_24ck86 FIND v(dout0_24) AT=435.025n

* CHECK dout0_25 Vdout0_25ck86 = 0 time = 435
.meas tran vdout0_25ck86 FIND v(dout0_25) AT=435.025n

* CHECK dout0_26 Vdout0_26ck86 = 0.9 time = 435
.meas tran vdout0_26ck86 FIND v(dout0_26) AT=435.025n

* CHECK dout0_27 Vdout0_27ck86 = 0.9 time = 435
.meas tran vdout0_27ck86 FIND v(dout0_27) AT=435.025n

* CHECK dout0_28 Vdout0_28ck86 = 0.9 time = 435
.meas tran vdout0_28ck86 FIND v(dout0_28) AT=435.025n

* CHECK dout0_29 Vdout0_29ck86 = 0 time = 435
.meas tran vdout0_29ck86 FIND v(dout0_29) AT=435.025n

* CHECK dout0_30 Vdout0_30ck86 = 0 time = 435
.meas tran vdout0_30ck86 FIND v(dout0_30) AT=435.025n

* CHECK dout0_31 Vdout0_31ck86 = 0.9 time = 435
.meas tran vdout0_31ck86 FIND v(dout0_31) AT=435.025n

* CHECK dout0_32 Vdout0_32ck86 = 0 time = 435
.meas tran vdout0_32ck86 FIND v(dout0_32) AT=435.025n

* CHECK dout0_33 Vdout0_33ck86 = 0 time = 435
.meas tran vdout0_33ck86 FIND v(dout0_33) AT=435.025n

* CHECK dout0_34 Vdout0_34ck86 = 0 time = 435
.meas tran vdout0_34ck86 FIND v(dout0_34) AT=435.025n

* CHECK dout0_35 Vdout0_35ck86 = 0.9 time = 435
.meas tran vdout0_35ck86 FIND v(dout0_35) AT=435.025n

* CHECK dout0_36 Vdout0_36ck86 = 0 time = 435
.meas tran vdout0_36ck86 FIND v(dout0_36) AT=435.025n

* CHECK dout0_37 Vdout0_37ck86 = 0 time = 435
.meas tran vdout0_37ck86 FIND v(dout0_37) AT=435.025n

* CHECK dout0_38 Vdout0_38ck86 = 0.9 time = 435
.meas tran vdout0_38ck86 FIND v(dout0_38) AT=435.025n

* CHECK dout0_39 Vdout0_39ck86 = 0 time = 435
.meas tran vdout0_39ck86 FIND v(dout0_39) AT=435.025n

* CHECK dout0_0 Vdout0_0ck91 = 0.9 time = 460
.meas tran vdout0_0ck91 FIND v(dout0_0) AT=460.025n

* CHECK dout0_1 Vdout0_1ck91 = 0.9 time = 460
.meas tran vdout0_1ck91 FIND v(dout0_1) AT=460.025n

* CHECK dout0_2 Vdout0_2ck91 = 0.9 time = 460
.meas tran vdout0_2ck91 FIND v(dout0_2) AT=460.025n

* CHECK dout0_3 Vdout0_3ck91 = 0.9 time = 460
.meas tran vdout0_3ck91 FIND v(dout0_3) AT=460.025n

* CHECK dout0_4 Vdout0_4ck91 = 0.9 time = 460
.meas tran vdout0_4ck91 FIND v(dout0_4) AT=460.025n

* CHECK dout0_5 Vdout0_5ck91 = 0 time = 460
.meas tran vdout0_5ck91 FIND v(dout0_5) AT=460.025n

* CHECK dout0_6 Vdout0_6ck91 = 0.9 time = 460
.meas tran vdout0_6ck91 FIND v(dout0_6) AT=460.025n

* CHECK dout0_7 Vdout0_7ck91 = 0 time = 460
.meas tran vdout0_7ck91 FIND v(dout0_7) AT=460.025n

* CHECK dout0_8 Vdout0_8ck91 = 0.9 time = 460
.meas tran vdout0_8ck91 FIND v(dout0_8) AT=460.025n

* CHECK dout0_9 Vdout0_9ck91 = 0.9 time = 460
.meas tran vdout0_9ck91 FIND v(dout0_9) AT=460.025n

* CHECK dout0_10 Vdout0_10ck91 = 0.9 time = 460
.meas tran vdout0_10ck91 FIND v(dout0_10) AT=460.025n

* CHECK dout0_11 Vdout0_11ck91 = 0.9 time = 460
.meas tran vdout0_11ck91 FIND v(dout0_11) AT=460.025n

* CHECK dout0_12 Vdout0_12ck91 = 0 time = 460
.meas tran vdout0_12ck91 FIND v(dout0_12) AT=460.025n

* CHECK dout0_13 Vdout0_13ck91 = 0 time = 460
.meas tran vdout0_13ck91 FIND v(dout0_13) AT=460.025n

* CHECK dout0_14 Vdout0_14ck91 = 0 time = 460
.meas tran vdout0_14ck91 FIND v(dout0_14) AT=460.025n

* CHECK dout0_15 Vdout0_15ck91 = 0 time = 460
.meas tran vdout0_15ck91 FIND v(dout0_15) AT=460.025n

* CHECK dout0_16 Vdout0_16ck91 = 0.9 time = 460
.meas tran vdout0_16ck91 FIND v(dout0_16) AT=460.025n

* CHECK dout0_17 Vdout0_17ck91 = 0.9 time = 460
.meas tran vdout0_17ck91 FIND v(dout0_17) AT=460.025n

* CHECK dout0_18 Vdout0_18ck91 = 0.9 time = 460
.meas tran vdout0_18ck91 FIND v(dout0_18) AT=460.025n

* CHECK dout0_19 Vdout0_19ck91 = 0.9 time = 460
.meas tran vdout0_19ck91 FIND v(dout0_19) AT=460.025n

* CHECK dout0_20 Vdout0_20ck91 = 0.9 time = 460
.meas tran vdout0_20ck91 FIND v(dout0_20) AT=460.025n

* CHECK dout0_21 Vdout0_21ck91 = 0 time = 460
.meas tran vdout0_21ck91 FIND v(dout0_21) AT=460.025n

* CHECK dout0_22 Vdout0_22ck91 = 0.9 time = 460
.meas tran vdout0_22ck91 FIND v(dout0_22) AT=460.025n

* CHECK dout0_23 Vdout0_23ck91 = 0 time = 460
.meas tran vdout0_23ck91 FIND v(dout0_23) AT=460.025n

* CHECK dout0_24 Vdout0_24ck91 = 0 time = 460
.meas tran vdout0_24ck91 FIND v(dout0_24) AT=460.025n

* CHECK dout0_25 Vdout0_25ck91 = 0.9 time = 460
.meas tran vdout0_25ck91 FIND v(dout0_25) AT=460.025n

* CHECK dout0_26 Vdout0_26ck91 = 0.9 time = 460
.meas tran vdout0_26ck91 FIND v(dout0_26) AT=460.025n

* CHECK dout0_27 Vdout0_27ck91 = 0 time = 460
.meas tran vdout0_27ck91 FIND v(dout0_27) AT=460.025n

* CHECK dout0_28 Vdout0_28ck91 = 0.9 time = 460
.meas tran vdout0_28ck91 FIND v(dout0_28) AT=460.025n

* CHECK dout0_29 Vdout0_29ck91 = 0 time = 460
.meas tran vdout0_29ck91 FIND v(dout0_29) AT=460.025n

* CHECK dout0_30 Vdout0_30ck91 = 0 time = 460
.meas tran vdout0_30ck91 FIND v(dout0_30) AT=460.025n

* CHECK dout0_31 Vdout0_31ck91 = 0 time = 460
.meas tran vdout0_31ck91 FIND v(dout0_31) AT=460.025n

* CHECK dout0_32 Vdout0_32ck91 = 0 time = 460
.meas tran vdout0_32ck91 FIND v(dout0_32) AT=460.025n

* CHECK dout0_33 Vdout0_33ck91 = 0.9 time = 460
.meas tran vdout0_33ck91 FIND v(dout0_33) AT=460.025n

* CHECK dout0_34 Vdout0_34ck91 = 0.9 time = 460
.meas tran vdout0_34ck91 FIND v(dout0_34) AT=460.025n

* CHECK dout0_35 Vdout0_35ck91 = 0 time = 460
.meas tran vdout0_35ck91 FIND v(dout0_35) AT=460.025n

* CHECK dout0_36 Vdout0_36ck91 = 0.9 time = 460
.meas tran vdout0_36ck91 FIND v(dout0_36) AT=460.025n

* CHECK dout0_37 Vdout0_37ck91 = 0.9 time = 460
.meas tran vdout0_37ck91 FIND v(dout0_37) AT=460.025n

* CHECK dout0_38 Vdout0_38ck91 = 0.9 time = 460
.meas tran vdout0_38ck91 FIND v(dout0_38) AT=460.025n

* CHECK dout0_39 Vdout0_39ck91 = 0.9 time = 460
.meas tran vdout0_39ck91 FIND v(dout0_39) AT=460.025n

* CHECK dout0_0 Vdout0_0ck92 = 0.9 time = 465
.meas tran vdout0_0ck92 FIND v(dout0_0) AT=465.025n

* CHECK dout0_1 Vdout0_1ck92 = 0.9 time = 465
.meas tran vdout0_1ck92 FIND v(dout0_1) AT=465.025n

* CHECK dout0_2 Vdout0_2ck92 = 0 time = 465
.meas tran vdout0_2ck92 FIND v(dout0_2) AT=465.025n

* CHECK dout0_3 Vdout0_3ck92 = 0.9 time = 465
.meas tran vdout0_3ck92 FIND v(dout0_3) AT=465.025n

* CHECK dout0_4 Vdout0_4ck92 = 0.9 time = 465
.meas tran vdout0_4ck92 FIND v(dout0_4) AT=465.025n

* CHECK dout0_5 Vdout0_5ck92 = 0.9 time = 465
.meas tran vdout0_5ck92 FIND v(dout0_5) AT=465.025n

* CHECK dout0_6 Vdout0_6ck92 = 0.9 time = 465
.meas tran vdout0_6ck92 FIND v(dout0_6) AT=465.025n

* CHECK dout0_7 Vdout0_7ck92 = 0 time = 465
.meas tran vdout0_7ck92 FIND v(dout0_7) AT=465.025n

* CHECK dout0_8 Vdout0_8ck92 = 0.9 time = 465
.meas tran vdout0_8ck92 FIND v(dout0_8) AT=465.025n

* CHECK dout0_9 Vdout0_9ck92 = 0 time = 465
.meas tran vdout0_9ck92 FIND v(dout0_9) AT=465.025n

* CHECK dout0_10 Vdout0_10ck92 = 0.9 time = 465
.meas tran vdout0_10ck92 FIND v(dout0_10) AT=465.025n

* CHECK dout0_11 Vdout0_11ck92 = 0 time = 465
.meas tran vdout0_11ck92 FIND v(dout0_11) AT=465.025n

* CHECK dout0_12 Vdout0_12ck92 = 0.9 time = 465
.meas tran vdout0_12ck92 FIND v(dout0_12) AT=465.025n

* CHECK dout0_13 Vdout0_13ck92 = 0.9 time = 465
.meas tran vdout0_13ck92 FIND v(dout0_13) AT=465.025n

* CHECK dout0_14 Vdout0_14ck92 = 0.9 time = 465
.meas tran vdout0_14ck92 FIND v(dout0_14) AT=465.025n

* CHECK dout0_15 Vdout0_15ck92 = 0 time = 465
.meas tran vdout0_15ck92 FIND v(dout0_15) AT=465.025n

* CHECK dout0_16 Vdout0_16ck92 = 0.9 time = 465
.meas tran vdout0_16ck92 FIND v(dout0_16) AT=465.025n

* CHECK dout0_17 Vdout0_17ck92 = 0.9 time = 465
.meas tran vdout0_17ck92 FIND v(dout0_17) AT=465.025n

* CHECK dout0_18 Vdout0_18ck92 = 0.9 time = 465
.meas tran vdout0_18ck92 FIND v(dout0_18) AT=465.025n

* CHECK dout0_19 Vdout0_19ck92 = 0 time = 465
.meas tran vdout0_19ck92 FIND v(dout0_19) AT=465.025n

* CHECK dout0_20 Vdout0_20ck92 = 0 time = 465
.meas tran vdout0_20ck92 FIND v(dout0_20) AT=465.025n

* CHECK dout0_21 Vdout0_21ck92 = 0 time = 465
.meas tran vdout0_21ck92 FIND v(dout0_21) AT=465.025n

* CHECK dout0_22 Vdout0_22ck92 = 0 time = 465
.meas tran vdout0_22ck92 FIND v(dout0_22) AT=465.025n

* CHECK dout0_23 Vdout0_23ck92 = 0 time = 465
.meas tran vdout0_23ck92 FIND v(dout0_23) AT=465.025n

* CHECK dout0_24 Vdout0_24ck92 = 0 time = 465
.meas tran vdout0_24ck92 FIND v(dout0_24) AT=465.025n

* CHECK dout0_25 Vdout0_25ck92 = 0.9 time = 465
.meas tran vdout0_25ck92 FIND v(dout0_25) AT=465.025n

* CHECK dout0_26 Vdout0_26ck92 = 0.9 time = 465
.meas tran vdout0_26ck92 FIND v(dout0_26) AT=465.025n

* CHECK dout0_27 Vdout0_27ck92 = 0.9 time = 465
.meas tran vdout0_27ck92 FIND v(dout0_27) AT=465.025n

* CHECK dout0_28 Vdout0_28ck92 = 0.9 time = 465
.meas tran vdout0_28ck92 FIND v(dout0_28) AT=465.025n

* CHECK dout0_29 Vdout0_29ck92 = 0.9 time = 465
.meas tran vdout0_29ck92 FIND v(dout0_29) AT=465.025n

* CHECK dout0_30 Vdout0_30ck92 = 0 time = 465
.meas tran vdout0_30ck92 FIND v(dout0_30) AT=465.025n

* CHECK dout0_31 Vdout0_31ck92 = 0 time = 465
.meas tran vdout0_31ck92 FIND v(dout0_31) AT=465.025n

* CHECK dout0_32 Vdout0_32ck92 = 0.9 time = 465
.meas tran vdout0_32ck92 FIND v(dout0_32) AT=465.025n

* CHECK dout0_33 Vdout0_33ck92 = 0 time = 465
.meas tran vdout0_33ck92 FIND v(dout0_33) AT=465.025n

* CHECK dout0_34 Vdout0_34ck92 = 0 time = 465
.meas tran vdout0_34ck92 FIND v(dout0_34) AT=465.025n

* CHECK dout0_35 Vdout0_35ck92 = 0.9 time = 465
.meas tran vdout0_35ck92 FIND v(dout0_35) AT=465.025n

* CHECK dout0_36 Vdout0_36ck92 = 0.9 time = 465
.meas tran vdout0_36ck92 FIND v(dout0_36) AT=465.025n

* CHECK dout0_37 Vdout0_37ck92 = 0.9 time = 465
.meas tran vdout0_37ck92 FIND v(dout0_37) AT=465.025n

* CHECK dout0_38 Vdout0_38ck92 = 0 time = 465
.meas tran vdout0_38ck92 FIND v(dout0_38) AT=465.025n

* CHECK dout0_39 Vdout0_39ck92 = 0 time = 465
.meas tran vdout0_39ck92 FIND v(dout0_39) AT=465.025n

* CHECK dout0_0 Vdout0_0ck93 = 0.9 time = 470
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=470.025n

* CHECK dout0_1 Vdout0_1ck93 = 0.9 time = 470
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=470.025n

* CHECK dout0_2 Vdout0_2ck93 = 0.9 time = 470
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=470.025n

* CHECK dout0_3 Vdout0_3ck93 = 0.9 time = 470
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=470.025n

* CHECK dout0_4 Vdout0_4ck93 = 0.9 time = 470
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=470.025n

* CHECK dout0_5 Vdout0_5ck93 = 0 time = 470
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=470.025n

* CHECK dout0_6 Vdout0_6ck93 = 0.9 time = 470
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=470.025n

* CHECK dout0_7 Vdout0_7ck93 = 0 time = 470
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=470.025n

* CHECK dout0_8 Vdout0_8ck93 = 0.9 time = 470
.meas tran vdout0_8ck93 FIND v(dout0_8) AT=470.025n

* CHECK dout0_9 Vdout0_9ck93 = 0.9 time = 470
.meas tran vdout0_9ck93 FIND v(dout0_9) AT=470.025n

* CHECK dout0_10 Vdout0_10ck93 = 0.9 time = 470
.meas tran vdout0_10ck93 FIND v(dout0_10) AT=470.025n

* CHECK dout0_11 Vdout0_11ck93 = 0.9 time = 470
.meas tran vdout0_11ck93 FIND v(dout0_11) AT=470.025n

* CHECK dout0_12 Vdout0_12ck93 = 0 time = 470
.meas tran vdout0_12ck93 FIND v(dout0_12) AT=470.025n

* CHECK dout0_13 Vdout0_13ck93 = 0 time = 470
.meas tran vdout0_13ck93 FIND v(dout0_13) AT=470.025n

* CHECK dout0_14 Vdout0_14ck93 = 0 time = 470
.meas tran vdout0_14ck93 FIND v(dout0_14) AT=470.025n

* CHECK dout0_15 Vdout0_15ck93 = 0 time = 470
.meas tran vdout0_15ck93 FIND v(dout0_15) AT=470.025n

* CHECK dout0_16 Vdout0_16ck93 = 0.9 time = 470
.meas tran vdout0_16ck93 FIND v(dout0_16) AT=470.025n

* CHECK dout0_17 Vdout0_17ck93 = 0.9 time = 470
.meas tran vdout0_17ck93 FIND v(dout0_17) AT=470.025n

* CHECK dout0_18 Vdout0_18ck93 = 0.9 time = 470
.meas tran vdout0_18ck93 FIND v(dout0_18) AT=470.025n

* CHECK dout0_19 Vdout0_19ck93 = 0.9 time = 470
.meas tran vdout0_19ck93 FIND v(dout0_19) AT=470.025n

* CHECK dout0_20 Vdout0_20ck93 = 0.9 time = 470
.meas tran vdout0_20ck93 FIND v(dout0_20) AT=470.025n

* CHECK dout0_21 Vdout0_21ck93 = 0 time = 470
.meas tran vdout0_21ck93 FIND v(dout0_21) AT=470.025n

* CHECK dout0_22 Vdout0_22ck93 = 0.9 time = 470
.meas tran vdout0_22ck93 FIND v(dout0_22) AT=470.025n

* CHECK dout0_23 Vdout0_23ck93 = 0 time = 470
.meas tran vdout0_23ck93 FIND v(dout0_23) AT=470.025n

* CHECK dout0_24 Vdout0_24ck93 = 0 time = 470
.meas tran vdout0_24ck93 FIND v(dout0_24) AT=470.025n

* CHECK dout0_25 Vdout0_25ck93 = 0.9 time = 470
.meas tran vdout0_25ck93 FIND v(dout0_25) AT=470.025n

* CHECK dout0_26 Vdout0_26ck93 = 0.9 time = 470
.meas tran vdout0_26ck93 FIND v(dout0_26) AT=470.025n

* CHECK dout0_27 Vdout0_27ck93 = 0 time = 470
.meas tran vdout0_27ck93 FIND v(dout0_27) AT=470.025n

* CHECK dout0_28 Vdout0_28ck93 = 0.9 time = 470
.meas tran vdout0_28ck93 FIND v(dout0_28) AT=470.025n

* CHECK dout0_29 Vdout0_29ck93 = 0 time = 470
.meas tran vdout0_29ck93 FIND v(dout0_29) AT=470.025n

* CHECK dout0_30 Vdout0_30ck93 = 0 time = 470
.meas tran vdout0_30ck93 FIND v(dout0_30) AT=470.025n

* CHECK dout0_31 Vdout0_31ck93 = 0 time = 470
.meas tran vdout0_31ck93 FIND v(dout0_31) AT=470.025n

* CHECK dout0_32 Vdout0_32ck93 = 0 time = 470
.meas tran vdout0_32ck93 FIND v(dout0_32) AT=470.025n

* CHECK dout0_33 Vdout0_33ck93 = 0.9 time = 470
.meas tran vdout0_33ck93 FIND v(dout0_33) AT=470.025n

* CHECK dout0_34 Vdout0_34ck93 = 0.9 time = 470
.meas tran vdout0_34ck93 FIND v(dout0_34) AT=470.025n

* CHECK dout0_35 Vdout0_35ck93 = 0 time = 470
.meas tran vdout0_35ck93 FIND v(dout0_35) AT=470.025n

* CHECK dout0_36 Vdout0_36ck93 = 0.9 time = 470
.meas tran vdout0_36ck93 FIND v(dout0_36) AT=470.025n

* CHECK dout0_37 Vdout0_37ck93 = 0.9 time = 470
.meas tran vdout0_37ck93 FIND v(dout0_37) AT=470.025n

* CHECK dout0_38 Vdout0_38ck93 = 0.9 time = 470
.meas tran vdout0_38ck93 FIND v(dout0_38) AT=470.025n

* CHECK dout0_39 Vdout0_39ck93 = 0.9 time = 470
.meas tran vdout0_39ck93 FIND v(dout0_39) AT=470.025n

* CHECK dout0_0 Vdout0_0ck95 = 0.9 time = 480
.meas tran vdout0_0ck95 FIND v(dout0_0) AT=480.025n

* CHECK dout0_1 Vdout0_1ck95 = 0.9 time = 480
.meas tran vdout0_1ck95 FIND v(dout0_1) AT=480.025n

* CHECK dout0_2 Vdout0_2ck95 = 0.9 time = 480
.meas tran vdout0_2ck95 FIND v(dout0_2) AT=480.025n

* CHECK dout0_3 Vdout0_3ck95 = 0.9 time = 480
.meas tran vdout0_3ck95 FIND v(dout0_3) AT=480.025n

* CHECK dout0_4 Vdout0_4ck95 = 0.9 time = 480
.meas tran vdout0_4ck95 FIND v(dout0_4) AT=480.025n

* CHECK dout0_5 Vdout0_5ck95 = 0 time = 480
.meas tran vdout0_5ck95 FIND v(dout0_5) AT=480.025n

* CHECK dout0_6 Vdout0_6ck95 = 0.9 time = 480
.meas tran vdout0_6ck95 FIND v(dout0_6) AT=480.025n

* CHECK dout0_7 Vdout0_7ck95 = 0 time = 480
.meas tran vdout0_7ck95 FIND v(dout0_7) AT=480.025n

* CHECK dout0_8 Vdout0_8ck95 = 0.9 time = 480
.meas tran vdout0_8ck95 FIND v(dout0_8) AT=480.025n

* CHECK dout0_9 Vdout0_9ck95 = 0.9 time = 480
.meas tran vdout0_9ck95 FIND v(dout0_9) AT=480.025n

* CHECK dout0_10 Vdout0_10ck95 = 0.9 time = 480
.meas tran vdout0_10ck95 FIND v(dout0_10) AT=480.025n

* CHECK dout0_11 Vdout0_11ck95 = 0.9 time = 480
.meas tran vdout0_11ck95 FIND v(dout0_11) AT=480.025n

* CHECK dout0_12 Vdout0_12ck95 = 0 time = 480
.meas tran vdout0_12ck95 FIND v(dout0_12) AT=480.025n

* CHECK dout0_13 Vdout0_13ck95 = 0 time = 480
.meas tran vdout0_13ck95 FIND v(dout0_13) AT=480.025n

* CHECK dout0_14 Vdout0_14ck95 = 0 time = 480
.meas tran vdout0_14ck95 FIND v(dout0_14) AT=480.025n

* CHECK dout0_15 Vdout0_15ck95 = 0 time = 480
.meas tran vdout0_15ck95 FIND v(dout0_15) AT=480.025n

* CHECK dout0_16 Vdout0_16ck95 = 0.9 time = 480
.meas tran vdout0_16ck95 FIND v(dout0_16) AT=480.025n

* CHECK dout0_17 Vdout0_17ck95 = 0.9 time = 480
.meas tran vdout0_17ck95 FIND v(dout0_17) AT=480.025n

* CHECK dout0_18 Vdout0_18ck95 = 0.9 time = 480
.meas tran vdout0_18ck95 FIND v(dout0_18) AT=480.025n

* CHECK dout0_19 Vdout0_19ck95 = 0.9 time = 480
.meas tran vdout0_19ck95 FIND v(dout0_19) AT=480.025n

* CHECK dout0_20 Vdout0_20ck95 = 0.9 time = 480
.meas tran vdout0_20ck95 FIND v(dout0_20) AT=480.025n

* CHECK dout0_21 Vdout0_21ck95 = 0 time = 480
.meas tran vdout0_21ck95 FIND v(dout0_21) AT=480.025n

* CHECK dout0_22 Vdout0_22ck95 = 0.9 time = 480
.meas tran vdout0_22ck95 FIND v(dout0_22) AT=480.025n

* CHECK dout0_23 Vdout0_23ck95 = 0 time = 480
.meas tran vdout0_23ck95 FIND v(dout0_23) AT=480.025n

* CHECK dout0_24 Vdout0_24ck95 = 0 time = 480
.meas tran vdout0_24ck95 FIND v(dout0_24) AT=480.025n

* CHECK dout0_25 Vdout0_25ck95 = 0.9 time = 480
.meas tran vdout0_25ck95 FIND v(dout0_25) AT=480.025n

* CHECK dout0_26 Vdout0_26ck95 = 0.9 time = 480
.meas tran vdout0_26ck95 FIND v(dout0_26) AT=480.025n

* CHECK dout0_27 Vdout0_27ck95 = 0 time = 480
.meas tran vdout0_27ck95 FIND v(dout0_27) AT=480.025n

* CHECK dout0_28 Vdout0_28ck95 = 0.9 time = 480
.meas tran vdout0_28ck95 FIND v(dout0_28) AT=480.025n

* CHECK dout0_29 Vdout0_29ck95 = 0 time = 480
.meas tran vdout0_29ck95 FIND v(dout0_29) AT=480.025n

* CHECK dout0_30 Vdout0_30ck95 = 0 time = 480
.meas tran vdout0_30ck95 FIND v(dout0_30) AT=480.025n

* CHECK dout0_31 Vdout0_31ck95 = 0 time = 480
.meas tran vdout0_31ck95 FIND v(dout0_31) AT=480.025n

* CHECK dout0_32 Vdout0_32ck95 = 0 time = 480
.meas tran vdout0_32ck95 FIND v(dout0_32) AT=480.025n

* CHECK dout0_33 Vdout0_33ck95 = 0.9 time = 480
.meas tran vdout0_33ck95 FIND v(dout0_33) AT=480.025n

* CHECK dout0_34 Vdout0_34ck95 = 0.9 time = 480
.meas tran vdout0_34ck95 FIND v(dout0_34) AT=480.025n

* CHECK dout0_35 Vdout0_35ck95 = 0 time = 480
.meas tran vdout0_35ck95 FIND v(dout0_35) AT=480.025n

* CHECK dout0_36 Vdout0_36ck95 = 0.9 time = 480
.meas tran vdout0_36ck95 FIND v(dout0_36) AT=480.025n

* CHECK dout0_37 Vdout0_37ck95 = 0.9 time = 480
.meas tran vdout0_37ck95 FIND v(dout0_37) AT=480.025n

* CHECK dout0_38 Vdout0_38ck95 = 0.9 time = 480
.meas tran vdout0_38ck95 FIND v(dout0_38) AT=480.025n

* CHECK dout0_39 Vdout0_39ck95 = 0.9 time = 480
.meas tran vdout0_39ck95 FIND v(dout0_39) AT=480.025n

* CHECK dout0_0 Vdout0_0ck98 = 0.9 time = 495
.meas tran vdout0_0ck98 FIND v(dout0_0) AT=495.025n

* CHECK dout0_1 Vdout0_1ck98 = 0.9 time = 495
.meas tran vdout0_1ck98 FIND v(dout0_1) AT=495.025n

* CHECK dout0_2 Vdout0_2ck98 = 0.9 time = 495
.meas tran vdout0_2ck98 FIND v(dout0_2) AT=495.025n

* CHECK dout0_3 Vdout0_3ck98 = 0.9 time = 495
.meas tran vdout0_3ck98 FIND v(dout0_3) AT=495.025n

* CHECK dout0_4 Vdout0_4ck98 = 0.9 time = 495
.meas tran vdout0_4ck98 FIND v(dout0_4) AT=495.025n

* CHECK dout0_5 Vdout0_5ck98 = 0 time = 495
.meas tran vdout0_5ck98 FIND v(dout0_5) AT=495.025n

* CHECK dout0_6 Vdout0_6ck98 = 0.9 time = 495
.meas tran vdout0_6ck98 FIND v(dout0_6) AT=495.025n

* CHECK dout0_7 Vdout0_7ck98 = 0 time = 495
.meas tran vdout0_7ck98 FIND v(dout0_7) AT=495.025n

* CHECK dout0_8 Vdout0_8ck98 = 0.9 time = 495
.meas tran vdout0_8ck98 FIND v(dout0_8) AT=495.025n

* CHECK dout0_9 Vdout0_9ck98 = 0.9 time = 495
.meas tran vdout0_9ck98 FIND v(dout0_9) AT=495.025n

* CHECK dout0_10 Vdout0_10ck98 = 0.9 time = 495
.meas tran vdout0_10ck98 FIND v(dout0_10) AT=495.025n

* CHECK dout0_11 Vdout0_11ck98 = 0.9 time = 495
.meas tran vdout0_11ck98 FIND v(dout0_11) AT=495.025n

* CHECK dout0_12 Vdout0_12ck98 = 0 time = 495
.meas tran vdout0_12ck98 FIND v(dout0_12) AT=495.025n

* CHECK dout0_13 Vdout0_13ck98 = 0 time = 495
.meas tran vdout0_13ck98 FIND v(dout0_13) AT=495.025n

* CHECK dout0_14 Vdout0_14ck98 = 0 time = 495
.meas tran vdout0_14ck98 FIND v(dout0_14) AT=495.025n

* CHECK dout0_15 Vdout0_15ck98 = 0 time = 495
.meas tran vdout0_15ck98 FIND v(dout0_15) AT=495.025n

* CHECK dout0_16 Vdout0_16ck98 = 0.9 time = 495
.meas tran vdout0_16ck98 FIND v(dout0_16) AT=495.025n

* CHECK dout0_17 Vdout0_17ck98 = 0.9 time = 495
.meas tran vdout0_17ck98 FIND v(dout0_17) AT=495.025n

* CHECK dout0_18 Vdout0_18ck98 = 0.9 time = 495
.meas tran vdout0_18ck98 FIND v(dout0_18) AT=495.025n

* CHECK dout0_19 Vdout0_19ck98 = 0.9 time = 495
.meas tran vdout0_19ck98 FIND v(dout0_19) AT=495.025n

* CHECK dout0_20 Vdout0_20ck98 = 0.9 time = 495
.meas tran vdout0_20ck98 FIND v(dout0_20) AT=495.025n

* CHECK dout0_21 Vdout0_21ck98 = 0 time = 495
.meas tran vdout0_21ck98 FIND v(dout0_21) AT=495.025n

* CHECK dout0_22 Vdout0_22ck98 = 0.9 time = 495
.meas tran vdout0_22ck98 FIND v(dout0_22) AT=495.025n

* CHECK dout0_23 Vdout0_23ck98 = 0 time = 495
.meas tran vdout0_23ck98 FIND v(dout0_23) AT=495.025n

* CHECK dout0_24 Vdout0_24ck98 = 0 time = 495
.meas tran vdout0_24ck98 FIND v(dout0_24) AT=495.025n

* CHECK dout0_25 Vdout0_25ck98 = 0.9 time = 495
.meas tran vdout0_25ck98 FIND v(dout0_25) AT=495.025n

* CHECK dout0_26 Vdout0_26ck98 = 0.9 time = 495
.meas tran vdout0_26ck98 FIND v(dout0_26) AT=495.025n

* CHECK dout0_27 Vdout0_27ck98 = 0 time = 495
.meas tran vdout0_27ck98 FIND v(dout0_27) AT=495.025n

* CHECK dout0_28 Vdout0_28ck98 = 0.9 time = 495
.meas tran vdout0_28ck98 FIND v(dout0_28) AT=495.025n

* CHECK dout0_29 Vdout0_29ck98 = 0 time = 495
.meas tran vdout0_29ck98 FIND v(dout0_29) AT=495.025n

* CHECK dout0_30 Vdout0_30ck98 = 0 time = 495
.meas tran vdout0_30ck98 FIND v(dout0_30) AT=495.025n

* CHECK dout0_31 Vdout0_31ck98 = 0 time = 495
.meas tran vdout0_31ck98 FIND v(dout0_31) AT=495.025n

* CHECK dout0_32 Vdout0_32ck98 = 0 time = 495
.meas tran vdout0_32ck98 FIND v(dout0_32) AT=495.025n

* CHECK dout0_33 Vdout0_33ck98 = 0.9 time = 495
.meas tran vdout0_33ck98 FIND v(dout0_33) AT=495.025n

* CHECK dout0_34 Vdout0_34ck98 = 0.9 time = 495
.meas tran vdout0_34ck98 FIND v(dout0_34) AT=495.025n

* CHECK dout0_35 Vdout0_35ck98 = 0 time = 495
.meas tran vdout0_35ck98 FIND v(dout0_35) AT=495.025n

* CHECK dout0_36 Vdout0_36ck98 = 0.9 time = 495
.meas tran vdout0_36ck98 FIND v(dout0_36) AT=495.025n

* CHECK dout0_37 Vdout0_37ck98 = 0.9 time = 495
.meas tran vdout0_37ck98 FIND v(dout0_37) AT=495.025n

* CHECK dout0_38 Vdout0_38ck98 = 0.9 time = 495
.meas tran vdout0_38ck98 FIND v(dout0_38) AT=495.025n

* CHECK dout0_39 Vdout0_39ck98 = 0.9 time = 495
.meas tran vdout0_39ck98 FIND v(dout0_39) AT=495.025n

* CHECK dout0_0 Vdout0_0ck101 = 0.9 time = 510
.meas tran vdout0_0ck101 FIND v(dout0_0) AT=510.025n

* CHECK dout0_1 Vdout0_1ck101 = 0.9 time = 510
.meas tran vdout0_1ck101 FIND v(dout0_1) AT=510.025n

* CHECK dout0_2 Vdout0_2ck101 = 0.9 time = 510
.meas tran vdout0_2ck101 FIND v(dout0_2) AT=510.025n

* CHECK dout0_3 Vdout0_3ck101 = 0 time = 510
.meas tran vdout0_3ck101 FIND v(dout0_3) AT=510.025n

* CHECK dout0_4 Vdout0_4ck101 = 0.9 time = 510
.meas tran vdout0_4ck101 FIND v(dout0_4) AT=510.025n

* CHECK dout0_5 Vdout0_5ck101 = 0 time = 510
.meas tran vdout0_5ck101 FIND v(dout0_5) AT=510.025n

* CHECK dout0_6 Vdout0_6ck101 = 0 time = 510
.meas tran vdout0_6ck101 FIND v(dout0_6) AT=510.025n

* CHECK dout0_7 Vdout0_7ck101 = 0 time = 510
.meas tran vdout0_7ck101 FIND v(dout0_7) AT=510.025n

* CHECK dout0_8 Vdout0_8ck101 = 0 time = 510
.meas tran vdout0_8ck101 FIND v(dout0_8) AT=510.025n

* CHECK dout0_9 Vdout0_9ck101 = 0.9 time = 510
.meas tran vdout0_9ck101 FIND v(dout0_9) AT=510.025n

* CHECK dout0_10 Vdout0_10ck101 = 0 time = 510
.meas tran vdout0_10ck101 FIND v(dout0_10) AT=510.025n

* CHECK dout0_11 Vdout0_11ck101 = 0.9 time = 510
.meas tran vdout0_11ck101 FIND v(dout0_11) AT=510.025n

* CHECK dout0_12 Vdout0_12ck101 = 0.9 time = 510
.meas tran vdout0_12ck101 FIND v(dout0_12) AT=510.025n

* CHECK dout0_13 Vdout0_13ck101 = 0.9 time = 510
.meas tran vdout0_13ck101 FIND v(dout0_13) AT=510.025n

* CHECK dout0_14 Vdout0_14ck101 = 0 time = 510
.meas tran vdout0_14ck101 FIND v(dout0_14) AT=510.025n

* CHECK dout0_15 Vdout0_15ck101 = 0 time = 510
.meas tran vdout0_15ck101 FIND v(dout0_15) AT=510.025n

* CHECK dout0_16 Vdout0_16ck101 = 0.9 time = 510
.meas tran vdout0_16ck101 FIND v(dout0_16) AT=510.025n

* CHECK dout0_17 Vdout0_17ck101 = 0 time = 510
.meas tran vdout0_17ck101 FIND v(dout0_17) AT=510.025n

* CHECK dout0_18 Vdout0_18ck101 = 0.9 time = 510
.meas tran vdout0_18ck101 FIND v(dout0_18) AT=510.025n

* CHECK dout0_19 Vdout0_19ck101 = 0.9 time = 510
.meas tran vdout0_19ck101 FIND v(dout0_19) AT=510.025n

* CHECK dout0_20 Vdout0_20ck101 = 0.9 time = 510
.meas tran vdout0_20ck101 FIND v(dout0_20) AT=510.025n

* CHECK dout0_21 Vdout0_21ck101 = 0 time = 510
.meas tran vdout0_21ck101 FIND v(dout0_21) AT=510.025n

* CHECK dout0_22 Vdout0_22ck101 = 0 time = 510
.meas tran vdout0_22ck101 FIND v(dout0_22) AT=510.025n

* CHECK dout0_23 Vdout0_23ck101 = 0 time = 510
.meas tran vdout0_23ck101 FIND v(dout0_23) AT=510.025n

* CHECK dout0_24 Vdout0_24ck101 = 0.9 time = 510
.meas tran vdout0_24ck101 FIND v(dout0_24) AT=510.025n

* CHECK dout0_25 Vdout0_25ck101 = 0 time = 510
.meas tran vdout0_25ck101 FIND v(dout0_25) AT=510.025n

* CHECK dout0_26 Vdout0_26ck101 = 0 time = 510
.meas tran vdout0_26ck101 FIND v(dout0_26) AT=510.025n

* CHECK dout0_27 Vdout0_27ck101 = 0 time = 510
.meas tran vdout0_27ck101 FIND v(dout0_27) AT=510.025n

* CHECK dout0_28 Vdout0_28ck101 = 0 time = 510
.meas tran vdout0_28ck101 FIND v(dout0_28) AT=510.025n

* CHECK dout0_29 Vdout0_29ck101 = 0.9 time = 510
.meas tran vdout0_29ck101 FIND v(dout0_29) AT=510.025n

* CHECK dout0_30 Vdout0_30ck101 = 0.9 time = 510
.meas tran vdout0_30ck101 FIND v(dout0_30) AT=510.025n

* CHECK dout0_31 Vdout0_31ck101 = 0.9 time = 510
.meas tran vdout0_31ck101 FIND v(dout0_31) AT=510.025n

* CHECK dout0_32 Vdout0_32ck101 = 0 time = 510
.meas tran vdout0_32ck101 FIND v(dout0_32) AT=510.025n

* CHECK dout0_33 Vdout0_33ck101 = 0.9 time = 510
.meas tran vdout0_33ck101 FIND v(dout0_33) AT=510.025n

* CHECK dout0_34 Vdout0_34ck101 = 0.9 time = 510
.meas tran vdout0_34ck101 FIND v(dout0_34) AT=510.025n

* CHECK dout0_35 Vdout0_35ck101 = 0.9 time = 510
.meas tran vdout0_35ck101 FIND v(dout0_35) AT=510.025n

* CHECK dout0_36 Vdout0_36ck101 = 0 time = 510
.meas tran vdout0_36ck101 FIND v(dout0_36) AT=510.025n

* CHECK dout0_37 Vdout0_37ck101 = 0 time = 510
.meas tran vdout0_37ck101 FIND v(dout0_37) AT=510.025n

* CHECK dout0_38 Vdout0_38ck101 = 0 time = 510
.meas tran vdout0_38ck101 FIND v(dout0_38) AT=510.025n

* CHECK dout0_39 Vdout0_39ck101 = 0.9 time = 510
.meas tran vdout0_39ck101 FIND v(dout0_39) AT=510.025n

* CHECK dout0_0 Vdout0_0ck102 = 0.9 time = 515
.meas tran vdout0_0ck102 FIND v(dout0_0) AT=515.025n

* CHECK dout0_1 Vdout0_1ck102 = 0.9 time = 515
.meas tran vdout0_1ck102 FIND v(dout0_1) AT=515.025n

* CHECK dout0_2 Vdout0_2ck102 = 0.9 time = 515
.meas tran vdout0_2ck102 FIND v(dout0_2) AT=515.025n

* CHECK dout0_3 Vdout0_3ck102 = 0.9 time = 515
.meas tran vdout0_3ck102 FIND v(dout0_3) AT=515.025n

* CHECK dout0_4 Vdout0_4ck102 = 0.9 time = 515
.meas tran vdout0_4ck102 FIND v(dout0_4) AT=515.025n

* CHECK dout0_5 Vdout0_5ck102 = 0 time = 515
.meas tran vdout0_5ck102 FIND v(dout0_5) AT=515.025n

* CHECK dout0_6 Vdout0_6ck102 = 0.9 time = 515
.meas tran vdout0_6ck102 FIND v(dout0_6) AT=515.025n

* CHECK dout0_7 Vdout0_7ck102 = 0 time = 515
.meas tran vdout0_7ck102 FIND v(dout0_7) AT=515.025n

* CHECK dout0_8 Vdout0_8ck102 = 0.9 time = 515
.meas tran vdout0_8ck102 FIND v(dout0_8) AT=515.025n

* CHECK dout0_9 Vdout0_9ck102 = 0.9 time = 515
.meas tran vdout0_9ck102 FIND v(dout0_9) AT=515.025n

* CHECK dout0_10 Vdout0_10ck102 = 0.9 time = 515
.meas tran vdout0_10ck102 FIND v(dout0_10) AT=515.025n

* CHECK dout0_11 Vdout0_11ck102 = 0.9 time = 515
.meas tran vdout0_11ck102 FIND v(dout0_11) AT=515.025n

* CHECK dout0_12 Vdout0_12ck102 = 0 time = 515
.meas tran vdout0_12ck102 FIND v(dout0_12) AT=515.025n

* CHECK dout0_13 Vdout0_13ck102 = 0 time = 515
.meas tran vdout0_13ck102 FIND v(dout0_13) AT=515.025n

* CHECK dout0_14 Vdout0_14ck102 = 0 time = 515
.meas tran vdout0_14ck102 FIND v(dout0_14) AT=515.025n

* CHECK dout0_15 Vdout0_15ck102 = 0 time = 515
.meas tran vdout0_15ck102 FIND v(dout0_15) AT=515.025n

* CHECK dout0_16 Vdout0_16ck102 = 0.9 time = 515
.meas tran vdout0_16ck102 FIND v(dout0_16) AT=515.025n

* CHECK dout0_17 Vdout0_17ck102 = 0.9 time = 515
.meas tran vdout0_17ck102 FIND v(dout0_17) AT=515.025n

* CHECK dout0_18 Vdout0_18ck102 = 0.9 time = 515
.meas tran vdout0_18ck102 FIND v(dout0_18) AT=515.025n

* CHECK dout0_19 Vdout0_19ck102 = 0.9 time = 515
.meas tran vdout0_19ck102 FIND v(dout0_19) AT=515.025n

* CHECK dout0_20 Vdout0_20ck102 = 0.9 time = 515
.meas tran vdout0_20ck102 FIND v(dout0_20) AT=515.025n

* CHECK dout0_21 Vdout0_21ck102 = 0 time = 515
.meas tran vdout0_21ck102 FIND v(dout0_21) AT=515.025n

* CHECK dout0_22 Vdout0_22ck102 = 0.9 time = 515
.meas tran vdout0_22ck102 FIND v(dout0_22) AT=515.025n

* CHECK dout0_23 Vdout0_23ck102 = 0 time = 515
.meas tran vdout0_23ck102 FIND v(dout0_23) AT=515.025n

* CHECK dout0_24 Vdout0_24ck102 = 0 time = 515
.meas tran vdout0_24ck102 FIND v(dout0_24) AT=515.025n

* CHECK dout0_25 Vdout0_25ck102 = 0.9 time = 515
.meas tran vdout0_25ck102 FIND v(dout0_25) AT=515.025n

* CHECK dout0_26 Vdout0_26ck102 = 0.9 time = 515
.meas tran vdout0_26ck102 FIND v(dout0_26) AT=515.025n

* CHECK dout0_27 Vdout0_27ck102 = 0 time = 515
.meas tran vdout0_27ck102 FIND v(dout0_27) AT=515.025n

* CHECK dout0_28 Vdout0_28ck102 = 0.9 time = 515
.meas tran vdout0_28ck102 FIND v(dout0_28) AT=515.025n

* CHECK dout0_29 Vdout0_29ck102 = 0 time = 515
.meas tran vdout0_29ck102 FIND v(dout0_29) AT=515.025n

* CHECK dout0_30 Vdout0_30ck102 = 0 time = 515
.meas tran vdout0_30ck102 FIND v(dout0_30) AT=515.025n

* CHECK dout0_31 Vdout0_31ck102 = 0 time = 515
.meas tran vdout0_31ck102 FIND v(dout0_31) AT=515.025n

* CHECK dout0_32 Vdout0_32ck102 = 0 time = 515
.meas tran vdout0_32ck102 FIND v(dout0_32) AT=515.025n

* CHECK dout0_33 Vdout0_33ck102 = 0.9 time = 515
.meas tran vdout0_33ck102 FIND v(dout0_33) AT=515.025n

* CHECK dout0_34 Vdout0_34ck102 = 0.9 time = 515
.meas tran vdout0_34ck102 FIND v(dout0_34) AT=515.025n

* CHECK dout0_35 Vdout0_35ck102 = 0 time = 515
.meas tran vdout0_35ck102 FIND v(dout0_35) AT=515.025n

* CHECK dout0_36 Vdout0_36ck102 = 0.9 time = 515
.meas tran vdout0_36ck102 FIND v(dout0_36) AT=515.025n

* CHECK dout0_37 Vdout0_37ck102 = 0.9 time = 515
.meas tran vdout0_37ck102 FIND v(dout0_37) AT=515.025n

* CHECK dout0_38 Vdout0_38ck102 = 0.9 time = 515
.meas tran vdout0_38ck102 FIND v(dout0_38) AT=515.025n

* CHECK dout0_39 Vdout0_39ck102 = 0.9 time = 515
.meas tran vdout0_39ck102 FIND v(dout0_39) AT=515.025n

* CHECK dout0_0 Vdout0_0ck103 = 0.9 time = 520
.meas tran vdout0_0ck103 FIND v(dout0_0) AT=520.025n

* CHECK dout0_1 Vdout0_1ck103 = 0.9 time = 520
.meas tran vdout0_1ck103 FIND v(dout0_1) AT=520.025n

* CHECK dout0_2 Vdout0_2ck103 = 0.9 time = 520
.meas tran vdout0_2ck103 FIND v(dout0_2) AT=520.025n

* CHECK dout0_3 Vdout0_3ck103 = 0.9 time = 520
.meas tran vdout0_3ck103 FIND v(dout0_3) AT=520.025n

* CHECK dout0_4 Vdout0_4ck103 = 0.9 time = 520
.meas tran vdout0_4ck103 FIND v(dout0_4) AT=520.025n

* CHECK dout0_5 Vdout0_5ck103 = 0 time = 520
.meas tran vdout0_5ck103 FIND v(dout0_5) AT=520.025n

* CHECK dout0_6 Vdout0_6ck103 = 0.9 time = 520
.meas tran vdout0_6ck103 FIND v(dout0_6) AT=520.025n

* CHECK dout0_7 Vdout0_7ck103 = 0 time = 520
.meas tran vdout0_7ck103 FIND v(dout0_7) AT=520.025n

* CHECK dout0_8 Vdout0_8ck103 = 0.9 time = 520
.meas tran vdout0_8ck103 FIND v(dout0_8) AT=520.025n

* CHECK dout0_9 Vdout0_9ck103 = 0.9 time = 520
.meas tran vdout0_9ck103 FIND v(dout0_9) AT=520.025n

* CHECK dout0_10 Vdout0_10ck103 = 0.9 time = 520
.meas tran vdout0_10ck103 FIND v(dout0_10) AT=520.025n

* CHECK dout0_11 Vdout0_11ck103 = 0.9 time = 520
.meas tran vdout0_11ck103 FIND v(dout0_11) AT=520.025n

* CHECK dout0_12 Vdout0_12ck103 = 0 time = 520
.meas tran vdout0_12ck103 FIND v(dout0_12) AT=520.025n

* CHECK dout0_13 Vdout0_13ck103 = 0 time = 520
.meas tran vdout0_13ck103 FIND v(dout0_13) AT=520.025n

* CHECK dout0_14 Vdout0_14ck103 = 0 time = 520
.meas tran vdout0_14ck103 FIND v(dout0_14) AT=520.025n

* CHECK dout0_15 Vdout0_15ck103 = 0 time = 520
.meas tran vdout0_15ck103 FIND v(dout0_15) AT=520.025n

* CHECK dout0_16 Vdout0_16ck103 = 0.9 time = 520
.meas tran vdout0_16ck103 FIND v(dout0_16) AT=520.025n

* CHECK dout0_17 Vdout0_17ck103 = 0.9 time = 520
.meas tran vdout0_17ck103 FIND v(dout0_17) AT=520.025n

* CHECK dout0_18 Vdout0_18ck103 = 0.9 time = 520
.meas tran vdout0_18ck103 FIND v(dout0_18) AT=520.025n

* CHECK dout0_19 Vdout0_19ck103 = 0.9 time = 520
.meas tran vdout0_19ck103 FIND v(dout0_19) AT=520.025n

* CHECK dout0_20 Vdout0_20ck103 = 0.9 time = 520
.meas tran vdout0_20ck103 FIND v(dout0_20) AT=520.025n

* CHECK dout0_21 Vdout0_21ck103 = 0 time = 520
.meas tran vdout0_21ck103 FIND v(dout0_21) AT=520.025n

* CHECK dout0_22 Vdout0_22ck103 = 0.9 time = 520
.meas tran vdout0_22ck103 FIND v(dout0_22) AT=520.025n

* CHECK dout0_23 Vdout0_23ck103 = 0 time = 520
.meas tran vdout0_23ck103 FIND v(dout0_23) AT=520.025n

* CHECK dout0_24 Vdout0_24ck103 = 0 time = 520
.meas tran vdout0_24ck103 FIND v(dout0_24) AT=520.025n

* CHECK dout0_25 Vdout0_25ck103 = 0.9 time = 520
.meas tran vdout0_25ck103 FIND v(dout0_25) AT=520.025n

* CHECK dout0_26 Vdout0_26ck103 = 0.9 time = 520
.meas tran vdout0_26ck103 FIND v(dout0_26) AT=520.025n

* CHECK dout0_27 Vdout0_27ck103 = 0 time = 520
.meas tran vdout0_27ck103 FIND v(dout0_27) AT=520.025n

* CHECK dout0_28 Vdout0_28ck103 = 0.9 time = 520
.meas tran vdout0_28ck103 FIND v(dout0_28) AT=520.025n

* CHECK dout0_29 Vdout0_29ck103 = 0 time = 520
.meas tran vdout0_29ck103 FIND v(dout0_29) AT=520.025n

* CHECK dout0_30 Vdout0_30ck103 = 0 time = 520
.meas tran vdout0_30ck103 FIND v(dout0_30) AT=520.025n

* CHECK dout0_31 Vdout0_31ck103 = 0 time = 520
.meas tran vdout0_31ck103 FIND v(dout0_31) AT=520.025n

* CHECK dout0_32 Vdout0_32ck103 = 0 time = 520
.meas tran vdout0_32ck103 FIND v(dout0_32) AT=520.025n

* CHECK dout0_33 Vdout0_33ck103 = 0.9 time = 520
.meas tran vdout0_33ck103 FIND v(dout0_33) AT=520.025n

* CHECK dout0_34 Vdout0_34ck103 = 0.9 time = 520
.meas tran vdout0_34ck103 FIND v(dout0_34) AT=520.025n

* CHECK dout0_35 Vdout0_35ck103 = 0 time = 520
.meas tran vdout0_35ck103 FIND v(dout0_35) AT=520.025n

* CHECK dout0_36 Vdout0_36ck103 = 0.9 time = 520
.meas tran vdout0_36ck103 FIND v(dout0_36) AT=520.025n

* CHECK dout0_37 Vdout0_37ck103 = 0.9 time = 520
.meas tran vdout0_37ck103 FIND v(dout0_37) AT=520.025n

* CHECK dout0_38 Vdout0_38ck103 = 0.9 time = 520
.meas tran vdout0_38ck103 FIND v(dout0_38) AT=520.025n

* CHECK dout0_39 Vdout0_39ck103 = 0.9 time = 520
.meas tran vdout0_39ck103 FIND v(dout0_39) AT=520.025n

* CHECK dout0_0 Vdout0_0ck105 = 0.9 time = 530
.meas tran vdout0_0ck105 FIND v(dout0_0) AT=530.025n

* CHECK dout0_1 Vdout0_1ck105 = 0.9 time = 530
.meas tran vdout0_1ck105 FIND v(dout0_1) AT=530.025n

* CHECK dout0_2 Vdout0_2ck105 = 0.9 time = 530
.meas tran vdout0_2ck105 FIND v(dout0_2) AT=530.025n

* CHECK dout0_3 Vdout0_3ck105 = 0.9 time = 530
.meas tran vdout0_3ck105 FIND v(dout0_3) AT=530.025n

* CHECK dout0_4 Vdout0_4ck105 = 0.9 time = 530
.meas tran vdout0_4ck105 FIND v(dout0_4) AT=530.025n

* CHECK dout0_5 Vdout0_5ck105 = 0 time = 530
.meas tran vdout0_5ck105 FIND v(dout0_5) AT=530.025n

* CHECK dout0_6 Vdout0_6ck105 = 0.9 time = 530
.meas tran vdout0_6ck105 FIND v(dout0_6) AT=530.025n

* CHECK dout0_7 Vdout0_7ck105 = 0 time = 530
.meas tran vdout0_7ck105 FIND v(dout0_7) AT=530.025n

* CHECK dout0_8 Vdout0_8ck105 = 0.9 time = 530
.meas tran vdout0_8ck105 FIND v(dout0_8) AT=530.025n

* CHECK dout0_9 Vdout0_9ck105 = 0.9 time = 530
.meas tran vdout0_9ck105 FIND v(dout0_9) AT=530.025n

* CHECK dout0_10 Vdout0_10ck105 = 0.9 time = 530
.meas tran vdout0_10ck105 FIND v(dout0_10) AT=530.025n

* CHECK dout0_11 Vdout0_11ck105 = 0.9 time = 530
.meas tran vdout0_11ck105 FIND v(dout0_11) AT=530.025n

* CHECK dout0_12 Vdout0_12ck105 = 0 time = 530
.meas tran vdout0_12ck105 FIND v(dout0_12) AT=530.025n

* CHECK dout0_13 Vdout0_13ck105 = 0 time = 530
.meas tran vdout0_13ck105 FIND v(dout0_13) AT=530.025n

* CHECK dout0_14 Vdout0_14ck105 = 0 time = 530
.meas tran vdout0_14ck105 FIND v(dout0_14) AT=530.025n

* CHECK dout0_15 Vdout0_15ck105 = 0 time = 530
.meas tran vdout0_15ck105 FIND v(dout0_15) AT=530.025n

* CHECK dout0_16 Vdout0_16ck105 = 0.9 time = 530
.meas tran vdout0_16ck105 FIND v(dout0_16) AT=530.025n

* CHECK dout0_17 Vdout0_17ck105 = 0.9 time = 530
.meas tran vdout0_17ck105 FIND v(dout0_17) AT=530.025n

* CHECK dout0_18 Vdout0_18ck105 = 0.9 time = 530
.meas tran vdout0_18ck105 FIND v(dout0_18) AT=530.025n

* CHECK dout0_19 Vdout0_19ck105 = 0.9 time = 530
.meas tran vdout0_19ck105 FIND v(dout0_19) AT=530.025n

* CHECK dout0_20 Vdout0_20ck105 = 0.9 time = 530
.meas tran vdout0_20ck105 FIND v(dout0_20) AT=530.025n

* CHECK dout0_21 Vdout0_21ck105 = 0 time = 530
.meas tran vdout0_21ck105 FIND v(dout0_21) AT=530.025n

* CHECK dout0_22 Vdout0_22ck105 = 0.9 time = 530
.meas tran vdout0_22ck105 FIND v(dout0_22) AT=530.025n

* CHECK dout0_23 Vdout0_23ck105 = 0 time = 530
.meas tran vdout0_23ck105 FIND v(dout0_23) AT=530.025n

* CHECK dout0_24 Vdout0_24ck105 = 0 time = 530
.meas tran vdout0_24ck105 FIND v(dout0_24) AT=530.025n

* CHECK dout0_25 Vdout0_25ck105 = 0.9 time = 530
.meas tran vdout0_25ck105 FIND v(dout0_25) AT=530.025n

* CHECK dout0_26 Vdout0_26ck105 = 0.9 time = 530
.meas tran vdout0_26ck105 FIND v(dout0_26) AT=530.025n

* CHECK dout0_27 Vdout0_27ck105 = 0 time = 530
.meas tran vdout0_27ck105 FIND v(dout0_27) AT=530.025n

* CHECK dout0_28 Vdout0_28ck105 = 0.9 time = 530
.meas tran vdout0_28ck105 FIND v(dout0_28) AT=530.025n

* CHECK dout0_29 Vdout0_29ck105 = 0 time = 530
.meas tran vdout0_29ck105 FIND v(dout0_29) AT=530.025n

* CHECK dout0_30 Vdout0_30ck105 = 0 time = 530
.meas tran vdout0_30ck105 FIND v(dout0_30) AT=530.025n

* CHECK dout0_31 Vdout0_31ck105 = 0 time = 530
.meas tran vdout0_31ck105 FIND v(dout0_31) AT=530.025n

* CHECK dout0_32 Vdout0_32ck105 = 0 time = 530
.meas tran vdout0_32ck105 FIND v(dout0_32) AT=530.025n

* CHECK dout0_33 Vdout0_33ck105 = 0.9 time = 530
.meas tran vdout0_33ck105 FIND v(dout0_33) AT=530.025n

* CHECK dout0_34 Vdout0_34ck105 = 0.9 time = 530
.meas tran vdout0_34ck105 FIND v(dout0_34) AT=530.025n

* CHECK dout0_35 Vdout0_35ck105 = 0 time = 530
.meas tran vdout0_35ck105 FIND v(dout0_35) AT=530.025n

* CHECK dout0_36 Vdout0_36ck105 = 0.9 time = 530
.meas tran vdout0_36ck105 FIND v(dout0_36) AT=530.025n

* CHECK dout0_37 Vdout0_37ck105 = 0.9 time = 530
.meas tran vdout0_37ck105 FIND v(dout0_37) AT=530.025n

* CHECK dout0_38 Vdout0_38ck105 = 0.9 time = 530
.meas tran vdout0_38ck105 FIND v(dout0_38) AT=530.025n

* CHECK dout0_39 Vdout0_39ck105 = 0.9 time = 530
.meas tran vdout0_39ck105 FIND v(dout0_39) AT=530.025n

* CHECK dout0_0 Vdout0_0ck107 = 0 time = 540
.meas tran vdout0_0ck107 FIND v(dout0_0) AT=540.025n

* CHECK dout0_1 Vdout0_1ck107 = 0.9 time = 540
.meas tran vdout0_1ck107 FIND v(dout0_1) AT=540.025n

* CHECK dout0_2 Vdout0_2ck107 = 0.9 time = 540
.meas tran vdout0_2ck107 FIND v(dout0_2) AT=540.025n

* CHECK dout0_3 Vdout0_3ck107 = 0 time = 540
.meas tran vdout0_3ck107 FIND v(dout0_3) AT=540.025n

* CHECK dout0_4 Vdout0_4ck107 = 0 time = 540
.meas tran vdout0_4ck107 FIND v(dout0_4) AT=540.025n

* CHECK dout0_5 Vdout0_5ck107 = 0 time = 540
.meas tran vdout0_5ck107 FIND v(dout0_5) AT=540.025n

* CHECK dout0_6 Vdout0_6ck107 = 0.9 time = 540
.meas tran vdout0_6ck107 FIND v(dout0_6) AT=540.025n

* CHECK dout0_7 Vdout0_7ck107 = 0.9 time = 540
.meas tran vdout0_7ck107 FIND v(dout0_7) AT=540.025n

* CHECK dout0_8 Vdout0_8ck107 = 0.9 time = 540
.meas tran vdout0_8ck107 FIND v(dout0_8) AT=540.025n

* CHECK dout0_9 Vdout0_9ck107 = 0.9 time = 540
.meas tran vdout0_9ck107 FIND v(dout0_9) AT=540.025n

* CHECK dout0_10 Vdout0_10ck107 = 0 time = 540
.meas tran vdout0_10ck107 FIND v(dout0_10) AT=540.025n

* CHECK dout0_11 Vdout0_11ck107 = 0.9 time = 540
.meas tran vdout0_11ck107 FIND v(dout0_11) AT=540.025n

* CHECK dout0_12 Vdout0_12ck107 = 0 time = 540
.meas tran vdout0_12ck107 FIND v(dout0_12) AT=540.025n

* CHECK dout0_13 Vdout0_13ck107 = 0.9 time = 540
.meas tran vdout0_13ck107 FIND v(dout0_13) AT=540.025n

* CHECK dout0_14 Vdout0_14ck107 = 0 time = 540
.meas tran vdout0_14ck107 FIND v(dout0_14) AT=540.025n

* CHECK dout0_15 Vdout0_15ck107 = 0.9 time = 540
.meas tran vdout0_15ck107 FIND v(dout0_15) AT=540.025n

* CHECK dout0_16 Vdout0_16ck107 = 0.9 time = 540
.meas tran vdout0_16ck107 FIND v(dout0_16) AT=540.025n

* CHECK dout0_17 Vdout0_17ck107 = 0.9 time = 540
.meas tran vdout0_17ck107 FIND v(dout0_17) AT=540.025n

* CHECK dout0_18 Vdout0_18ck107 = 0.9 time = 540
.meas tran vdout0_18ck107 FIND v(dout0_18) AT=540.025n

* CHECK dout0_19 Vdout0_19ck107 = 0.9 time = 540
.meas tran vdout0_19ck107 FIND v(dout0_19) AT=540.025n

* CHECK dout0_20 Vdout0_20ck107 = 0.9 time = 540
.meas tran vdout0_20ck107 FIND v(dout0_20) AT=540.025n

* CHECK dout0_21 Vdout0_21ck107 = 0.9 time = 540
.meas tran vdout0_21ck107 FIND v(dout0_21) AT=540.025n

* CHECK dout0_22 Vdout0_22ck107 = 0 time = 540
.meas tran vdout0_22ck107 FIND v(dout0_22) AT=540.025n

* CHECK dout0_23 Vdout0_23ck107 = 0.9 time = 540
.meas tran vdout0_23ck107 FIND v(dout0_23) AT=540.025n

* CHECK dout0_24 Vdout0_24ck107 = 0 time = 540
.meas tran vdout0_24ck107 FIND v(dout0_24) AT=540.025n

* CHECK dout0_25 Vdout0_25ck107 = 0 time = 540
.meas tran vdout0_25ck107 FIND v(dout0_25) AT=540.025n

* CHECK dout0_26 Vdout0_26ck107 = 0.9 time = 540
.meas tran vdout0_26ck107 FIND v(dout0_26) AT=540.025n

* CHECK dout0_27 Vdout0_27ck107 = 0.9 time = 540
.meas tran vdout0_27ck107 FIND v(dout0_27) AT=540.025n

* CHECK dout0_28 Vdout0_28ck107 = 0 time = 540
.meas tran vdout0_28ck107 FIND v(dout0_28) AT=540.025n

* CHECK dout0_29 Vdout0_29ck107 = 0 time = 540
.meas tran vdout0_29ck107 FIND v(dout0_29) AT=540.025n

* CHECK dout0_30 Vdout0_30ck107 = 0 time = 540
.meas tran vdout0_30ck107 FIND v(dout0_30) AT=540.025n

* CHECK dout0_31 Vdout0_31ck107 = 0 time = 540
.meas tran vdout0_31ck107 FIND v(dout0_31) AT=540.025n

* CHECK dout0_32 Vdout0_32ck107 = 0 time = 540
.meas tran vdout0_32ck107 FIND v(dout0_32) AT=540.025n

* CHECK dout0_33 Vdout0_33ck107 = 0.9 time = 540
.meas tran vdout0_33ck107 FIND v(dout0_33) AT=540.025n

* CHECK dout0_34 Vdout0_34ck107 = 0 time = 540
.meas tran vdout0_34ck107 FIND v(dout0_34) AT=540.025n

* CHECK dout0_35 Vdout0_35ck107 = 0 time = 540
.meas tran vdout0_35ck107 FIND v(dout0_35) AT=540.025n

* CHECK dout0_36 Vdout0_36ck107 = 0 time = 540
.meas tran vdout0_36ck107 FIND v(dout0_36) AT=540.025n

* CHECK dout0_37 Vdout0_37ck107 = 0 time = 540
.meas tran vdout0_37ck107 FIND v(dout0_37) AT=540.025n

* CHECK dout0_38 Vdout0_38ck107 = 0 time = 540
.meas tran vdout0_38ck107 FIND v(dout0_38) AT=540.025n

* CHECK dout0_39 Vdout0_39ck107 = 0 time = 540
.meas tran vdout0_39ck107 FIND v(dout0_39) AT=540.025n

* CHECK dout0_0 Vdout0_0ck109 = 0.9 time = 550
.meas tran vdout0_0ck109 FIND v(dout0_0) AT=550.025n

* CHECK dout0_1 Vdout0_1ck109 = 0.9 time = 550
.meas tran vdout0_1ck109 FIND v(dout0_1) AT=550.025n

* CHECK dout0_2 Vdout0_2ck109 = 0.9 time = 550
.meas tran vdout0_2ck109 FIND v(dout0_2) AT=550.025n

* CHECK dout0_3 Vdout0_3ck109 = 0 time = 550
.meas tran vdout0_3ck109 FIND v(dout0_3) AT=550.025n

* CHECK dout0_4 Vdout0_4ck109 = 0.9 time = 550
.meas tran vdout0_4ck109 FIND v(dout0_4) AT=550.025n

* CHECK dout0_5 Vdout0_5ck109 = 0 time = 550
.meas tran vdout0_5ck109 FIND v(dout0_5) AT=550.025n

* CHECK dout0_6 Vdout0_6ck109 = 0 time = 550
.meas tran vdout0_6ck109 FIND v(dout0_6) AT=550.025n

* CHECK dout0_7 Vdout0_7ck109 = 0 time = 550
.meas tran vdout0_7ck109 FIND v(dout0_7) AT=550.025n

* CHECK dout0_8 Vdout0_8ck109 = 0 time = 550
.meas tran vdout0_8ck109 FIND v(dout0_8) AT=550.025n

* CHECK dout0_9 Vdout0_9ck109 = 0.9 time = 550
.meas tran vdout0_9ck109 FIND v(dout0_9) AT=550.025n

* CHECK dout0_10 Vdout0_10ck109 = 0 time = 550
.meas tran vdout0_10ck109 FIND v(dout0_10) AT=550.025n

* CHECK dout0_11 Vdout0_11ck109 = 0.9 time = 550
.meas tran vdout0_11ck109 FIND v(dout0_11) AT=550.025n

* CHECK dout0_12 Vdout0_12ck109 = 0.9 time = 550
.meas tran vdout0_12ck109 FIND v(dout0_12) AT=550.025n

* CHECK dout0_13 Vdout0_13ck109 = 0.9 time = 550
.meas tran vdout0_13ck109 FIND v(dout0_13) AT=550.025n

* CHECK dout0_14 Vdout0_14ck109 = 0 time = 550
.meas tran vdout0_14ck109 FIND v(dout0_14) AT=550.025n

* CHECK dout0_15 Vdout0_15ck109 = 0 time = 550
.meas tran vdout0_15ck109 FIND v(dout0_15) AT=550.025n

* CHECK dout0_16 Vdout0_16ck109 = 0.9 time = 550
.meas tran vdout0_16ck109 FIND v(dout0_16) AT=550.025n

* CHECK dout0_17 Vdout0_17ck109 = 0 time = 550
.meas tran vdout0_17ck109 FIND v(dout0_17) AT=550.025n

* CHECK dout0_18 Vdout0_18ck109 = 0.9 time = 550
.meas tran vdout0_18ck109 FIND v(dout0_18) AT=550.025n

* CHECK dout0_19 Vdout0_19ck109 = 0.9 time = 550
.meas tran vdout0_19ck109 FIND v(dout0_19) AT=550.025n

* CHECK dout0_20 Vdout0_20ck109 = 0.9 time = 550
.meas tran vdout0_20ck109 FIND v(dout0_20) AT=550.025n

* CHECK dout0_21 Vdout0_21ck109 = 0 time = 550
.meas tran vdout0_21ck109 FIND v(dout0_21) AT=550.025n

* CHECK dout0_22 Vdout0_22ck109 = 0 time = 550
.meas tran vdout0_22ck109 FIND v(dout0_22) AT=550.025n

* CHECK dout0_23 Vdout0_23ck109 = 0 time = 550
.meas tran vdout0_23ck109 FIND v(dout0_23) AT=550.025n

* CHECK dout0_24 Vdout0_24ck109 = 0.9 time = 550
.meas tran vdout0_24ck109 FIND v(dout0_24) AT=550.025n

* CHECK dout0_25 Vdout0_25ck109 = 0 time = 550
.meas tran vdout0_25ck109 FIND v(dout0_25) AT=550.025n

* CHECK dout0_26 Vdout0_26ck109 = 0 time = 550
.meas tran vdout0_26ck109 FIND v(dout0_26) AT=550.025n

* CHECK dout0_27 Vdout0_27ck109 = 0 time = 550
.meas tran vdout0_27ck109 FIND v(dout0_27) AT=550.025n

* CHECK dout0_28 Vdout0_28ck109 = 0 time = 550
.meas tran vdout0_28ck109 FIND v(dout0_28) AT=550.025n

* CHECK dout0_29 Vdout0_29ck109 = 0.9 time = 550
.meas tran vdout0_29ck109 FIND v(dout0_29) AT=550.025n

* CHECK dout0_30 Vdout0_30ck109 = 0.9 time = 550
.meas tran vdout0_30ck109 FIND v(dout0_30) AT=550.025n

* CHECK dout0_31 Vdout0_31ck109 = 0.9 time = 550
.meas tran vdout0_31ck109 FIND v(dout0_31) AT=550.025n

* CHECK dout0_32 Vdout0_32ck109 = 0 time = 550
.meas tran vdout0_32ck109 FIND v(dout0_32) AT=550.025n

* CHECK dout0_33 Vdout0_33ck109 = 0.9 time = 550
.meas tran vdout0_33ck109 FIND v(dout0_33) AT=550.025n

* CHECK dout0_34 Vdout0_34ck109 = 0.9 time = 550
.meas tran vdout0_34ck109 FIND v(dout0_34) AT=550.025n

* CHECK dout0_35 Vdout0_35ck109 = 0.9 time = 550
.meas tran vdout0_35ck109 FIND v(dout0_35) AT=550.025n

* CHECK dout0_36 Vdout0_36ck109 = 0 time = 550
.meas tran vdout0_36ck109 FIND v(dout0_36) AT=550.025n

* CHECK dout0_37 Vdout0_37ck109 = 0 time = 550
.meas tran vdout0_37ck109 FIND v(dout0_37) AT=550.025n

* CHECK dout0_38 Vdout0_38ck109 = 0 time = 550
.meas tran vdout0_38ck109 FIND v(dout0_38) AT=550.025n

* CHECK dout0_39 Vdout0_39ck109 = 0.9 time = 550
.meas tran vdout0_39ck109 FIND v(dout0_39) AT=550.025n

* CHECK dout0_0 Vdout0_0ck111 = 0.9 time = 560
.meas tran vdout0_0ck111 FIND v(dout0_0) AT=560.025n

* CHECK dout0_1 Vdout0_1ck111 = 0.9 time = 560
.meas tran vdout0_1ck111 FIND v(dout0_1) AT=560.025n

* CHECK dout0_2 Vdout0_2ck111 = 0.9 time = 560
.meas tran vdout0_2ck111 FIND v(dout0_2) AT=560.025n

* CHECK dout0_3 Vdout0_3ck111 = 0 time = 560
.meas tran vdout0_3ck111 FIND v(dout0_3) AT=560.025n

* CHECK dout0_4 Vdout0_4ck111 = 0 time = 560
.meas tran vdout0_4ck111 FIND v(dout0_4) AT=560.025n

* CHECK dout0_5 Vdout0_5ck111 = 0.9 time = 560
.meas tran vdout0_5ck111 FIND v(dout0_5) AT=560.025n

* CHECK dout0_6 Vdout0_6ck111 = 0.9 time = 560
.meas tran vdout0_6ck111 FIND v(dout0_6) AT=560.025n

* CHECK dout0_7 Vdout0_7ck111 = 0 time = 560
.meas tran vdout0_7ck111 FIND v(dout0_7) AT=560.025n

* CHECK dout0_8 Vdout0_8ck111 = 0 time = 560
.meas tran vdout0_8ck111 FIND v(dout0_8) AT=560.025n

* CHECK dout0_9 Vdout0_9ck111 = 0 time = 560
.meas tran vdout0_9ck111 FIND v(dout0_9) AT=560.025n

* CHECK dout0_10 Vdout0_10ck111 = 0 time = 560
.meas tran vdout0_10ck111 FIND v(dout0_10) AT=560.025n

* CHECK dout0_11 Vdout0_11ck111 = 0.9 time = 560
.meas tran vdout0_11ck111 FIND v(dout0_11) AT=560.025n

* CHECK dout0_12 Vdout0_12ck111 = 0 time = 560
.meas tran vdout0_12ck111 FIND v(dout0_12) AT=560.025n

* CHECK dout0_13 Vdout0_13ck111 = 0.9 time = 560
.meas tran vdout0_13ck111 FIND v(dout0_13) AT=560.025n

* CHECK dout0_14 Vdout0_14ck111 = 0 time = 560
.meas tran vdout0_14ck111 FIND v(dout0_14) AT=560.025n

* CHECK dout0_15 Vdout0_15ck111 = 0.9 time = 560
.meas tran vdout0_15ck111 FIND v(dout0_15) AT=560.025n

* CHECK dout0_16 Vdout0_16ck111 = 0.9 time = 560
.meas tran vdout0_16ck111 FIND v(dout0_16) AT=560.025n

* CHECK dout0_17 Vdout0_17ck111 = 0 time = 560
.meas tran vdout0_17ck111 FIND v(dout0_17) AT=560.025n

* CHECK dout0_18 Vdout0_18ck111 = 0.9 time = 560
.meas tran vdout0_18ck111 FIND v(dout0_18) AT=560.025n

* CHECK dout0_19 Vdout0_19ck111 = 0.9 time = 560
.meas tran vdout0_19ck111 FIND v(dout0_19) AT=560.025n

* CHECK dout0_20 Vdout0_20ck111 = 0 time = 560
.meas tran vdout0_20ck111 FIND v(dout0_20) AT=560.025n

* CHECK dout0_21 Vdout0_21ck111 = 0.9 time = 560
.meas tran vdout0_21ck111 FIND v(dout0_21) AT=560.025n

* CHECK dout0_22 Vdout0_22ck111 = 0 time = 560
.meas tran vdout0_22ck111 FIND v(dout0_22) AT=560.025n

* CHECK dout0_23 Vdout0_23ck111 = 0 time = 560
.meas tran vdout0_23ck111 FIND v(dout0_23) AT=560.025n

* CHECK dout0_24 Vdout0_24ck111 = 0.9 time = 560
.meas tran vdout0_24ck111 FIND v(dout0_24) AT=560.025n

* CHECK dout0_25 Vdout0_25ck111 = 0.9 time = 560
.meas tran vdout0_25ck111 FIND v(dout0_25) AT=560.025n

* CHECK dout0_26 Vdout0_26ck111 = 0.9 time = 560
.meas tran vdout0_26ck111 FIND v(dout0_26) AT=560.025n

* CHECK dout0_27 Vdout0_27ck111 = 0 time = 560
.meas tran vdout0_27ck111 FIND v(dout0_27) AT=560.025n

* CHECK dout0_28 Vdout0_28ck111 = 0.9 time = 560
.meas tran vdout0_28ck111 FIND v(dout0_28) AT=560.025n

* CHECK dout0_29 Vdout0_29ck111 = 0 time = 560
.meas tran vdout0_29ck111 FIND v(dout0_29) AT=560.025n

* CHECK dout0_30 Vdout0_30ck111 = 0.9 time = 560
.meas tran vdout0_30ck111 FIND v(dout0_30) AT=560.025n

* CHECK dout0_31 Vdout0_31ck111 = 0.9 time = 560
.meas tran vdout0_31ck111 FIND v(dout0_31) AT=560.025n

* CHECK dout0_32 Vdout0_32ck111 = 0 time = 560
.meas tran vdout0_32ck111 FIND v(dout0_32) AT=560.025n

* CHECK dout0_33 Vdout0_33ck111 = 0.9 time = 560
.meas tran vdout0_33ck111 FIND v(dout0_33) AT=560.025n

* CHECK dout0_34 Vdout0_34ck111 = 0 time = 560
.meas tran vdout0_34ck111 FIND v(dout0_34) AT=560.025n

* CHECK dout0_35 Vdout0_35ck111 = 0.9 time = 560
.meas tran vdout0_35ck111 FIND v(dout0_35) AT=560.025n

* CHECK dout0_36 Vdout0_36ck111 = 0 time = 560
.meas tran vdout0_36ck111 FIND v(dout0_36) AT=560.025n

* CHECK dout0_37 Vdout0_37ck111 = 0 time = 560
.meas tran vdout0_37ck111 FIND v(dout0_37) AT=560.025n

* CHECK dout0_38 Vdout0_38ck111 = 0.9 time = 560
.meas tran vdout0_38ck111 FIND v(dout0_38) AT=560.025n

* CHECK dout0_39 Vdout0_39ck111 = 0 time = 560
.meas tran vdout0_39ck111 FIND v(dout0_39) AT=560.025n

* CHECK dout0_0 Vdout0_0ck112 = 0.9 time = 565
.meas tran vdout0_0ck112 FIND v(dout0_0) AT=565.025n

* CHECK dout0_1 Vdout0_1ck112 = 0.9 time = 565
.meas tran vdout0_1ck112 FIND v(dout0_1) AT=565.025n

* CHECK dout0_2 Vdout0_2ck112 = 0.9 time = 565
.meas tran vdout0_2ck112 FIND v(dout0_2) AT=565.025n

* CHECK dout0_3 Vdout0_3ck112 = 0 time = 565
.meas tran vdout0_3ck112 FIND v(dout0_3) AT=565.025n

* CHECK dout0_4 Vdout0_4ck112 = 0 time = 565
.meas tran vdout0_4ck112 FIND v(dout0_4) AT=565.025n

* CHECK dout0_5 Vdout0_5ck112 = 0.9 time = 565
.meas tran vdout0_5ck112 FIND v(dout0_5) AT=565.025n

* CHECK dout0_6 Vdout0_6ck112 = 0.9 time = 565
.meas tran vdout0_6ck112 FIND v(dout0_6) AT=565.025n

* CHECK dout0_7 Vdout0_7ck112 = 0 time = 565
.meas tran vdout0_7ck112 FIND v(dout0_7) AT=565.025n

* CHECK dout0_8 Vdout0_8ck112 = 0 time = 565
.meas tran vdout0_8ck112 FIND v(dout0_8) AT=565.025n

* CHECK dout0_9 Vdout0_9ck112 = 0 time = 565
.meas tran vdout0_9ck112 FIND v(dout0_9) AT=565.025n

* CHECK dout0_10 Vdout0_10ck112 = 0 time = 565
.meas tran vdout0_10ck112 FIND v(dout0_10) AT=565.025n

* CHECK dout0_11 Vdout0_11ck112 = 0.9 time = 565
.meas tran vdout0_11ck112 FIND v(dout0_11) AT=565.025n

* CHECK dout0_12 Vdout0_12ck112 = 0 time = 565
.meas tran vdout0_12ck112 FIND v(dout0_12) AT=565.025n

* CHECK dout0_13 Vdout0_13ck112 = 0.9 time = 565
.meas tran vdout0_13ck112 FIND v(dout0_13) AT=565.025n

* CHECK dout0_14 Vdout0_14ck112 = 0 time = 565
.meas tran vdout0_14ck112 FIND v(dout0_14) AT=565.025n

* CHECK dout0_15 Vdout0_15ck112 = 0.9 time = 565
.meas tran vdout0_15ck112 FIND v(dout0_15) AT=565.025n

* CHECK dout0_16 Vdout0_16ck112 = 0.9 time = 565
.meas tran vdout0_16ck112 FIND v(dout0_16) AT=565.025n

* CHECK dout0_17 Vdout0_17ck112 = 0 time = 565
.meas tran vdout0_17ck112 FIND v(dout0_17) AT=565.025n

* CHECK dout0_18 Vdout0_18ck112 = 0.9 time = 565
.meas tran vdout0_18ck112 FIND v(dout0_18) AT=565.025n

* CHECK dout0_19 Vdout0_19ck112 = 0.9 time = 565
.meas tran vdout0_19ck112 FIND v(dout0_19) AT=565.025n

* CHECK dout0_20 Vdout0_20ck112 = 0 time = 565
.meas tran vdout0_20ck112 FIND v(dout0_20) AT=565.025n

* CHECK dout0_21 Vdout0_21ck112 = 0.9 time = 565
.meas tran vdout0_21ck112 FIND v(dout0_21) AT=565.025n

* CHECK dout0_22 Vdout0_22ck112 = 0 time = 565
.meas tran vdout0_22ck112 FIND v(dout0_22) AT=565.025n

* CHECK dout0_23 Vdout0_23ck112 = 0 time = 565
.meas tran vdout0_23ck112 FIND v(dout0_23) AT=565.025n

* CHECK dout0_24 Vdout0_24ck112 = 0.9 time = 565
.meas tran vdout0_24ck112 FIND v(dout0_24) AT=565.025n

* CHECK dout0_25 Vdout0_25ck112 = 0.9 time = 565
.meas tran vdout0_25ck112 FIND v(dout0_25) AT=565.025n

* CHECK dout0_26 Vdout0_26ck112 = 0.9 time = 565
.meas tran vdout0_26ck112 FIND v(dout0_26) AT=565.025n

* CHECK dout0_27 Vdout0_27ck112 = 0 time = 565
.meas tran vdout0_27ck112 FIND v(dout0_27) AT=565.025n

* CHECK dout0_28 Vdout0_28ck112 = 0.9 time = 565
.meas tran vdout0_28ck112 FIND v(dout0_28) AT=565.025n

* CHECK dout0_29 Vdout0_29ck112 = 0 time = 565
.meas tran vdout0_29ck112 FIND v(dout0_29) AT=565.025n

* CHECK dout0_30 Vdout0_30ck112 = 0.9 time = 565
.meas tran vdout0_30ck112 FIND v(dout0_30) AT=565.025n

* CHECK dout0_31 Vdout0_31ck112 = 0.9 time = 565
.meas tran vdout0_31ck112 FIND v(dout0_31) AT=565.025n

* CHECK dout0_32 Vdout0_32ck112 = 0 time = 565
.meas tran vdout0_32ck112 FIND v(dout0_32) AT=565.025n

* CHECK dout0_33 Vdout0_33ck112 = 0.9 time = 565
.meas tran vdout0_33ck112 FIND v(dout0_33) AT=565.025n

* CHECK dout0_34 Vdout0_34ck112 = 0 time = 565
.meas tran vdout0_34ck112 FIND v(dout0_34) AT=565.025n

* CHECK dout0_35 Vdout0_35ck112 = 0.9 time = 565
.meas tran vdout0_35ck112 FIND v(dout0_35) AT=565.025n

* CHECK dout0_36 Vdout0_36ck112 = 0 time = 565
.meas tran vdout0_36ck112 FIND v(dout0_36) AT=565.025n

* CHECK dout0_37 Vdout0_37ck112 = 0 time = 565
.meas tran vdout0_37ck112 FIND v(dout0_37) AT=565.025n

* CHECK dout0_38 Vdout0_38ck112 = 0.9 time = 565
.meas tran vdout0_38ck112 FIND v(dout0_38) AT=565.025n

* CHECK dout0_39 Vdout0_39ck112 = 0 time = 565
.meas tran vdout0_39ck112 FIND v(dout0_39) AT=565.025n

* CHECK dout0_0 Vdout0_0ck118 = 0 time = 595
.meas tran vdout0_0ck118 FIND v(dout0_0) AT=595.025n

* CHECK dout0_1 Vdout0_1ck118 = 0.9 time = 595
.meas tran vdout0_1ck118 FIND v(dout0_1) AT=595.025n

* CHECK dout0_2 Vdout0_2ck118 = 0 time = 595
.meas tran vdout0_2ck118 FIND v(dout0_2) AT=595.025n

* CHECK dout0_3 Vdout0_3ck118 = 0 time = 595
.meas tran vdout0_3ck118 FIND v(dout0_3) AT=595.025n

* CHECK dout0_4 Vdout0_4ck118 = 0 time = 595
.meas tran vdout0_4ck118 FIND v(dout0_4) AT=595.025n

* CHECK dout0_5 Vdout0_5ck118 = 0 time = 595
.meas tran vdout0_5ck118 FIND v(dout0_5) AT=595.025n

* CHECK dout0_6 Vdout0_6ck118 = 0.9 time = 595
.meas tran vdout0_6ck118 FIND v(dout0_6) AT=595.025n

* CHECK dout0_7 Vdout0_7ck118 = 0 time = 595
.meas tran vdout0_7ck118 FIND v(dout0_7) AT=595.025n

* CHECK dout0_8 Vdout0_8ck118 = 0 time = 595
.meas tran vdout0_8ck118 FIND v(dout0_8) AT=595.025n

* CHECK dout0_9 Vdout0_9ck118 = 0 time = 595
.meas tran vdout0_9ck118 FIND v(dout0_9) AT=595.025n

* CHECK dout0_10 Vdout0_10ck118 = 0.9 time = 595
.meas tran vdout0_10ck118 FIND v(dout0_10) AT=595.025n

* CHECK dout0_11 Vdout0_11ck118 = 0 time = 595
.meas tran vdout0_11ck118 FIND v(dout0_11) AT=595.025n

* CHECK dout0_12 Vdout0_12ck118 = 0 time = 595
.meas tran vdout0_12ck118 FIND v(dout0_12) AT=595.025n

* CHECK dout0_13 Vdout0_13ck118 = 0.9 time = 595
.meas tran vdout0_13ck118 FIND v(dout0_13) AT=595.025n

* CHECK dout0_14 Vdout0_14ck118 = 0.9 time = 595
.meas tran vdout0_14ck118 FIND v(dout0_14) AT=595.025n

* CHECK dout0_15 Vdout0_15ck118 = 0 time = 595
.meas tran vdout0_15ck118 FIND v(dout0_15) AT=595.025n

* CHECK dout0_16 Vdout0_16ck118 = 0 time = 595
.meas tran vdout0_16ck118 FIND v(dout0_16) AT=595.025n

* CHECK dout0_17 Vdout0_17ck118 = 0.9 time = 595
.meas tran vdout0_17ck118 FIND v(dout0_17) AT=595.025n

* CHECK dout0_18 Vdout0_18ck118 = 0 time = 595
.meas tran vdout0_18ck118 FIND v(dout0_18) AT=595.025n

* CHECK dout0_19 Vdout0_19ck118 = 0 time = 595
.meas tran vdout0_19ck118 FIND v(dout0_19) AT=595.025n

* CHECK dout0_20 Vdout0_20ck118 = 0.9 time = 595
.meas tran vdout0_20ck118 FIND v(dout0_20) AT=595.025n

* CHECK dout0_21 Vdout0_21ck118 = 0 time = 595
.meas tran vdout0_21ck118 FIND v(dout0_21) AT=595.025n

* CHECK dout0_22 Vdout0_22ck118 = 0.9 time = 595
.meas tran vdout0_22ck118 FIND v(dout0_22) AT=595.025n

* CHECK dout0_23 Vdout0_23ck118 = 0 time = 595
.meas tran vdout0_23ck118 FIND v(dout0_23) AT=595.025n

* CHECK dout0_24 Vdout0_24ck118 = 0 time = 595
.meas tran vdout0_24ck118 FIND v(dout0_24) AT=595.025n

* CHECK dout0_25 Vdout0_25ck118 = 0.9 time = 595
.meas tran vdout0_25ck118 FIND v(dout0_25) AT=595.025n

* CHECK dout0_26 Vdout0_26ck118 = 0.9 time = 595
.meas tran vdout0_26ck118 FIND v(dout0_26) AT=595.025n

* CHECK dout0_27 Vdout0_27ck118 = 0 time = 595
.meas tran vdout0_27ck118 FIND v(dout0_27) AT=595.025n

* CHECK dout0_28 Vdout0_28ck118 = 0.9 time = 595
.meas tran vdout0_28ck118 FIND v(dout0_28) AT=595.025n

* CHECK dout0_29 Vdout0_29ck118 = 0 time = 595
.meas tran vdout0_29ck118 FIND v(dout0_29) AT=595.025n

* CHECK dout0_30 Vdout0_30ck118 = 0 time = 595
.meas tran vdout0_30ck118 FIND v(dout0_30) AT=595.025n

* CHECK dout0_31 Vdout0_31ck118 = 0 time = 595
.meas tran vdout0_31ck118 FIND v(dout0_31) AT=595.025n

* CHECK dout0_32 Vdout0_32ck118 = 0 time = 595
.meas tran vdout0_32ck118 FIND v(dout0_32) AT=595.025n

* CHECK dout0_33 Vdout0_33ck118 = 0.9 time = 595
.meas tran vdout0_33ck118 FIND v(dout0_33) AT=595.025n

* CHECK dout0_34 Vdout0_34ck118 = 0.9 time = 595
.meas tran vdout0_34ck118 FIND v(dout0_34) AT=595.025n

* CHECK dout0_35 Vdout0_35ck118 = 0 time = 595
.meas tran vdout0_35ck118 FIND v(dout0_35) AT=595.025n

* CHECK dout0_36 Vdout0_36ck118 = 0.9 time = 595
.meas tran vdout0_36ck118 FIND v(dout0_36) AT=595.025n

* CHECK dout0_37 Vdout0_37ck118 = 0.9 time = 595
.meas tran vdout0_37ck118 FIND v(dout0_37) AT=595.025n

* CHECK dout0_38 Vdout0_38ck118 = 0.9 time = 595
.meas tran vdout0_38ck118 FIND v(dout0_38) AT=595.025n

* CHECK dout0_39 Vdout0_39ck118 = 0.9 time = 595
.meas tran vdout0_39ck118 FIND v(dout0_39) AT=595.025n

* CHECK dout0_0 Vdout0_0ck119 = 0 time = 600
.meas tran vdout0_0ck119 FIND v(dout0_0) AT=600.025n

* CHECK dout0_1 Vdout0_1ck119 = 0.9 time = 600
.meas tran vdout0_1ck119 FIND v(dout0_1) AT=600.025n

* CHECK dout0_2 Vdout0_2ck119 = 0 time = 600
.meas tran vdout0_2ck119 FIND v(dout0_2) AT=600.025n

* CHECK dout0_3 Vdout0_3ck119 = 0 time = 600
.meas tran vdout0_3ck119 FIND v(dout0_3) AT=600.025n

* CHECK dout0_4 Vdout0_4ck119 = 0 time = 600
.meas tran vdout0_4ck119 FIND v(dout0_4) AT=600.025n

* CHECK dout0_5 Vdout0_5ck119 = 0 time = 600
.meas tran vdout0_5ck119 FIND v(dout0_5) AT=600.025n

* CHECK dout0_6 Vdout0_6ck119 = 0.9 time = 600
.meas tran vdout0_6ck119 FIND v(dout0_6) AT=600.025n

* CHECK dout0_7 Vdout0_7ck119 = 0 time = 600
.meas tran vdout0_7ck119 FIND v(dout0_7) AT=600.025n

* CHECK dout0_8 Vdout0_8ck119 = 0 time = 600
.meas tran vdout0_8ck119 FIND v(dout0_8) AT=600.025n

* CHECK dout0_9 Vdout0_9ck119 = 0 time = 600
.meas tran vdout0_9ck119 FIND v(dout0_9) AT=600.025n

* CHECK dout0_10 Vdout0_10ck119 = 0.9 time = 600
.meas tran vdout0_10ck119 FIND v(dout0_10) AT=600.025n

* CHECK dout0_11 Vdout0_11ck119 = 0 time = 600
.meas tran vdout0_11ck119 FIND v(dout0_11) AT=600.025n

* CHECK dout0_12 Vdout0_12ck119 = 0 time = 600
.meas tran vdout0_12ck119 FIND v(dout0_12) AT=600.025n

* CHECK dout0_13 Vdout0_13ck119 = 0.9 time = 600
.meas tran vdout0_13ck119 FIND v(dout0_13) AT=600.025n

* CHECK dout0_14 Vdout0_14ck119 = 0.9 time = 600
.meas tran vdout0_14ck119 FIND v(dout0_14) AT=600.025n

* CHECK dout0_15 Vdout0_15ck119 = 0 time = 600
.meas tran vdout0_15ck119 FIND v(dout0_15) AT=600.025n

* CHECK dout0_16 Vdout0_16ck119 = 0 time = 600
.meas tran vdout0_16ck119 FIND v(dout0_16) AT=600.025n

* CHECK dout0_17 Vdout0_17ck119 = 0.9 time = 600
.meas tran vdout0_17ck119 FIND v(dout0_17) AT=600.025n

* CHECK dout0_18 Vdout0_18ck119 = 0 time = 600
.meas tran vdout0_18ck119 FIND v(dout0_18) AT=600.025n

* CHECK dout0_19 Vdout0_19ck119 = 0 time = 600
.meas tran vdout0_19ck119 FIND v(dout0_19) AT=600.025n

* CHECK dout0_20 Vdout0_20ck119 = 0.9 time = 600
.meas tran vdout0_20ck119 FIND v(dout0_20) AT=600.025n

* CHECK dout0_21 Vdout0_21ck119 = 0 time = 600
.meas tran vdout0_21ck119 FIND v(dout0_21) AT=600.025n

* CHECK dout0_22 Vdout0_22ck119 = 0.9 time = 600
.meas tran vdout0_22ck119 FIND v(dout0_22) AT=600.025n

* CHECK dout0_23 Vdout0_23ck119 = 0 time = 600
.meas tran vdout0_23ck119 FIND v(dout0_23) AT=600.025n

* CHECK dout0_24 Vdout0_24ck119 = 0 time = 600
.meas tran vdout0_24ck119 FIND v(dout0_24) AT=600.025n

* CHECK dout0_25 Vdout0_25ck119 = 0.9 time = 600
.meas tran vdout0_25ck119 FIND v(dout0_25) AT=600.025n

* CHECK dout0_26 Vdout0_26ck119 = 0.9 time = 600
.meas tran vdout0_26ck119 FIND v(dout0_26) AT=600.025n

* CHECK dout0_27 Vdout0_27ck119 = 0 time = 600
.meas tran vdout0_27ck119 FIND v(dout0_27) AT=600.025n

* CHECK dout0_28 Vdout0_28ck119 = 0.9 time = 600
.meas tran vdout0_28ck119 FIND v(dout0_28) AT=600.025n

* CHECK dout0_29 Vdout0_29ck119 = 0 time = 600
.meas tran vdout0_29ck119 FIND v(dout0_29) AT=600.025n

* CHECK dout0_30 Vdout0_30ck119 = 0 time = 600
.meas tran vdout0_30ck119 FIND v(dout0_30) AT=600.025n

* CHECK dout0_31 Vdout0_31ck119 = 0 time = 600
.meas tran vdout0_31ck119 FIND v(dout0_31) AT=600.025n

* CHECK dout0_32 Vdout0_32ck119 = 0 time = 600
.meas tran vdout0_32ck119 FIND v(dout0_32) AT=600.025n

* CHECK dout0_33 Vdout0_33ck119 = 0.9 time = 600
.meas tran vdout0_33ck119 FIND v(dout0_33) AT=600.025n

* CHECK dout0_34 Vdout0_34ck119 = 0.9 time = 600
.meas tran vdout0_34ck119 FIND v(dout0_34) AT=600.025n

* CHECK dout0_35 Vdout0_35ck119 = 0 time = 600
.meas tran vdout0_35ck119 FIND v(dout0_35) AT=600.025n

* CHECK dout0_36 Vdout0_36ck119 = 0.9 time = 600
.meas tran vdout0_36ck119 FIND v(dout0_36) AT=600.025n

* CHECK dout0_37 Vdout0_37ck119 = 0.9 time = 600
.meas tran vdout0_37ck119 FIND v(dout0_37) AT=600.025n

* CHECK dout0_38 Vdout0_38ck119 = 0.9 time = 600
.meas tran vdout0_38ck119 FIND v(dout0_38) AT=600.025n

* CHECK dout0_39 Vdout0_39ck119 = 0.9 time = 600
.meas tran vdout0_39ck119 FIND v(dout0_39) AT=600.025n

* CHECK dout0_0 Vdout0_0ck121 = 0.9 time = 610
.meas tran vdout0_0ck121 FIND v(dout0_0) AT=610.025n

* CHECK dout0_1 Vdout0_1ck121 = 0.9 time = 610
.meas tran vdout0_1ck121 FIND v(dout0_1) AT=610.025n

* CHECK dout0_2 Vdout0_2ck121 = 0.9 time = 610
.meas tran vdout0_2ck121 FIND v(dout0_2) AT=610.025n

* CHECK dout0_3 Vdout0_3ck121 = 0 time = 610
.meas tran vdout0_3ck121 FIND v(dout0_3) AT=610.025n

* CHECK dout0_4 Vdout0_4ck121 = 0 time = 610
.meas tran vdout0_4ck121 FIND v(dout0_4) AT=610.025n

* CHECK dout0_5 Vdout0_5ck121 = 0.9 time = 610
.meas tran vdout0_5ck121 FIND v(dout0_5) AT=610.025n

* CHECK dout0_6 Vdout0_6ck121 = 0.9 time = 610
.meas tran vdout0_6ck121 FIND v(dout0_6) AT=610.025n

* CHECK dout0_7 Vdout0_7ck121 = 0 time = 610
.meas tran vdout0_7ck121 FIND v(dout0_7) AT=610.025n

* CHECK dout0_8 Vdout0_8ck121 = 0 time = 610
.meas tran vdout0_8ck121 FIND v(dout0_8) AT=610.025n

* CHECK dout0_9 Vdout0_9ck121 = 0 time = 610
.meas tran vdout0_9ck121 FIND v(dout0_9) AT=610.025n

* CHECK dout0_10 Vdout0_10ck121 = 0 time = 610
.meas tran vdout0_10ck121 FIND v(dout0_10) AT=610.025n

* CHECK dout0_11 Vdout0_11ck121 = 0.9 time = 610
.meas tran vdout0_11ck121 FIND v(dout0_11) AT=610.025n

* CHECK dout0_12 Vdout0_12ck121 = 0 time = 610
.meas tran vdout0_12ck121 FIND v(dout0_12) AT=610.025n

* CHECK dout0_13 Vdout0_13ck121 = 0.9 time = 610
.meas tran vdout0_13ck121 FIND v(dout0_13) AT=610.025n

* CHECK dout0_14 Vdout0_14ck121 = 0 time = 610
.meas tran vdout0_14ck121 FIND v(dout0_14) AT=610.025n

* CHECK dout0_15 Vdout0_15ck121 = 0.9 time = 610
.meas tran vdout0_15ck121 FIND v(dout0_15) AT=610.025n

* CHECK dout0_16 Vdout0_16ck121 = 0.9 time = 610
.meas tran vdout0_16ck121 FIND v(dout0_16) AT=610.025n

* CHECK dout0_17 Vdout0_17ck121 = 0 time = 610
.meas tran vdout0_17ck121 FIND v(dout0_17) AT=610.025n

* CHECK dout0_18 Vdout0_18ck121 = 0.9 time = 610
.meas tran vdout0_18ck121 FIND v(dout0_18) AT=610.025n

* CHECK dout0_19 Vdout0_19ck121 = 0.9 time = 610
.meas tran vdout0_19ck121 FIND v(dout0_19) AT=610.025n

* CHECK dout0_20 Vdout0_20ck121 = 0 time = 610
.meas tran vdout0_20ck121 FIND v(dout0_20) AT=610.025n

* CHECK dout0_21 Vdout0_21ck121 = 0.9 time = 610
.meas tran vdout0_21ck121 FIND v(dout0_21) AT=610.025n

* CHECK dout0_22 Vdout0_22ck121 = 0 time = 610
.meas tran vdout0_22ck121 FIND v(dout0_22) AT=610.025n

* CHECK dout0_23 Vdout0_23ck121 = 0 time = 610
.meas tran vdout0_23ck121 FIND v(dout0_23) AT=610.025n

* CHECK dout0_24 Vdout0_24ck121 = 0.9 time = 610
.meas tran vdout0_24ck121 FIND v(dout0_24) AT=610.025n

* CHECK dout0_25 Vdout0_25ck121 = 0.9 time = 610
.meas tran vdout0_25ck121 FIND v(dout0_25) AT=610.025n

* CHECK dout0_26 Vdout0_26ck121 = 0.9 time = 610
.meas tran vdout0_26ck121 FIND v(dout0_26) AT=610.025n

* CHECK dout0_27 Vdout0_27ck121 = 0 time = 610
.meas tran vdout0_27ck121 FIND v(dout0_27) AT=610.025n

* CHECK dout0_28 Vdout0_28ck121 = 0.9 time = 610
.meas tran vdout0_28ck121 FIND v(dout0_28) AT=610.025n

* CHECK dout0_29 Vdout0_29ck121 = 0 time = 610
.meas tran vdout0_29ck121 FIND v(dout0_29) AT=610.025n

* CHECK dout0_30 Vdout0_30ck121 = 0.9 time = 610
.meas tran vdout0_30ck121 FIND v(dout0_30) AT=610.025n

* CHECK dout0_31 Vdout0_31ck121 = 0.9 time = 610
.meas tran vdout0_31ck121 FIND v(dout0_31) AT=610.025n

* CHECK dout0_32 Vdout0_32ck121 = 0 time = 610
.meas tran vdout0_32ck121 FIND v(dout0_32) AT=610.025n

* CHECK dout0_33 Vdout0_33ck121 = 0.9 time = 610
.meas tran vdout0_33ck121 FIND v(dout0_33) AT=610.025n

* CHECK dout0_34 Vdout0_34ck121 = 0 time = 610
.meas tran vdout0_34ck121 FIND v(dout0_34) AT=610.025n

* CHECK dout0_35 Vdout0_35ck121 = 0.9 time = 610
.meas tran vdout0_35ck121 FIND v(dout0_35) AT=610.025n

* CHECK dout0_36 Vdout0_36ck121 = 0 time = 610
.meas tran vdout0_36ck121 FIND v(dout0_36) AT=610.025n

* CHECK dout0_37 Vdout0_37ck121 = 0 time = 610
.meas tran vdout0_37ck121 FIND v(dout0_37) AT=610.025n

* CHECK dout0_38 Vdout0_38ck121 = 0.9 time = 610
.meas tran vdout0_38ck121 FIND v(dout0_38) AT=610.025n

* CHECK dout0_39 Vdout0_39ck121 = 0 time = 610
.meas tran vdout0_39ck121 FIND v(dout0_39) AT=610.025n

* CHECK dout0_0 Vdout0_0ck123 = 0 time = 620
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=620.025n

* CHECK dout0_1 Vdout0_1ck123 = 0 time = 620
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=620.025n

* CHECK dout0_2 Vdout0_2ck123 = 0.9 time = 620
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=620.025n

* CHECK dout0_3 Vdout0_3ck123 = 0.9 time = 620
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=620.025n

* CHECK dout0_4 Vdout0_4ck123 = 0 time = 620
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=620.025n

* CHECK dout0_5 Vdout0_5ck123 = 0 time = 620
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=620.025n

* CHECK dout0_6 Vdout0_6ck123 = 0.9 time = 620
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=620.025n

* CHECK dout0_7 Vdout0_7ck123 = 0.9 time = 620
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=620.025n

* CHECK dout0_8 Vdout0_8ck123 = 0 time = 620
.meas tran vdout0_8ck123 FIND v(dout0_8) AT=620.025n

* CHECK dout0_9 Vdout0_9ck123 = 0.9 time = 620
.meas tran vdout0_9ck123 FIND v(dout0_9) AT=620.025n

* CHECK dout0_10 Vdout0_10ck123 = 0 time = 620
.meas tran vdout0_10ck123 FIND v(dout0_10) AT=620.025n

* CHECK dout0_11 Vdout0_11ck123 = 0.9 time = 620
.meas tran vdout0_11ck123 FIND v(dout0_11) AT=620.025n

* CHECK dout0_12 Vdout0_12ck123 = 0 time = 620
.meas tran vdout0_12ck123 FIND v(dout0_12) AT=620.025n

* CHECK dout0_13 Vdout0_13ck123 = 0.9 time = 620
.meas tran vdout0_13ck123 FIND v(dout0_13) AT=620.025n

* CHECK dout0_14 Vdout0_14ck123 = 0 time = 620
.meas tran vdout0_14ck123 FIND v(dout0_14) AT=620.025n

* CHECK dout0_15 Vdout0_15ck123 = 0 time = 620
.meas tran vdout0_15ck123 FIND v(dout0_15) AT=620.025n

* CHECK dout0_16 Vdout0_16ck123 = 0.9 time = 620
.meas tran vdout0_16ck123 FIND v(dout0_16) AT=620.025n

* CHECK dout0_17 Vdout0_17ck123 = 0 time = 620
.meas tran vdout0_17ck123 FIND v(dout0_17) AT=620.025n

* CHECK dout0_18 Vdout0_18ck123 = 0.9 time = 620
.meas tran vdout0_18ck123 FIND v(dout0_18) AT=620.025n

* CHECK dout0_19 Vdout0_19ck123 = 0 time = 620
.meas tran vdout0_19ck123 FIND v(dout0_19) AT=620.025n

* CHECK dout0_20 Vdout0_20ck123 = 0.9 time = 620
.meas tran vdout0_20ck123 FIND v(dout0_20) AT=620.025n

* CHECK dout0_21 Vdout0_21ck123 = 0 time = 620
.meas tran vdout0_21ck123 FIND v(dout0_21) AT=620.025n

* CHECK dout0_22 Vdout0_22ck123 = 0 time = 620
.meas tran vdout0_22ck123 FIND v(dout0_22) AT=620.025n

* CHECK dout0_23 Vdout0_23ck123 = 0 time = 620
.meas tran vdout0_23ck123 FIND v(dout0_23) AT=620.025n

* CHECK dout0_24 Vdout0_24ck123 = 0 time = 620
.meas tran vdout0_24ck123 FIND v(dout0_24) AT=620.025n

* CHECK dout0_25 Vdout0_25ck123 = 0 time = 620
.meas tran vdout0_25ck123 FIND v(dout0_25) AT=620.025n

* CHECK dout0_26 Vdout0_26ck123 = 0.9 time = 620
.meas tran vdout0_26ck123 FIND v(dout0_26) AT=620.025n

* CHECK dout0_27 Vdout0_27ck123 = 0 time = 620
.meas tran vdout0_27ck123 FIND v(dout0_27) AT=620.025n

* CHECK dout0_28 Vdout0_28ck123 = 0 time = 620
.meas tran vdout0_28ck123 FIND v(dout0_28) AT=620.025n

* CHECK dout0_29 Vdout0_29ck123 = 0 time = 620
.meas tran vdout0_29ck123 FIND v(dout0_29) AT=620.025n

* CHECK dout0_30 Vdout0_30ck123 = 0.9 time = 620
.meas tran vdout0_30ck123 FIND v(dout0_30) AT=620.025n

* CHECK dout0_31 Vdout0_31ck123 = 0.9 time = 620
.meas tran vdout0_31ck123 FIND v(dout0_31) AT=620.025n

* CHECK dout0_32 Vdout0_32ck123 = 0.9 time = 620
.meas tran vdout0_32ck123 FIND v(dout0_32) AT=620.025n

* CHECK dout0_33 Vdout0_33ck123 = 0 time = 620
.meas tran vdout0_33ck123 FIND v(dout0_33) AT=620.025n

* CHECK dout0_34 Vdout0_34ck123 = 0 time = 620
.meas tran vdout0_34ck123 FIND v(dout0_34) AT=620.025n

* CHECK dout0_35 Vdout0_35ck123 = 0.9 time = 620
.meas tran vdout0_35ck123 FIND v(dout0_35) AT=620.025n

* CHECK dout0_36 Vdout0_36ck123 = 0.9 time = 620
.meas tran vdout0_36ck123 FIND v(dout0_36) AT=620.025n

* CHECK dout0_37 Vdout0_37ck123 = 0 time = 620
.meas tran vdout0_37ck123 FIND v(dout0_37) AT=620.025n

* CHECK dout0_38 Vdout0_38ck123 = 0 time = 620
.meas tran vdout0_38ck123 FIND v(dout0_38) AT=620.025n

* CHECK dout0_39 Vdout0_39ck123 = 0.9 time = 620
.meas tran vdout0_39ck123 FIND v(dout0_39) AT=620.025n

* CHECK dout0_0 Vdout0_0ck125 = 0 time = 630
.meas tran vdout0_0ck125 FIND v(dout0_0) AT=630.025n

* CHECK dout0_1 Vdout0_1ck125 = 0.9 time = 630
.meas tran vdout0_1ck125 FIND v(dout0_1) AT=630.025n

* CHECK dout0_2 Vdout0_2ck125 = 0.9 time = 630
.meas tran vdout0_2ck125 FIND v(dout0_2) AT=630.025n

* CHECK dout0_3 Vdout0_3ck125 = 0 time = 630
.meas tran vdout0_3ck125 FIND v(dout0_3) AT=630.025n

* CHECK dout0_4 Vdout0_4ck125 = 0.9 time = 630
.meas tran vdout0_4ck125 FIND v(dout0_4) AT=630.025n

* CHECK dout0_5 Vdout0_5ck125 = 0.9 time = 630
.meas tran vdout0_5ck125 FIND v(dout0_5) AT=630.025n

* CHECK dout0_6 Vdout0_6ck125 = 0 time = 630
.meas tran vdout0_6ck125 FIND v(dout0_6) AT=630.025n

* CHECK dout0_7 Vdout0_7ck125 = 0 time = 630
.meas tran vdout0_7ck125 FIND v(dout0_7) AT=630.025n

* CHECK dout0_8 Vdout0_8ck125 = 0 time = 630
.meas tran vdout0_8ck125 FIND v(dout0_8) AT=630.025n

* CHECK dout0_9 Vdout0_9ck125 = 0 time = 630
.meas tran vdout0_9ck125 FIND v(dout0_9) AT=630.025n

* CHECK dout0_10 Vdout0_10ck125 = 0 time = 630
.meas tran vdout0_10ck125 FIND v(dout0_10) AT=630.025n

* CHECK dout0_11 Vdout0_11ck125 = 0.9 time = 630
.meas tran vdout0_11ck125 FIND v(dout0_11) AT=630.025n

* CHECK dout0_12 Vdout0_12ck125 = 0 time = 630
.meas tran vdout0_12ck125 FIND v(dout0_12) AT=630.025n

* CHECK dout0_13 Vdout0_13ck125 = 0.9 time = 630
.meas tran vdout0_13ck125 FIND v(dout0_13) AT=630.025n

* CHECK dout0_14 Vdout0_14ck125 = 0 time = 630
.meas tran vdout0_14ck125 FIND v(dout0_14) AT=630.025n

* CHECK dout0_15 Vdout0_15ck125 = 0 time = 630
.meas tran vdout0_15ck125 FIND v(dout0_15) AT=630.025n

* CHECK dout0_16 Vdout0_16ck125 = 0 time = 630
.meas tran vdout0_16ck125 FIND v(dout0_16) AT=630.025n

* CHECK dout0_17 Vdout0_17ck125 = 0 time = 630
.meas tran vdout0_17ck125 FIND v(dout0_17) AT=630.025n

* CHECK dout0_18 Vdout0_18ck125 = 0.9 time = 630
.meas tran vdout0_18ck125 FIND v(dout0_18) AT=630.025n

* CHECK dout0_19 Vdout0_19ck125 = 0.9 time = 630
.meas tran vdout0_19ck125 FIND v(dout0_19) AT=630.025n

* CHECK dout0_20 Vdout0_20ck125 = 0.9 time = 630
.meas tran vdout0_20ck125 FIND v(dout0_20) AT=630.025n

* CHECK dout0_21 Vdout0_21ck125 = 0.9 time = 630
.meas tran vdout0_21ck125 FIND v(dout0_21) AT=630.025n

* CHECK dout0_22 Vdout0_22ck125 = 0 time = 630
.meas tran vdout0_22ck125 FIND v(dout0_22) AT=630.025n

* CHECK dout0_23 Vdout0_23ck125 = 0.9 time = 630
.meas tran vdout0_23ck125 FIND v(dout0_23) AT=630.025n

* CHECK dout0_24 Vdout0_24ck125 = 0 time = 630
.meas tran vdout0_24ck125 FIND v(dout0_24) AT=630.025n

* CHECK dout0_25 Vdout0_25ck125 = 0.9 time = 630
.meas tran vdout0_25ck125 FIND v(dout0_25) AT=630.025n

* CHECK dout0_26 Vdout0_26ck125 = 0.9 time = 630
.meas tran vdout0_26ck125 FIND v(dout0_26) AT=630.025n

* CHECK dout0_27 Vdout0_27ck125 = 0.9 time = 630
.meas tran vdout0_27ck125 FIND v(dout0_27) AT=630.025n

* CHECK dout0_28 Vdout0_28ck125 = 0.9 time = 630
.meas tran vdout0_28ck125 FIND v(dout0_28) AT=630.025n

* CHECK dout0_29 Vdout0_29ck125 = 0 time = 630
.meas tran vdout0_29ck125 FIND v(dout0_29) AT=630.025n

* CHECK dout0_30 Vdout0_30ck125 = 0 time = 630
.meas tran vdout0_30ck125 FIND v(dout0_30) AT=630.025n

* CHECK dout0_31 Vdout0_31ck125 = 0 time = 630
.meas tran vdout0_31ck125 FIND v(dout0_31) AT=630.025n

* CHECK dout0_32 Vdout0_32ck125 = 0.9 time = 630
.meas tran vdout0_32ck125 FIND v(dout0_32) AT=630.025n

* CHECK dout0_33 Vdout0_33ck125 = 0.9 time = 630
.meas tran vdout0_33ck125 FIND v(dout0_33) AT=630.025n

* CHECK dout0_34 Vdout0_34ck125 = 0 time = 630
.meas tran vdout0_34ck125 FIND v(dout0_34) AT=630.025n

* CHECK dout0_35 Vdout0_35ck125 = 0.9 time = 630
.meas tran vdout0_35ck125 FIND v(dout0_35) AT=630.025n

* CHECK dout0_36 Vdout0_36ck125 = 0 time = 630
.meas tran vdout0_36ck125 FIND v(dout0_36) AT=630.025n

* CHECK dout0_37 Vdout0_37ck125 = 0 time = 630
.meas tran vdout0_37ck125 FIND v(dout0_37) AT=630.025n

* CHECK dout0_38 Vdout0_38ck125 = 0 time = 630
.meas tran vdout0_38ck125 FIND v(dout0_38) AT=630.025n

* CHECK dout0_39 Vdout0_39ck125 = 0 time = 630
.meas tran vdout0_39ck125 FIND v(dout0_39) AT=630.025n

* CHECK dout0_0 Vdout0_0ck129 = 0.9 time = 650
.meas tran vdout0_0ck129 FIND v(dout0_0) AT=650.025n

* CHECK dout0_1 Vdout0_1ck129 = 0.9 time = 650
.meas tran vdout0_1ck129 FIND v(dout0_1) AT=650.025n

* CHECK dout0_2 Vdout0_2ck129 = 0.9 time = 650
.meas tran vdout0_2ck129 FIND v(dout0_2) AT=650.025n

* CHECK dout0_3 Vdout0_3ck129 = 0.9 time = 650
.meas tran vdout0_3ck129 FIND v(dout0_3) AT=650.025n

* CHECK dout0_4 Vdout0_4ck129 = 0 time = 650
.meas tran vdout0_4ck129 FIND v(dout0_4) AT=650.025n

* CHECK dout0_5 Vdout0_5ck129 = 0 time = 650
.meas tran vdout0_5ck129 FIND v(dout0_5) AT=650.025n

* CHECK dout0_6 Vdout0_6ck129 = 0.9 time = 650
.meas tran vdout0_6ck129 FIND v(dout0_6) AT=650.025n

* CHECK dout0_7 Vdout0_7ck129 = 0.9 time = 650
.meas tran vdout0_7ck129 FIND v(dout0_7) AT=650.025n

* CHECK dout0_8 Vdout0_8ck129 = 0.9 time = 650
.meas tran vdout0_8ck129 FIND v(dout0_8) AT=650.025n

* CHECK dout0_9 Vdout0_9ck129 = 0 time = 650
.meas tran vdout0_9ck129 FIND v(dout0_9) AT=650.025n

* CHECK dout0_10 Vdout0_10ck129 = 0.9 time = 650
.meas tran vdout0_10ck129 FIND v(dout0_10) AT=650.025n

* CHECK dout0_11 Vdout0_11ck129 = 0 time = 650
.meas tran vdout0_11ck129 FIND v(dout0_11) AT=650.025n

* CHECK dout0_12 Vdout0_12ck129 = 0 time = 650
.meas tran vdout0_12ck129 FIND v(dout0_12) AT=650.025n

* CHECK dout0_13 Vdout0_13ck129 = 0.9 time = 650
.meas tran vdout0_13ck129 FIND v(dout0_13) AT=650.025n

* CHECK dout0_14 Vdout0_14ck129 = 0.9 time = 650
.meas tran vdout0_14ck129 FIND v(dout0_14) AT=650.025n

* CHECK dout0_15 Vdout0_15ck129 = 0 time = 650
.meas tran vdout0_15ck129 FIND v(dout0_15) AT=650.025n

* CHECK dout0_16 Vdout0_16ck129 = 0.9 time = 650
.meas tran vdout0_16ck129 FIND v(dout0_16) AT=650.025n

* CHECK dout0_17 Vdout0_17ck129 = 0 time = 650
.meas tran vdout0_17ck129 FIND v(dout0_17) AT=650.025n

* CHECK dout0_18 Vdout0_18ck129 = 0 time = 650
.meas tran vdout0_18ck129 FIND v(dout0_18) AT=650.025n

* CHECK dout0_19 Vdout0_19ck129 = 0.9 time = 650
.meas tran vdout0_19ck129 FIND v(dout0_19) AT=650.025n

* CHECK dout0_20 Vdout0_20ck129 = 0.9 time = 650
.meas tran vdout0_20ck129 FIND v(dout0_20) AT=650.025n

* CHECK dout0_21 Vdout0_21ck129 = 0 time = 650
.meas tran vdout0_21ck129 FIND v(dout0_21) AT=650.025n

* CHECK dout0_22 Vdout0_22ck129 = 0 time = 650
.meas tran vdout0_22ck129 FIND v(dout0_22) AT=650.025n

* CHECK dout0_23 Vdout0_23ck129 = 0.9 time = 650
.meas tran vdout0_23ck129 FIND v(dout0_23) AT=650.025n

* CHECK dout0_24 Vdout0_24ck129 = 0 time = 650
.meas tran vdout0_24ck129 FIND v(dout0_24) AT=650.025n

* CHECK dout0_25 Vdout0_25ck129 = 0.9 time = 650
.meas tran vdout0_25ck129 FIND v(dout0_25) AT=650.025n

* CHECK dout0_26 Vdout0_26ck129 = 0.9 time = 650
.meas tran vdout0_26ck129 FIND v(dout0_26) AT=650.025n

* CHECK dout0_27 Vdout0_27ck129 = 0.9 time = 650
.meas tran vdout0_27ck129 FIND v(dout0_27) AT=650.025n

* CHECK dout0_28 Vdout0_28ck129 = 0.9 time = 650
.meas tran vdout0_28ck129 FIND v(dout0_28) AT=650.025n

* CHECK dout0_29 Vdout0_29ck129 = 0.9 time = 650
.meas tran vdout0_29ck129 FIND v(dout0_29) AT=650.025n

* CHECK dout0_30 Vdout0_30ck129 = 0.9 time = 650
.meas tran vdout0_30ck129 FIND v(dout0_30) AT=650.025n

* CHECK dout0_31 Vdout0_31ck129 = 0.9 time = 650
.meas tran vdout0_31ck129 FIND v(dout0_31) AT=650.025n

* CHECK dout0_32 Vdout0_32ck129 = 0.9 time = 650
.meas tran vdout0_32ck129 FIND v(dout0_32) AT=650.025n

* CHECK dout0_33 Vdout0_33ck129 = 0 time = 650
.meas tran vdout0_33ck129 FIND v(dout0_33) AT=650.025n

* CHECK dout0_34 Vdout0_34ck129 = 0.9 time = 650
.meas tran vdout0_34ck129 FIND v(dout0_34) AT=650.025n

* CHECK dout0_35 Vdout0_35ck129 = 0 time = 650
.meas tran vdout0_35ck129 FIND v(dout0_35) AT=650.025n

* CHECK dout0_36 Vdout0_36ck129 = 0 time = 650
.meas tran vdout0_36ck129 FIND v(dout0_36) AT=650.025n

* CHECK dout0_37 Vdout0_37ck129 = 0 time = 650
.meas tran vdout0_37ck129 FIND v(dout0_37) AT=650.025n

* CHECK dout0_38 Vdout0_38ck129 = 0 time = 650
.meas tran vdout0_38ck129 FIND v(dout0_38) AT=650.025n

* CHECK dout0_39 Vdout0_39ck129 = 0 time = 650
.meas tran vdout0_39ck129 FIND v(dout0_39) AT=650.025n

* CHECK dout0_0 Vdout0_0ck133 = 0 time = 670
.meas tran vdout0_0ck133 FIND v(dout0_0) AT=670.025n

* CHECK dout0_1 Vdout0_1ck133 = 0.9 time = 670
.meas tran vdout0_1ck133 FIND v(dout0_1) AT=670.025n

* CHECK dout0_2 Vdout0_2ck133 = 0.9 time = 670
.meas tran vdout0_2ck133 FIND v(dout0_2) AT=670.025n

* CHECK dout0_3 Vdout0_3ck133 = 0.9 time = 670
.meas tran vdout0_3ck133 FIND v(dout0_3) AT=670.025n

* CHECK dout0_4 Vdout0_4ck133 = 0.9 time = 670
.meas tran vdout0_4ck133 FIND v(dout0_4) AT=670.025n

* CHECK dout0_5 Vdout0_5ck133 = 0.9 time = 670
.meas tran vdout0_5ck133 FIND v(dout0_5) AT=670.025n

* CHECK dout0_6 Vdout0_6ck133 = 0 time = 670
.meas tran vdout0_6ck133 FIND v(dout0_6) AT=670.025n

* CHECK dout0_7 Vdout0_7ck133 = 0.9 time = 670
.meas tran vdout0_7ck133 FIND v(dout0_7) AT=670.025n

* CHECK dout0_8 Vdout0_8ck133 = 0 time = 670
.meas tran vdout0_8ck133 FIND v(dout0_8) AT=670.025n

* CHECK dout0_9 Vdout0_9ck133 = 0 time = 670
.meas tran vdout0_9ck133 FIND v(dout0_9) AT=670.025n

* CHECK dout0_10 Vdout0_10ck133 = 0.9 time = 670
.meas tran vdout0_10ck133 FIND v(dout0_10) AT=670.025n

* CHECK dout0_11 Vdout0_11ck133 = 0.9 time = 670
.meas tran vdout0_11ck133 FIND v(dout0_11) AT=670.025n

* CHECK dout0_12 Vdout0_12ck133 = 0 time = 670
.meas tran vdout0_12ck133 FIND v(dout0_12) AT=670.025n

* CHECK dout0_13 Vdout0_13ck133 = 0.9 time = 670
.meas tran vdout0_13ck133 FIND v(dout0_13) AT=670.025n

* CHECK dout0_14 Vdout0_14ck133 = 0.9 time = 670
.meas tran vdout0_14ck133 FIND v(dout0_14) AT=670.025n

* CHECK dout0_15 Vdout0_15ck133 = 0 time = 670
.meas tran vdout0_15ck133 FIND v(dout0_15) AT=670.025n

* CHECK dout0_16 Vdout0_16ck133 = 0 time = 670
.meas tran vdout0_16ck133 FIND v(dout0_16) AT=670.025n

* CHECK dout0_17 Vdout0_17ck133 = 0.9 time = 670
.meas tran vdout0_17ck133 FIND v(dout0_17) AT=670.025n

* CHECK dout0_18 Vdout0_18ck133 = 0 time = 670
.meas tran vdout0_18ck133 FIND v(dout0_18) AT=670.025n

* CHECK dout0_19 Vdout0_19ck133 = 0 time = 670
.meas tran vdout0_19ck133 FIND v(dout0_19) AT=670.025n

* CHECK dout0_20 Vdout0_20ck133 = 0 time = 670
.meas tran vdout0_20ck133 FIND v(dout0_20) AT=670.025n

* CHECK dout0_21 Vdout0_21ck133 = 0.9 time = 670
.meas tran vdout0_21ck133 FIND v(dout0_21) AT=670.025n

* CHECK dout0_22 Vdout0_22ck133 = 0.9 time = 670
.meas tran vdout0_22ck133 FIND v(dout0_22) AT=670.025n

* CHECK dout0_23 Vdout0_23ck133 = 0.9 time = 670
.meas tran vdout0_23ck133 FIND v(dout0_23) AT=670.025n

* CHECK dout0_24 Vdout0_24ck133 = 0.9 time = 670
.meas tran vdout0_24ck133 FIND v(dout0_24) AT=670.025n

* CHECK dout0_25 Vdout0_25ck133 = 0 time = 670
.meas tran vdout0_25ck133 FIND v(dout0_25) AT=670.025n

* CHECK dout0_26 Vdout0_26ck133 = 0 time = 670
.meas tran vdout0_26ck133 FIND v(dout0_26) AT=670.025n

* CHECK dout0_27 Vdout0_27ck133 = 0 time = 670
.meas tran vdout0_27ck133 FIND v(dout0_27) AT=670.025n

* CHECK dout0_28 Vdout0_28ck133 = 0 time = 670
.meas tran vdout0_28ck133 FIND v(dout0_28) AT=670.025n

* CHECK dout0_29 Vdout0_29ck133 = 0.9 time = 670
.meas tran vdout0_29ck133 FIND v(dout0_29) AT=670.025n

* CHECK dout0_30 Vdout0_30ck133 = 0 time = 670
.meas tran vdout0_30ck133 FIND v(dout0_30) AT=670.025n

* CHECK dout0_31 Vdout0_31ck133 = 0.9 time = 670
.meas tran vdout0_31ck133 FIND v(dout0_31) AT=670.025n

* CHECK dout0_32 Vdout0_32ck133 = 0.9 time = 670
.meas tran vdout0_32ck133 FIND v(dout0_32) AT=670.025n

* CHECK dout0_33 Vdout0_33ck133 = 0 time = 670
.meas tran vdout0_33ck133 FIND v(dout0_33) AT=670.025n

* CHECK dout0_34 Vdout0_34ck133 = 0.9 time = 670
.meas tran vdout0_34ck133 FIND v(dout0_34) AT=670.025n

* CHECK dout0_35 Vdout0_35ck133 = 0 time = 670
.meas tran vdout0_35ck133 FIND v(dout0_35) AT=670.025n

* CHECK dout0_36 Vdout0_36ck133 = 0.9 time = 670
.meas tran vdout0_36ck133 FIND v(dout0_36) AT=670.025n

* CHECK dout0_37 Vdout0_37ck133 = 0.9 time = 670
.meas tran vdout0_37ck133 FIND v(dout0_37) AT=670.025n

* CHECK dout0_38 Vdout0_38ck133 = 0.9 time = 670
.meas tran vdout0_38ck133 FIND v(dout0_38) AT=670.025n

* CHECK dout0_39 Vdout0_39ck133 = 0.9 time = 670
.meas tran vdout0_39ck133 FIND v(dout0_39) AT=670.025n

* CHECK dout0_0 Vdout0_0ck138 = 0.9 time = 695
.meas tran vdout0_0ck138 FIND v(dout0_0) AT=695.025n

* CHECK dout0_1 Vdout0_1ck138 = 0 time = 695
.meas tran vdout0_1ck138 FIND v(dout0_1) AT=695.025n

* CHECK dout0_2 Vdout0_2ck138 = 0 time = 695
.meas tran vdout0_2ck138 FIND v(dout0_2) AT=695.025n

* CHECK dout0_3 Vdout0_3ck138 = 0 time = 695
.meas tran vdout0_3ck138 FIND v(dout0_3) AT=695.025n

* CHECK dout0_4 Vdout0_4ck138 = 0 time = 695
.meas tran vdout0_4ck138 FIND v(dout0_4) AT=695.025n

* CHECK dout0_5 Vdout0_5ck138 = 0.9 time = 695
.meas tran vdout0_5ck138 FIND v(dout0_5) AT=695.025n

* CHECK dout0_6 Vdout0_6ck138 = 0.9 time = 695
.meas tran vdout0_6ck138 FIND v(dout0_6) AT=695.025n

* CHECK dout0_7 Vdout0_7ck138 = 0.9 time = 695
.meas tran vdout0_7ck138 FIND v(dout0_7) AT=695.025n

* CHECK dout0_8 Vdout0_8ck138 = 0.9 time = 695
.meas tran vdout0_8ck138 FIND v(dout0_8) AT=695.025n

* CHECK dout0_9 Vdout0_9ck138 = 0.9 time = 695
.meas tran vdout0_9ck138 FIND v(dout0_9) AT=695.025n

* CHECK dout0_10 Vdout0_10ck138 = 0 time = 695
.meas tran vdout0_10ck138 FIND v(dout0_10) AT=695.025n

* CHECK dout0_11 Vdout0_11ck138 = 0 time = 695
.meas tran vdout0_11ck138 FIND v(dout0_11) AT=695.025n

* CHECK dout0_12 Vdout0_12ck138 = 0.9 time = 695
.meas tran vdout0_12ck138 FIND v(dout0_12) AT=695.025n

* CHECK dout0_13 Vdout0_13ck138 = 0.9 time = 695
.meas tran vdout0_13ck138 FIND v(dout0_13) AT=695.025n

* CHECK dout0_14 Vdout0_14ck138 = 0.9 time = 695
.meas tran vdout0_14ck138 FIND v(dout0_14) AT=695.025n

* CHECK dout0_15 Vdout0_15ck138 = 0.9 time = 695
.meas tran vdout0_15ck138 FIND v(dout0_15) AT=695.025n

* CHECK dout0_16 Vdout0_16ck138 = 0.9 time = 695
.meas tran vdout0_16ck138 FIND v(dout0_16) AT=695.025n

* CHECK dout0_17 Vdout0_17ck138 = 0 time = 695
.meas tran vdout0_17ck138 FIND v(dout0_17) AT=695.025n

* CHECK dout0_18 Vdout0_18ck138 = 0.9 time = 695
.meas tran vdout0_18ck138 FIND v(dout0_18) AT=695.025n

* CHECK dout0_19 Vdout0_19ck138 = 0.9 time = 695
.meas tran vdout0_19ck138 FIND v(dout0_19) AT=695.025n

* CHECK dout0_20 Vdout0_20ck138 = 0 time = 695
.meas tran vdout0_20ck138 FIND v(dout0_20) AT=695.025n

* CHECK dout0_21 Vdout0_21ck138 = 0.9 time = 695
.meas tran vdout0_21ck138 FIND v(dout0_21) AT=695.025n

* CHECK dout0_22 Vdout0_22ck138 = 0.9 time = 695
.meas tran vdout0_22ck138 FIND v(dout0_22) AT=695.025n

* CHECK dout0_23 Vdout0_23ck138 = 0 time = 695
.meas tran vdout0_23ck138 FIND v(dout0_23) AT=695.025n

* CHECK dout0_24 Vdout0_24ck138 = 0 time = 695
.meas tran vdout0_24ck138 FIND v(dout0_24) AT=695.025n

* CHECK dout0_25 Vdout0_25ck138 = 0 time = 695
.meas tran vdout0_25ck138 FIND v(dout0_25) AT=695.025n

* CHECK dout0_26 Vdout0_26ck138 = 0.9 time = 695
.meas tran vdout0_26ck138 FIND v(dout0_26) AT=695.025n

* CHECK dout0_27 Vdout0_27ck138 = 0 time = 695
.meas tran vdout0_27ck138 FIND v(dout0_27) AT=695.025n

* CHECK dout0_28 Vdout0_28ck138 = 0 time = 695
.meas tran vdout0_28ck138 FIND v(dout0_28) AT=695.025n

* CHECK dout0_29 Vdout0_29ck138 = 0 time = 695
.meas tran vdout0_29ck138 FIND v(dout0_29) AT=695.025n

* CHECK dout0_30 Vdout0_30ck138 = 0 time = 695
.meas tran vdout0_30ck138 FIND v(dout0_30) AT=695.025n

* CHECK dout0_31 Vdout0_31ck138 = 0.9 time = 695
.meas tran vdout0_31ck138 FIND v(dout0_31) AT=695.025n

* CHECK dout0_32 Vdout0_32ck138 = 0 time = 695
.meas tran vdout0_32ck138 FIND v(dout0_32) AT=695.025n

* CHECK dout0_33 Vdout0_33ck138 = 0.9 time = 695
.meas tran vdout0_33ck138 FIND v(dout0_33) AT=695.025n

* CHECK dout0_34 Vdout0_34ck138 = 0.9 time = 695
.meas tran vdout0_34ck138 FIND v(dout0_34) AT=695.025n

* CHECK dout0_35 Vdout0_35ck138 = 0.9 time = 695
.meas tran vdout0_35ck138 FIND v(dout0_35) AT=695.025n

* CHECK dout0_36 Vdout0_36ck138 = 0 time = 695
.meas tran vdout0_36ck138 FIND v(dout0_36) AT=695.025n

* CHECK dout0_37 Vdout0_37ck138 = 0.9 time = 695
.meas tran vdout0_37ck138 FIND v(dout0_37) AT=695.025n

* CHECK dout0_38 Vdout0_38ck138 = 0 time = 695
.meas tran vdout0_38ck138 FIND v(dout0_38) AT=695.025n

* CHECK dout0_39 Vdout0_39ck138 = 0.9 time = 695
.meas tran vdout0_39ck138 FIND v(dout0_39) AT=695.025n

* CHECK dout0_0 Vdout0_0ck140 = 0.9 time = 705
.meas tran vdout0_0ck140 FIND v(dout0_0) AT=705.025n

* CHECK dout0_1 Vdout0_1ck140 = 0 time = 705
.meas tran vdout0_1ck140 FIND v(dout0_1) AT=705.025n

* CHECK dout0_2 Vdout0_2ck140 = 0 time = 705
.meas tran vdout0_2ck140 FIND v(dout0_2) AT=705.025n

* CHECK dout0_3 Vdout0_3ck140 = 0.9 time = 705
.meas tran vdout0_3ck140 FIND v(dout0_3) AT=705.025n

* CHECK dout0_4 Vdout0_4ck140 = 0 time = 705
.meas tran vdout0_4ck140 FIND v(dout0_4) AT=705.025n

* CHECK dout0_5 Vdout0_5ck140 = 0 time = 705
.meas tran vdout0_5ck140 FIND v(dout0_5) AT=705.025n

* CHECK dout0_6 Vdout0_6ck140 = 0.9 time = 705
.meas tran vdout0_6ck140 FIND v(dout0_6) AT=705.025n

* CHECK dout0_7 Vdout0_7ck140 = 0 time = 705
.meas tran vdout0_7ck140 FIND v(dout0_7) AT=705.025n

* CHECK dout0_8 Vdout0_8ck140 = 0.9 time = 705
.meas tran vdout0_8ck140 FIND v(dout0_8) AT=705.025n

* CHECK dout0_9 Vdout0_9ck140 = 0.9 time = 705
.meas tran vdout0_9ck140 FIND v(dout0_9) AT=705.025n

* CHECK dout0_10 Vdout0_10ck140 = 0.9 time = 705
.meas tran vdout0_10ck140 FIND v(dout0_10) AT=705.025n

* CHECK dout0_11 Vdout0_11ck140 = 0 time = 705
.meas tran vdout0_11ck140 FIND v(dout0_11) AT=705.025n

* CHECK dout0_12 Vdout0_12ck140 = 0.9 time = 705
.meas tran vdout0_12ck140 FIND v(dout0_12) AT=705.025n

* CHECK dout0_13 Vdout0_13ck140 = 0 time = 705
.meas tran vdout0_13ck140 FIND v(dout0_13) AT=705.025n

* CHECK dout0_14 Vdout0_14ck140 = 0.9 time = 705
.meas tran vdout0_14ck140 FIND v(dout0_14) AT=705.025n

* CHECK dout0_15 Vdout0_15ck140 = 0.9 time = 705
.meas tran vdout0_15ck140 FIND v(dout0_15) AT=705.025n

* CHECK dout0_16 Vdout0_16ck140 = 0 time = 705
.meas tran vdout0_16ck140 FIND v(dout0_16) AT=705.025n

* CHECK dout0_17 Vdout0_17ck140 = 0.9 time = 705
.meas tran vdout0_17ck140 FIND v(dout0_17) AT=705.025n

* CHECK dout0_18 Vdout0_18ck140 = 0.9 time = 705
.meas tran vdout0_18ck140 FIND v(dout0_18) AT=705.025n

* CHECK dout0_19 Vdout0_19ck140 = 0 time = 705
.meas tran vdout0_19ck140 FIND v(dout0_19) AT=705.025n

* CHECK dout0_20 Vdout0_20ck140 = 0 time = 705
.meas tran vdout0_20ck140 FIND v(dout0_20) AT=705.025n

* CHECK dout0_21 Vdout0_21ck140 = 0.9 time = 705
.meas tran vdout0_21ck140 FIND v(dout0_21) AT=705.025n

* CHECK dout0_22 Vdout0_22ck140 = 0.9 time = 705
.meas tran vdout0_22ck140 FIND v(dout0_22) AT=705.025n

* CHECK dout0_23 Vdout0_23ck140 = 0.9 time = 705
.meas tran vdout0_23ck140 FIND v(dout0_23) AT=705.025n

* CHECK dout0_24 Vdout0_24ck140 = 0.9 time = 705
.meas tran vdout0_24ck140 FIND v(dout0_24) AT=705.025n

* CHECK dout0_25 Vdout0_25ck140 = 0 time = 705
.meas tran vdout0_25ck140 FIND v(dout0_25) AT=705.025n

* CHECK dout0_26 Vdout0_26ck140 = 0 time = 705
.meas tran vdout0_26ck140 FIND v(dout0_26) AT=705.025n

* CHECK dout0_27 Vdout0_27ck140 = 0 time = 705
.meas tran vdout0_27ck140 FIND v(dout0_27) AT=705.025n

* CHECK dout0_28 Vdout0_28ck140 = 0 time = 705
.meas tran vdout0_28ck140 FIND v(dout0_28) AT=705.025n

* CHECK dout0_29 Vdout0_29ck140 = 0.9 time = 705
.meas tran vdout0_29ck140 FIND v(dout0_29) AT=705.025n

* CHECK dout0_30 Vdout0_30ck140 = 0 time = 705
.meas tran vdout0_30ck140 FIND v(dout0_30) AT=705.025n

* CHECK dout0_31 Vdout0_31ck140 = 0.9 time = 705
.meas tran vdout0_31ck140 FIND v(dout0_31) AT=705.025n

* CHECK dout0_32 Vdout0_32ck140 = 0.9 time = 705
.meas tran vdout0_32ck140 FIND v(dout0_32) AT=705.025n

* CHECK dout0_33 Vdout0_33ck140 = 0 time = 705
.meas tran vdout0_33ck140 FIND v(dout0_33) AT=705.025n

* CHECK dout0_34 Vdout0_34ck140 = 0.9 time = 705
.meas tran vdout0_34ck140 FIND v(dout0_34) AT=705.025n

* CHECK dout0_35 Vdout0_35ck140 = 0 time = 705
.meas tran vdout0_35ck140 FIND v(dout0_35) AT=705.025n

* CHECK dout0_36 Vdout0_36ck140 = 0.9 time = 705
.meas tran vdout0_36ck140 FIND v(dout0_36) AT=705.025n

* CHECK dout0_37 Vdout0_37ck140 = 0.9 time = 705
.meas tran vdout0_37ck140 FIND v(dout0_37) AT=705.025n

* CHECK dout0_38 Vdout0_38ck140 = 0.9 time = 705
.meas tran vdout0_38ck140 FIND v(dout0_38) AT=705.025n

* CHECK dout0_39 Vdout0_39ck140 = 0.9 time = 705
.meas tran vdout0_39ck140 FIND v(dout0_39) AT=705.025n

* CHECK dout0_0 Vdout0_0ck142 = 0.9 time = 715
.meas tran vdout0_0ck142 FIND v(dout0_0) AT=715.025n

* CHECK dout0_1 Vdout0_1ck142 = 0.9 time = 715
.meas tran vdout0_1ck142 FIND v(dout0_1) AT=715.025n

* CHECK dout0_2 Vdout0_2ck142 = 0 time = 715
.meas tran vdout0_2ck142 FIND v(dout0_2) AT=715.025n

* CHECK dout0_3 Vdout0_3ck142 = 0.9 time = 715
.meas tran vdout0_3ck142 FIND v(dout0_3) AT=715.025n

* CHECK dout0_4 Vdout0_4ck142 = 0 time = 715
.meas tran vdout0_4ck142 FIND v(dout0_4) AT=715.025n

* CHECK dout0_5 Vdout0_5ck142 = 0 time = 715
.meas tran vdout0_5ck142 FIND v(dout0_5) AT=715.025n

* CHECK dout0_6 Vdout0_6ck142 = 0 time = 715
.meas tran vdout0_6ck142 FIND v(dout0_6) AT=715.025n

* CHECK dout0_7 Vdout0_7ck142 = 0 time = 715
.meas tran vdout0_7ck142 FIND v(dout0_7) AT=715.025n

* CHECK dout0_8 Vdout0_8ck142 = 0 time = 715
.meas tran vdout0_8ck142 FIND v(dout0_8) AT=715.025n

* CHECK dout0_9 Vdout0_9ck142 = 0 time = 715
.meas tran vdout0_9ck142 FIND v(dout0_9) AT=715.025n

* CHECK dout0_10 Vdout0_10ck142 = 0 time = 715
.meas tran vdout0_10ck142 FIND v(dout0_10) AT=715.025n

* CHECK dout0_11 Vdout0_11ck142 = 0.9 time = 715
.meas tran vdout0_11ck142 FIND v(dout0_11) AT=715.025n

* CHECK dout0_12 Vdout0_12ck142 = 0 time = 715
.meas tran vdout0_12ck142 FIND v(dout0_12) AT=715.025n

* CHECK dout0_13 Vdout0_13ck142 = 0.9 time = 715
.meas tran vdout0_13ck142 FIND v(dout0_13) AT=715.025n

* CHECK dout0_14 Vdout0_14ck142 = 0.9 time = 715
.meas tran vdout0_14ck142 FIND v(dout0_14) AT=715.025n

* CHECK dout0_15 Vdout0_15ck142 = 0.9 time = 715
.meas tran vdout0_15ck142 FIND v(dout0_15) AT=715.025n

* CHECK dout0_16 Vdout0_16ck142 = 0 time = 715
.meas tran vdout0_16ck142 FIND v(dout0_16) AT=715.025n

* CHECK dout0_17 Vdout0_17ck142 = 0.9 time = 715
.meas tran vdout0_17ck142 FIND v(dout0_17) AT=715.025n

* CHECK dout0_18 Vdout0_18ck142 = 0.9 time = 715
.meas tran vdout0_18ck142 FIND v(dout0_18) AT=715.025n

* CHECK dout0_19 Vdout0_19ck142 = 0.9 time = 715
.meas tran vdout0_19ck142 FIND v(dout0_19) AT=715.025n

* CHECK dout0_20 Vdout0_20ck142 = 0.9 time = 715
.meas tran vdout0_20ck142 FIND v(dout0_20) AT=715.025n

* CHECK dout0_21 Vdout0_21ck142 = 0.9 time = 715
.meas tran vdout0_21ck142 FIND v(dout0_21) AT=715.025n

* CHECK dout0_22 Vdout0_22ck142 = 0 time = 715
.meas tran vdout0_22ck142 FIND v(dout0_22) AT=715.025n

* CHECK dout0_23 Vdout0_23ck142 = 0 time = 715
.meas tran vdout0_23ck142 FIND v(dout0_23) AT=715.025n

* CHECK dout0_24 Vdout0_24ck142 = 0.9 time = 715
.meas tran vdout0_24ck142 FIND v(dout0_24) AT=715.025n

* CHECK dout0_25 Vdout0_25ck142 = 0.9 time = 715
.meas tran vdout0_25ck142 FIND v(dout0_25) AT=715.025n

* CHECK dout0_26 Vdout0_26ck142 = 0.9 time = 715
.meas tran vdout0_26ck142 FIND v(dout0_26) AT=715.025n

* CHECK dout0_27 Vdout0_27ck142 = 0.9 time = 715
.meas tran vdout0_27ck142 FIND v(dout0_27) AT=715.025n

* CHECK dout0_28 Vdout0_28ck142 = 0.9 time = 715
.meas tran vdout0_28ck142 FIND v(dout0_28) AT=715.025n

* CHECK dout0_29 Vdout0_29ck142 = 0 time = 715
.meas tran vdout0_29ck142 FIND v(dout0_29) AT=715.025n

* CHECK dout0_30 Vdout0_30ck142 = 0 time = 715
.meas tran vdout0_30ck142 FIND v(dout0_30) AT=715.025n

* CHECK dout0_31 Vdout0_31ck142 = 0 time = 715
.meas tran vdout0_31ck142 FIND v(dout0_31) AT=715.025n

* CHECK dout0_32 Vdout0_32ck142 = 0 time = 715
.meas tran vdout0_32ck142 FIND v(dout0_32) AT=715.025n

* CHECK dout0_33 Vdout0_33ck142 = 0.9 time = 715
.meas tran vdout0_33ck142 FIND v(dout0_33) AT=715.025n

* CHECK dout0_34 Vdout0_34ck142 = 0.9 time = 715
.meas tran vdout0_34ck142 FIND v(dout0_34) AT=715.025n

* CHECK dout0_35 Vdout0_35ck142 = 0 time = 715
.meas tran vdout0_35ck142 FIND v(dout0_35) AT=715.025n

* CHECK dout0_36 Vdout0_36ck142 = 0 time = 715
.meas tran vdout0_36ck142 FIND v(dout0_36) AT=715.025n

* CHECK dout0_37 Vdout0_37ck142 = 0 time = 715
.meas tran vdout0_37ck142 FIND v(dout0_37) AT=715.025n

* CHECK dout0_38 Vdout0_38ck142 = 0 time = 715
.meas tran vdout0_38ck142 FIND v(dout0_38) AT=715.025n

* CHECK dout0_39 Vdout0_39ck142 = 0.9 time = 715
.meas tran vdout0_39ck142 FIND v(dout0_39) AT=715.025n

* CHECK dout0_0 Vdout0_0ck143 = 0.9 time = 720
.meas tran vdout0_0ck143 FIND v(dout0_0) AT=720.025n

* CHECK dout0_1 Vdout0_1ck143 = 0.9 time = 720
.meas tran vdout0_1ck143 FIND v(dout0_1) AT=720.025n

* CHECK dout0_2 Vdout0_2ck143 = 0 time = 720
.meas tran vdout0_2ck143 FIND v(dout0_2) AT=720.025n

* CHECK dout0_3 Vdout0_3ck143 = 0.9 time = 720
.meas tran vdout0_3ck143 FIND v(dout0_3) AT=720.025n

* CHECK dout0_4 Vdout0_4ck143 = 0 time = 720
.meas tran vdout0_4ck143 FIND v(dout0_4) AT=720.025n

* CHECK dout0_5 Vdout0_5ck143 = 0 time = 720
.meas tran vdout0_5ck143 FIND v(dout0_5) AT=720.025n

* CHECK dout0_6 Vdout0_6ck143 = 0 time = 720
.meas tran vdout0_6ck143 FIND v(dout0_6) AT=720.025n

* CHECK dout0_7 Vdout0_7ck143 = 0 time = 720
.meas tran vdout0_7ck143 FIND v(dout0_7) AT=720.025n

* CHECK dout0_8 Vdout0_8ck143 = 0 time = 720
.meas tran vdout0_8ck143 FIND v(dout0_8) AT=720.025n

* CHECK dout0_9 Vdout0_9ck143 = 0 time = 720
.meas tran vdout0_9ck143 FIND v(dout0_9) AT=720.025n

* CHECK dout0_10 Vdout0_10ck143 = 0 time = 720
.meas tran vdout0_10ck143 FIND v(dout0_10) AT=720.025n

* CHECK dout0_11 Vdout0_11ck143 = 0.9 time = 720
.meas tran vdout0_11ck143 FIND v(dout0_11) AT=720.025n

* CHECK dout0_12 Vdout0_12ck143 = 0 time = 720
.meas tran vdout0_12ck143 FIND v(dout0_12) AT=720.025n

* CHECK dout0_13 Vdout0_13ck143 = 0.9 time = 720
.meas tran vdout0_13ck143 FIND v(dout0_13) AT=720.025n

* CHECK dout0_14 Vdout0_14ck143 = 0.9 time = 720
.meas tran vdout0_14ck143 FIND v(dout0_14) AT=720.025n

* CHECK dout0_15 Vdout0_15ck143 = 0.9 time = 720
.meas tran vdout0_15ck143 FIND v(dout0_15) AT=720.025n

* CHECK dout0_16 Vdout0_16ck143 = 0 time = 720
.meas tran vdout0_16ck143 FIND v(dout0_16) AT=720.025n

* CHECK dout0_17 Vdout0_17ck143 = 0.9 time = 720
.meas tran vdout0_17ck143 FIND v(dout0_17) AT=720.025n

* CHECK dout0_18 Vdout0_18ck143 = 0.9 time = 720
.meas tran vdout0_18ck143 FIND v(dout0_18) AT=720.025n

* CHECK dout0_19 Vdout0_19ck143 = 0.9 time = 720
.meas tran vdout0_19ck143 FIND v(dout0_19) AT=720.025n

* CHECK dout0_20 Vdout0_20ck143 = 0.9 time = 720
.meas tran vdout0_20ck143 FIND v(dout0_20) AT=720.025n

* CHECK dout0_21 Vdout0_21ck143 = 0.9 time = 720
.meas tran vdout0_21ck143 FIND v(dout0_21) AT=720.025n

* CHECK dout0_22 Vdout0_22ck143 = 0 time = 720
.meas tran vdout0_22ck143 FIND v(dout0_22) AT=720.025n

* CHECK dout0_23 Vdout0_23ck143 = 0 time = 720
.meas tran vdout0_23ck143 FIND v(dout0_23) AT=720.025n

* CHECK dout0_24 Vdout0_24ck143 = 0.9 time = 720
.meas tran vdout0_24ck143 FIND v(dout0_24) AT=720.025n

* CHECK dout0_25 Vdout0_25ck143 = 0.9 time = 720
.meas tran vdout0_25ck143 FIND v(dout0_25) AT=720.025n

* CHECK dout0_26 Vdout0_26ck143 = 0.9 time = 720
.meas tran vdout0_26ck143 FIND v(dout0_26) AT=720.025n

* CHECK dout0_27 Vdout0_27ck143 = 0.9 time = 720
.meas tran vdout0_27ck143 FIND v(dout0_27) AT=720.025n

* CHECK dout0_28 Vdout0_28ck143 = 0.9 time = 720
.meas tran vdout0_28ck143 FIND v(dout0_28) AT=720.025n

* CHECK dout0_29 Vdout0_29ck143 = 0 time = 720
.meas tran vdout0_29ck143 FIND v(dout0_29) AT=720.025n

* CHECK dout0_30 Vdout0_30ck143 = 0 time = 720
.meas tran vdout0_30ck143 FIND v(dout0_30) AT=720.025n

* CHECK dout0_31 Vdout0_31ck143 = 0 time = 720
.meas tran vdout0_31ck143 FIND v(dout0_31) AT=720.025n

* CHECK dout0_32 Vdout0_32ck143 = 0 time = 720
.meas tran vdout0_32ck143 FIND v(dout0_32) AT=720.025n

* CHECK dout0_33 Vdout0_33ck143 = 0.9 time = 720
.meas tran vdout0_33ck143 FIND v(dout0_33) AT=720.025n

* CHECK dout0_34 Vdout0_34ck143 = 0.9 time = 720
.meas tran vdout0_34ck143 FIND v(dout0_34) AT=720.025n

* CHECK dout0_35 Vdout0_35ck143 = 0 time = 720
.meas tran vdout0_35ck143 FIND v(dout0_35) AT=720.025n

* CHECK dout0_36 Vdout0_36ck143 = 0 time = 720
.meas tran vdout0_36ck143 FIND v(dout0_36) AT=720.025n

* CHECK dout0_37 Vdout0_37ck143 = 0 time = 720
.meas tran vdout0_37ck143 FIND v(dout0_37) AT=720.025n

* CHECK dout0_38 Vdout0_38ck143 = 0 time = 720
.meas tran vdout0_38ck143 FIND v(dout0_38) AT=720.025n

* CHECK dout0_39 Vdout0_39ck143 = 0.9 time = 720
.meas tran vdout0_39ck143 FIND v(dout0_39) AT=720.025n

* CHECK dout0_0 Vdout0_0ck150 = 0.9 time = 755
.meas tran vdout0_0ck150 FIND v(dout0_0) AT=755.025n

* CHECK dout0_1 Vdout0_1ck150 = 0.9 time = 755
.meas tran vdout0_1ck150 FIND v(dout0_1) AT=755.025n

* CHECK dout0_2 Vdout0_2ck150 = 0.9 time = 755
.meas tran vdout0_2ck150 FIND v(dout0_2) AT=755.025n

* CHECK dout0_3 Vdout0_3ck150 = 0.9 time = 755
.meas tran vdout0_3ck150 FIND v(dout0_3) AT=755.025n

* CHECK dout0_4 Vdout0_4ck150 = 0 time = 755
.meas tran vdout0_4ck150 FIND v(dout0_4) AT=755.025n

* CHECK dout0_5 Vdout0_5ck150 = 0 time = 755
.meas tran vdout0_5ck150 FIND v(dout0_5) AT=755.025n

* CHECK dout0_6 Vdout0_6ck150 = 0.9 time = 755
.meas tran vdout0_6ck150 FIND v(dout0_6) AT=755.025n

* CHECK dout0_7 Vdout0_7ck150 = 0.9 time = 755
.meas tran vdout0_7ck150 FIND v(dout0_7) AT=755.025n

* CHECK dout0_8 Vdout0_8ck150 = 0.9 time = 755
.meas tran vdout0_8ck150 FIND v(dout0_8) AT=755.025n

* CHECK dout0_9 Vdout0_9ck150 = 0 time = 755
.meas tran vdout0_9ck150 FIND v(dout0_9) AT=755.025n

* CHECK dout0_10 Vdout0_10ck150 = 0.9 time = 755
.meas tran vdout0_10ck150 FIND v(dout0_10) AT=755.025n

* CHECK dout0_11 Vdout0_11ck150 = 0 time = 755
.meas tran vdout0_11ck150 FIND v(dout0_11) AT=755.025n

* CHECK dout0_12 Vdout0_12ck150 = 0 time = 755
.meas tran vdout0_12ck150 FIND v(dout0_12) AT=755.025n

* CHECK dout0_13 Vdout0_13ck150 = 0.9 time = 755
.meas tran vdout0_13ck150 FIND v(dout0_13) AT=755.025n

* CHECK dout0_14 Vdout0_14ck150 = 0.9 time = 755
.meas tran vdout0_14ck150 FIND v(dout0_14) AT=755.025n

* CHECK dout0_15 Vdout0_15ck150 = 0 time = 755
.meas tran vdout0_15ck150 FIND v(dout0_15) AT=755.025n

* CHECK dout0_16 Vdout0_16ck150 = 0.9 time = 755
.meas tran vdout0_16ck150 FIND v(dout0_16) AT=755.025n

* CHECK dout0_17 Vdout0_17ck150 = 0 time = 755
.meas tran vdout0_17ck150 FIND v(dout0_17) AT=755.025n

* CHECK dout0_18 Vdout0_18ck150 = 0 time = 755
.meas tran vdout0_18ck150 FIND v(dout0_18) AT=755.025n

* CHECK dout0_19 Vdout0_19ck150 = 0.9 time = 755
.meas tran vdout0_19ck150 FIND v(dout0_19) AT=755.025n

* CHECK dout0_20 Vdout0_20ck150 = 0.9 time = 755
.meas tran vdout0_20ck150 FIND v(dout0_20) AT=755.025n

* CHECK dout0_21 Vdout0_21ck150 = 0 time = 755
.meas tran vdout0_21ck150 FIND v(dout0_21) AT=755.025n

* CHECK dout0_22 Vdout0_22ck150 = 0 time = 755
.meas tran vdout0_22ck150 FIND v(dout0_22) AT=755.025n

* CHECK dout0_23 Vdout0_23ck150 = 0.9 time = 755
.meas tran vdout0_23ck150 FIND v(dout0_23) AT=755.025n

* CHECK dout0_24 Vdout0_24ck150 = 0 time = 755
.meas tran vdout0_24ck150 FIND v(dout0_24) AT=755.025n

* CHECK dout0_25 Vdout0_25ck150 = 0.9 time = 755
.meas tran vdout0_25ck150 FIND v(dout0_25) AT=755.025n

* CHECK dout0_26 Vdout0_26ck150 = 0.9 time = 755
.meas tran vdout0_26ck150 FIND v(dout0_26) AT=755.025n

* CHECK dout0_27 Vdout0_27ck150 = 0.9 time = 755
.meas tran vdout0_27ck150 FIND v(dout0_27) AT=755.025n

* CHECK dout0_28 Vdout0_28ck150 = 0.9 time = 755
.meas tran vdout0_28ck150 FIND v(dout0_28) AT=755.025n

* CHECK dout0_29 Vdout0_29ck150 = 0.9 time = 755
.meas tran vdout0_29ck150 FIND v(dout0_29) AT=755.025n

* CHECK dout0_30 Vdout0_30ck150 = 0.9 time = 755
.meas tran vdout0_30ck150 FIND v(dout0_30) AT=755.025n

* CHECK dout0_31 Vdout0_31ck150 = 0.9 time = 755
.meas tran vdout0_31ck150 FIND v(dout0_31) AT=755.025n

* CHECK dout0_32 Vdout0_32ck150 = 0.9 time = 755
.meas tran vdout0_32ck150 FIND v(dout0_32) AT=755.025n

* CHECK dout0_33 Vdout0_33ck150 = 0 time = 755
.meas tran vdout0_33ck150 FIND v(dout0_33) AT=755.025n

* CHECK dout0_34 Vdout0_34ck150 = 0.9 time = 755
.meas tran vdout0_34ck150 FIND v(dout0_34) AT=755.025n

* CHECK dout0_35 Vdout0_35ck150 = 0 time = 755
.meas tran vdout0_35ck150 FIND v(dout0_35) AT=755.025n

* CHECK dout0_36 Vdout0_36ck150 = 0 time = 755
.meas tran vdout0_36ck150 FIND v(dout0_36) AT=755.025n

* CHECK dout0_37 Vdout0_37ck150 = 0 time = 755
.meas tran vdout0_37ck150 FIND v(dout0_37) AT=755.025n

* CHECK dout0_38 Vdout0_38ck150 = 0 time = 755
.meas tran vdout0_38ck150 FIND v(dout0_38) AT=755.025n

* CHECK dout0_39 Vdout0_39ck150 = 0 time = 755
.meas tran vdout0_39ck150 FIND v(dout0_39) AT=755.025n

* CHECK dout0_0 Vdout0_0ck151 = 0.9 time = 760
.meas tran vdout0_0ck151 FIND v(dout0_0) AT=760.025n

* CHECK dout0_1 Vdout0_1ck151 = 0 time = 760
.meas tran vdout0_1ck151 FIND v(dout0_1) AT=760.025n

* CHECK dout0_2 Vdout0_2ck151 = 0.9 time = 760
.meas tran vdout0_2ck151 FIND v(dout0_2) AT=760.025n

* CHECK dout0_3 Vdout0_3ck151 = 0.9 time = 760
.meas tran vdout0_3ck151 FIND v(dout0_3) AT=760.025n

* CHECK dout0_4 Vdout0_4ck151 = 0 time = 760
.meas tran vdout0_4ck151 FIND v(dout0_4) AT=760.025n

* CHECK dout0_5 Vdout0_5ck151 = 0 time = 760
.meas tran vdout0_5ck151 FIND v(dout0_5) AT=760.025n

* CHECK dout0_6 Vdout0_6ck151 = 0.9 time = 760
.meas tran vdout0_6ck151 FIND v(dout0_6) AT=760.025n

* CHECK dout0_7 Vdout0_7ck151 = 0.9 time = 760
.meas tran vdout0_7ck151 FIND v(dout0_7) AT=760.025n

* CHECK dout0_8 Vdout0_8ck151 = 0.9 time = 760
.meas tran vdout0_8ck151 FIND v(dout0_8) AT=760.025n

* CHECK dout0_9 Vdout0_9ck151 = 0 time = 760
.meas tran vdout0_9ck151 FIND v(dout0_9) AT=760.025n

* CHECK dout0_10 Vdout0_10ck151 = 0.9 time = 760
.meas tran vdout0_10ck151 FIND v(dout0_10) AT=760.025n

* CHECK dout0_11 Vdout0_11ck151 = 0.9 time = 760
.meas tran vdout0_11ck151 FIND v(dout0_11) AT=760.025n

* CHECK dout0_12 Vdout0_12ck151 = 0.9 time = 760
.meas tran vdout0_12ck151 FIND v(dout0_12) AT=760.025n

* CHECK dout0_13 Vdout0_13ck151 = 0.9 time = 760
.meas tran vdout0_13ck151 FIND v(dout0_13) AT=760.025n

* CHECK dout0_14 Vdout0_14ck151 = 0 time = 760
.meas tran vdout0_14ck151 FIND v(dout0_14) AT=760.025n

* CHECK dout0_15 Vdout0_15ck151 = 0.9 time = 760
.meas tran vdout0_15ck151 FIND v(dout0_15) AT=760.025n

* CHECK dout0_16 Vdout0_16ck151 = 0.9 time = 760
.meas tran vdout0_16ck151 FIND v(dout0_16) AT=760.025n

* CHECK dout0_17 Vdout0_17ck151 = 0.9 time = 760
.meas tran vdout0_17ck151 FIND v(dout0_17) AT=760.025n

* CHECK dout0_18 Vdout0_18ck151 = 0 time = 760
.meas tran vdout0_18ck151 FIND v(dout0_18) AT=760.025n

* CHECK dout0_19 Vdout0_19ck151 = 0 time = 760
.meas tran vdout0_19ck151 FIND v(dout0_19) AT=760.025n

* CHECK dout0_20 Vdout0_20ck151 = 0.9 time = 760
.meas tran vdout0_20ck151 FIND v(dout0_20) AT=760.025n

* CHECK dout0_21 Vdout0_21ck151 = 0.9 time = 760
.meas tran vdout0_21ck151 FIND v(dout0_21) AT=760.025n

* CHECK dout0_22 Vdout0_22ck151 = 0 time = 760
.meas tran vdout0_22ck151 FIND v(dout0_22) AT=760.025n

* CHECK dout0_23 Vdout0_23ck151 = 0.9 time = 760
.meas tran vdout0_23ck151 FIND v(dout0_23) AT=760.025n

* CHECK dout0_24 Vdout0_24ck151 = 0 time = 760
.meas tran vdout0_24ck151 FIND v(dout0_24) AT=760.025n

* CHECK dout0_25 Vdout0_25ck151 = 0.9 time = 760
.meas tran vdout0_25ck151 FIND v(dout0_25) AT=760.025n

* CHECK dout0_26 Vdout0_26ck151 = 0 time = 760
.meas tran vdout0_26ck151 FIND v(dout0_26) AT=760.025n

* CHECK dout0_27 Vdout0_27ck151 = 0 time = 760
.meas tran vdout0_27ck151 FIND v(dout0_27) AT=760.025n

* CHECK dout0_28 Vdout0_28ck151 = 0.9 time = 760
.meas tran vdout0_28ck151 FIND v(dout0_28) AT=760.025n

* CHECK dout0_29 Vdout0_29ck151 = 0 time = 760
.meas tran vdout0_29ck151 FIND v(dout0_29) AT=760.025n

* CHECK dout0_30 Vdout0_30ck151 = 0.9 time = 760
.meas tran vdout0_30ck151 FIND v(dout0_30) AT=760.025n

* CHECK dout0_31 Vdout0_31ck151 = 0.9 time = 760
.meas tran vdout0_31ck151 FIND v(dout0_31) AT=760.025n

* CHECK dout0_32 Vdout0_32ck151 = 0.9 time = 760
.meas tran vdout0_32ck151 FIND v(dout0_32) AT=760.025n

* CHECK dout0_33 Vdout0_33ck151 = 0 time = 760
.meas tran vdout0_33ck151 FIND v(dout0_33) AT=760.025n

* CHECK dout0_34 Vdout0_34ck151 = 0.9 time = 760
.meas tran vdout0_34ck151 FIND v(dout0_34) AT=760.025n

* CHECK dout0_35 Vdout0_35ck151 = 0 time = 760
.meas tran vdout0_35ck151 FIND v(dout0_35) AT=760.025n

* CHECK dout0_36 Vdout0_36ck151 = 0.9 time = 760
.meas tran vdout0_36ck151 FIND v(dout0_36) AT=760.025n

* CHECK dout0_37 Vdout0_37ck151 = 0.9 time = 760
.meas tran vdout0_37ck151 FIND v(dout0_37) AT=760.025n

* CHECK dout0_38 Vdout0_38ck151 = 0.9 time = 760
.meas tran vdout0_38ck151 FIND v(dout0_38) AT=760.025n

* CHECK dout0_39 Vdout0_39ck151 = 0.9 time = 760
.meas tran vdout0_39ck151 FIND v(dout0_39) AT=760.025n

* CHECK dout0_0 Vdout0_0ck152 = 0 time = 765
.meas tran vdout0_0ck152 FIND v(dout0_0) AT=765.025n

* CHECK dout0_1 Vdout0_1ck152 = 0 time = 765
.meas tran vdout0_1ck152 FIND v(dout0_1) AT=765.025n

* CHECK dout0_2 Vdout0_2ck152 = 0.9 time = 765
.meas tran vdout0_2ck152 FIND v(dout0_2) AT=765.025n

* CHECK dout0_3 Vdout0_3ck152 = 0.9 time = 765
.meas tran vdout0_3ck152 FIND v(dout0_3) AT=765.025n

* CHECK dout0_4 Vdout0_4ck152 = 0 time = 765
.meas tran vdout0_4ck152 FIND v(dout0_4) AT=765.025n

* CHECK dout0_5 Vdout0_5ck152 = 0.9 time = 765
.meas tran vdout0_5ck152 FIND v(dout0_5) AT=765.025n

* CHECK dout0_6 Vdout0_6ck152 = 0 time = 765
.meas tran vdout0_6ck152 FIND v(dout0_6) AT=765.025n

* CHECK dout0_7 Vdout0_7ck152 = 0 time = 765
.meas tran vdout0_7ck152 FIND v(dout0_7) AT=765.025n

* CHECK dout0_8 Vdout0_8ck152 = 0 time = 765
.meas tran vdout0_8ck152 FIND v(dout0_8) AT=765.025n

* CHECK dout0_9 Vdout0_9ck152 = 0 time = 765
.meas tran vdout0_9ck152 FIND v(dout0_9) AT=765.025n

* CHECK dout0_10 Vdout0_10ck152 = 0.9 time = 765
.meas tran vdout0_10ck152 FIND v(dout0_10) AT=765.025n

* CHECK dout0_11 Vdout0_11ck152 = 0 time = 765
.meas tran vdout0_11ck152 FIND v(dout0_11) AT=765.025n

* CHECK dout0_12 Vdout0_12ck152 = 0.9 time = 765
.meas tran vdout0_12ck152 FIND v(dout0_12) AT=765.025n

* CHECK dout0_13 Vdout0_13ck152 = 0.9 time = 765
.meas tran vdout0_13ck152 FIND v(dout0_13) AT=765.025n

* CHECK dout0_14 Vdout0_14ck152 = 0.9 time = 765
.meas tran vdout0_14ck152 FIND v(dout0_14) AT=765.025n

* CHECK dout0_15 Vdout0_15ck152 = 0 time = 765
.meas tran vdout0_15ck152 FIND v(dout0_15) AT=765.025n

* CHECK dout0_16 Vdout0_16ck152 = 0.9 time = 765
.meas tran vdout0_16ck152 FIND v(dout0_16) AT=765.025n

* CHECK dout0_17 Vdout0_17ck152 = 0.9 time = 765
.meas tran vdout0_17ck152 FIND v(dout0_17) AT=765.025n

* CHECK dout0_18 Vdout0_18ck152 = 0.9 time = 765
.meas tran vdout0_18ck152 FIND v(dout0_18) AT=765.025n

* CHECK dout0_19 Vdout0_19ck152 = 0 time = 765
.meas tran vdout0_19ck152 FIND v(dout0_19) AT=765.025n

* CHECK dout0_20 Vdout0_20ck152 = 0 time = 765
.meas tran vdout0_20ck152 FIND v(dout0_20) AT=765.025n

* CHECK dout0_21 Vdout0_21ck152 = 0.9 time = 765
.meas tran vdout0_21ck152 FIND v(dout0_21) AT=765.025n

* CHECK dout0_22 Vdout0_22ck152 = 0.9 time = 765
.meas tran vdout0_22ck152 FIND v(dout0_22) AT=765.025n

* CHECK dout0_23 Vdout0_23ck152 = 0 time = 765
.meas tran vdout0_23ck152 FIND v(dout0_23) AT=765.025n

* CHECK dout0_24 Vdout0_24ck152 = 0 time = 765
.meas tran vdout0_24ck152 FIND v(dout0_24) AT=765.025n

* CHECK dout0_25 Vdout0_25ck152 = 0 time = 765
.meas tran vdout0_25ck152 FIND v(dout0_25) AT=765.025n

* CHECK dout0_26 Vdout0_26ck152 = 0.9 time = 765
.meas tran vdout0_26ck152 FIND v(dout0_26) AT=765.025n

* CHECK dout0_27 Vdout0_27ck152 = 0 time = 765
.meas tran vdout0_27ck152 FIND v(dout0_27) AT=765.025n

* CHECK dout0_28 Vdout0_28ck152 = 0 time = 765
.meas tran vdout0_28ck152 FIND v(dout0_28) AT=765.025n

* CHECK dout0_29 Vdout0_29ck152 = 0 time = 765
.meas tran vdout0_29ck152 FIND v(dout0_29) AT=765.025n

* CHECK dout0_30 Vdout0_30ck152 = 0 time = 765
.meas tran vdout0_30ck152 FIND v(dout0_30) AT=765.025n

* CHECK dout0_31 Vdout0_31ck152 = 0.9 time = 765
.meas tran vdout0_31ck152 FIND v(dout0_31) AT=765.025n

* CHECK dout0_32 Vdout0_32ck152 = 0 time = 765
.meas tran vdout0_32ck152 FIND v(dout0_32) AT=765.025n

* CHECK dout0_33 Vdout0_33ck152 = 0.9 time = 765
.meas tran vdout0_33ck152 FIND v(dout0_33) AT=765.025n

* CHECK dout0_34 Vdout0_34ck152 = 0.9 time = 765
.meas tran vdout0_34ck152 FIND v(dout0_34) AT=765.025n

* CHECK dout0_35 Vdout0_35ck152 = 0.9 time = 765
.meas tran vdout0_35ck152 FIND v(dout0_35) AT=765.025n

* CHECK dout0_36 Vdout0_36ck152 = 0 time = 765
.meas tran vdout0_36ck152 FIND v(dout0_36) AT=765.025n

* CHECK dout0_37 Vdout0_37ck152 = 0.9 time = 765
.meas tran vdout0_37ck152 FIND v(dout0_37) AT=765.025n

* CHECK dout0_38 Vdout0_38ck152 = 0 time = 765
.meas tran vdout0_38ck152 FIND v(dout0_38) AT=765.025n

* CHECK dout0_39 Vdout0_39ck152 = 0.9 time = 765
.meas tran vdout0_39ck152 FIND v(dout0_39) AT=765.025n

* CHECK dout0_0 Vdout0_0ck156 = 0.9 time = 785
.meas tran vdout0_0ck156 FIND v(dout0_0) AT=785.025n

* CHECK dout0_1 Vdout0_1ck156 = 0 time = 785
.meas tran vdout0_1ck156 FIND v(dout0_1) AT=785.025n

* CHECK dout0_2 Vdout0_2ck156 = 0.9 time = 785
.meas tran vdout0_2ck156 FIND v(dout0_2) AT=785.025n

* CHECK dout0_3 Vdout0_3ck156 = 0.9 time = 785
.meas tran vdout0_3ck156 FIND v(dout0_3) AT=785.025n

* CHECK dout0_4 Vdout0_4ck156 = 0 time = 785
.meas tran vdout0_4ck156 FIND v(dout0_4) AT=785.025n

* CHECK dout0_5 Vdout0_5ck156 = 0 time = 785
.meas tran vdout0_5ck156 FIND v(dout0_5) AT=785.025n

* CHECK dout0_6 Vdout0_6ck156 = 0.9 time = 785
.meas tran vdout0_6ck156 FIND v(dout0_6) AT=785.025n

* CHECK dout0_7 Vdout0_7ck156 = 0.9 time = 785
.meas tran vdout0_7ck156 FIND v(dout0_7) AT=785.025n

* CHECK dout0_8 Vdout0_8ck156 = 0.9 time = 785
.meas tran vdout0_8ck156 FIND v(dout0_8) AT=785.025n

* CHECK dout0_9 Vdout0_9ck156 = 0 time = 785
.meas tran vdout0_9ck156 FIND v(dout0_9) AT=785.025n

* CHECK dout0_10 Vdout0_10ck156 = 0.9 time = 785
.meas tran vdout0_10ck156 FIND v(dout0_10) AT=785.025n

* CHECK dout0_11 Vdout0_11ck156 = 0.9 time = 785
.meas tran vdout0_11ck156 FIND v(dout0_11) AT=785.025n

* CHECK dout0_12 Vdout0_12ck156 = 0.9 time = 785
.meas tran vdout0_12ck156 FIND v(dout0_12) AT=785.025n

* CHECK dout0_13 Vdout0_13ck156 = 0.9 time = 785
.meas tran vdout0_13ck156 FIND v(dout0_13) AT=785.025n

* CHECK dout0_14 Vdout0_14ck156 = 0 time = 785
.meas tran vdout0_14ck156 FIND v(dout0_14) AT=785.025n

* CHECK dout0_15 Vdout0_15ck156 = 0.9 time = 785
.meas tran vdout0_15ck156 FIND v(dout0_15) AT=785.025n

* CHECK dout0_16 Vdout0_16ck156 = 0.9 time = 785
.meas tran vdout0_16ck156 FIND v(dout0_16) AT=785.025n

* CHECK dout0_17 Vdout0_17ck156 = 0.9 time = 785
.meas tran vdout0_17ck156 FIND v(dout0_17) AT=785.025n

* CHECK dout0_18 Vdout0_18ck156 = 0 time = 785
.meas tran vdout0_18ck156 FIND v(dout0_18) AT=785.025n

* CHECK dout0_19 Vdout0_19ck156 = 0 time = 785
.meas tran vdout0_19ck156 FIND v(dout0_19) AT=785.025n

* CHECK dout0_20 Vdout0_20ck156 = 0.9 time = 785
.meas tran vdout0_20ck156 FIND v(dout0_20) AT=785.025n

* CHECK dout0_21 Vdout0_21ck156 = 0.9 time = 785
.meas tran vdout0_21ck156 FIND v(dout0_21) AT=785.025n

* CHECK dout0_22 Vdout0_22ck156 = 0 time = 785
.meas tran vdout0_22ck156 FIND v(dout0_22) AT=785.025n

* CHECK dout0_23 Vdout0_23ck156 = 0.9 time = 785
.meas tran vdout0_23ck156 FIND v(dout0_23) AT=785.025n

* CHECK dout0_24 Vdout0_24ck156 = 0 time = 785
.meas tran vdout0_24ck156 FIND v(dout0_24) AT=785.025n

* CHECK dout0_25 Vdout0_25ck156 = 0.9 time = 785
.meas tran vdout0_25ck156 FIND v(dout0_25) AT=785.025n

* CHECK dout0_26 Vdout0_26ck156 = 0 time = 785
.meas tran vdout0_26ck156 FIND v(dout0_26) AT=785.025n

* CHECK dout0_27 Vdout0_27ck156 = 0 time = 785
.meas tran vdout0_27ck156 FIND v(dout0_27) AT=785.025n

* CHECK dout0_28 Vdout0_28ck156 = 0.9 time = 785
.meas tran vdout0_28ck156 FIND v(dout0_28) AT=785.025n

* CHECK dout0_29 Vdout0_29ck156 = 0 time = 785
.meas tran vdout0_29ck156 FIND v(dout0_29) AT=785.025n

* CHECK dout0_30 Vdout0_30ck156 = 0.9 time = 785
.meas tran vdout0_30ck156 FIND v(dout0_30) AT=785.025n

* CHECK dout0_31 Vdout0_31ck156 = 0.9 time = 785
.meas tran vdout0_31ck156 FIND v(dout0_31) AT=785.025n

* CHECK dout0_32 Vdout0_32ck156 = 0.9 time = 785
.meas tran vdout0_32ck156 FIND v(dout0_32) AT=785.025n

* CHECK dout0_33 Vdout0_33ck156 = 0 time = 785
.meas tran vdout0_33ck156 FIND v(dout0_33) AT=785.025n

* CHECK dout0_34 Vdout0_34ck156 = 0.9 time = 785
.meas tran vdout0_34ck156 FIND v(dout0_34) AT=785.025n

* CHECK dout0_35 Vdout0_35ck156 = 0 time = 785
.meas tran vdout0_35ck156 FIND v(dout0_35) AT=785.025n

* CHECK dout0_36 Vdout0_36ck156 = 0.9 time = 785
.meas tran vdout0_36ck156 FIND v(dout0_36) AT=785.025n

* CHECK dout0_37 Vdout0_37ck156 = 0.9 time = 785
.meas tran vdout0_37ck156 FIND v(dout0_37) AT=785.025n

* CHECK dout0_38 Vdout0_38ck156 = 0.9 time = 785
.meas tran vdout0_38ck156 FIND v(dout0_38) AT=785.025n

* CHECK dout0_39 Vdout0_39ck156 = 0.9 time = 785
.meas tran vdout0_39ck156 FIND v(dout0_39) AT=785.025n

* CHECK dout0_0 Vdout0_0ck158 = 0 time = 795
.meas tran vdout0_0ck158 FIND v(dout0_0) AT=795.025n

* CHECK dout0_1 Vdout0_1ck158 = 0 time = 795
.meas tran vdout0_1ck158 FIND v(dout0_1) AT=795.025n

* CHECK dout0_2 Vdout0_2ck158 = 0 time = 795
.meas tran vdout0_2ck158 FIND v(dout0_2) AT=795.025n

* CHECK dout0_3 Vdout0_3ck158 = 0 time = 795
.meas tran vdout0_3ck158 FIND v(dout0_3) AT=795.025n

* CHECK dout0_4 Vdout0_4ck158 = 0.9 time = 795
.meas tran vdout0_4ck158 FIND v(dout0_4) AT=795.025n

* CHECK dout0_5 Vdout0_5ck158 = 0.9 time = 795
.meas tran vdout0_5ck158 FIND v(dout0_5) AT=795.025n

* CHECK dout0_6 Vdout0_6ck158 = 0.9 time = 795
.meas tran vdout0_6ck158 FIND v(dout0_6) AT=795.025n

* CHECK dout0_7 Vdout0_7ck158 = 0 time = 795
.meas tran vdout0_7ck158 FIND v(dout0_7) AT=795.025n

* CHECK dout0_8 Vdout0_8ck158 = 0.9 time = 795
.meas tran vdout0_8ck158 FIND v(dout0_8) AT=795.025n

* CHECK dout0_9 Vdout0_9ck158 = 0 time = 795
.meas tran vdout0_9ck158 FIND v(dout0_9) AT=795.025n

* CHECK dout0_10 Vdout0_10ck158 = 0 time = 795
.meas tran vdout0_10ck158 FIND v(dout0_10) AT=795.025n

* CHECK dout0_11 Vdout0_11ck158 = 0.9 time = 795
.meas tran vdout0_11ck158 FIND v(dout0_11) AT=795.025n

* CHECK dout0_12 Vdout0_12ck158 = 0 time = 795
.meas tran vdout0_12ck158 FIND v(dout0_12) AT=795.025n

* CHECK dout0_13 Vdout0_13ck158 = 0 time = 795
.meas tran vdout0_13ck158 FIND v(dout0_13) AT=795.025n

* CHECK dout0_14 Vdout0_14ck158 = 0 time = 795
.meas tran vdout0_14ck158 FIND v(dout0_14) AT=795.025n

* CHECK dout0_15 Vdout0_15ck158 = 0 time = 795
.meas tran vdout0_15ck158 FIND v(dout0_15) AT=795.025n

* CHECK dout0_16 Vdout0_16ck158 = 0.9 time = 795
.meas tran vdout0_16ck158 FIND v(dout0_16) AT=795.025n

* CHECK dout0_17 Vdout0_17ck158 = 0 time = 795
.meas tran vdout0_17ck158 FIND v(dout0_17) AT=795.025n

* CHECK dout0_18 Vdout0_18ck158 = 0 time = 795
.meas tran vdout0_18ck158 FIND v(dout0_18) AT=795.025n

* CHECK dout0_19 Vdout0_19ck158 = 0 time = 795
.meas tran vdout0_19ck158 FIND v(dout0_19) AT=795.025n

* CHECK dout0_20 Vdout0_20ck158 = 0.9 time = 795
.meas tran vdout0_20ck158 FIND v(dout0_20) AT=795.025n

* CHECK dout0_21 Vdout0_21ck158 = 0.9 time = 795
.meas tran vdout0_21ck158 FIND v(dout0_21) AT=795.025n

* CHECK dout0_22 Vdout0_22ck158 = 0 time = 795
.meas tran vdout0_22ck158 FIND v(dout0_22) AT=795.025n

* CHECK dout0_23 Vdout0_23ck158 = 0.9 time = 795
.meas tran vdout0_23ck158 FIND v(dout0_23) AT=795.025n

* CHECK dout0_24 Vdout0_24ck158 = 0 time = 795
.meas tran vdout0_24ck158 FIND v(dout0_24) AT=795.025n

* CHECK dout0_25 Vdout0_25ck158 = 0.9 time = 795
.meas tran vdout0_25ck158 FIND v(dout0_25) AT=795.025n

* CHECK dout0_26 Vdout0_26ck158 = 0 time = 795
.meas tran vdout0_26ck158 FIND v(dout0_26) AT=795.025n

* CHECK dout0_27 Vdout0_27ck158 = 0 time = 795
.meas tran vdout0_27ck158 FIND v(dout0_27) AT=795.025n

* CHECK dout0_28 Vdout0_28ck158 = 0.9 time = 795
.meas tran vdout0_28ck158 FIND v(dout0_28) AT=795.025n

* CHECK dout0_29 Vdout0_29ck158 = 0 time = 795
.meas tran vdout0_29ck158 FIND v(dout0_29) AT=795.025n

* CHECK dout0_30 Vdout0_30ck158 = 0.9 time = 795
.meas tran vdout0_30ck158 FIND v(dout0_30) AT=795.025n

* CHECK dout0_31 Vdout0_31ck158 = 0.9 time = 795
.meas tran vdout0_31ck158 FIND v(dout0_31) AT=795.025n

* CHECK dout0_32 Vdout0_32ck158 = 0.9 time = 795
.meas tran vdout0_32ck158 FIND v(dout0_32) AT=795.025n

* CHECK dout0_33 Vdout0_33ck158 = 0 time = 795
.meas tran vdout0_33ck158 FIND v(dout0_33) AT=795.025n

* CHECK dout0_34 Vdout0_34ck158 = 0.9 time = 795
.meas tran vdout0_34ck158 FIND v(dout0_34) AT=795.025n

* CHECK dout0_35 Vdout0_35ck158 = 0 time = 795
.meas tran vdout0_35ck158 FIND v(dout0_35) AT=795.025n

* CHECK dout0_36 Vdout0_36ck158 = 0.9 time = 795
.meas tran vdout0_36ck158 FIND v(dout0_36) AT=795.025n

* CHECK dout0_37 Vdout0_37ck158 = 0.9 time = 795
.meas tran vdout0_37ck158 FIND v(dout0_37) AT=795.025n

* CHECK dout0_38 Vdout0_38ck158 = 0.9 time = 795
.meas tran vdout0_38ck158 FIND v(dout0_38) AT=795.025n

* CHECK dout0_39 Vdout0_39ck158 = 0.9 time = 795
.meas tran vdout0_39ck158 FIND v(dout0_39) AT=795.025n

* CHECK dout0_0 Vdout0_0ck162 = 0 time = 815
.meas tran vdout0_0ck162 FIND v(dout0_0) AT=815.025n

* CHECK dout0_1 Vdout0_1ck162 = 0 time = 815
.meas tran vdout0_1ck162 FIND v(dout0_1) AT=815.025n

* CHECK dout0_2 Vdout0_2ck162 = 0.9 time = 815
.meas tran vdout0_2ck162 FIND v(dout0_2) AT=815.025n

* CHECK dout0_3 Vdout0_3ck162 = 0.9 time = 815
.meas tran vdout0_3ck162 FIND v(dout0_3) AT=815.025n

* CHECK dout0_4 Vdout0_4ck162 = 0 time = 815
.meas tran vdout0_4ck162 FIND v(dout0_4) AT=815.025n

* CHECK dout0_5 Vdout0_5ck162 = 0.9 time = 815
.meas tran vdout0_5ck162 FIND v(dout0_5) AT=815.025n

* CHECK dout0_6 Vdout0_6ck162 = 0 time = 815
.meas tran vdout0_6ck162 FIND v(dout0_6) AT=815.025n

* CHECK dout0_7 Vdout0_7ck162 = 0 time = 815
.meas tran vdout0_7ck162 FIND v(dout0_7) AT=815.025n

* CHECK dout0_8 Vdout0_8ck162 = 0 time = 815
.meas tran vdout0_8ck162 FIND v(dout0_8) AT=815.025n

* CHECK dout0_9 Vdout0_9ck162 = 0 time = 815
.meas tran vdout0_9ck162 FIND v(dout0_9) AT=815.025n

* CHECK dout0_10 Vdout0_10ck162 = 0.9 time = 815
.meas tran vdout0_10ck162 FIND v(dout0_10) AT=815.025n

* CHECK dout0_11 Vdout0_11ck162 = 0 time = 815
.meas tran vdout0_11ck162 FIND v(dout0_11) AT=815.025n

* CHECK dout0_12 Vdout0_12ck162 = 0.9 time = 815
.meas tran vdout0_12ck162 FIND v(dout0_12) AT=815.025n

* CHECK dout0_13 Vdout0_13ck162 = 0.9 time = 815
.meas tran vdout0_13ck162 FIND v(dout0_13) AT=815.025n

* CHECK dout0_14 Vdout0_14ck162 = 0.9 time = 815
.meas tran vdout0_14ck162 FIND v(dout0_14) AT=815.025n

* CHECK dout0_15 Vdout0_15ck162 = 0 time = 815
.meas tran vdout0_15ck162 FIND v(dout0_15) AT=815.025n

* CHECK dout0_16 Vdout0_16ck162 = 0.9 time = 815
.meas tran vdout0_16ck162 FIND v(dout0_16) AT=815.025n

* CHECK dout0_17 Vdout0_17ck162 = 0.9 time = 815
.meas tran vdout0_17ck162 FIND v(dout0_17) AT=815.025n

* CHECK dout0_18 Vdout0_18ck162 = 0.9 time = 815
.meas tran vdout0_18ck162 FIND v(dout0_18) AT=815.025n

* CHECK dout0_19 Vdout0_19ck162 = 0 time = 815
.meas tran vdout0_19ck162 FIND v(dout0_19) AT=815.025n

* CHECK dout0_20 Vdout0_20ck162 = 0 time = 815
.meas tran vdout0_20ck162 FIND v(dout0_20) AT=815.025n

* CHECK dout0_21 Vdout0_21ck162 = 0.9 time = 815
.meas tran vdout0_21ck162 FIND v(dout0_21) AT=815.025n

* CHECK dout0_22 Vdout0_22ck162 = 0.9 time = 815
.meas tran vdout0_22ck162 FIND v(dout0_22) AT=815.025n

* CHECK dout0_23 Vdout0_23ck162 = 0 time = 815
.meas tran vdout0_23ck162 FIND v(dout0_23) AT=815.025n

* CHECK dout0_24 Vdout0_24ck162 = 0 time = 815
.meas tran vdout0_24ck162 FIND v(dout0_24) AT=815.025n

* CHECK dout0_25 Vdout0_25ck162 = 0 time = 815
.meas tran vdout0_25ck162 FIND v(dout0_25) AT=815.025n

* CHECK dout0_26 Vdout0_26ck162 = 0.9 time = 815
.meas tran vdout0_26ck162 FIND v(dout0_26) AT=815.025n

* CHECK dout0_27 Vdout0_27ck162 = 0 time = 815
.meas tran vdout0_27ck162 FIND v(dout0_27) AT=815.025n

* CHECK dout0_28 Vdout0_28ck162 = 0 time = 815
.meas tran vdout0_28ck162 FIND v(dout0_28) AT=815.025n

* CHECK dout0_29 Vdout0_29ck162 = 0 time = 815
.meas tran vdout0_29ck162 FIND v(dout0_29) AT=815.025n

* CHECK dout0_30 Vdout0_30ck162 = 0 time = 815
.meas tran vdout0_30ck162 FIND v(dout0_30) AT=815.025n

* CHECK dout0_31 Vdout0_31ck162 = 0.9 time = 815
.meas tran vdout0_31ck162 FIND v(dout0_31) AT=815.025n

* CHECK dout0_32 Vdout0_32ck162 = 0 time = 815
.meas tran vdout0_32ck162 FIND v(dout0_32) AT=815.025n

* CHECK dout0_33 Vdout0_33ck162 = 0.9 time = 815
.meas tran vdout0_33ck162 FIND v(dout0_33) AT=815.025n

* CHECK dout0_34 Vdout0_34ck162 = 0.9 time = 815
.meas tran vdout0_34ck162 FIND v(dout0_34) AT=815.025n

* CHECK dout0_35 Vdout0_35ck162 = 0.9 time = 815
.meas tran vdout0_35ck162 FIND v(dout0_35) AT=815.025n

* CHECK dout0_36 Vdout0_36ck162 = 0 time = 815
.meas tran vdout0_36ck162 FIND v(dout0_36) AT=815.025n

* CHECK dout0_37 Vdout0_37ck162 = 0.9 time = 815
.meas tran vdout0_37ck162 FIND v(dout0_37) AT=815.025n

* CHECK dout0_38 Vdout0_38ck162 = 0 time = 815
.meas tran vdout0_38ck162 FIND v(dout0_38) AT=815.025n

* CHECK dout0_39 Vdout0_39ck162 = 0.9 time = 815
.meas tran vdout0_39ck162 FIND v(dout0_39) AT=815.025n

* CHECK dout0_0 Vdout0_0ck163 = 0 time = 820
.meas tran vdout0_0ck163 FIND v(dout0_0) AT=820.025n

* CHECK dout0_1 Vdout0_1ck163 = 0 time = 820
.meas tran vdout0_1ck163 FIND v(dout0_1) AT=820.025n

* CHECK dout0_2 Vdout0_2ck163 = 0.9 time = 820
.meas tran vdout0_2ck163 FIND v(dout0_2) AT=820.025n

* CHECK dout0_3 Vdout0_3ck163 = 0.9 time = 820
.meas tran vdout0_3ck163 FIND v(dout0_3) AT=820.025n

* CHECK dout0_4 Vdout0_4ck163 = 0 time = 820
.meas tran vdout0_4ck163 FIND v(dout0_4) AT=820.025n

* CHECK dout0_5 Vdout0_5ck163 = 0.9 time = 820
.meas tran vdout0_5ck163 FIND v(dout0_5) AT=820.025n

* CHECK dout0_6 Vdout0_6ck163 = 0 time = 820
.meas tran vdout0_6ck163 FIND v(dout0_6) AT=820.025n

* CHECK dout0_7 Vdout0_7ck163 = 0 time = 820
.meas tran vdout0_7ck163 FIND v(dout0_7) AT=820.025n

* CHECK dout0_8 Vdout0_8ck163 = 0 time = 820
.meas tran vdout0_8ck163 FIND v(dout0_8) AT=820.025n

* CHECK dout0_9 Vdout0_9ck163 = 0 time = 820
.meas tran vdout0_9ck163 FIND v(dout0_9) AT=820.025n

* CHECK dout0_10 Vdout0_10ck163 = 0.9 time = 820
.meas tran vdout0_10ck163 FIND v(dout0_10) AT=820.025n

* CHECK dout0_11 Vdout0_11ck163 = 0 time = 820
.meas tran vdout0_11ck163 FIND v(dout0_11) AT=820.025n

* CHECK dout0_12 Vdout0_12ck163 = 0.9 time = 820
.meas tran vdout0_12ck163 FIND v(dout0_12) AT=820.025n

* CHECK dout0_13 Vdout0_13ck163 = 0.9 time = 820
.meas tran vdout0_13ck163 FIND v(dout0_13) AT=820.025n

* CHECK dout0_14 Vdout0_14ck163 = 0.9 time = 820
.meas tran vdout0_14ck163 FIND v(dout0_14) AT=820.025n

* CHECK dout0_15 Vdout0_15ck163 = 0 time = 820
.meas tran vdout0_15ck163 FIND v(dout0_15) AT=820.025n

* CHECK dout0_16 Vdout0_16ck163 = 0.9 time = 820
.meas tran vdout0_16ck163 FIND v(dout0_16) AT=820.025n

* CHECK dout0_17 Vdout0_17ck163 = 0.9 time = 820
.meas tran vdout0_17ck163 FIND v(dout0_17) AT=820.025n

* CHECK dout0_18 Vdout0_18ck163 = 0.9 time = 820
.meas tran vdout0_18ck163 FIND v(dout0_18) AT=820.025n

* CHECK dout0_19 Vdout0_19ck163 = 0 time = 820
.meas tran vdout0_19ck163 FIND v(dout0_19) AT=820.025n

* CHECK dout0_20 Vdout0_20ck163 = 0 time = 820
.meas tran vdout0_20ck163 FIND v(dout0_20) AT=820.025n

* CHECK dout0_21 Vdout0_21ck163 = 0.9 time = 820
.meas tran vdout0_21ck163 FIND v(dout0_21) AT=820.025n

* CHECK dout0_22 Vdout0_22ck163 = 0.9 time = 820
.meas tran vdout0_22ck163 FIND v(dout0_22) AT=820.025n

* CHECK dout0_23 Vdout0_23ck163 = 0 time = 820
.meas tran vdout0_23ck163 FIND v(dout0_23) AT=820.025n

* CHECK dout0_24 Vdout0_24ck163 = 0 time = 820
.meas tran vdout0_24ck163 FIND v(dout0_24) AT=820.025n

* CHECK dout0_25 Vdout0_25ck163 = 0 time = 820
.meas tran vdout0_25ck163 FIND v(dout0_25) AT=820.025n

* CHECK dout0_26 Vdout0_26ck163 = 0.9 time = 820
.meas tran vdout0_26ck163 FIND v(dout0_26) AT=820.025n

* CHECK dout0_27 Vdout0_27ck163 = 0 time = 820
.meas tran vdout0_27ck163 FIND v(dout0_27) AT=820.025n

* CHECK dout0_28 Vdout0_28ck163 = 0 time = 820
.meas tran vdout0_28ck163 FIND v(dout0_28) AT=820.025n

* CHECK dout0_29 Vdout0_29ck163 = 0 time = 820
.meas tran vdout0_29ck163 FIND v(dout0_29) AT=820.025n

* CHECK dout0_30 Vdout0_30ck163 = 0 time = 820
.meas tran vdout0_30ck163 FIND v(dout0_30) AT=820.025n

* CHECK dout0_31 Vdout0_31ck163 = 0.9 time = 820
.meas tran vdout0_31ck163 FIND v(dout0_31) AT=820.025n

* CHECK dout0_32 Vdout0_32ck163 = 0 time = 820
.meas tran vdout0_32ck163 FIND v(dout0_32) AT=820.025n

* CHECK dout0_33 Vdout0_33ck163 = 0.9 time = 820
.meas tran vdout0_33ck163 FIND v(dout0_33) AT=820.025n

* CHECK dout0_34 Vdout0_34ck163 = 0.9 time = 820
.meas tran vdout0_34ck163 FIND v(dout0_34) AT=820.025n

* CHECK dout0_35 Vdout0_35ck163 = 0.9 time = 820
.meas tran vdout0_35ck163 FIND v(dout0_35) AT=820.025n

* CHECK dout0_36 Vdout0_36ck163 = 0 time = 820
.meas tran vdout0_36ck163 FIND v(dout0_36) AT=820.025n

* CHECK dout0_37 Vdout0_37ck163 = 0.9 time = 820
.meas tran vdout0_37ck163 FIND v(dout0_37) AT=820.025n

* CHECK dout0_38 Vdout0_38ck163 = 0 time = 820
.meas tran vdout0_38ck163 FIND v(dout0_38) AT=820.025n

* CHECK dout0_39 Vdout0_39ck163 = 0.9 time = 820
.meas tran vdout0_39ck163 FIND v(dout0_39) AT=820.025n

* CHECK dout0_0 Vdout0_0ck164 = 0.9 time = 825
.meas tran vdout0_0ck164 FIND v(dout0_0) AT=825.025n

* CHECK dout0_1 Vdout0_1ck164 = 0 time = 825
.meas tran vdout0_1ck164 FIND v(dout0_1) AT=825.025n

* CHECK dout0_2 Vdout0_2ck164 = 0.9 time = 825
.meas tran vdout0_2ck164 FIND v(dout0_2) AT=825.025n

* CHECK dout0_3 Vdout0_3ck164 = 0.9 time = 825
.meas tran vdout0_3ck164 FIND v(dout0_3) AT=825.025n

* CHECK dout0_4 Vdout0_4ck164 = 0 time = 825
.meas tran vdout0_4ck164 FIND v(dout0_4) AT=825.025n

* CHECK dout0_5 Vdout0_5ck164 = 0 time = 825
.meas tran vdout0_5ck164 FIND v(dout0_5) AT=825.025n

* CHECK dout0_6 Vdout0_6ck164 = 0.9 time = 825
.meas tran vdout0_6ck164 FIND v(dout0_6) AT=825.025n

* CHECK dout0_7 Vdout0_7ck164 = 0 time = 825
.meas tran vdout0_7ck164 FIND v(dout0_7) AT=825.025n

* CHECK dout0_8 Vdout0_8ck164 = 0.9 time = 825
.meas tran vdout0_8ck164 FIND v(dout0_8) AT=825.025n

* CHECK dout0_9 Vdout0_9ck164 = 0.9 time = 825
.meas tran vdout0_9ck164 FIND v(dout0_9) AT=825.025n

* CHECK dout0_10 Vdout0_10ck164 = 0.9 time = 825
.meas tran vdout0_10ck164 FIND v(dout0_10) AT=825.025n

* CHECK dout0_11 Vdout0_11ck164 = 0 time = 825
.meas tran vdout0_11ck164 FIND v(dout0_11) AT=825.025n

* CHECK dout0_12 Vdout0_12ck164 = 0.9 time = 825
.meas tran vdout0_12ck164 FIND v(dout0_12) AT=825.025n

* CHECK dout0_13 Vdout0_13ck164 = 0.9 time = 825
.meas tran vdout0_13ck164 FIND v(dout0_13) AT=825.025n

* CHECK dout0_14 Vdout0_14ck164 = 0 time = 825
.meas tran vdout0_14ck164 FIND v(dout0_14) AT=825.025n

* CHECK dout0_15 Vdout0_15ck164 = 0.9 time = 825
.meas tran vdout0_15ck164 FIND v(dout0_15) AT=825.025n

* CHECK dout0_16 Vdout0_16ck164 = 0.9 time = 825
.meas tran vdout0_16ck164 FIND v(dout0_16) AT=825.025n

* CHECK dout0_17 Vdout0_17ck164 = 0.9 time = 825
.meas tran vdout0_17ck164 FIND v(dout0_17) AT=825.025n

* CHECK dout0_18 Vdout0_18ck164 = 0.9 time = 825
.meas tran vdout0_18ck164 FIND v(dout0_18) AT=825.025n

* CHECK dout0_19 Vdout0_19ck164 = 0.9 time = 825
.meas tran vdout0_19ck164 FIND v(dout0_19) AT=825.025n

* CHECK dout0_20 Vdout0_20ck164 = 0 time = 825
.meas tran vdout0_20ck164 FIND v(dout0_20) AT=825.025n

* CHECK dout0_21 Vdout0_21ck164 = 0.9 time = 825
.meas tran vdout0_21ck164 FIND v(dout0_21) AT=825.025n

* CHECK dout0_22 Vdout0_22ck164 = 0.9 time = 825
.meas tran vdout0_22ck164 FIND v(dout0_22) AT=825.025n

* CHECK dout0_23 Vdout0_23ck164 = 0.9 time = 825
.meas tran vdout0_23ck164 FIND v(dout0_23) AT=825.025n

* CHECK dout0_24 Vdout0_24ck164 = 0 time = 825
.meas tran vdout0_24ck164 FIND v(dout0_24) AT=825.025n

* CHECK dout0_25 Vdout0_25ck164 = 0 time = 825
.meas tran vdout0_25ck164 FIND v(dout0_25) AT=825.025n

* CHECK dout0_26 Vdout0_26ck164 = 0 time = 825
.meas tran vdout0_26ck164 FIND v(dout0_26) AT=825.025n

* CHECK dout0_27 Vdout0_27ck164 = 0.9 time = 825
.meas tran vdout0_27ck164 FIND v(dout0_27) AT=825.025n

* CHECK dout0_28 Vdout0_28ck164 = 0.9 time = 825
.meas tran vdout0_28ck164 FIND v(dout0_28) AT=825.025n

* CHECK dout0_29 Vdout0_29ck164 = 0.9 time = 825
.meas tran vdout0_29ck164 FIND v(dout0_29) AT=825.025n

* CHECK dout0_30 Vdout0_30ck164 = 0 time = 825
.meas tran vdout0_30ck164 FIND v(dout0_30) AT=825.025n

* CHECK dout0_31 Vdout0_31ck164 = 0 time = 825
.meas tran vdout0_31ck164 FIND v(dout0_31) AT=825.025n

* CHECK dout0_32 Vdout0_32ck164 = 0 time = 825
.meas tran vdout0_32ck164 FIND v(dout0_32) AT=825.025n

* CHECK dout0_33 Vdout0_33ck164 = 0 time = 825
.meas tran vdout0_33ck164 FIND v(dout0_33) AT=825.025n

* CHECK dout0_34 Vdout0_34ck164 = 0 time = 825
.meas tran vdout0_34ck164 FIND v(dout0_34) AT=825.025n

* CHECK dout0_35 Vdout0_35ck164 = 0 time = 825
.meas tran vdout0_35ck164 FIND v(dout0_35) AT=825.025n

* CHECK dout0_36 Vdout0_36ck164 = 0.9 time = 825
.meas tran vdout0_36ck164 FIND v(dout0_36) AT=825.025n

* CHECK dout0_37 Vdout0_37ck164 = 0 time = 825
.meas tran vdout0_37ck164 FIND v(dout0_37) AT=825.025n

* CHECK dout0_38 Vdout0_38ck164 = 0 time = 825
.meas tran vdout0_38ck164 FIND v(dout0_38) AT=825.025n

* CHECK dout0_39 Vdout0_39ck164 = 0 time = 825
.meas tran vdout0_39ck164 FIND v(dout0_39) AT=825.025n

* CHECK dout0_0 Vdout0_0ck166 = 0.9 time = 835
.meas tran vdout0_0ck166 FIND v(dout0_0) AT=835.025n

* CHECK dout0_1 Vdout0_1ck166 = 0 time = 835
.meas tran vdout0_1ck166 FIND v(dout0_1) AT=835.025n

* CHECK dout0_2 Vdout0_2ck166 = 0.9 time = 835
.meas tran vdout0_2ck166 FIND v(dout0_2) AT=835.025n

* CHECK dout0_3 Vdout0_3ck166 = 0.9 time = 835
.meas tran vdout0_3ck166 FIND v(dout0_3) AT=835.025n

* CHECK dout0_4 Vdout0_4ck166 = 0 time = 835
.meas tran vdout0_4ck166 FIND v(dout0_4) AT=835.025n

* CHECK dout0_5 Vdout0_5ck166 = 0 time = 835
.meas tran vdout0_5ck166 FIND v(dout0_5) AT=835.025n

* CHECK dout0_6 Vdout0_6ck166 = 0.9 time = 835
.meas tran vdout0_6ck166 FIND v(dout0_6) AT=835.025n

* CHECK dout0_7 Vdout0_7ck166 = 0 time = 835
.meas tran vdout0_7ck166 FIND v(dout0_7) AT=835.025n

* CHECK dout0_8 Vdout0_8ck166 = 0.9 time = 835
.meas tran vdout0_8ck166 FIND v(dout0_8) AT=835.025n

* CHECK dout0_9 Vdout0_9ck166 = 0.9 time = 835
.meas tran vdout0_9ck166 FIND v(dout0_9) AT=835.025n

* CHECK dout0_10 Vdout0_10ck166 = 0.9 time = 835
.meas tran vdout0_10ck166 FIND v(dout0_10) AT=835.025n

* CHECK dout0_11 Vdout0_11ck166 = 0 time = 835
.meas tran vdout0_11ck166 FIND v(dout0_11) AT=835.025n

* CHECK dout0_12 Vdout0_12ck166 = 0.9 time = 835
.meas tran vdout0_12ck166 FIND v(dout0_12) AT=835.025n

* CHECK dout0_13 Vdout0_13ck166 = 0.9 time = 835
.meas tran vdout0_13ck166 FIND v(dout0_13) AT=835.025n

* CHECK dout0_14 Vdout0_14ck166 = 0 time = 835
.meas tran vdout0_14ck166 FIND v(dout0_14) AT=835.025n

* CHECK dout0_15 Vdout0_15ck166 = 0.9 time = 835
.meas tran vdout0_15ck166 FIND v(dout0_15) AT=835.025n

* CHECK dout0_16 Vdout0_16ck166 = 0.9 time = 835
.meas tran vdout0_16ck166 FIND v(dout0_16) AT=835.025n

* CHECK dout0_17 Vdout0_17ck166 = 0.9 time = 835
.meas tran vdout0_17ck166 FIND v(dout0_17) AT=835.025n

* CHECK dout0_18 Vdout0_18ck166 = 0.9 time = 835
.meas tran vdout0_18ck166 FIND v(dout0_18) AT=835.025n

* CHECK dout0_19 Vdout0_19ck166 = 0.9 time = 835
.meas tran vdout0_19ck166 FIND v(dout0_19) AT=835.025n

* CHECK dout0_20 Vdout0_20ck166 = 0 time = 835
.meas tran vdout0_20ck166 FIND v(dout0_20) AT=835.025n

* CHECK dout0_21 Vdout0_21ck166 = 0.9 time = 835
.meas tran vdout0_21ck166 FIND v(dout0_21) AT=835.025n

* CHECK dout0_22 Vdout0_22ck166 = 0.9 time = 835
.meas tran vdout0_22ck166 FIND v(dout0_22) AT=835.025n

* CHECK dout0_23 Vdout0_23ck166 = 0.9 time = 835
.meas tran vdout0_23ck166 FIND v(dout0_23) AT=835.025n

* CHECK dout0_24 Vdout0_24ck166 = 0 time = 835
.meas tran vdout0_24ck166 FIND v(dout0_24) AT=835.025n

* CHECK dout0_25 Vdout0_25ck166 = 0 time = 835
.meas tran vdout0_25ck166 FIND v(dout0_25) AT=835.025n

* CHECK dout0_26 Vdout0_26ck166 = 0 time = 835
.meas tran vdout0_26ck166 FIND v(dout0_26) AT=835.025n

* CHECK dout0_27 Vdout0_27ck166 = 0.9 time = 835
.meas tran vdout0_27ck166 FIND v(dout0_27) AT=835.025n

* CHECK dout0_28 Vdout0_28ck166 = 0.9 time = 835
.meas tran vdout0_28ck166 FIND v(dout0_28) AT=835.025n

* CHECK dout0_29 Vdout0_29ck166 = 0.9 time = 835
.meas tran vdout0_29ck166 FIND v(dout0_29) AT=835.025n

* CHECK dout0_30 Vdout0_30ck166 = 0 time = 835
.meas tran vdout0_30ck166 FIND v(dout0_30) AT=835.025n

* CHECK dout0_31 Vdout0_31ck166 = 0 time = 835
.meas tran vdout0_31ck166 FIND v(dout0_31) AT=835.025n

* CHECK dout0_32 Vdout0_32ck166 = 0 time = 835
.meas tran vdout0_32ck166 FIND v(dout0_32) AT=835.025n

* CHECK dout0_33 Vdout0_33ck166 = 0 time = 835
.meas tran vdout0_33ck166 FIND v(dout0_33) AT=835.025n

* CHECK dout0_34 Vdout0_34ck166 = 0 time = 835
.meas tran vdout0_34ck166 FIND v(dout0_34) AT=835.025n

* CHECK dout0_35 Vdout0_35ck166 = 0 time = 835
.meas tran vdout0_35ck166 FIND v(dout0_35) AT=835.025n

* CHECK dout0_36 Vdout0_36ck166 = 0.9 time = 835
.meas tran vdout0_36ck166 FIND v(dout0_36) AT=835.025n

* CHECK dout0_37 Vdout0_37ck166 = 0 time = 835
.meas tran vdout0_37ck166 FIND v(dout0_37) AT=835.025n

* CHECK dout0_38 Vdout0_38ck166 = 0 time = 835
.meas tran vdout0_38ck166 FIND v(dout0_38) AT=835.025n

* CHECK dout0_39 Vdout0_39ck166 = 0 time = 835
.meas tran vdout0_39ck166 FIND v(dout0_39) AT=835.025n

* CHECK dout0_0 Vdout0_0ck169 = 0.9 time = 850
.meas tran vdout0_0ck169 FIND v(dout0_0) AT=850.025n

* CHECK dout0_1 Vdout0_1ck169 = 0.9 time = 850
.meas tran vdout0_1ck169 FIND v(dout0_1) AT=850.025n

* CHECK dout0_2 Vdout0_2ck169 = 0 time = 850
.meas tran vdout0_2ck169 FIND v(dout0_2) AT=850.025n

* CHECK dout0_3 Vdout0_3ck169 = 0 time = 850
.meas tran vdout0_3ck169 FIND v(dout0_3) AT=850.025n

* CHECK dout0_4 Vdout0_4ck169 = 0 time = 850
.meas tran vdout0_4ck169 FIND v(dout0_4) AT=850.025n

* CHECK dout0_5 Vdout0_5ck169 = 0.9 time = 850
.meas tran vdout0_5ck169 FIND v(dout0_5) AT=850.025n

* CHECK dout0_6 Vdout0_6ck169 = 0 time = 850
.meas tran vdout0_6ck169 FIND v(dout0_6) AT=850.025n

* CHECK dout0_7 Vdout0_7ck169 = 0 time = 850
.meas tran vdout0_7ck169 FIND v(dout0_7) AT=850.025n

* CHECK dout0_8 Vdout0_8ck169 = 0.9 time = 850
.meas tran vdout0_8ck169 FIND v(dout0_8) AT=850.025n

* CHECK dout0_9 Vdout0_9ck169 = 0 time = 850
.meas tran vdout0_9ck169 FIND v(dout0_9) AT=850.025n

* CHECK dout0_10 Vdout0_10ck169 = 0 time = 850
.meas tran vdout0_10ck169 FIND v(dout0_10) AT=850.025n

* CHECK dout0_11 Vdout0_11ck169 = 0 time = 850
.meas tran vdout0_11ck169 FIND v(dout0_11) AT=850.025n

* CHECK dout0_12 Vdout0_12ck169 = 0 time = 850
.meas tran vdout0_12ck169 FIND v(dout0_12) AT=850.025n

* CHECK dout0_13 Vdout0_13ck169 = 0 time = 850
.meas tran vdout0_13ck169 FIND v(dout0_13) AT=850.025n

* CHECK dout0_14 Vdout0_14ck169 = 0.9 time = 850
.meas tran vdout0_14ck169 FIND v(dout0_14) AT=850.025n

* CHECK dout0_15 Vdout0_15ck169 = 0 time = 850
.meas tran vdout0_15ck169 FIND v(dout0_15) AT=850.025n

* CHECK dout0_16 Vdout0_16ck169 = 0 time = 850
.meas tran vdout0_16ck169 FIND v(dout0_16) AT=850.025n

* CHECK dout0_17 Vdout0_17ck169 = 0.9 time = 850
.meas tran vdout0_17ck169 FIND v(dout0_17) AT=850.025n

* CHECK dout0_18 Vdout0_18ck169 = 0.9 time = 850
.meas tran vdout0_18ck169 FIND v(dout0_18) AT=850.025n

* CHECK dout0_19 Vdout0_19ck169 = 0.9 time = 850
.meas tran vdout0_19ck169 FIND v(dout0_19) AT=850.025n

* CHECK dout0_20 Vdout0_20ck169 = 0.9 time = 850
.meas tran vdout0_20ck169 FIND v(dout0_20) AT=850.025n

* CHECK dout0_21 Vdout0_21ck169 = 0 time = 850
.meas tran vdout0_21ck169 FIND v(dout0_21) AT=850.025n

* CHECK dout0_22 Vdout0_22ck169 = 0.9 time = 850
.meas tran vdout0_22ck169 FIND v(dout0_22) AT=850.025n

* CHECK dout0_23 Vdout0_23ck169 = 0 time = 850
.meas tran vdout0_23ck169 FIND v(dout0_23) AT=850.025n

* CHECK dout0_24 Vdout0_24ck169 = 0.9 time = 850
.meas tran vdout0_24ck169 FIND v(dout0_24) AT=850.025n

* CHECK dout0_25 Vdout0_25ck169 = 0.9 time = 850
.meas tran vdout0_25ck169 FIND v(dout0_25) AT=850.025n

* CHECK dout0_26 Vdout0_26ck169 = 0 time = 850
.meas tran vdout0_26ck169 FIND v(dout0_26) AT=850.025n

* CHECK dout0_27 Vdout0_27ck169 = 0.9 time = 850
.meas tran vdout0_27ck169 FIND v(dout0_27) AT=850.025n

* CHECK dout0_28 Vdout0_28ck169 = 0.9 time = 850
.meas tran vdout0_28ck169 FIND v(dout0_28) AT=850.025n

* CHECK dout0_29 Vdout0_29ck169 = 0.9 time = 850
.meas tran vdout0_29ck169 FIND v(dout0_29) AT=850.025n

* CHECK dout0_30 Vdout0_30ck169 = 0 time = 850
.meas tran vdout0_30ck169 FIND v(dout0_30) AT=850.025n

* CHECK dout0_31 Vdout0_31ck169 = 0.9 time = 850
.meas tran vdout0_31ck169 FIND v(dout0_31) AT=850.025n

* CHECK dout0_32 Vdout0_32ck169 = 0 time = 850
.meas tran vdout0_32ck169 FIND v(dout0_32) AT=850.025n

* CHECK dout0_33 Vdout0_33ck169 = 0.9 time = 850
.meas tran vdout0_33ck169 FIND v(dout0_33) AT=850.025n

* CHECK dout0_34 Vdout0_34ck169 = 0.9 time = 850
.meas tran vdout0_34ck169 FIND v(dout0_34) AT=850.025n

* CHECK dout0_35 Vdout0_35ck169 = 0 time = 850
.meas tran vdout0_35ck169 FIND v(dout0_35) AT=850.025n

* CHECK dout0_36 Vdout0_36ck169 = 0 time = 850
.meas tran vdout0_36ck169 FIND v(dout0_36) AT=850.025n

* CHECK dout0_37 Vdout0_37ck169 = 0.9 time = 850
.meas tran vdout0_37ck169 FIND v(dout0_37) AT=850.025n

* CHECK dout0_38 Vdout0_38ck169 = 0.9 time = 850
.meas tran vdout0_38ck169 FIND v(dout0_38) AT=850.025n

* CHECK dout0_39 Vdout0_39ck169 = 0 time = 850
.meas tran vdout0_39ck169 FIND v(dout0_39) AT=850.025n

* CHECK dout0_0 Vdout0_0ck173 = 0 time = 870
.meas tran vdout0_0ck173 FIND v(dout0_0) AT=870.025n

* CHECK dout0_1 Vdout0_1ck173 = 0.9 time = 870
.meas tran vdout0_1ck173 FIND v(dout0_1) AT=870.025n

* CHECK dout0_2 Vdout0_2ck173 = 0 time = 870
.meas tran vdout0_2ck173 FIND v(dout0_2) AT=870.025n

* CHECK dout0_3 Vdout0_3ck173 = 0 time = 870
.meas tran vdout0_3ck173 FIND v(dout0_3) AT=870.025n

* CHECK dout0_4 Vdout0_4ck173 = 0.9 time = 870
.meas tran vdout0_4ck173 FIND v(dout0_4) AT=870.025n

* CHECK dout0_5 Vdout0_5ck173 = 0 time = 870
.meas tran vdout0_5ck173 FIND v(dout0_5) AT=870.025n

* CHECK dout0_6 Vdout0_6ck173 = 0 time = 870
.meas tran vdout0_6ck173 FIND v(dout0_6) AT=870.025n

* CHECK dout0_7 Vdout0_7ck173 = 0.9 time = 870
.meas tran vdout0_7ck173 FIND v(dout0_7) AT=870.025n

* CHECK dout0_8 Vdout0_8ck173 = 0.9 time = 870
.meas tran vdout0_8ck173 FIND v(dout0_8) AT=870.025n

* CHECK dout0_9 Vdout0_9ck173 = 0 time = 870
.meas tran vdout0_9ck173 FIND v(dout0_9) AT=870.025n

* CHECK dout0_10 Vdout0_10ck173 = 0.9 time = 870
.meas tran vdout0_10ck173 FIND v(dout0_10) AT=870.025n

* CHECK dout0_11 Vdout0_11ck173 = 0 time = 870
.meas tran vdout0_11ck173 FIND v(dout0_11) AT=870.025n

* CHECK dout0_12 Vdout0_12ck173 = 0.9 time = 870
.meas tran vdout0_12ck173 FIND v(dout0_12) AT=870.025n

* CHECK dout0_13 Vdout0_13ck173 = 0 time = 870
.meas tran vdout0_13ck173 FIND v(dout0_13) AT=870.025n

* CHECK dout0_14 Vdout0_14ck173 = 0.9 time = 870
.meas tran vdout0_14ck173 FIND v(dout0_14) AT=870.025n

* CHECK dout0_15 Vdout0_15ck173 = 0.9 time = 870
.meas tran vdout0_15ck173 FIND v(dout0_15) AT=870.025n

* CHECK dout0_16 Vdout0_16ck173 = 0 time = 870
.meas tran vdout0_16ck173 FIND v(dout0_16) AT=870.025n

* CHECK dout0_17 Vdout0_17ck173 = 0 time = 870
.meas tran vdout0_17ck173 FIND v(dout0_17) AT=870.025n

* CHECK dout0_18 Vdout0_18ck173 = 0.9 time = 870
.meas tran vdout0_18ck173 FIND v(dout0_18) AT=870.025n

* CHECK dout0_19 Vdout0_19ck173 = 0.9 time = 870
.meas tran vdout0_19ck173 FIND v(dout0_19) AT=870.025n

* CHECK dout0_20 Vdout0_20ck173 = 0.9 time = 870
.meas tran vdout0_20ck173 FIND v(dout0_20) AT=870.025n

* CHECK dout0_21 Vdout0_21ck173 = 0.9 time = 870
.meas tran vdout0_21ck173 FIND v(dout0_21) AT=870.025n

* CHECK dout0_22 Vdout0_22ck173 = 0 time = 870
.meas tran vdout0_22ck173 FIND v(dout0_22) AT=870.025n

* CHECK dout0_23 Vdout0_23ck173 = 0.9 time = 870
.meas tran vdout0_23ck173 FIND v(dout0_23) AT=870.025n

* CHECK dout0_24 Vdout0_24ck173 = 0 time = 870
.meas tran vdout0_24ck173 FIND v(dout0_24) AT=870.025n

* CHECK dout0_25 Vdout0_25ck173 = 0.9 time = 870
.meas tran vdout0_25ck173 FIND v(dout0_25) AT=870.025n

* CHECK dout0_26 Vdout0_26ck173 = 0 time = 870
.meas tran vdout0_26ck173 FIND v(dout0_26) AT=870.025n

* CHECK dout0_27 Vdout0_27ck173 = 0 time = 870
.meas tran vdout0_27ck173 FIND v(dout0_27) AT=870.025n

* CHECK dout0_28 Vdout0_28ck173 = 0.9 time = 870
.meas tran vdout0_28ck173 FIND v(dout0_28) AT=870.025n

* CHECK dout0_29 Vdout0_29ck173 = 0.9 time = 870
.meas tran vdout0_29ck173 FIND v(dout0_29) AT=870.025n

* CHECK dout0_30 Vdout0_30ck173 = 0 time = 870
.meas tran vdout0_30ck173 FIND v(dout0_30) AT=870.025n

* CHECK dout0_31 Vdout0_31ck173 = 0 time = 870
.meas tran vdout0_31ck173 FIND v(dout0_31) AT=870.025n

* CHECK dout0_32 Vdout0_32ck173 = 0.9 time = 870
.meas tran vdout0_32ck173 FIND v(dout0_32) AT=870.025n

* CHECK dout0_33 Vdout0_33ck173 = 0.9 time = 870
.meas tran vdout0_33ck173 FIND v(dout0_33) AT=870.025n

* CHECK dout0_34 Vdout0_34ck173 = 0 time = 870
.meas tran vdout0_34ck173 FIND v(dout0_34) AT=870.025n

* CHECK dout0_35 Vdout0_35ck173 = 0.9 time = 870
.meas tran vdout0_35ck173 FIND v(dout0_35) AT=870.025n

* CHECK dout0_36 Vdout0_36ck173 = 0 time = 870
.meas tran vdout0_36ck173 FIND v(dout0_36) AT=870.025n

* CHECK dout0_37 Vdout0_37ck173 = 0.9 time = 870
.meas tran vdout0_37ck173 FIND v(dout0_37) AT=870.025n

* CHECK dout0_38 Vdout0_38ck173 = 0.9 time = 870
.meas tran vdout0_38ck173 FIND v(dout0_38) AT=870.025n

* CHECK dout0_39 Vdout0_39ck173 = 0.9 time = 870
.meas tran vdout0_39ck173 FIND v(dout0_39) AT=870.025n

* CHECK dout0_0 Vdout0_0ck175 = 0 time = 880
.meas tran vdout0_0ck175 FIND v(dout0_0) AT=880.025n

* CHECK dout0_1 Vdout0_1ck175 = 0 time = 880
.meas tran vdout0_1ck175 FIND v(dout0_1) AT=880.025n

* CHECK dout0_2 Vdout0_2ck175 = 0.9 time = 880
.meas tran vdout0_2ck175 FIND v(dout0_2) AT=880.025n

* CHECK dout0_3 Vdout0_3ck175 = 0 time = 880
.meas tran vdout0_3ck175 FIND v(dout0_3) AT=880.025n

* CHECK dout0_4 Vdout0_4ck175 = 0.9 time = 880
.meas tran vdout0_4ck175 FIND v(dout0_4) AT=880.025n

* CHECK dout0_5 Vdout0_5ck175 = 0.9 time = 880
.meas tran vdout0_5ck175 FIND v(dout0_5) AT=880.025n

* CHECK dout0_6 Vdout0_6ck175 = 0.9 time = 880
.meas tran vdout0_6ck175 FIND v(dout0_6) AT=880.025n

* CHECK dout0_7 Vdout0_7ck175 = 0 time = 880
.meas tran vdout0_7ck175 FIND v(dout0_7) AT=880.025n

* CHECK dout0_8 Vdout0_8ck175 = 0.9 time = 880
.meas tran vdout0_8ck175 FIND v(dout0_8) AT=880.025n

* CHECK dout0_9 Vdout0_9ck175 = 0.9 time = 880
.meas tran vdout0_9ck175 FIND v(dout0_9) AT=880.025n

* CHECK dout0_10 Vdout0_10ck175 = 0.9 time = 880
.meas tran vdout0_10ck175 FIND v(dout0_10) AT=880.025n

* CHECK dout0_11 Vdout0_11ck175 = 0 time = 880
.meas tran vdout0_11ck175 FIND v(dout0_11) AT=880.025n

* CHECK dout0_12 Vdout0_12ck175 = 0 time = 880
.meas tran vdout0_12ck175 FIND v(dout0_12) AT=880.025n

* CHECK dout0_13 Vdout0_13ck175 = 0.9 time = 880
.meas tran vdout0_13ck175 FIND v(dout0_13) AT=880.025n

* CHECK dout0_14 Vdout0_14ck175 = 0 time = 880
.meas tran vdout0_14ck175 FIND v(dout0_14) AT=880.025n

* CHECK dout0_15 Vdout0_15ck175 = 0 time = 880
.meas tran vdout0_15ck175 FIND v(dout0_15) AT=880.025n

* CHECK dout0_16 Vdout0_16ck175 = 0 time = 880
.meas tran vdout0_16ck175 FIND v(dout0_16) AT=880.025n

* CHECK dout0_17 Vdout0_17ck175 = 0.9 time = 880
.meas tran vdout0_17ck175 FIND v(dout0_17) AT=880.025n

* CHECK dout0_18 Vdout0_18ck175 = 0 time = 880
.meas tran vdout0_18ck175 FIND v(dout0_18) AT=880.025n

* CHECK dout0_19 Vdout0_19ck175 = 0 time = 880
.meas tran vdout0_19ck175 FIND v(dout0_19) AT=880.025n

* CHECK dout0_20 Vdout0_20ck175 = 0 time = 880
.meas tran vdout0_20ck175 FIND v(dout0_20) AT=880.025n

* CHECK dout0_21 Vdout0_21ck175 = 0.9 time = 880
.meas tran vdout0_21ck175 FIND v(dout0_21) AT=880.025n

* CHECK dout0_22 Vdout0_22ck175 = 0 time = 880
.meas tran vdout0_22ck175 FIND v(dout0_22) AT=880.025n

* CHECK dout0_23 Vdout0_23ck175 = 0.9 time = 880
.meas tran vdout0_23ck175 FIND v(dout0_23) AT=880.025n

* CHECK dout0_24 Vdout0_24ck175 = 0 time = 880
.meas tran vdout0_24ck175 FIND v(dout0_24) AT=880.025n

* CHECK dout0_25 Vdout0_25ck175 = 0.9 time = 880
.meas tran vdout0_25ck175 FIND v(dout0_25) AT=880.025n

* CHECK dout0_26 Vdout0_26ck175 = 0 time = 880
.meas tran vdout0_26ck175 FIND v(dout0_26) AT=880.025n

* CHECK dout0_27 Vdout0_27ck175 = 0 time = 880
.meas tran vdout0_27ck175 FIND v(dout0_27) AT=880.025n

* CHECK dout0_28 Vdout0_28ck175 = 0.9 time = 880
.meas tran vdout0_28ck175 FIND v(dout0_28) AT=880.025n

* CHECK dout0_29 Vdout0_29ck175 = 0.9 time = 880
.meas tran vdout0_29ck175 FIND v(dout0_29) AT=880.025n

* CHECK dout0_30 Vdout0_30ck175 = 0.9 time = 880
.meas tran vdout0_30ck175 FIND v(dout0_30) AT=880.025n

* CHECK dout0_31 Vdout0_31ck175 = 0.9 time = 880
.meas tran vdout0_31ck175 FIND v(dout0_31) AT=880.025n

* CHECK dout0_32 Vdout0_32ck175 = 0.9 time = 880
.meas tran vdout0_32ck175 FIND v(dout0_32) AT=880.025n

* CHECK dout0_33 Vdout0_33ck175 = 0.9 time = 880
.meas tran vdout0_33ck175 FIND v(dout0_33) AT=880.025n

* CHECK dout0_34 Vdout0_34ck175 = 0 time = 880
.meas tran vdout0_34ck175 FIND v(dout0_34) AT=880.025n

* CHECK dout0_35 Vdout0_35ck175 = 0 time = 880
.meas tran vdout0_35ck175 FIND v(dout0_35) AT=880.025n

* CHECK dout0_36 Vdout0_36ck175 = 0.9 time = 880
.meas tran vdout0_36ck175 FIND v(dout0_36) AT=880.025n

* CHECK dout0_37 Vdout0_37ck175 = 0 time = 880
.meas tran vdout0_37ck175 FIND v(dout0_37) AT=880.025n

* CHECK dout0_38 Vdout0_38ck175 = 0 time = 880
.meas tran vdout0_38ck175 FIND v(dout0_38) AT=880.025n

* CHECK dout0_39 Vdout0_39ck175 = 0 time = 880
.meas tran vdout0_39ck175 FIND v(dout0_39) AT=880.025n

* CHECK dout0_0 Vdout0_0ck176 = 0.9 time = 885
.meas tran vdout0_0ck176 FIND v(dout0_0) AT=885.025n

* CHECK dout0_1 Vdout0_1ck176 = 0.9 time = 885
.meas tran vdout0_1ck176 FIND v(dout0_1) AT=885.025n

* CHECK dout0_2 Vdout0_2ck176 = 0 time = 885
.meas tran vdout0_2ck176 FIND v(dout0_2) AT=885.025n

* CHECK dout0_3 Vdout0_3ck176 = 0 time = 885
.meas tran vdout0_3ck176 FIND v(dout0_3) AT=885.025n

* CHECK dout0_4 Vdout0_4ck176 = 0 time = 885
.meas tran vdout0_4ck176 FIND v(dout0_4) AT=885.025n

* CHECK dout0_5 Vdout0_5ck176 = 0.9 time = 885
.meas tran vdout0_5ck176 FIND v(dout0_5) AT=885.025n

* CHECK dout0_6 Vdout0_6ck176 = 0 time = 885
.meas tran vdout0_6ck176 FIND v(dout0_6) AT=885.025n

* CHECK dout0_7 Vdout0_7ck176 = 0 time = 885
.meas tran vdout0_7ck176 FIND v(dout0_7) AT=885.025n

* CHECK dout0_8 Vdout0_8ck176 = 0.9 time = 885
.meas tran vdout0_8ck176 FIND v(dout0_8) AT=885.025n

* CHECK dout0_9 Vdout0_9ck176 = 0 time = 885
.meas tran vdout0_9ck176 FIND v(dout0_9) AT=885.025n

* CHECK dout0_10 Vdout0_10ck176 = 0 time = 885
.meas tran vdout0_10ck176 FIND v(dout0_10) AT=885.025n

* CHECK dout0_11 Vdout0_11ck176 = 0 time = 885
.meas tran vdout0_11ck176 FIND v(dout0_11) AT=885.025n

* CHECK dout0_12 Vdout0_12ck176 = 0 time = 885
.meas tran vdout0_12ck176 FIND v(dout0_12) AT=885.025n

* CHECK dout0_13 Vdout0_13ck176 = 0 time = 885
.meas tran vdout0_13ck176 FIND v(dout0_13) AT=885.025n

* CHECK dout0_14 Vdout0_14ck176 = 0.9 time = 885
.meas tran vdout0_14ck176 FIND v(dout0_14) AT=885.025n

* CHECK dout0_15 Vdout0_15ck176 = 0 time = 885
.meas tran vdout0_15ck176 FIND v(dout0_15) AT=885.025n

* CHECK dout0_16 Vdout0_16ck176 = 0 time = 885
.meas tran vdout0_16ck176 FIND v(dout0_16) AT=885.025n

* CHECK dout0_17 Vdout0_17ck176 = 0.9 time = 885
.meas tran vdout0_17ck176 FIND v(dout0_17) AT=885.025n

* CHECK dout0_18 Vdout0_18ck176 = 0.9 time = 885
.meas tran vdout0_18ck176 FIND v(dout0_18) AT=885.025n

* CHECK dout0_19 Vdout0_19ck176 = 0.9 time = 885
.meas tran vdout0_19ck176 FIND v(dout0_19) AT=885.025n

* CHECK dout0_20 Vdout0_20ck176 = 0.9 time = 885
.meas tran vdout0_20ck176 FIND v(dout0_20) AT=885.025n

* CHECK dout0_21 Vdout0_21ck176 = 0.9 time = 885
.meas tran vdout0_21ck176 FIND v(dout0_21) AT=885.025n

* CHECK dout0_22 Vdout0_22ck176 = 0 time = 885
.meas tran vdout0_22ck176 FIND v(dout0_22) AT=885.025n

* CHECK dout0_23 Vdout0_23ck176 = 0 time = 885
.meas tran vdout0_23ck176 FIND v(dout0_23) AT=885.025n

* CHECK dout0_24 Vdout0_24ck176 = 0.9 time = 885
.meas tran vdout0_24ck176 FIND v(dout0_24) AT=885.025n

* CHECK dout0_25 Vdout0_25ck176 = 0 time = 885
.meas tran vdout0_25ck176 FIND v(dout0_25) AT=885.025n

* CHECK dout0_26 Vdout0_26ck176 = 0.9 time = 885
.meas tran vdout0_26ck176 FIND v(dout0_26) AT=885.025n

* CHECK dout0_27 Vdout0_27ck176 = 0.9 time = 885
.meas tran vdout0_27ck176 FIND v(dout0_27) AT=885.025n

* CHECK dout0_28 Vdout0_28ck176 = 0 time = 885
.meas tran vdout0_28ck176 FIND v(dout0_28) AT=885.025n

* CHECK dout0_29 Vdout0_29ck176 = 0.9 time = 885
.meas tran vdout0_29ck176 FIND v(dout0_29) AT=885.025n

* CHECK dout0_30 Vdout0_30ck176 = 0.9 time = 885
.meas tran vdout0_30ck176 FIND v(dout0_30) AT=885.025n

* CHECK dout0_31 Vdout0_31ck176 = 0 time = 885
.meas tran vdout0_31ck176 FIND v(dout0_31) AT=885.025n

* CHECK dout0_32 Vdout0_32ck176 = 0 time = 885
.meas tran vdout0_32ck176 FIND v(dout0_32) AT=885.025n

* CHECK dout0_33 Vdout0_33ck176 = 0.9 time = 885
.meas tran vdout0_33ck176 FIND v(dout0_33) AT=885.025n

* CHECK dout0_34 Vdout0_34ck176 = 0 time = 885
.meas tran vdout0_34ck176 FIND v(dout0_34) AT=885.025n

* CHECK dout0_35 Vdout0_35ck176 = 0.9 time = 885
.meas tran vdout0_35ck176 FIND v(dout0_35) AT=885.025n

* CHECK dout0_36 Vdout0_36ck176 = 0 time = 885
.meas tran vdout0_36ck176 FIND v(dout0_36) AT=885.025n

* CHECK dout0_37 Vdout0_37ck176 = 0.9 time = 885
.meas tran vdout0_37ck176 FIND v(dout0_37) AT=885.025n

* CHECK dout0_38 Vdout0_38ck176 = 0.9 time = 885
.meas tran vdout0_38ck176 FIND v(dout0_38) AT=885.025n

* CHECK dout0_39 Vdout0_39ck176 = 0 time = 885
.meas tran vdout0_39ck176 FIND v(dout0_39) AT=885.025n

* CHECK dout0_0 Vdout0_0ck180 = 0 time = 905
.meas tran vdout0_0ck180 FIND v(dout0_0) AT=905.025n

* CHECK dout0_1 Vdout0_1ck180 = 0 time = 905
.meas tran vdout0_1ck180 FIND v(dout0_1) AT=905.025n

* CHECK dout0_2 Vdout0_2ck180 = 0.9 time = 905
.meas tran vdout0_2ck180 FIND v(dout0_2) AT=905.025n

* CHECK dout0_3 Vdout0_3ck180 = 0 time = 905
.meas tran vdout0_3ck180 FIND v(dout0_3) AT=905.025n

* CHECK dout0_4 Vdout0_4ck180 = 0.9 time = 905
.meas tran vdout0_4ck180 FIND v(dout0_4) AT=905.025n

* CHECK dout0_5 Vdout0_5ck180 = 0.9 time = 905
.meas tran vdout0_5ck180 FIND v(dout0_5) AT=905.025n

* CHECK dout0_6 Vdout0_6ck180 = 0.9 time = 905
.meas tran vdout0_6ck180 FIND v(dout0_6) AT=905.025n

* CHECK dout0_7 Vdout0_7ck180 = 0 time = 905
.meas tran vdout0_7ck180 FIND v(dout0_7) AT=905.025n

* CHECK dout0_8 Vdout0_8ck180 = 0.9 time = 905
.meas tran vdout0_8ck180 FIND v(dout0_8) AT=905.025n

* CHECK dout0_9 Vdout0_9ck180 = 0.9 time = 905
.meas tran vdout0_9ck180 FIND v(dout0_9) AT=905.025n

* CHECK dout0_10 Vdout0_10ck180 = 0.9 time = 905
.meas tran vdout0_10ck180 FIND v(dout0_10) AT=905.025n

* CHECK dout0_11 Vdout0_11ck180 = 0 time = 905
.meas tran vdout0_11ck180 FIND v(dout0_11) AT=905.025n

* CHECK dout0_12 Vdout0_12ck180 = 0 time = 905
.meas tran vdout0_12ck180 FIND v(dout0_12) AT=905.025n

* CHECK dout0_13 Vdout0_13ck180 = 0.9 time = 905
.meas tran vdout0_13ck180 FIND v(dout0_13) AT=905.025n

* CHECK dout0_14 Vdout0_14ck180 = 0 time = 905
.meas tran vdout0_14ck180 FIND v(dout0_14) AT=905.025n

* CHECK dout0_15 Vdout0_15ck180 = 0 time = 905
.meas tran vdout0_15ck180 FIND v(dout0_15) AT=905.025n

* CHECK dout0_16 Vdout0_16ck180 = 0 time = 905
.meas tran vdout0_16ck180 FIND v(dout0_16) AT=905.025n

* CHECK dout0_17 Vdout0_17ck180 = 0.9 time = 905
.meas tran vdout0_17ck180 FIND v(dout0_17) AT=905.025n

* CHECK dout0_18 Vdout0_18ck180 = 0 time = 905
.meas tran vdout0_18ck180 FIND v(dout0_18) AT=905.025n

* CHECK dout0_19 Vdout0_19ck180 = 0 time = 905
.meas tran vdout0_19ck180 FIND v(dout0_19) AT=905.025n

* CHECK dout0_20 Vdout0_20ck180 = 0 time = 905
.meas tran vdout0_20ck180 FIND v(dout0_20) AT=905.025n

* CHECK dout0_21 Vdout0_21ck180 = 0.9 time = 905
.meas tran vdout0_21ck180 FIND v(dout0_21) AT=905.025n

* CHECK dout0_22 Vdout0_22ck180 = 0 time = 905
.meas tran vdout0_22ck180 FIND v(dout0_22) AT=905.025n

* CHECK dout0_23 Vdout0_23ck180 = 0.9 time = 905
.meas tran vdout0_23ck180 FIND v(dout0_23) AT=905.025n

* CHECK dout0_24 Vdout0_24ck180 = 0 time = 905
.meas tran vdout0_24ck180 FIND v(dout0_24) AT=905.025n

* CHECK dout0_25 Vdout0_25ck180 = 0.9 time = 905
.meas tran vdout0_25ck180 FIND v(dout0_25) AT=905.025n

* CHECK dout0_26 Vdout0_26ck180 = 0 time = 905
.meas tran vdout0_26ck180 FIND v(dout0_26) AT=905.025n

* CHECK dout0_27 Vdout0_27ck180 = 0 time = 905
.meas tran vdout0_27ck180 FIND v(dout0_27) AT=905.025n

* CHECK dout0_28 Vdout0_28ck180 = 0.9 time = 905
.meas tran vdout0_28ck180 FIND v(dout0_28) AT=905.025n

* CHECK dout0_29 Vdout0_29ck180 = 0.9 time = 905
.meas tran vdout0_29ck180 FIND v(dout0_29) AT=905.025n

* CHECK dout0_30 Vdout0_30ck180 = 0.9 time = 905
.meas tran vdout0_30ck180 FIND v(dout0_30) AT=905.025n

* CHECK dout0_31 Vdout0_31ck180 = 0.9 time = 905
.meas tran vdout0_31ck180 FIND v(dout0_31) AT=905.025n

* CHECK dout0_32 Vdout0_32ck180 = 0.9 time = 905
.meas tran vdout0_32ck180 FIND v(dout0_32) AT=905.025n

* CHECK dout0_33 Vdout0_33ck180 = 0.9 time = 905
.meas tran vdout0_33ck180 FIND v(dout0_33) AT=905.025n

* CHECK dout0_34 Vdout0_34ck180 = 0 time = 905
.meas tran vdout0_34ck180 FIND v(dout0_34) AT=905.025n

* CHECK dout0_35 Vdout0_35ck180 = 0 time = 905
.meas tran vdout0_35ck180 FIND v(dout0_35) AT=905.025n

* CHECK dout0_36 Vdout0_36ck180 = 0.9 time = 905
.meas tran vdout0_36ck180 FIND v(dout0_36) AT=905.025n

* CHECK dout0_37 Vdout0_37ck180 = 0 time = 905
.meas tran vdout0_37ck180 FIND v(dout0_37) AT=905.025n

* CHECK dout0_38 Vdout0_38ck180 = 0 time = 905
.meas tran vdout0_38ck180 FIND v(dout0_38) AT=905.025n

* CHECK dout0_39 Vdout0_39ck180 = 0 time = 905
.meas tran vdout0_39ck180 FIND v(dout0_39) AT=905.025n

* CHECK dout0_0 Vdout0_0ck181 = 0 time = 910
.meas tran vdout0_0ck181 FIND v(dout0_0) AT=910.025n

* CHECK dout0_1 Vdout0_1ck181 = 0 time = 910
.meas tran vdout0_1ck181 FIND v(dout0_1) AT=910.025n

* CHECK dout0_2 Vdout0_2ck181 = 0.9 time = 910
.meas tran vdout0_2ck181 FIND v(dout0_2) AT=910.025n

* CHECK dout0_3 Vdout0_3ck181 = 0 time = 910
.meas tran vdout0_3ck181 FIND v(dout0_3) AT=910.025n

* CHECK dout0_4 Vdout0_4ck181 = 0.9 time = 910
.meas tran vdout0_4ck181 FIND v(dout0_4) AT=910.025n

* CHECK dout0_5 Vdout0_5ck181 = 0.9 time = 910
.meas tran vdout0_5ck181 FIND v(dout0_5) AT=910.025n

* CHECK dout0_6 Vdout0_6ck181 = 0.9 time = 910
.meas tran vdout0_6ck181 FIND v(dout0_6) AT=910.025n

* CHECK dout0_7 Vdout0_7ck181 = 0 time = 910
.meas tran vdout0_7ck181 FIND v(dout0_7) AT=910.025n

* CHECK dout0_8 Vdout0_8ck181 = 0.9 time = 910
.meas tran vdout0_8ck181 FIND v(dout0_8) AT=910.025n

* CHECK dout0_9 Vdout0_9ck181 = 0.9 time = 910
.meas tran vdout0_9ck181 FIND v(dout0_9) AT=910.025n

* CHECK dout0_10 Vdout0_10ck181 = 0.9 time = 910
.meas tran vdout0_10ck181 FIND v(dout0_10) AT=910.025n

* CHECK dout0_11 Vdout0_11ck181 = 0 time = 910
.meas tran vdout0_11ck181 FIND v(dout0_11) AT=910.025n

* CHECK dout0_12 Vdout0_12ck181 = 0 time = 910
.meas tran vdout0_12ck181 FIND v(dout0_12) AT=910.025n

* CHECK dout0_13 Vdout0_13ck181 = 0.9 time = 910
.meas tran vdout0_13ck181 FIND v(dout0_13) AT=910.025n

* CHECK dout0_14 Vdout0_14ck181 = 0 time = 910
.meas tran vdout0_14ck181 FIND v(dout0_14) AT=910.025n

* CHECK dout0_15 Vdout0_15ck181 = 0 time = 910
.meas tran vdout0_15ck181 FIND v(dout0_15) AT=910.025n

* CHECK dout0_16 Vdout0_16ck181 = 0 time = 910
.meas tran vdout0_16ck181 FIND v(dout0_16) AT=910.025n

* CHECK dout0_17 Vdout0_17ck181 = 0.9 time = 910
.meas tran vdout0_17ck181 FIND v(dout0_17) AT=910.025n

* CHECK dout0_18 Vdout0_18ck181 = 0 time = 910
.meas tran vdout0_18ck181 FIND v(dout0_18) AT=910.025n

* CHECK dout0_19 Vdout0_19ck181 = 0 time = 910
.meas tran vdout0_19ck181 FIND v(dout0_19) AT=910.025n

* CHECK dout0_20 Vdout0_20ck181 = 0 time = 910
.meas tran vdout0_20ck181 FIND v(dout0_20) AT=910.025n

* CHECK dout0_21 Vdout0_21ck181 = 0.9 time = 910
.meas tran vdout0_21ck181 FIND v(dout0_21) AT=910.025n

* CHECK dout0_22 Vdout0_22ck181 = 0 time = 910
.meas tran vdout0_22ck181 FIND v(dout0_22) AT=910.025n

* CHECK dout0_23 Vdout0_23ck181 = 0.9 time = 910
.meas tran vdout0_23ck181 FIND v(dout0_23) AT=910.025n

* CHECK dout0_24 Vdout0_24ck181 = 0 time = 910
.meas tran vdout0_24ck181 FIND v(dout0_24) AT=910.025n

* CHECK dout0_25 Vdout0_25ck181 = 0.9 time = 910
.meas tran vdout0_25ck181 FIND v(dout0_25) AT=910.025n

* CHECK dout0_26 Vdout0_26ck181 = 0 time = 910
.meas tran vdout0_26ck181 FIND v(dout0_26) AT=910.025n

* CHECK dout0_27 Vdout0_27ck181 = 0 time = 910
.meas tran vdout0_27ck181 FIND v(dout0_27) AT=910.025n

* CHECK dout0_28 Vdout0_28ck181 = 0.9 time = 910
.meas tran vdout0_28ck181 FIND v(dout0_28) AT=910.025n

* CHECK dout0_29 Vdout0_29ck181 = 0.9 time = 910
.meas tran vdout0_29ck181 FIND v(dout0_29) AT=910.025n

* CHECK dout0_30 Vdout0_30ck181 = 0.9 time = 910
.meas tran vdout0_30ck181 FIND v(dout0_30) AT=910.025n

* CHECK dout0_31 Vdout0_31ck181 = 0.9 time = 910
.meas tran vdout0_31ck181 FIND v(dout0_31) AT=910.025n

* CHECK dout0_32 Vdout0_32ck181 = 0.9 time = 910
.meas tran vdout0_32ck181 FIND v(dout0_32) AT=910.025n

* CHECK dout0_33 Vdout0_33ck181 = 0.9 time = 910
.meas tran vdout0_33ck181 FIND v(dout0_33) AT=910.025n

* CHECK dout0_34 Vdout0_34ck181 = 0 time = 910
.meas tran vdout0_34ck181 FIND v(dout0_34) AT=910.025n

* CHECK dout0_35 Vdout0_35ck181 = 0 time = 910
.meas tran vdout0_35ck181 FIND v(dout0_35) AT=910.025n

* CHECK dout0_36 Vdout0_36ck181 = 0.9 time = 910
.meas tran vdout0_36ck181 FIND v(dout0_36) AT=910.025n

* CHECK dout0_37 Vdout0_37ck181 = 0 time = 910
.meas tran vdout0_37ck181 FIND v(dout0_37) AT=910.025n

* CHECK dout0_38 Vdout0_38ck181 = 0 time = 910
.meas tran vdout0_38ck181 FIND v(dout0_38) AT=910.025n

* CHECK dout0_39 Vdout0_39ck181 = 0 time = 910
.meas tran vdout0_39ck181 FIND v(dout0_39) AT=910.025n

* CHECK dout0_0 Vdout0_0ck185 = 0.9 time = 930
.meas tran vdout0_0ck185 FIND v(dout0_0) AT=930.025n

* CHECK dout0_1 Vdout0_1ck185 = 0 time = 930
.meas tran vdout0_1ck185 FIND v(dout0_1) AT=930.025n

* CHECK dout0_2 Vdout0_2ck185 = 0 time = 930
.meas tran vdout0_2ck185 FIND v(dout0_2) AT=930.025n

* CHECK dout0_3 Vdout0_3ck185 = 0 time = 930
.meas tran vdout0_3ck185 FIND v(dout0_3) AT=930.025n

* CHECK dout0_4 Vdout0_4ck185 = 0.9 time = 930
.meas tran vdout0_4ck185 FIND v(dout0_4) AT=930.025n

* CHECK dout0_5 Vdout0_5ck185 = 0.9 time = 930
.meas tran vdout0_5ck185 FIND v(dout0_5) AT=930.025n

* CHECK dout0_6 Vdout0_6ck185 = 0.9 time = 930
.meas tran vdout0_6ck185 FIND v(dout0_6) AT=930.025n

* CHECK dout0_7 Vdout0_7ck185 = 0.9 time = 930
.meas tran vdout0_7ck185 FIND v(dout0_7) AT=930.025n

* CHECK dout0_8 Vdout0_8ck185 = 0.9 time = 930
.meas tran vdout0_8ck185 FIND v(dout0_8) AT=930.025n

* CHECK dout0_9 Vdout0_9ck185 = 0 time = 930
.meas tran vdout0_9ck185 FIND v(dout0_9) AT=930.025n

* CHECK dout0_10 Vdout0_10ck185 = 0.9 time = 930
.meas tran vdout0_10ck185 FIND v(dout0_10) AT=930.025n

* CHECK dout0_11 Vdout0_11ck185 = 0.9 time = 930
.meas tran vdout0_11ck185 FIND v(dout0_11) AT=930.025n

* CHECK dout0_12 Vdout0_12ck185 = 0 time = 930
.meas tran vdout0_12ck185 FIND v(dout0_12) AT=930.025n

* CHECK dout0_13 Vdout0_13ck185 = 0.9 time = 930
.meas tran vdout0_13ck185 FIND v(dout0_13) AT=930.025n

* CHECK dout0_14 Vdout0_14ck185 = 0.9 time = 930
.meas tran vdout0_14ck185 FIND v(dout0_14) AT=930.025n

* CHECK dout0_15 Vdout0_15ck185 = 0 time = 930
.meas tran vdout0_15ck185 FIND v(dout0_15) AT=930.025n

* CHECK dout0_16 Vdout0_16ck185 = 0.9 time = 930
.meas tran vdout0_16ck185 FIND v(dout0_16) AT=930.025n

* CHECK dout0_17 Vdout0_17ck185 = 0.9 time = 930
.meas tran vdout0_17ck185 FIND v(dout0_17) AT=930.025n

* CHECK dout0_18 Vdout0_18ck185 = 0.9 time = 930
.meas tran vdout0_18ck185 FIND v(dout0_18) AT=930.025n

* CHECK dout0_19 Vdout0_19ck185 = 0 time = 930
.meas tran vdout0_19ck185 FIND v(dout0_19) AT=930.025n

* CHECK dout0_20 Vdout0_20ck185 = 0.9 time = 930
.meas tran vdout0_20ck185 FIND v(dout0_20) AT=930.025n

* CHECK dout0_21 Vdout0_21ck185 = 0.9 time = 930
.meas tran vdout0_21ck185 FIND v(dout0_21) AT=930.025n

* CHECK dout0_22 Vdout0_22ck185 = 0.9 time = 930
.meas tran vdout0_22ck185 FIND v(dout0_22) AT=930.025n

* CHECK dout0_23 Vdout0_23ck185 = 0.9 time = 930
.meas tran vdout0_23ck185 FIND v(dout0_23) AT=930.025n

* CHECK dout0_24 Vdout0_24ck185 = 0.9 time = 930
.meas tran vdout0_24ck185 FIND v(dout0_24) AT=930.025n

* CHECK dout0_25 Vdout0_25ck185 = 0 time = 930
.meas tran vdout0_25ck185 FIND v(dout0_25) AT=930.025n

* CHECK dout0_26 Vdout0_26ck185 = 0.9 time = 930
.meas tran vdout0_26ck185 FIND v(dout0_26) AT=930.025n

* CHECK dout0_27 Vdout0_27ck185 = 0.9 time = 930
.meas tran vdout0_27ck185 FIND v(dout0_27) AT=930.025n

* CHECK dout0_28 Vdout0_28ck185 = 0 time = 930
.meas tran vdout0_28ck185 FIND v(dout0_28) AT=930.025n

* CHECK dout0_29 Vdout0_29ck185 = 0 time = 930
.meas tran vdout0_29ck185 FIND v(dout0_29) AT=930.025n

* CHECK dout0_30 Vdout0_30ck185 = 0.9 time = 930
.meas tran vdout0_30ck185 FIND v(dout0_30) AT=930.025n

* CHECK dout0_31 Vdout0_31ck185 = 0.9 time = 930
.meas tran vdout0_31ck185 FIND v(dout0_31) AT=930.025n

* CHECK dout0_32 Vdout0_32ck185 = 0.9 time = 930
.meas tran vdout0_32ck185 FIND v(dout0_32) AT=930.025n

* CHECK dout0_33 Vdout0_33ck185 = 0.9 time = 930
.meas tran vdout0_33ck185 FIND v(dout0_33) AT=930.025n

* CHECK dout0_34 Vdout0_34ck185 = 0.9 time = 930
.meas tran vdout0_34ck185 FIND v(dout0_34) AT=930.025n

* CHECK dout0_35 Vdout0_35ck185 = 0.9 time = 930
.meas tran vdout0_35ck185 FIND v(dout0_35) AT=930.025n

* CHECK dout0_36 Vdout0_36ck185 = 0 time = 930
.meas tran vdout0_36ck185 FIND v(dout0_36) AT=930.025n

* CHECK dout0_37 Vdout0_37ck185 = 0 time = 930
.meas tran vdout0_37ck185 FIND v(dout0_37) AT=930.025n

* CHECK dout0_38 Vdout0_38ck185 = 0.9 time = 930
.meas tran vdout0_38ck185 FIND v(dout0_38) AT=930.025n

* CHECK dout0_39 Vdout0_39ck185 = 0 time = 930
.meas tran vdout0_39ck185 FIND v(dout0_39) AT=930.025n

* CHECK dout0_0 Vdout0_0ck186 = 0 time = 935
.meas tran vdout0_0ck186 FIND v(dout0_0) AT=935.025n

* CHECK dout0_1 Vdout0_1ck186 = 0 time = 935
.meas tran vdout0_1ck186 FIND v(dout0_1) AT=935.025n

* CHECK dout0_2 Vdout0_2ck186 = 0.9 time = 935
.meas tran vdout0_2ck186 FIND v(dout0_2) AT=935.025n

* CHECK dout0_3 Vdout0_3ck186 = 0 time = 935
.meas tran vdout0_3ck186 FIND v(dout0_3) AT=935.025n

* CHECK dout0_4 Vdout0_4ck186 = 0.9 time = 935
.meas tran vdout0_4ck186 FIND v(dout0_4) AT=935.025n

* CHECK dout0_5 Vdout0_5ck186 = 0.9 time = 935
.meas tran vdout0_5ck186 FIND v(dout0_5) AT=935.025n

* CHECK dout0_6 Vdout0_6ck186 = 0.9 time = 935
.meas tran vdout0_6ck186 FIND v(dout0_6) AT=935.025n

* CHECK dout0_7 Vdout0_7ck186 = 0 time = 935
.meas tran vdout0_7ck186 FIND v(dout0_7) AT=935.025n

* CHECK dout0_8 Vdout0_8ck186 = 0 time = 935
.meas tran vdout0_8ck186 FIND v(dout0_8) AT=935.025n

* CHECK dout0_9 Vdout0_9ck186 = 0.9 time = 935
.meas tran vdout0_9ck186 FIND v(dout0_9) AT=935.025n

* CHECK dout0_10 Vdout0_10ck186 = 0.9 time = 935
.meas tran vdout0_10ck186 FIND v(dout0_10) AT=935.025n

* CHECK dout0_11 Vdout0_11ck186 = 0 time = 935
.meas tran vdout0_11ck186 FIND v(dout0_11) AT=935.025n

* CHECK dout0_12 Vdout0_12ck186 = 0.9 time = 935
.meas tran vdout0_12ck186 FIND v(dout0_12) AT=935.025n

* CHECK dout0_13 Vdout0_13ck186 = 0.9 time = 935
.meas tran vdout0_13ck186 FIND v(dout0_13) AT=935.025n

* CHECK dout0_14 Vdout0_14ck186 = 0 time = 935
.meas tran vdout0_14ck186 FIND v(dout0_14) AT=935.025n

* CHECK dout0_15 Vdout0_15ck186 = 0.9 time = 935
.meas tran vdout0_15ck186 FIND v(dout0_15) AT=935.025n

* CHECK dout0_16 Vdout0_16ck186 = 0 time = 935
.meas tran vdout0_16ck186 FIND v(dout0_16) AT=935.025n

* CHECK dout0_17 Vdout0_17ck186 = 0.9 time = 935
.meas tran vdout0_17ck186 FIND v(dout0_17) AT=935.025n

* CHECK dout0_18 Vdout0_18ck186 = 0.9 time = 935
.meas tran vdout0_18ck186 FIND v(dout0_18) AT=935.025n

* CHECK dout0_19 Vdout0_19ck186 = 0.9 time = 935
.meas tran vdout0_19ck186 FIND v(dout0_19) AT=935.025n

* CHECK dout0_20 Vdout0_20ck186 = 0.9 time = 935
.meas tran vdout0_20ck186 FIND v(dout0_20) AT=935.025n

* CHECK dout0_21 Vdout0_21ck186 = 0 time = 935
.meas tran vdout0_21ck186 FIND v(dout0_21) AT=935.025n

* CHECK dout0_22 Vdout0_22ck186 = 0.9 time = 935
.meas tran vdout0_22ck186 FIND v(dout0_22) AT=935.025n

* CHECK dout0_23 Vdout0_23ck186 = 0.9 time = 935
.meas tran vdout0_23ck186 FIND v(dout0_23) AT=935.025n

* CHECK dout0_24 Vdout0_24ck186 = 0 time = 935
.meas tran vdout0_24ck186 FIND v(dout0_24) AT=935.025n

* CHECK dout0_25 Vdout0_25ck186 = 0 time = 935
.meas tran vdout0_25ck186 FIND v(dout0_25) AT=935.025n

* CHECK dout0_26 Vdout0_26ck186 = 0.9 time = 935
.meas tran vdout0_26ck186 FIND v(dout0_26) AT=935.025n

* CHECK dout0_27 Vdout0_27ck186 = 0.9 time = 935
.meas tran vdout0_27ck186 FIND v(dout0_27) AT=935.025n

* CHECK dout0_28 Vdout0_28ck186 = 0 time = 935
.meas tran vdout0_28ck186 FIND v(dout0_28) AT=935.025n

* CHECK dout0_29 Vdout0_29ck186 = 0 time = 935
.meas tran vdout0_29ck186 FIND v(dout0_29) AT=935.025n

* CHECK dout0_30 Vdout0_30ck186 = 0.9 time = 935
.meas tran vdout0_30ck186 FIND v(dout0_30) AT=935.025n

* CHECK dout0_31 Vdout0_31ck186 = 0.9 time = 935
.meas tran vdout0_31ck186 FIND v(dout0_31) AT=935.025n

* CHECK dout0_32 Vdout0_32ck186 = 0.9 time = 935
.meas tran vdout0_32ck186 FIND v(dout0_32) AT=935.025n

* CHECK dout0_33 Vdout0_33ck186 = 0 time = 935
.meas tran vdout0_33ck186 FIND v(dout0_33) AT=935.025n

* CHECK dout0_34 Vdout0_34ck186 = 0 time = 935
.meas tran vdout0_34ck186 FIND v(dout0_34) AT=935.025n

* CHECK dout0_35 Vdout0_35ck186 = 0 time = 935
.meas tran vdout0_35ck186 FIND v(dout0_35) AT=935.025n

* CHECK dout0_36 Vdout0_36ck186 = 0.9 time = 935
.meas tran vdout0_36ck186 FIND v(dout0_36) AT=935.025n

* CHECK dout0_37 Vdout0_37ck186 = 0.9 time = 935
.meas tran vdout0_37ck186 FIND v(dout0_37) AT=935.025n

* CHECK dout0_38 Vdout0_38ck186 = 0 time = 935
.meas tran vdout0_38ck186 FIND v(dout0_38) AT=935.025n

* CHECK dout0_39 Vdout0_39ck186 = 0.9 time = 935
.meas tran vdout0_39ck186 FIND v(dout0_39) AT=935.025n

* CHECK dout0_0 Vdout0_0ck188 = 0.9 time = 945
.meas tran vdout0_0ck188 FIND v(dout0_0) AT=945.025n

* CHECK dout0_1 Vdout0_1ck188 = 0.9 time = 945
.meas tran vdout0_1ck188 FIND v(dout0_1) AT=945.025n

* CHECK dout0_2 Vdout0_2ck188 = 0 time = 945
.meas tran vdout0_2ck188 FIND v(dout0_2) AT=945.025n

* CHECK dout0_3 Vdout0_3ck188 = 0 time = 945
.meas tran vdout0_3ck188 FIND v(dout0_3) AT=945.025n

* CHECK dout0_4 Vdout0_4ck188 = 0 time = 945
.meas tran vdout0_4ck188 FIND v(dout0_4) AT=945.025n

* CHECK dout0_5 Vdout0_5ck188 = 0.9 time = 945
.meas tran vdout0_5ck188 FIND v(dout0_5) AT=945.025n

* CHECK dout0_6 Vdout0_6ck188 = 0 time = 945
.meas tran vdout0_6ck188 FIND v(dout0_6) AT=945.025n

* CHECK dout0_7 Vdout0_7ck188 = 0 time = 945
.meas tran vdout0_7ck188 FIND v(dout0_7) AT=945.025n

* CHECK dout0_8 Vdout0_8ck188 = 0.9 time = 945
.meas tran vdout0_8ck188 FIND v(dout0_8) AT=945.025n

* CHECK dout0_9 Vdout0_9ck188 = 0 time = 945
.meas tran vdout0_9ck188 FIND v(dout0_9) AT=945.025n

* CHECK dout0_10 Vdout0_10ck188 = 0 time = 945
.meas tran vdout0_10ck188 FIND v(dout0_10) AT=945.025n

* CHECK dout0_11 Vdout0_11ck188 = 0 time = 945
.meas tran vdout0_11ck188 FIND v(dout0_11) AT=945.025n

* CHECK dout0_12 Vdout0_12ck188 = 0 time = 945
.meas tran vdout0_12ck188 FIND v(dout0_12) AT=945.025n

* CHECK dout0_13 Vdout0_13ck188 = 0 time = 945
.meas tran vdout0_13ck188 FIND v(dout0_13) AT=945.025n

* CHECK dout0_14 Vdout0_14ck188 = 0.9 time = 945
.meas tran vdout0_14ck188 FIND v(dout0_14) AT=945.025n

* CHECK dout0_15 Vdout0_15ck188 = 0 time = 945
.meas tran vdout0_15ck188 FIND v(dout0_15) AT=945.025n

* CHECK dout0_16 Vdout0_16ck188 = 0 time = 945
.meas tran vdout0_16ck188 FIND v(dout0_16) AT=945.025n

* CHECK dout0_17 Vdout0_17ck188 = 0.9 time = 945
.meas tran vdout0_17ck188 FIND v(dout0_17) AT=945.025n

* CHECK dout0_18 Vdout0_18ck188 = 0.9 time = 945
.meas tran vdout0_18ck188 FIND v(dout0_18) AT=945.025n

* CHECK dout0_19 Vdout0_19ck188 = 0.9 time = 945
.meas tran vdout0_19ck188 FIND v(dout0_19) AT=945.025n

* CHECK dout0_20 Vdout0_20ck188 = 0.9 time = 945
.meas tran vdout0_20ck188 FIND v(dout0_20) AT=945.025n

* CHECK dout0_21 Vdout0_21ck188 = 0.9 time = 945
.meas tran vdout0_21ck188 FIND v(dout0_21) AT=945.025n

* CHECK dout0_22 Vdout0_22ck188 = 0 time = 945
.meas tran vdout0_22ck188 FIND v(dout0_22) AT=945.025n

* CHECK dout0_23 Vdout0_23ck188 = 0 time = 945
.meas tran vdout0_23ck188 FIND v(dout0_23) AT=945.025n

* CHECK dout0_24 Vdout0_24ck188 = 0.9 time = 945
.meas tran vdout0_24ck188 FIND v(dout0_24) AT=945.025n

* CHECK dout0_25 Vdout0_25ck188 = 0 time = 945
.meas tran vdout0_25ck188 FIND v(dout0_25) AT=945.025n

* CHECK dout0_26 Vdout0_26ck188 = 0.9 time = 945
.meas tran vdout0_26ck188 FIND v(dout0_26) AT=945.025n

* CHECK dout0_27 Vdout0_27ck188 = 0.9 time = 945
.meas tran vdout0_27ck188 FIND v(dout0_27) AT=945.025n

* CHECK dout0_28 Vdout0_28ck188 = 0 time = 945
.meas tran vdout0_28ck188 FIND v(dout0_28) AT=945.025n

* CHECK dout0_29 Vdout0_29ck188 = 0.9 time = 945
.meas tran vdout0_29ck188 FIND v(dout0_29) AT=945.025n

* CHECK dout0_30 Vdout0_30ck188 = 0.9 time = 945
.meas tran vdout0_30ck188 FIND v(dout0_30) AT=945.025n

* CHECK dout0_31 Vdout0_31ck188 = 0 time = 945
.meas tran vdout0_31ck188 FIND v(dout0_31) AT=945.025n

* CHECK dout0_32 Vdout0_32ck188 = 0 time = 945
.meas tran vdout0_32ck188 FIND v(dout0_32) AT=945.025n

* CHECK dout0_33 Vdout0_33ck188 = 0.9 time = 945
.meas tran vdout0_33ck188 FIND v(dout0_33) AT=945.025n

* CHECK dout0_34 Vdout0_34ck188 = 0 time = 945
.meas tran vdout0_34ck188 FIND v(dout0_34) AT=945.025n

* CHECK dout0_35 Vdout0_35ck188 = 0.9 time = 945
.meas tran vdout0_35ck188 FIND v(dout0_35) AT=945.025n

* CHECK dout0_36 Vdout0_36ck188 = 0 time = 945
.meas tran vdout0_36ck188 FIND v(dout0_36) AT=945.025n

* CHECK dout0_37 Vdout0_37ck188 = 0.9 time = 945
.meas tran vdout0_37ck188 FIND v(dout0_37) AT=945.025n

* CHECK dout0_38 Vdout0_38ck188 = 0.9 time = 945
.meas tran vdout0_38ck188 FIND v(dout0_38) AT=945.025n

* CHECK dout0_39 Vdout0_39ck188 = 0 time = 945
.meas tran vdout0_39ck188 FIND v(dout0_39) AT=945.025n

* CHECK dout0_0 Vdout0_0ck189 = 0.9 time = 950
.meas tran vdout0_0ck189 FIND v(dout0_0) AT=950.025n

* CHECK dout0_1 Vdout0_1ck189 = 0.9 time = 950
.meas tran vdout0_1ck189 FIND v(dout0_1) AT=950.025n

* CHECK dout0_2 Vdout0_2ck189 = 0 time = 950
.meas tran vdout0_2ck189 FIND v(dout0_2) AT=950.025n

* CHECK dout0_3 Vdout0_3ck189 = 0 time = 950
.meas tran vdout0_3ck189 FIND v(dout0_3) AT=950.025n

* CHECK dout0_4 Vdout0_4ck189 = 0 time = 950
.meas tran vdout0_4ck189 FIND v(dout0_4) AT=950.025n

* CHECK dout0_5 Vdout0_5ck189 = 0.9 time = 950
.meas tran vdout0_5ck189 FIND v(dout0_5) AT=950.025n

* CHECK dout0_6 Vdout0_6ck189 = 0 time = 950
.meas tran vdout0_6ck189 FIND v(dout0_6) AT=950.025n

* CHECK dout0_7 Vdout0_7ck189 = 0 time = 950
.meas tran vdout0_7ck189 FIND v(dout0_7) AT=950.025n

* CHECK dout0_8 Vdout0_8ck189 = 0.9 time = 950
.meas tran vdout0_8ck189 FIND v(dout0_8) AT=950.025n

* CHECK dout0_9 Vdout0_9ck189 = 0 time = 950
.meas tran vdout0_9ck189 FIND v(dout0_9) AT=950.025n

* CHECK dout0_10 Vdout0_10ck189 = 0 time = 950
.meas tran vdout0_10ck189 FIND v(dout0_10) AT=950.025n

* CHECK dout0_11 Vdout0_11ck189 = 0 time = 950
.meas tran vdout0_11ck189 FIND v(dout0_11) AT=950.025n

* CHECK dout0_12 Vdout0_12ck189 = 0 time = 950
.meas tran vdout0_12ck189 FIND v(dout0_12) AT=950.025n

* CHECK dout0_13 Vdout0_13ck189 = 0 time = 950
.meas tran vdout0_13ck189 FIND v(dout0_13) AT=950.025n

* CHECK dout0_14 Vdout0_14ck189 = 0.9 time = 950
.meas tran vdout0_14ck189 FIND v(dout0_14) AT=950.025n

* CHECK dout0_15 Vdout0_15ck189 = 0 time = 950
.meas tran vdout0_15ck189 FIND v(dout0_15) AT=950.025n

* CHECK dout0_16 Vdout0_16ck189 = 0 time = 950
.meas tran vdout0_16ck189 FIND v(dout0_16) AT=950.025n

* CHECK dout0_17 Vdout0_17ck189 = 0.9 time = 950
.meas tran vdout0_17ck189 FIND v(dout0_17) AT=950.025n

* CHECK dout0_18 Vdout0_18ck189 = 0.9 time = 950
.meas tran vdout0_18ck189 FIND v(dout0_18) AT=950.025n

* CHECK dout0_19 Vdout0_19ck189 = 0.9 time = 950
.meas tran vdout0_19ck189 FIND v(dout0_19) AT=950.025n

* CHECK dout0_20 Vdout0_20ck189 = 0.9 time = 950
.meas tran vdout0_20ck189 FIND v(dout0_20) AT=950.025n

* CHECK dout0_21 Vdout0_21ck189 = 0.9 time = 950
.meas tran vdout0_21ck189 FIND v(dout0_21) AT=950.025n

* CHECK dout0_22 Vdout0_22ck189 = 0 time = 950
.meas tran vdout0_22ck189 FIND v(dout0_22) AT=950.025n

* CHECK dout0_23 Vdout0_23ck189 = 0 time = 950
.meas tran vdout0_23ck189 FIND v(dout0_23) AT=950.025n

* CHECK dout0_24 Vdout0_24ck189 = 0.9 time = 950
.meas tran vdout0_24ck189 FIND v(dout0_24) AT=950.025n

* CHECK dout0_25 Vdout0_25ck189 = 0 time = 950
.meas tran vdout0_25ck189 FIND v(dout0_25) AT=950.025n

* CHECK dout0_26 Vdout0_26ck189 = 0.9 time = 950
.meas tran vdout0_26ck189 FIND v(dout0_26) AT=950.025n

* CHECK dout0_27 Vdout0_27ck189 = 0.9 time = 950
.meas tran vdout0_27ck189 FIND v(dout0_27) AT=950.025n

* CHECK dout0_28 Vdout0_28ck189 = 0 time = 950
.meas tran vdout0_28ck189 FIND v(dout0_28) AT=950.025n

* CHECK dout0_29 Vdout0_29ck189 = 0.9 time = 950
.meas tran vdout0_29ck189 FIND v(dout0_29) AT=950.025n

* CHECK dout0_30 Vdout0_30ck189 = 0.9 time = 950
.meas tran vdout0_30ck189 FIND v(dout0_30) AT=950.025n

* CHECK dout0_31 Vdout0_31ck189 = 0 time = 950
.meas tran vdout0_31ck189 FIND v(dout0_31) AT=950.025n

* CHECK dout0_32 Vdout0_32ck189 = 0 time = 950
.meas tran vdout0_32ck189 FIND v(dout0_32) AT=950.025n

* CHECK dout0_33 Vdout0_33ck189 = 0.9 time = 950
.meas tran vdout0_33ck189 FIND v(dout0_33) AT=950.025n

* CHECK dout0_34 Vdout0_34ck189 = 0 time = 950
.meas tran vdout0_34ck189 FIND v(dout0_34) AT=950.025n

* CHECK dout0_35 Vdout0_35ck189 = 0.9 time = 950
.meas tran vdout0_35ck189 FIND v(dout0_35) AT=950.025n

* CHECK dout0_36 Vdout0_36ck189 = 0 time = 950
.meas tran vdout0_36ck189 FIND v(dout0_36) AT=950.025n

* CHECK dout0_37 Vdout0_37ck189 = 0.9 time = 950
.meas tran vdout0_37ck189 FIND v(dout0_37) AT=950.025n

* CHECK dout0_38 Vdout0_38ck189 = 0.9 time = 950
.meas tran vdout0_38ck189 FIND v(dout0_38) AT=950.025n

* CHECK dout0_39 Vdout0_39ck189 = 0 time = 950
.meas tran vdout0_39ck189 FIND v(dout0_39) AT=950.025n

* CHECK dout0_0 Vdout0_0ck190 = 0.9 time = 955
.meas tran vdout0_0ck190 FIND v(dout0_0) AT=955.025n

* CHECK dout0_1 Vdout0_1ck190 = 0.9 time = 955
.meas tran vdout0_1ck190 FIND v(dout0_1) AT=955.025n

* CHECK dout0_2 Vdout0_2ck190 = 0 time = 955
.meas tran vdout0_2ck190 FIND v(dout0_2) AT=955.025n

* CHECK dout0_3 Vdout0_3ck190 = 0 time = 955
.meas tran vdout0_3ck190 FIND v(dout0_3) AT=955.025n

* CHECK dout0_4 Vdout0_4ck190 = 0.9 time = 955
.meas tran vdout0_4ck190 FIND v(dout0_4) AT=955.025n

* CHECK dout0_5 Vdout0_5ck190 = 0 time = 955
.meas tran vdout0_5ck190 FIND v(dout0_5) AT=955.025n

* CHECK dout0_6 Vdout0_6ck190 = 0.9 time = 955
.meas tran vdout0_6ck190 FIND v(dout0_6) AT=955.025n

* CHECK dout0_7 Vdout0_7ck190 = 0 time = 955
.meas tran vdout0_7ck190 FIND v(dout0_7) AT=955.025n

* CHECK dout0_8 Vdout0_8ck190 = 0.9 time = 955
.meas tran vdout0_8ck190 FIND v(dout0_8) AT=955.025n

* CHECK dout0_9 Vdout0_9ck190 = 0 time = 955
.meas tran vdout0_9ck190 FIND v(dout0_9) AT=955.025n

* CHECK dout0_10 Vdout0_10ck190 = 0 time = 955
.meas tran vdout0_10ck190 FIND v(dout0_10) AT=955.025n

* CHECK dout0_11 Vdout0_11ck190 = 0 time = 955
.meas tran vdout0_11ck190 FIND v(dout0_11) AT=955.025n

* CHECK dout0_12 Vdout0_12ck190 = 0 time = 955
.meas tran vdout0_12ck190 FIND v(dout0_12) AT=955.025n

* CHECK dout0_13 Vdout0_13ck190 = 0.9 time = 955
.meas tran vdout0_13ck190 FIND v(dout0_13) AT=955.025n

* CHECK dout0_14 Vdout0_14ck190 = 0 time = 955
.meas tran vdout0_14ck190 FIND v(dout0_14) AT=955.025n

* CHECK dout0_15 Vdout0_15ck190 = 0 time = 955
.meas tran vdout0_15ck190 FIND v(dout0_15) AT=955.025n

* CHECK dout0_16 Vdout0_16ck190 = 0 time = 955
.meas tran vdout0_16ck190 FIND v(dout0_16) AT=955.025n

* CHECK dout0_17 Vdout0_17ck190 = 0 time = 955
.meas tran vdout0_17ck190 FIND v(dout0_17) AT=955.025n

* CHECK dout0_18 Vdout0_18ck190 = 0 time = 955
.meas tran vdout0_18ck190 FIND v(dout0_18) AT=955.025n

* CHECK dout0_19 Vdout0_19ck190 = 0.9 time = 955
.meas tran vdout0_19ck190 FIND v(dout0_19) AT=955.025n

* CHECK dout0_20 Vdout0_20ck190 = 0 time = 955
.meas tran vdout0_20ck190 FIND v(dout0_20) AT=955.025n

* CHECK dout0_21 Vdout0_21ck190 = 0.9 time = 955
.meas tran vdout0_21ck190 FIND v(dout0_21) AT=955.025n

* CHECK dout0_22 Vdout0_22ck190 = 0.9 time = 955
.meas tran vdout0_22ck190 FIND v(dout0_22) AT=955.025n

* CHECK dout0_23 Vdout0_23ck190 = 0 time = 955
.meas tran vdout0_23ck190 FIND v(dout0_23) AT=955.025n

* CHECK dout0_24 Vdout0_24ck190 = 0 time = 955
.meas tran vdout0_24ck190 FIND v(dout0_24) AT=955.025n

* CHECK dout0_25 Vdout0_25ck190 = 0.9 time = 955
.meas tran vdout0_25ck190 FIND v(dout0_25) AT=955.025n

* CHECK dout0_26 Vdout0_26ck190 = 0 time = 955
.meas tran vdout0_26ck190 FIND v(dout0_26) AT=955.025n

* CHECK dout0_27 Vdout0_27ck190 = 0 time = 955
.meas tran vdout0_27ck190 FIND v(dout0_27) AT=955.025n

* CHECK dout0_28 Vdout0_28ck190 = 0.9 time = 955
.meas tran vdout0_28ck190 FIND v(dout0_28) AT=955.025n

* CHECK dout0_29 Vdout0_29ck190 = 0.9 time = 955
.meas tran vdout0_29ck190 FIND v(dout0_29) AT=955.025n

* CHECK dout0_30 Vdout0_30ck190 = 0 time = 955
.meas tran vdout0_30ck190 FIND v(dout0_30) AT=955.025n

* CHECK dout0_31 Vdout0_31ck190 = 0.9 time = 955
.meas tran vdout0_31ck190 FIND v(dout0_31) AT=955.025n

* CHECK dout0_32 Vdout0_32ck190 = 0 time = 955
.meas tran vdout0_32ck190 FIND v(dout0_32) AT=955.025n

* CHECK dout0_33 Vdout0_33ck190 = 0 time = 955
.meas tran vdout0_33ck190 FIND v(dout0_33) AT=955.025n

* CHECK dout0_34 Vdout0_34ck190 = 0 time = 955
.meas tran vdout0_34ck190 FIND v(dout0_34) AT=955.025n

* CHECK dout0_35 Vdout0_35ck190 = 0 time = 955
.meas tran vdout0_35ck190 FIND v(dout0_35) AT=955.025n

* CHECK dout0_36 Vdout0_36ck190 = 0.9 time = 955
.meas tran vdout0_36ck190 FIND v(dout0_36) AT=955.025n

* CHECK dout0_37 Vdout0_37ck190 = 0 time = 955
.meas tran vdout0_37ck190 FIND v(dout0_37) AT=955.025n

* CHECK dout0_38 Vdout0_38ck190 = 0 time = 955
.meas tran vdout0_38ck190 FIND v(dout0_38) AT=955.025n

* CHECK dout0_39 Vdout0_39ck190 = 0 time = 955
.meas tran vdout0_39ck190 FIND v(dout0_39) AT=955.025n

* CHECK dout0_0 Vdout0_0ck195 = 0.9 time = 980
.meas tran vdout0_0ck195 FIND v(dout0_0) AT=980.025n

* CHECK dout0_1 Vdout0_1ck195 = 0 time = 980
.meas tran vdout0_1ck195 FIND v(dout0_1) AT=980.025n

* CHECK dout0_2 Vdout0_2ck195 = 0 time = 980
.meas tran vdout0_2ck195 FIND v(dout0_2) AT=980.025n

* CHECK dout0_3 Vdout0_3ck195 = 0 time = 980
.meas tran vdout0_3ck195 FIND v(dout0_3) AT=980.025n

* CHECK dout0_4 Vdout0_4ck195 = 0 time = 980
.meas tran vdout0_4ck195 FIND v(dout0_4) AT=980.025n

* CHECK dout0_5 Vdout0_5ck195 = 0 time = 980
.meas tran vdout0_5ck195 FIND v(dout0_5) AT=980.025n

* CHECK dout0_6 Vdout0_6ck195 = 0.9 time = 980
.meas tran vdout0_6ck195 FIND v(dout0_6) AT=980.025n

* CHECK dout0_7 Vdout0_7ck195 = 0 time = 980
.meas tran vdout0_7ck195 FIND v(dout0_7) AT=980.025n

* CHECK dout0_8 Vdout0_8ck195 = 0.9 time = 980
.meas tran vdout0_8ck195 FIND v(dout0_8) AT=980.025n

* CHECK dout0_9 Vdout0_9ck195 = 0 time = 980
.meas tran vdout0_9ck195 FIND v(dout0_9) AT=980.025n

* CHECK dout0_10 Vdout0_10ck195 = 0 time = 980
.meas tran vdout0_10ck195 FIND v(dout0_10) AT=980.025n

* CHECK dout0_11 Vdout0_11ck195 = 0 time = 980
.meas tran vdout0_11ck195 FIND v(dout0_11) AT=980.025n

* CHECK dout0_12 Vdout0_12ck195 = 0 time = 980
.meas tran vdout0_12ck195 FIND v(dout0_12) AT=980.025n

* CHECK dout0_13 Vdout0_13ck195 = 0 time = 980
.meas tran vdout0_13ck195 FIND v(dout0_13) AT=980.025n

* CHECK dout0_14 Vdout0_14ck195 = 0.9 time = 980
.meas tran vdout0_14ck195 FIND v(dout0_14) AT=980.025n

* CHECK dout0_15 Vdout0_15ck195 = 0 time = 980
.meas tran vdout0_15ck195 FIND v(dout0_15) AT=980.025n

* CHECK dout0_16 Vdout0_16ck195 = 0 time = 980
.meas tran vdout0_16ck195 FIND v(dout0_16) AT=980.025n

* CHECK dout0_17 Vdout0_17ck195 = 0 time = 980
.meas tran vdout0_17ck195 FIND v(dout0_17) AT=980.025n

* CHECK dout0_18 Vdout0_18ck195 = 0.9 time = 980
.meas tran vdout0_18ck195 FIND v(dout0_18) AT=980.025n

* CHECK dout0_19 Vdout0_19ck195 = 0 time = 980
.meas tran vdout0_19ck195 FIND v(dout0_19) AT=980.025n

* CHECK dout0_20 Vdout0_20ck195 = 0.9 time = 980
.meas tran vdout0_20ck195 FIND v(dout0_20) AT=980.025n

* CHECK dout0_21 Vdout0_21ck195 = 0.9 time = 980
.meas tran vdout0_21ck195 FIND v(dout0_21) AT=980.025n

* CHECK dout0_22 Vdout0_22ck195 = 0.9 time = 980
.meas tran vdout0_22ck195 FIND v(dout0_22) AT=980.025n

* CHECK dout0_23 Vdout0_23ck195 = 0.9 time = 980
.meas tran vdout0_23ck195 FIND v(dout0_23) AT=980.025n

* CHECK dout0_24 Vdout0_24ck195 = 0.9 time = 980
.meas tran vdout0_24ck195 FIND v(dout0_24) AT=980.025n

* CHECK dout0_25 Vdout0_25ck195 = 0 time = 980
.meas tran vdout0_25ck195 FIND v(dout0_25) AT=980.025n

* CHECK dout0_26 Vdout0_26ck195 = 0.9 time = 980
.meas tran vdout0_26ck195 FIND v(dout0_26) AT=980.025n

* CHECK dout0_27 Vdout0_27ck195 = 0.9 time = 980
.meas tran vdout0_27ck195 FIND v(dout0_27) AT=980.025n

* CHECK dout0_28 Vdout0_28ck195 = 0 time = 980
.meas tran vdout0_28ck195 FIND v(dout0_28) AT=980.025n

* CHECK dout0_29 Vdout0_29ck195 = 0 time = 980
.meas tran vdout0_29ck195 FIND v(dout0_29) AT=980.025n

* CHECK dout0_30 Vdout0_30ck195 = 0.9 time = 980
.meas tran vdout0_30ck195 FIND v(dout0_30) AT=980.025n

* CHECK dout0_31 Vdout0_31ck195 = 0.9 time = 980
.meas tran vdout0_31ck195 FIND v(dout0_31) AT=980.025n

* CHECK dout0_32 Vdout0_32ck195 = 0.9 time = 980
.meas tran vdout0_32ck195 FIND v(dout0_32) AT=980.025n

* CHECK dout0_33 Vdout0_33ck195 = 0.9 time = 980
.meas tran vdout0_33ck195 FIND v(dout0_33) AT=980.025n

* CHECK dout0_34 Vdout0_34ck195 = 0.9 time = 980
.meas tran vdout0_34ck195 FIND v(dout0_34) AT=980.025n

* CHECK dout0_35 Vdout0_35ck195 = 0.9 time = 980
.meas tran vdout0_35ck195 FIND v(dout0_35) AT=980.025n

* CHECK dout0_36 Vdout0_36ck195 = 0 time = 980
.meas tran vdout0_36ck195 FIND v(dout0_36) AT=980.025n

* CHECK dout0_37 Vdout0_37ck195 = 0 time = 980
.meas tran vdout0_37ck195 FIND v(dout0_37) AT=980.025n

* CHECK dout0_38 Vdout0_38ck195 = 0.9 time = 980
.meas tran vdout0_38ck195 FIND v(dout0_38) AT=980.025n

* CHECK dout0_39 Vdout0_39ck195 = 0 time = 980
.meas tran vdout0_39ck195 FIND v(dout0_39) AT=980.025n

* CHECK dout0_0 Vdout0_0ck196 = 0.9 time = 985
.meas tran vdout0_0ck196 FIND v(dout0_0) AT=985.025n

* CHECK dout0_1 Vdout0_1ck196 = 0.9 time = 985
.meas tran vdout0_1ck196 FIND v(dout0_1) AT=985.025n

* CHECK dout0_2 Vdout0_2ck196 = 0 time = 985
.meas tran vdout0_2ck196 FIND v(dout0_2) AT=985.025n

* CHECK dout0_3 Vdout0_3ck196 = 0.9 time = 985
.meas tran vdout0_3ck196 FIND v(dout0_3) AT=985.025n

* CHECK dout0_4 Vdout0_4ck196 = 0 time = 985
.meas tran vdout0_4ck196 FIND v(dout0_4) AT=985.025n

* CHECK dout0_5 Vdout0_5ck196 = 0 time = 985
.meas tran vdout0_5ck196 FIND v(dout0_5) AT=985.025n

* CHECK dout0_6 Vdout0_6ck196 = 0 time = 985
.meas tran vdout0_6ck196 FIND v(dout0_6) AT=985.025n

* CHECK dout0_7 Vdout0_7ck196 = 0 time = 985
.meas tran vdout0_7ck196 FIND v(dout0_7) AT=985.025n

* CHECK dout0_8 Vdout0_8ck196 = 0 time = 985
.meas tran vdout0_8ck196 FIND v(dout0_8) AT=985.025n

* CHECK dout0_9 Vdout0_9ck196 = 0.9 time = 985
.meas tran vdout0_9ck196 FIND v(dout0_9) AT=985.025n

* CHECK dout0_10 Vdout0_10ck196 = 0.9 time = 985
.meas tran vdout0_10ck196 FIND v(dout0_10) AT=985.025n

* CHECK dout0_11 Vdout0_11ck196 = 0 time = 985
.meas tran vdout0_11ck196 FIND v(dout0_11) AT=985.025n

* CHECK dout0_12 Vdout0_12ck196 = 0.9 time = 985
.meas tran vdout0_12ck196 FIND v(dout0_12) AT=985.025n

* CHECK dout0_13 Vdout0_13ck196 = 0 time = 985
.meas tran vdout0_13ck196 FIND v(dout0_13) AT=985.025n

* CHECK dout0_14 Vdout0_14ck196 = 0 time = 985
.meas tran vdout0_14ck196 FIND v(dout0_14) AT=985.025n

* CHECK dout0_15 Vdout0_15ck196 = 0 time = 985
.meas tran vdout0_15ck196 FIND v(dout0_15) AT=985.025n

* CHECK dout0_16 Vdout0_16ck196 = 0 time = 985
.meas tran vdout0_16ck196 FIND v(dout0_16) AT=985.025n

* CHECK dout0_17 Vdout0_17ck196 = 0 time = 985
.meas tran vdout0_17ck196 FIND v(dout0_17) AT=985.025n

* CHECK dout0_18 Vdout0_18ck196 = 0 time = 985
.meas tran vdout0_18ck196 FIND v(dout0_18) AT=985.025n

* CHECK dout0_19 Vdout0_19ck196 = 0.9 time = 985
.meas tran vdout0_19ck196 FIND v(dout0_19) AT=985.025n

* CHECK dout0_20 Vdout0_20ck196 = 0.9 time = 985
.meas tran vdout0_20ck196 FIND v(dout0_20) AT=985.025n

* CHECK dout0_21 Vdout0_21ck196 = 0.9 time = 985
.meas tran vdout0_21ck196 FIND v(dout0_21) AT=985.025n

* CHECK dout0_22 Vdout0_22ck196 = 0 time = 985
.meas tran vdout0_22ck196 FIND v(dout0_22) AT=985.025n

* CHECK dout0_23 Vdout0_23ck196 = 0 time = 985
.meas tran vdout0_23ck196 FIND v(dout0_23) AT=985.025n

* CHECK dout0_24 Vdout0_24ck196 = 0 time = 985
.meas tran vdout0_24ck196 FIND v(dout0_24) AT=985.025n

* CHECK dout0_25 Vdout0_25ck196 = 0.9 time = 985
.meas tran vdout0_25ck196 FIND v(dout0_25) AT=985.025n

* CHECK dout0_26 Vdout0_26ck196 = 0 time = 985
.meas tran vdout0_26ck196 FIND v(dout0_26) AT=985.025n

* CHECK dout0_27 Vdout0_27ck196 = 0 time = 985
.meas tran vdout0_27ck196 FIND v(dout0_27) AT=985.025n

* CHECK dout0_28 Vdout0_28ck196 = 0.9 time = 985
.meas tran vdout0_28ck196 FIND v(dout0_28) AT=985.025n

* CHECK dout0_29 Vdout0_29ck196 = 0.9 time = 985
.meas tran vdout0_29ck196 FIND v(dout0_29) AT=985.025n

* CHECK dout0_30 Vdout0_30ck196 = 0 time = 985
.meas tran vdout0_30ck196 FIND v(dout0_30) AT=985.025n

* CHECK dout0_31 Vdout0_31ck196 = 0.9 time = 985
.meas tran vdout0_31ck196 FIND v(dout0_31) AT=985.025n

* CHECK dout0_32 Vdout0_32ck196 = 0 time = 985
.meas tran vdout0_32ck196 FIND v(dout0_32) AT=985.025n

* CHECK dout0_33 Vdout0_33ck196 = 0.9 time = 985
.meas tran vdout0_33ck196 FIND v(dout0_33) AT=985.025n

* CHECK dout0_34 Vdout0_34ck196 = 0.9 time = 985
.meas tran vdout0_34ck196 FIND v(dout0_34) AT=985.025n

* CHECK dout0_35 Vdout0_35ck196 = 0.9 time = 985
.meas tran vdout0_35ck196 FIND v(dout0_35) AT=985.025n

* CHECK dout0_36 Vdout0_36ck196 = 0 time = 985
.meas tran vdout0_36ck196 FIND v(dout0_36) AT=985.025n

* CHECK dout0_37 Vdout0_37ck196 = 0.9 time = 985
.meas tran vdout0_37ck196 FIND v(dout0_37) AT=985.025n

* CHECK dout0_38 Vdout0_38ck196 = 0 time = 985
.meas tran vdout0_38ck196 FIND v(dout0_38) AT=985.025n

* CHECK dout0_39 Vdout0_39ck196 = 0.9 time = 985
.meas tran vdout0_39ck196 FIND v(dout0_39) AT=985.025n

* CHECK dout0_0 Vdout0_0ck197 = 0.9 time = 990
.meas tran vdout0_0ck197 FIND v(dout0_0) AT=990.025n

* CHECK dout0_1 Vdout0_1ck197 = 0 time = 990
.meas tran vdout0_1ck197 FIND v(dout0_1) AT=990.025n

* CHECK dout0_2 Vdout0_2ck197 = 0 time = 990
.meas tran vdout0_2ck197 FIND v(dout0_2) AT=990.025n

* CHECK dout0_3 Vdout0_3ck197 = 0 time = 990
.meas tran vdout0_3ck197 FIND v(dout0_3) AT=990.025n

* CHECK dout0_4 Vdout0_4ck197 = 0 time = 990
.meas tran vdout0_4ck197 FIND v(dout0_4) AT=990.025n

* CHECK dout0_5 Vdout0_5ck197 = 0 time = 990
.meas tran vdout0_5ck197 FIND v(dout0_5) AT=990.025n

* CHECK dout0_6 Vdout0_6ck197 = 0.9 time = 990
.meas tran vdout0_6ck197 FIND v(dout0_6) AT=990.025n

* CHECK dout0_7 Vdout0_7ck197 = 0 time = 990
.meas tran vdout0_7ck197 FIND v(dout0_7) AT=990.025n

* CHECK dout0_8 Vdout0_8ck197 = 0.9 time = 990
.meas tran vdout0_8ck197 FIND v(dout0_8) AT=990.025n

* CHECK dout0_9 Vdout0_9ck197 = 0 time = 990
.meas tran vdout0_9ck197 FIND v(dout0_9) AT=990.025n

* CHECK dout0_10 Vdout0_10ck197 = 0 time = 990
.meas tran vdout0_10ck197 FIND v(dout0_10) AT=990.025n

* CHECK dout0_11 Vdout0_11ck197 = 0 time = 990
.meas tran vdout0_11ck197 FIND v(dout0_11) AT=990.025n

* CHECK dout0_12 Vdout0_12ck197 = 0 time = 990
.meas tran vdout0_12ck197 FIND v(dout0_12) AT=990.025n

* CHECK dout0_13 Vdout0_13ck197 = 0 time = 990
.meas tran vdout0_13ck197 FIND v(dout0_13) AT=990.025n

* CHECK dout0_14 Vdout0_14ck197 = 0.9 time = 990
.meas tran vdout0_14ck197 FIND v(dout0_14) AT=990.025n

* CHECK dout0_15 Vdout0_15ck197 = 0 time = 990
.meas tran vdout0_15ck197 FIND v(dout0_15) AT=990.025n

* CHECK dout0_16 Vdout0_16ck197 = 0 time = 990
.meas tran vdout0_16ck197 FIND v(dout0_16) AT=990.025n

* CHECK dout0_17 Vdout0_17ck197 = 0 time = 990
.meas tran vdout0_17ck197 FIND v(dout0_17) AT=990.025n

* CHECK dout0_18 Vdout0_18ck197 = 0.9 time = 990
.meas tran vdout0_18ck197 FIND v(dout0_18) AT=990.025n

* CHECK dout0_19 Vdout0_19ck197 = 0 time = 990
.meas tran vdout0_19ck197 FIND v(dout0_19) AT=990.025n

* CHECK dout0_20 Vdout0_20ck197 = 0.9 time = 990
.meas tran vdout0_20ck197 FIND v(dout0_20) AT=990.025n

* CHECK dout0_21 Vdout0_21ck197 = 0.9 time = 990
.meas tran vdout0_21ck197 FIND v(dout0_21) AT=990.025n

* CHECK dout0_22 Vdout0_22ck197 = 0.9 time = 990
.meas tran vdout0_22ck197 FIND v(dout0_22) AT=990.025n

* CHECK dout0_23 Vdout0_23ck197 = 0.9 time = 990
.meas tran vdout0_23ck197 FIND v(dout0_23) AT=990.025n

* CHECK dout0_24 Vdout0_24ck197 = 0.9 time = 990
.meas tran vdout0_24ck197 FIND v(dout0_24) AT=990.025n

* CHECK dout0_25 Vdout0_25ck197 = 0 time = 990
.meas tran vdout0_25ck197 FIND v(dout0_25) AT=990.025n

* CHECK dout0_26 Vdout0_26ck197 = 0.9 time = 990
.meas tran vdout0_26ck197 FIND v(dout0_26) AT=990.025n

* CHECK dout0_27 Vdout0_27ck197 = 0.9 time = 990
.meas tran vdout0_27ck197 FIND v(dout0_27) AT=990.025n

* CHECK dout0_28 Vdout0_28ck197 = 0 time = 990
.meas tran vdout0_28ck197 FIND v(dout0_28) AT=990.025n

* CHECK dout0_29 Vdout0_29ck197 = 0 time = 990
.meas tran vdout0_29ck197 FIND v(dout0_29) AT=990.025n

* CHECK dout0_30 Vdout0_30ck197 = 0.9 time = 990
.meas tran vdout0_30ck197 FIND v(dout0_30) AT=990.025n

* CHECK dout0_31 Vdout0_31ck197 = 0.9 time = 990
.meas tran vdout0_31ck197 FIND v(dout0_31) AT=990.025n

* CHECK dout0_32 Vdout0_32ck197 = 0.9 time = 990
.meas tran vdout0_32ck197 FIND v(dout0_32) AT=990.025n

* CHECK dout0_33 Vdout0_33ck197 = 0.9 time = 990
.meas tran vdout0_33ck197 FIND v(dout0_33) AT=990.025n

* CHECK dout0_34 Vdout0_34ck197 = 0.9 time = 990
.meas tran vdout0_34ck197 FIND v(dout0_34) AT=990.025n

* CHECK dout0_35 Vdout0_35ck197 = 0.9 time = 990
.meas tran vdout0_35ck197 FIND v(dout0_35) AT=990.025n

* CHECK dout0_36 Vdout0_36ck197 = 0 time = 990
.meas tran vdout0_36ck197 FIND v(dout0_36) AT=990.025n

* CHECK dout0_37 Vdout0_37ck197 = 0 time = 990
.meas tran vdout0_37ck197 FIND v(dout0_37) AT=990.025n

* CHECK dout0_38 Vdout0_38ck197 = 0.9 time = 990
.meas tran vdout0_38ck197 FIND v(dout0_38) AT=990.025n

* CHECK dout0_39 Vdout0_39ck197 = 0 time = 990
.meas tran vdout0_39ck197 FIND v(dout0_39) AT=990.025n

* CHECK dout0_0 Vdout0_0ck198 = 0.9 time = 995
.meas tran vdout0_0ck198 FIND v(dout0_0) AT=995.025n

* CHECK dout0_1 Vdout0_1ck198 = 0 time = 995
.meas tran vdout0_1ck198 FIND v(dout0_1) AT=995.025n

* CHECK dout0_2 Vdout0_2ck198 = 0 time = 995
.meas tran vdout0_2ck198 FIND v(dout0_2) AT=995.025n

* CHECK dout0_3 Vdout0_3ck198 = 0 time = 995
.meas tran vdout0_3ck198 FIND v(dout0_3) AT=995.025n

* CHECK dout0_4 Vdout0_4ck198 = 0 time = 995
.meas tran vdout0_4ck198 FIND v(dout0_4) AT=995.025n

* CHECK dout0_5 Vdout0_5ck198 = 0 time = 995
.meas tran vdout0_5ck198 FIND v(dout0_5) AT=995.025n

* CHECK dout0_6 Vdout0_6ck198 = 0.9 time = 995
.meas tran vdout0_6ck198 FIND v(dout0_6) AT=995.025n

* CHECK dout0_7 Vdout0_7ck198 = 0 time = 995
.meas tran vdout0_7ck198 FIND v(dout0_7) AT=995.025n

* CHECK dout0_8 Vdout0_8ck198 = 0.9 time = 995
.meas tran vdout0_8ck198 FIND v(dout0_8) AT=995.025n

* CHECK dout0_9 Vdout0_9ck198 = 0 time = 995
.meas tran vdout0_9ck198 FIND v(dout0_9) AT=995.025n

* CHECK dout0_10 Vdout0_10ck198 = 0 time = 995
.meas tran vdout0_10ck198 FIND v(dout0_10) AT=995.025n

* CHECK dout0_11 Vdout0_11ck198 = 0 time = 995
.meas tran vdout0_11ck198 FIND v(dout0_11) AT=995.025n

* CHECK dout0_12 Vdout0_12ck198 = 0 time = 995
.meas tran vdout0_12ck198 FIND v(dout0_12) AT=995.025n

* CHECK dout0_13 Vdout0_13ck198 = 0 time = 995
.meas tran vdout0_13ck198 FIND v(dout0_13) AT=995.025n

* CHECK dout0_14 Vdout0_14ck198 = 0.9 time = 995
.meas tran vdout0_14ck198 FIND v(dout0_14) AT=995.025n

* CHECK dout0_15 Vdout0_15ck198 = 0 time = 995
.meas tran vdout0_15ck198 FIND v(dout0_15) AT=995.025n

* CHECK dout0_16 Vdout0_16ck198 = 0 time = 995
.meas tran vdout0_16ck198 FIND v(dout0_16) AT=995.025n

* CHECK dout0_17 Vdout0_17ck198 = 0 time = 995
.meas tran vdout0_17ck198 FIND v(dout0_17) AT=995.025n

* CHECK dout0_18 Vdout0_18ck198 = 0.9 time = 995
.meas tran vdout0_18ck198 FIND v(dout0_18) AT=995.025n

* CHECK dout0_19 Vdout0_19ck198 = 0 time = 995
.meas tran vdout0_19ck198 FIND v(dout0_19) AT=995.025n

* CHECK dout0_20 Vdout0_20ck198 = 0.9 time = 995
.meas tran vdout0_20ck198 FIND v(dout0_20) AT=995.025n

* CHECK dout0_21 Vdout0_21ck198 = 0.9 time = 995
.meas tran vdout0_21ck198 FIND v(dout0_21) AT=995.025n

* CHECK dout0_22 Vdout0_22ck198 = 0.9 time = 995
.meas tran vdout0_22ck198 FIND v(dout0_22) AT=995.025n

* CHECK dout0_23 Vdout0_23ck198 = 0.9 time = 995
.meas tran vdout0_23ck198 FIND v(dout0_23) AT=995.025n

* CHECK dout0_24 Vdout0_24ck198 = 0.9 time = 995
.meas tran vdout0_24ck198 FIND v(dout0_24) AT=995.025n

* CHECK dout0_25 Vdout0_25ck198 = 0 time = 995
.meas tran vdout0_25ck198 FIND v(dout0_25) AT=995.025n

* CHECK dout0_26 Vdout0_26ck198 = 0.9 time = 995
.meas tran vdout0_26ck198 FIND v(dout0_26) AT=995.025n

* CHECK dout0_27 Vdout0_27ck198 = 0.9 time = 995
.meas tran vdout0_27ck198 FIND v(dout0_27) AT=995.025n

* CHECK dout0_28 Vdout0_28ck198 = 0 time = 995
.meas tran vdout0_28ck198 FIND v(dout0_28) AT=995.025n

* CHECK dout0_29 Vdout0_29ck198 = 0 time = 995
.meas tran vdout0_29ck198 FIND v(dout0_29) AT=995.025n

* CHECK dout0_30 Vdout0_30ck198 = 0.9 time = 995
.meas tran vdout0_30ck198 FIND v(dout0_30) AT=995.025n

* CHECK dout0_31 Vdout0_31ck198 = 0.9 time = 995
.meas tran vdout0_31ck198 FIND v(dout0_31) AT=995.025n

* CHECK dout0_32 Vdout0_32ck198 = 0.9 time = 995
.meas tran vdout0_32ck198 FIND v(dout0_32) AT=995.025n

* CHECK dout0_33 Vdout0_33ck198 = 0.9 time = 995
.meas tran vdout0_33ck198 FIND v(dout0_33) AT=995.025n

* CHECK dout0_34 Vdout0_34ck198 = 0.9 time = 995
.meas tran vdout0_34ck198 FIND v(dout0_34) AT=995.025n

* CHECK dout0_35 Vdout0_35ck198 = 0.9 time = 995
.meas tran vdout0_35ck198 FIND v(dout0_35) AT=995.025n

* CHECK dout0_36 Vdout0_36ck198 = 0 time = 995
.meas tran vdout0_36ck198 FIND v(dout0_36) AT=995.025n

* CHECK dout0_37 Vdout0_37ck198 = 0 time = 995
.meas tran vdout0_37ck198 FIND v(dout0_37) AT=995.025n

* CHECK dout0_38 Vdout0_38ck198 = 0.9 time = 995
.meas tran vdout0_38ck198 FIND v(dout0_38) AT=995.025n

* CHECK dout0_39 Vdout0_39ck198 = 0 time = 995
.meas tran vdout0_39ck198 FIND v(dout0_39) AT=995.025n

* CHECK dout0_0 Vdout0_0ck200 = 0.9 time = 1005
.meas tran vdout0_0ck200 FIND v(dout0_0) AT=1005.025n

* CHECK dout0_1 Vdout0_1ck200 = 0.9 time = 1005
.meas tran vdout0_1ck200 FIND v(dout0_1) AT=1005.025n

* CHECK dout0_2 Vdout0_2ck200 = 0 time = 1005
.meas tran vdout0_2ck200 FIND v(dout0_2) AT=1005.025n

* CHECK dout0_3 Vdout0_3ck200 = 0.9 time = 1005
.meas tran vdout0_3ck200 FIND v(dout0_3) AT=1005.025n

* CHECK dout0_4 Vdout0_4ck200 = 0 time = 1005
.meas tran vdout0_4ck200 FIND v(dout0_4) AT=1005.025n

* CHECK dout0_5 Vdout0_5ck200 = 0 time = 1005
.meas tran vdout0_5ck200 FIND v(dout0_5) AT=1005.025n

* CHECK dout0_6 Vdout0_6ck200 = 0 time = 1005
.meas tran vdout0_6ck200 FIND v(dout0_6) AT=1005.025n

* CHECK dout0_7 Vdout0_7ck200 = 0 time = 1005
.meas tran vdout0_7ck200 FIND v(dout0_7) AT=1005.025n

* CHECK dout0_8 Vdout0_8ck200 = 0 time = 1005
.meas tran vdout0_8ck200 FIND v(dout0_8) AT=1005.025n

* CHECK dout0_9 Vdout0_9ck200 = 0.9 time = 1005
.meas tran vdout0_9ck200 FIND v(dout0_9) AT=1005.025n

* CHECK dout0_10 Vdout0_10ck200 = 0.9 time = 1005
.meas tran vdout0_10ck200 FIND v(dout0_10) AT=1005.025n

* CHECK dout0_11 Vdout0_11ck200 = 0 time = 1005
.meas tran vdout0_11ck200 FIND v(dout0_11) AT=1005.025n

* CHECK dout0_12 Vdout0_12ck200 = 0.9 time = 1005
.meas tran vdout0_12ck200 FIND v(dout0_12) AT=1005.025n

* CHECK dout0_13 Vdout0_13ck200 = 0 time = 1005
.meas tran vdout0_13ck200 FIND v(dout0_13) AT=1005.025n

* CHECK dout0_14 Vdout0_14ck200 = 0 time = 1005
.meas tran vdout0_14ck200 FIND v(dout0_14) AT=1005.025n

* CHECK dout0_15 Vdout0_15ck200 = 0 time = 1005
.meas tran vdout0_15ck200 FIND v(dout0_15) AT=1005.025n

* CHECK dout0_16 Vdout0_16ck200 = 0 time = 1005
.meas tran vdout0_16ck200 FIND v(dout0_16) AT=1005.025n

* CHECK dout0_17 Vdout0_17ck200 = 0 time = 1005
.meas tran vdout0_17ck200 FIND v(dout0_17) AT=1005.025n

* CHECK dout0_18 Vdout0_18ck200 = 0 time = 1005
.meas tran vdout0_18ck200 FIND v(dout0_18) AT=1005.025n

* CHECK dout0_19 Vdout0_19ck200 = 0.9 time = 1005
.meas tran vdout0_19ck200 FIND v(dout0_19) AT=1005.025n

* CHECK dout0_20 Vdout0_20ck200 = 0.9 time = 1005
.meas tran vdout0_20ck200 FIND v(dout0_20) AT=1005.025n

* CHECK dout0_21 Vdout0_21ck200 = 0.9 time = 1005
.meas tran vdout0_21ck200 FIND v(dout0_21) AT=1005.025n

* CHECK dout0_22 Vdout0_22ck200 = 0 time = 1005
.meas tran vdout0_22ck200 FIND v(dout0_22) AT=1005.025n

* CHECK dout0_23 Vdout0_23ck200 = 0 time = 1005
.meas tran vdout0_23ck200 FIND v(dout0_23) AT=1005.025n

* CHECK dout0_24 Vdout0_24ck200 = 0 time = 1005
.meas tran vdout0_24ck200 FIND v(dout0_24) AT=1005.025n

* CHECK dout0_25 Vdout0_25ck200 = 0.9 time = 1005
.meas tran vdout0_25ck200 FIND v(dout0_25) AT=1005.025n

* CHECK dout0_26 Vdout0_26ck200 = 0 time = 1005
.meas tran vdout0_26ck200 FIND v(dout0_26) AT=1005.025n

* CHECK dout0_27 Vdout0_27ck200 = 0 time = 1005
.meas tran vdout0_27ck200 FIND v(dout0_27) AT=1005.025n

* CHECK dout0_28 Vdout0_28ck200 = 0.9 time = 1005
.meas tran vdout0_28ck200 FIND v(dout0_28) AT=1005.025n

* CHECK dout0_29 Vdout0_29ck200 = 0.9 time = 1005
.meas tran vdout0_29ck200 FIND v(dout0_29) AT=1005.025n

* CHECK dout0_30 Vdout0_30ck200 = 0 time = 1005
.meas tran vdout0_30ck200 FIND v(dout0_30) AT=1005.025n

* CHECK dout0_31 Vdout0_31ck200 = 0.9 time = 1005
.meas tran vdout0_31ck200 FIND v(dout0_31) AT=1005.025n

* CHECK dout0_32 Vdout0_32ck200 = 0 time = 1005
.meas tran vdout0_32ck200 FIND v(dout0_32) AT=1005.025n

* CHECK dout0_33 Vdout0_33ck200 = 0.9 time = 1005
.meas tran vdout0_33ck200 FIND v(dout0_33) AT=1005.025n

* CHECK dout0_34 Vdout0_34ck200 = 0.9 time = 1005
.meas tran vdout0_34ck200 FIND v(dout0_34) AT=1005.025n

* CHECK dout0_35 Vdout0_35ck200 = 0.9 time = 1005
.meas tran vdout0_35ck200 FIND v(dout0_35) AT=1005.025n

* CHECK dout0_36 Vdout0_36ck200 = 0 time = 1005
.meas tran vdout0_36ck200 FIND v(dout0_36) AT=1005.025n

* CHECK dout0_37 Vdout0_37ck200 = 0.9 time = 1005
.meas tran vdout0_37ck200 FIND v(dout0_37) AT=1005.025n

* CHECK dout0_38 Vdout0_38ck200 = 0 time = 1005
.meas tran vdout0_38ck200 FIND v(dout0_38) AT=1005.025n

* CHECK dout0_39 Vdout0_39ck200 = 0.9 time = 1005
.meas tran vdout0_39ck200 FIND v(dout0_39) AT=1005.025n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
