* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "freepdk45_sram_1rw0r_512x64.sp"

* Global Power Supplies
Vvdd vdd 0 0.9

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xfreepdk45_sram_1rw0r_512x64 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 din0_40 din0_41 din0_42 din0_43 din0_44 din0_45 din0_46 din0_47 din0_48 din0_49 din0_50 din0_51 din0_52 din0_53 din0_54 din0_55 din0_56 din0_57 din0_58 din0_59 din0_60 din0_61 din0_62 din0_63 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 a0_8 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout0_32 dout0_33 dout0_34 dout0_35 dout0_36 dout0_37 dout0_38 dout0_39 dout0_40 dout0_41 dout0_42 dout0_43 dout0_44 dout0_45 dout0_46 dout0_47 dout0_48 dout0_49 dout0_50 dout0_51 dout0_52 dout0_53 dout0_54 dout0_55 dout0_56 dout0_57 dout0_58 dout0_59 dout0_60 dout0_61 dout0_62 dout0_63 vdd gnd freepdk45_sram_1rw0r_512x64

* SRAM output loads
CD00 dout0_0  0 0.8364f
CD01 dout0_1  0 0.8364f
CD02 dout0_2  0 0.8364f
CD03 dout0_3  0 0.8364f
CD04 dout0_4  0 0.8364f
CD05 dout0_5  0 0.8364f
CD06 dout0_6  0 0.8364f
CD07 dout0_7  0 0.8364f
CD08 dout0_8  0 0.8364f
CD09 dout0_9  0 0.8364f
CD010 dout0_10  0 0.8364f
CD011 dout0_11  0 0.8364f
CD012 dout0_12  0 0.8364f
CD013 dout0_13  0 0.8364f
CD014 dout0_14  0 0.8364f
CD015 dout0_15  0 0.8364f
CD016 dout0_16  0 0.8364f
CD017 dout0_17  0 0.8364f
CD018 dout0_18  0 0.8364f
CD019 dout0_19  0 0.8364f
CD020 dout0_20  0 0.8364f
CD021 dout0_21  0 0.8364f
CD022 dout0_22  0 0.8364f
CD023 dout0_23  0 0.8364f
CD024 dout0_24  0 0.8364f
CD025 dout0_25  0 0.8364f
CD026 dout0_26  0 0.8364f
CD027 dout0_27  0 0.8364f
CD028 dout0_28  0 0.8364f
CD029 dout0_29  0 0.8364f
CD030 dout0_30  0 0.8364f
CD031 dout0_31  0 0.8364f
CD032 dout0_32  0 0.8364f
CD033 dout0_33  0 0.8364f
CD034 dout0_34  0 0.8364f
CD035 dout0_35  0 0.8364f
CD036 dout0_36  0 0.8364f
CD037 dout0_37  0 0.8364f
CD038 dout0_38  0 0.8364f
CD039 dout0_39  0 0.8364f
CD040 dout0_40  0 0.8364f
CD041 dout0_41  0 0.8364f
CD042 dout0_42  0 0.8364f
CD043 dout0_43  0 0.8364f
CD044 dout0_44  0 0.8364f
CD045 dout0_45  0 0.8364f
CD046 dout0_46  0 0.8364f
CD047 dout0_47  0 0.8364f
CD048 dout0_48  0 0.8364f
CD049 dout0_49  0 0.8364f
CD050 dout0_50  0 0.8364f
CD051 dout0_51  0 0.8364f
CD052 dout0_52  0 0.8364f
CD053 dout0_53  0 0.8364f
CD054 dout0_54  0 0.8364f
CD055 dout0_55  0 0.8364f
CD056 dout0_56  0 0.8364f
CD057 dout0_57  0 0.8364f
CD058 dout0_58  0 0.8364f
CD059 dout0_59  0 0.8364f
CD060 dout0_60  0 0.8364f
CD061 dout0_61  0 0.8364f
CD062 dout0_62  0 0.8364f
CD063 dout0_63  0 0.8364f

* Important signals for debug
* bl:	xfreepdk45_sram_1rw0r_512x64.xbank0.bl_0_0
* br:	xfreepdk45_sram_1rw0r_512x64.xbank0.br_0_0
* s_en:	xfreepdk45_sram_1rw0r_512x64.s_en
* q:	xfreepdk45_sram_1rw0r_512x64.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xfreepdk45_sram_1rw0r_512x64.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 0101110010111110010101101011111011100100001000011111101001010100  to  address 000000011 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 1110010110001111100010011000110111011001100001111110111110010001  to  address 000000010 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 1010001011001111111111011111110000110101100111110010000100011000  to  address 111111110 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 1110010110001111100010011000110111011001100001111110111110010001 from address 000000010 (from port 0) during cycle 4 (20ns - 25ns)
*	Reading 0101110010111110010101101011111011100100001000011111101001010100 from address 000000011 (from port 0) during cycle 6 (30ns - 35ns)
*	Reading 1110010110001111100010011000110111011001100001111110111110010001 from address 000000010 (from port 0) during cycle 8 (40ns - 45ns)
*	Reading 1010001011001111111111011111110000110101100111110010000100011000 from address 111111110 (from port 0) during cycle 9 (45ns - 50ns)
*	Reading 1010001011001111111111011111110000110101100111110010000100011000 from address 111111110 (from port 0) during cycle 10 (50ns - 55ns)
*	Reading 1010001011001111111111011111110000110101100111110010000100011000 from address 111111110 (from port 0) during cycle 11 (55ns - 60ns)
*	Reading 1110010110001111100010011000110111011001100001111110111110010001 from address 000000010 (from port 0) during cycle 12 (60ns - 65ns)
*	Reading 1010001011001111111111011111110000110101100111110010000100011000 from address 111111110 (from port 0) during cycle 13 (65ns - 70ns)
*	Writing 1101000011101001111110101100001111101001100110110100001101110100  to  address 111111101 (from port 0) during cycle 15 (75ns - 80ns)
*	Reading 1110010110001111100010011000110111011001100001111110111110010001 from address 000000010 (from port 0) during cycle 18 (90ns - 95ns)
*	Reading 1101000011101001111110101100001111101001100110110100001101110100 from address 111111101 (from port 0) during cycle 20 (100ns - 105ns)
*	Reading 1101000011101001111110101100001111101001100110110100001101110100 from address 111111101 (from port 0) during cycle 21 (105ns - 110ns)
*	Reading 0101110010111110010101101011111011100100001000011111101001010100 from address 000000011 (from port 0) during cycle 22 (110ns - 115ns)
*	Reading 1110010110001111100010011000110111011001100001111110111110010001 from address 000000010 (from port 0) during cycle 23 (115ns - 120ns)
*	Reading 1010001011001111111111011111110000110101100111110010000100011000 from address 111111110 (from port 0) during cycle 24 (120ns - 125ns)
*	Writing 0110101010000001000111000100011001000000111101111000000110110011  to  address 000000001 (from port 0) during cycle 27 (135ns - 140ns)
*	Reading 0101110010111110010101101011111011100100001000011111101001010100 from address 000000011 (from port 0) during cycle 28 (140ns - 145ns)
*	Reading 1010001011001111111111011111110000110101100111110010000100011000 from address 111111110 (from port 0) during cycle 29 (145ns - 150ns)
*	Reading 1110010110001111100010011000110111011001100001111110111110010001 from address 000000010 (from port 0) during cycle 30 (150ns - 155ns)
*	Reading 0110101010000001000111000100011001000000111101111000000110110011 from address 000000001 (from port 0) during cycle 32 (160ns - 165ns)
*	Reading 0110101010000001000111000100011001000000111101111000000110110011 from address 000000001 (from port 0) during cycle 33 (165ns - 170ns)
*	Reading 0110101010000001000111000100011001000000111101111000000110110011 from address 000000001 (from port 0) during cycle 35 (175ns - 180ns)
*	Writing 1010000000100010011010000101000000110111001111001000100111101010  to  address 000000000 (from port 0) during cycle 38 (190ns - 195ns)
*	Reading 0110101010000001000111000100011001000000111101111000000110110011 from address 000000001 (from port 0) during cycle 39 (195ns - 200ns)
*	Reading 1010000000100010011010000101000000110111001111001000100111101010 from address 000000000 (from port 0) during cycle 40 (200ns - 205ns)
*	Reading 1101000011101001111110101100001111101001100110110100001101110100 from address 111111101 (from port 0) during cycle 43 (215ns - 220ns)
*	Reading 0110101010000001000111000100011001000000111101111000000110110011 from address 000000001 (from port 0) during cycle 44 (220ns - 225ns)
*	Writing 1110101111001001101010100010000000100011001101011000000001111010  to  address 111111100 (from port 0) during cycle 46 (230ns - 235ns)
*	Reading 1110101111001001101010100010000000100011001101011000000001111010 from address 111111100 (from port 0) during cycle 47 (235ns - 240ns)
*	Reading 1110101111001001101010100010000000100011001101011000000001111010 from address 111111100 (from port 0) during cycle 48 (240ns - 245ns)
*	Reading 1010000000100010011010000101000000110111001111001000100111101010 from address 000000000 (from port 0) during cycle 50 (250ns - 255ns)
*	Writing 0000010010101001000001101101001101000010111001001011010000011001  to  address 111111110 (from port 0) during cycle 51 (255ns - 260ns)
*	Reading 0110101010000001000111000100011001000000111101111000000110110011 from address 000000001 (from port 0) during cycle 54 (270ns - 275ns)
*	Reading 0110101010000001000111000100011001000000111101111000000110110011 from address 000000001 (from port 0) during cycle 56 (280ns - 285ns)
*	Writing 1101010110000011001110000101000000111000101100011010001101000111  to  address 111111011 (from port 0) during cycle 57 (285ns - 290ns)
*	Writing 1100011101000111110011000011100011100101000101101001011001011100  to  address 000000011 (from port 0) during cycle 58 (290ns - 295ns)
*	Writing 1000111100111001110110010111010111000000011000001010111001011010  to  address 111111101 (from port 0) during cycle 59 (295ns - 300ns)
*	Writing 1011010101100011000010010011100010110100001111100000110011001001  to  address 111111101 (from port 0) during cycle 60 (300ns - 305ns)
*	Reading 1110010110001111100010011000110111011001100001111110111110010001 from address 000000010 (from port 0) during cycle 61 (305ns - 310ns)
*	Writing 0110000011101010010000100000100111101111101111111001100110001010  to  address 111111011 (from port 0) during cycle 62 (310ns - 315ns)
*	Reading 1110010110001111100010011000110111011001100001111110111110010001 from address 000000010 (from port 0) during cycle 65 (325ns - 330ns)
*	Reading 0110000011101010010000100000100111101111101111111001100110001010 from address 111111011 (from port 0) during cycle 66 (330ns - 335ns)
*	Reading 1110101111001001101010100010000000100011001101011000000001111010 from address 111111100 (from port 0) during cycle 67 (335ns - 340ns)
*	Writing 1100101010111011101011110001000001101101110010110110001001001100  to  address 000000010 (from port 0) during cycle 69 (345ns - 350ns)
*	Reading 1110101111001001101010100010000000100011001101011000000001111010 from address 111111100 (from port 0) during cycle 70 (350ns - 355ns)
*	Writing 1101111001111011001100000101101001111000011001100010000011001110  to  address 111111110 (from port 0) during cycle 71 (355ns - 360ns)
*	Writing 0101101001101101001111101010001010001001110111001011100111100111  to  address 000000000 (from port 0) during cycle 72 (360ns - 365ns)
*	Writing 0001111001101011011110101110010110001110111100110001101101001010  to  address 111111101 (from port 0) during cycle 73 (365ns - 370ns)
*	Writing 1110111100110110010101110100011101101010000100110011111100101110  to  address 000000000 (from port 0) during cycle 74 (370ns - 375ns)
*	Reading 1110111100110110010101110100011101101010000100110011111100101110 from address 000000000 (from port 0) during cycle 75 (375ns - 380ns)
*	Reading 1110111100110110010101110100011101101010000100110011111100101110 from address 000000000 (from port 0) during cycle 77 (385ns - 390ns)
*	Reading 0001111001101011011110101110010110001110111100110001101101001010 from address 111111101 (from port 0) during cycle 78 (390ns - 395ns)
*	Reading 1100011101000111110011000011100011100101000101101001011001011100 from address 000000011 (from port 0) during cycle 79 (395ns - 400ns)
*	Reading 1110111100110110010101110100011101101010000100110011111100101110 from address 000000000 (from port 0) during cycle 80 (400ns - 405ns)
*	Reading 1101111001111011001100000101101001111000011001100010000011001110 from address 111111110 (from port 0) during cycle 82 (410ns - 415ns)
*	Reading 1100101010111011101011110001000001101101110010110110001001001100 from address 000000010 (from port 0) during cycle 83 (415ns - 420ns)
*	Reading 0110101010000001000111000100011001000000111101111000000110110011 from address 000000001 (from port 0) during cycle 85 (425ns - 430ns)
*	Reading 0110101010000001000111000100011001000000111101111000000110110011 from address 000000001 (from port 0) during cycle 86 (430ns - 435ns)
*	Reading 1110101111001001101010100010000000100011001101011000000001111010 from address 111111100 (from port 0) during cycle 87 (435ns - 440ns)
*	Reading 0001111001101011011110101110010110001110111100110001101101001010 from address 111111101 (from port 0) during cycle 88 (440ns - 445ns)
*	Reading 1100011101000111110011000011100011100101000101101001011001011100 from address 000000011 (from port 0) during cycle 89 (445ns - 450ns)
*	Reading 0110101010000001000111000100011001000000111101111000000110110011 from address 000000001 (from port 0) during cycle 90 (450ns - 455ns)
*	Reading 0110000011101010010000100000100111101111101111111001100110001010 from address 111111011 (from port 0) during cycle 92 (460ns - 465ns)
*	Reading 0110000011101010010000100000100111101111101111111001100110001010 from address 111111011 (from port 0) during cycle 93 (465ns - 470ns)
*	Writing 0010010110101000011101000111111100111110011010011111100010110000  to  address 111111011 (from port 0) during cycle 95 (475ns - 480ns)
*	Reading 1100101010111011101011110001000001101101110010110110001001001100 from address 000000010 (from port 0) during cycle 97 (485ns - 490ns)
*	Writing 0011010001010010111001001110011001011000111000101110110110001010  to  address 111111110 (from port 0) during cycle 98 (490ns - 495ns)
*	Reading 0110101010000001000111000100011001000000111101111000000110110011 from address 000000001 (from port 0) during cycle 99 (495ns - 500ns)
*	Reading 0010010110101000011101000111111100111110011010011111100010110000 from address 111111011 (from port 0) during cycle 100 (500ns - 505ns)
*	Reading 0011010001010010111001001110011001011000111000101110110110001010 from address 111111110 (from port 0) during cycle 101 (505ns - 510ns)
*	Reading 0010010110101000011101000111111100111110011010011111100010110000 from address 111111011 (from port 0) during cycle 102 (510ns - 515ns)
*	Writing 0001010110100101100000111110001001111110000001101100001100100101  to  address 111111100 (from port 0) during cycle 103 (515ns - 520ns)
*	Reading 1100011101000111110011000011100011100101000101101001011001011100 from address 000000011 (from port 0) during cycle 106 (530ns - 535ns)
*	Reading 0010010110101000011101000111111100111110011010011111100010110000 from address 111111011 (from port 0) during cycle 108 (540ns - 545ns)
*	Reading 0001111001101011011110101110010110001110111100110001101101001010 from address 111111101 (from port 0) during cycle 110 (550ns - 555ns)
*	Writing 0001111110011111110001000110111011011101011100000110110001011010  to  address 000000011 (from port 0) during cycle 111 (555ns - 560ns)
*	Writing 0000001001010100001111001011010000100101110000010001100001100010  to  address 111111101 (from port 0) during cycle 113 (565ns - 570ns)
*	Reading 0011010001010010111001001110011001011000111000101110110110001010 from address 111111110 (from port 0) during cycle 116 (580ns - 585ns)
*	Reading 0001111110011111110001000110111011011101011100000110110001011010 from address 000000011 (from port 0) during cycle 118 (590ns - 595ns)
*	Reading 1100101010111011101011110001000001101101110010110110001001001100 from address 000000010 (from port 0) during cycle 119 (595ns - 600ns)
*	Reading 0010010110101000011101000111111100111110011010011111100010110000 from address 111111011 (from port 0) during cycle 120 (600ns - 605ns)
*	Writing 1101101111110110000100100110000011000001000000010101011011011100  to  address 000000001 (from port 0) during cycle 121 (605ns - 610ns)
*	Reading 0001010110100101100000111110001001111110000001101100001100100101 from address 111111100 (from port 0) during cycle 123 (615ns - 620ns)
*	Reading 0001010110100101100000111110001001111110000001101100001100100101 from address 111111100 (from port 0) during cycle 124 (620ns - 625ns)
*	Writing 1010110010110010110000010001110010011011101010110110111100100101  to  address 111111011 (from port 0) during cycle 125 (625ns - 630ns)
*	Writing 0001111001011011101010001110100100101001101001110111111000101100  to  address 111111110 (from port 0) during cycle 126 (630ns - 635ns)
*	Writing 0100000011010000001011011110001010111000111001110100010011000101  to  address 111111100 (from port 0) during cycle 127 (635ns - 640ns)
*	Reading 0001111001011011101010001110100100101001101001110111111000101100 from address 111111110 (from port 0) during cycle 128 (640ns - 645ns)
*	Reading 1010110010110010110000010001110010011011101010110110111100100101 from address 111111011 (from port 0) during cycle 129 (645ns - 650ns)
*	Writing 0010011111001100110001101000011100100101000110001001101100010110  to  address 000000001 (from port 0) during cycle 130 (650ns - 655ns)
*	Reading 0001111001011011101010001110100100101001101001110111111000101100 from address 111111110 (from port 0) during cycle 131 (655ns - 660ns)
*	Reading 0100000011010000001011011110001010111000111001110100010011000101 from address 111111100 (from port 0) during cycle 133 (665ns - 670ns)
*	Writing 0000101011101101101110101101101100001000111001010011101100111101  to  address 000000000 (from port 0) during cycle 134 (670ns - 675ns)
*	Reading 1010110010110010110000010001110010011011101010110110111100100101 from address 111111011 (from port 0) during cycle 135 (675ns - 680ns)
*	Writing 1000010111001100100000101110101111011000010011011101100011001101  to  address 111111101 (from port 0) during cycle 136 (680ns - 685ns)
*	Reading 0000101011101101101110101101101100001000111001010011101100111101 from address 000000000 (from port 0) during cycle 138 (690ns - 695ns)
*	Writing 1000001000001100111001100000110110010010010000001010111111011000  to  address 000000000 (from port 0) during cycle 139 (695ns - 700ns)
*	Reading 1000001000001100111001100000110110010010010000001010111111011000 from address 000000000 (from port 0) during cycle 140 (700ns - 705ns)
*	Reading 1000001000001100111001100000110110010010010000001010111111011000 from address 000000000 (from port 0) during cycle 141 (705ns - 710ns)
*	Reading 0001111001011011101010001110100100101001101001110111111000101100 from address 111111110 (from port 0) during cycle 144 (720ns - 725ns)
*	Writing 1100111001101000010100100110001001001011111000100010111110010111  to  address 111111100 (from port 0) during cycle 145 (725ns - 730ns)
*	Writing 0110100100111100111100010101101011100101001100101111100111111111  to  address 000000010 (from port 0) during cycle 146 (730ns - 735ns)
*	Writing 0010111001000100011100100001111101101010100001001011110101011001  to  address 000000011 (from port 0) during cycle 147 (735ns - 740ns)
*	Reading 1100111001101000010100100110001001001011111000100010111110010111 from address 111111100 (from port 0) during cycle 149 (745ns - 750ns)
*	Reading 0010011111001100110001101000011100100101000110001001101100010110 from address 000000001 (from port 0) during cycle 151 (755ns - 760ns)
*	Reading 1100111001101000010100100110001001001011111000100010111110010111 from address 111111100 (from port 0) during cycle 152 (760ns - 765ns)
*	Reading 0010111001000100011100100001111101101010100001001011110101011001 from address 000000011 (from port 0) during cycle 153 (765ns - 770ns)
*	Reading 1100111001101000010100100110001001001011111000100010111110010111 from address 111111100 (from port 0) during cycle 154 (770ns - 775ns)
*	Writing 1001100111110001000000110010001000000011010011001011110001101000  to  address 111111011 (from port 0) during cycle 155 (775ns - 780ns)
*	Reading 0001111001011011101010001110100100101001101001110111111000101100 from address 111111110 (from port 0) during cycle 157 (785ns - 790ns)
*	Reading 0001111001011011101010001110100100101001101001110111111000101100 from address 111111110 (from port 0) during cycle 158 (790ns - 795ns)
*	Writing 0011000000000110011100101001011100011110010001011100010100111010  to  address 111111100 (from port 0) during cycle 159 (795ns - 800ns)
*	Reading 0011000000000110011100101001011100011110010001011100010100111010 from address 111111100 (from port 0) during cycle 160 (800ns - 805ns)
*	Reading 0010111001000100011100100001111101101010100001001011110101011001 from address 000000011 (from port 0) during cycle 161 (805ns - 810ns)
*	Reading 0001111001011011101010001110100100101001101001110111111000101100 from address 111111110 (from port 0) during cycle 162 (810ns - 815ns)
*	Reading 1000010111001100100000101110101111011000010011011101100011001101 from address 111111101 (from port 0) during cycle 163 (815ns - 820ns)
*	Writing 1000101000110100000101100000110001011011000011100101111101011001  to  address 111111110 (from port 0) during cycle 165 (825ns - 830ns)
*	Reading 1001100111110001000000110010001000000011010011001011110001101000 from address 111111011 (from port 0) during cycle 166 (830ns - 835ns)
*	Writing 1010111110111011010010001001001101110000000101110111100110001011  to  address 000000000 (from port 0) during cycle 168 (840ns - 845ns)
*	Reading 0010011111001100110001101000011100100101000110001001101100010110 from address 000000001 (from port 0) during cycle 169 (845ns - 850ns)
*	Reading 0010111001000100011100100001111101101010100001001011110101011001 from address 000000011 (from port 0) during cycle 171 (855ns - 860ns)
*	Reading 1000101000110100000101100000110001011011000011100101111101011001 from address 111111110 (from port 0) during cycle 172 (860ns - 865ns)
*	Writing 0001101000101101011101011101000000001010000010110100001010001110  to  address 111111101 (from port 0) during cycle 173 (865ns - 870ns)
*	Reading 0011000000000110011100101001011100011110010001011100010100111010 from address 111111100 (from port 0) during cycle 174 (870ns - 875ns)
*	Reading 1001100111110001000000110010001000000011010011001011110001101000 from address 111111011 (from port 0) during cycle 175 (875ns - 880ns)
*	Reading 1001100111110001000000110010001000000011010011001011110001101000 from address 111111011 (from port 0) during cycle 176 (880ns - 885ns)
*	Writing 0000000111010010010111110000000010011111011100010111111100010111  to  address 000000010 (from port 0) during cycle 177 (885ns - 890ns)
*	Writing 1111110101101000111100101101111001101101110000100000101000110001  to  address 111111100 (from port 0) during cycle 180 (900ns - 905ns)
*	Reading 0001101000101101011101011101000000001010000010110100001010001110 from address 111111101 (from port 0) during cycle 181 (905ns - 910ns)
*	Reading 1010111110111011010010001001001101110000000101110111100110001011 from address 000000000 (from port 0) during cycle 182 (910ns - 915ns)
*	Reading 0010011111001100110001101000011100100101000110001001101100010110 from address 000000001 (from port 0) during cycle 183 (915ns - 920ns)
*	Writing 1000101101110101101110101101101101110111001001001000001011100110  to  address 111111101 (from port 0) during cycle 184 (920ns - 925ns)
*	Reading 0000000111010010010111110000000010011111011100010111111100010111 from address 000000010 (from port 0) during cycle 187 (935ns - 940ns)
*	Writing 0001000000101100001101011110100001000110011011000111100101100001  to  address 111111101 (from port 0) during cycle 190 (950ns - 955ns)
*	Reading 0001000000101100001101011110100001000110011011000111100101100001 from address 111111101 (from port 0) during cycle 191 (955ns - 960ns)
*	Reading 1001100111110001000000110010001000000011010011001011110001101000 from address 111111011 (from port 0) during cycle 192 (960ns - 965ns)
*	Reading 0010011111001100110001101000011100100101000110001001101100010110 from address 000000001 (from port 0) during cycle 193 (965ns - 970ns)
*	Reading 0010011111001100110001101000011100100101000110001001101100010110 from address 000000001 (from port 0) during cycle 194 (970ns - 975ns)
*	Reading 0010011111001100110001101000011100100101000110001001101100010110 from address 000000001 (from port 0) during cycle 196 (980ns - 985ns)
*	Writing 0111001111010000101010110000100101001110101110111001000110100101  to  address 000000011 (from port 0) during cycle 197 (985ns - 990ns)
*	Writing 0011110011010001010000010001001100001000010000001011111101011101  to  address 111111011 (from port 0) during cycle 199 (995ns - 1000ns)
*	Writing 0110011000010101011111100010011101010001010111010001110101011101  to  address 000000011 (from port 0) during cycle 200 (1000ns - 1005ns)
*	Writing 1001101111100111110001010001110110001000011000101110011001100111  to  address 000000011 (from port 0) during cycle 201 (1005ns - 1010ns)
*	Reading 0011110011010001010000010001001100001000010000001011111101011101 from address 111111011 (from port 0) during cycle 202 (1010ns - 1015ns)
*	Reading 1111110101101000111100101101111001101101110000100000101000110001 from address 111111100 (from port 0) during cycle 203 (1015ns - 1020ns)
*	Reading 1001101111100111110001010001110110001000011000101110011001100111 from address 000000011 (from port 0) during cycle 204 (1020ns - 1025ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_40  din0_40  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_41  din0_41  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 0), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_42  din0_42  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_43  din0_43  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_44  din0_44  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_45  din0_45  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_46  din0_46  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_47  din0_47  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_48  din0_48  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_49  din0_49  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_50  din0_50  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_51  din0_51  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_52  din0_52  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_53  din0_53  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_54  din0_54  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_55  din0_55  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_56  din0_56  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_57  din0_57  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_58  din0_58  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_59  din0_59  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_60  din0_60  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_61  din0_61  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_62  din0_62  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_63  din0_63  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 0), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 0), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 0), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 1), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 1), (810, 1), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va0_6  a0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va0_7  a0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 1), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va0_8  a0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 0), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 1), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 1), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 1), (540, 0), (545, 1), (550, 0), (555, 0), (560, 1), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 0), (480, 1), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 0), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWEB0 WEB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 0.9 time = 25
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=25.025n

* CHECK dout0_1 Vdout0_1ck4 = 0 time = 25
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=25.025n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 25
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=25.025n

* CHECK dout0_3 Vdout0_3ck4 = 0 time = 25
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=25.025n

* CHECK dout0_4 Vdout0_4ck4 = 0.9 time = 25
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=25.025n

* CHECK dout0_5 Vdout0_5ck4 = 0 time = 25
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=25.025n

* CHECK dout0_6 Vdout0_6ck4 = 0 time = 25
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=25.025n

* CHECK dout0_7 Vdout0_7ck4 = 0.9 time = 25
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=25.025n

* CHECK dout0_8 Vdout0_8ck4 = 0.9 time = 25
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=25.025n

* CHECK dout0_9 Vdout0_9ck4 = 0.9 time = 25
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=25.025n

* CHECK dout0_10 Vdout0_10ck4 = 0.9 time = 25
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=25.025n

* CHECK dout0_11 Vdout0_11ck4 = 0.9 time = 25
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=25.025n

* CHECK dout0_12 Vdout0_12ck4 = 0 time = 25
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=25.025n

* CHECK dout0_13 Vdout0_13ck4 = 0.9 time = 25
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=25.025n

* CHECK dout0_14 Vdout0_14ck4 = 0.9 time = 25
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=25.025n

* CHECK dout0_15 Vdout0_15ck4 = 0.9 time = 25
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=25.025n

* CHECK dout0_16 Vdout0_16ck4 = 0.9 time = 25
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=25.025n

* CHECK dout0_17 Vdout0_17ck4 = 0.9 time = 25
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=25.025n

* CHECK dout0_18 Vdout0_18ck4 = 0.9 time = 25
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=25.025n

* CHECK dout0_19 Vdout0_19ck4 = 0 time = 25
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=25.025n

* CHECK dout0_20 Vdout0_20ck4 = 0 time = 25
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=25.025n

* CHECK dout0_21 Vdout0_21ck4 = 0 time = 25
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=25.025n

* CHECK dout0_22 Vdout0_22ck4 = 0 time = 25
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=25.025n

* CHECK dout0_23 Vdout0_23ck4 = 0.9 time = 25
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=25.025n

* CHECK dout0_24 Vdout0_24ck4 = 0.9 time = 25
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=25.025n

* CHECK dout0_25 Vdout0_25ck4 = 0 time = 25
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=25.025n

* CHECK dout0_26 Vdout0_26ck4 = 0 time = 25
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=25.025n

* CHECK dout0_27 Vdout0_27ck4 = 0.9 time = 25
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=25.025n

* CHECK dout0_28 Vdout0_28ck4 = 0.9 time = 25
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=25.025n

* CHECK dout0_29 Vdout0_29ck4 = 0 time = 25
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=25.025n

* CHECK dout0_30 Vdout0_30ck4 = 0.9 time = 25
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=25.025n

* CHECK dout0_31 Vdout0_31ck4 = 0.9 time = 25
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=25.025n

* CHECK dout0_32 Vdout0_32ck4 = 0.9 time = 25
.meas tran vdout0_32ck4 FIND v(dout0_32) AT=25.025n

* CHECK dout0_33 Vdout0_33ck4 = 0 time = 25
.meas tran vdout0_33ck4 FIND v(dout0_33) AT=25.025n

* CHECK dout0_34 Vdout0_34ck4 = 0.9 time = 25
.meas tran vdout0_34ck4 FIND v(dout0_34) AT=25.025n

* CHECK dout0_35 Vdout0_35ck4 = 0.9 time = 25
.meas tran vdout0_35ck4 FIND v(dout0_35) AT=25.025n

* CHECK dout0_36 Vdout0_36ck4 = 0 time = 25
.meas tran vdout0_36ck4 FIND v(dout0_36) AT=25.025n

* CHECK dout0_37 Vdout0_37ck4 = 0 time = 25
.meas tran vdout0_37ck4 FIND v(dout0_37) AT=25.025n

* CHECK dout0_38 Vdout0_38ck4 = 0 time = 25
.meas tran vdout0_38ck4 FIND v(dout0_38) AT=25.025n

* CHECK dout0_39 Vdout0_39ck4 = 0.9 time = 25
.meas tran vdout0_39ck4 FIND v(dout0_39) AT=25.025n

* CHECK dout0_40 Vdout0_40ck4 = 0.9 time = 25
.meas tran vdout0_40ck4 FIND v(dout0_40) AT=25.025n

* CHECK dout0_41 Vdout0_41ck4 = 0 time = 25
.meas tran vdout0_41ck4 FIND v(dout0_41) AT=25.025n

* CHECK dout0_42 Vdout0_42ck4 = 0 time = 25
.meas tran vdout0_42ck4 FIND v(dout0_42) AT=25.025n

* CHECK dout0_43 Vdout0_43ck4 = 0.9 time = 25
.meas tran vdout0_43ck4 FIND v(dout0_43) AT=25.025n

* CHECK dout0_44 Vdout0_44ck4 = 0 time = 25
.meas tran vdout0_44ck4 FIND v(dout0_44) AT=25.025n

* CHECK dout0_45 Vdout0_45ck4 = 0 time = 25
.meas tran vdout0_45ck4 FIND v(dout0_45) AT=25.025n

* CHECK dout0_46 Vdout0_46ck4 = 0 time = 25
.meas tran vdout0_46ck4 FIND v(dout0_46) AT=25.025n

* CHECK dout0_47 Vdout0_47ck4 = 0.9 time = 25
.meas tran vdout0_47ck4 FIND v(dout0_47) AT=25.025n

* CHECK dout0_48 Vdout0_48ck4 = 0.9 time = 25
.meas tran vdout0_48ck4 FIND v(dout0_48) AT=25.025n

* CHECK dout0_49 Vdout0_49ck4 = 0.9 time = 25
.meas tran vdout0_49ck4 FIND v(dout0_49) AT=25.025n

* CHECK dout0_50 Vdout0_50ck4 = 0.9 time = 25
.meas tran vdout0_50ck4 FIND v(dout0_50) AT=25.025n

* CHECK dout0_51 Vdout0_51ck4 = 0.9 time = 25
.meas tran vdout0_51ck4 FIND v(dout0_51) AT=25.025n

* CHECK dout0_52 Vdout0_52ck4 = 0 time = 25
.meas tran vdout0_52ck4 FIND v(dout0_52) AT=25.025n

* CHECK dout0_53 Vdout0_53ck4 = 0 time = 25
.meas tran vdout0_53ck4 FIND v(dout0_53) AT=25.025n

* CHECK dout0_54 Vdout0_54ck4 = 0 time = 25
.meas tran vdout0_54ck4 FIND v(dout0_54) AT=25.025n

* CHECK dout0_55 Vdout0_55ck4 = 0.9 time = 25
.meas tran vdout0_55ck4 FIND v(dout0_55) AT=25.025n

* CHECK dout0_56 Vdout0_56ck4 = 0.9 time = 25
.meas tran vdout0_56ck4 FIND v(dout0_56) AT=25.025n

* CHECK dout0_57 Vdout0_57ck4 = 0 time = 25
.meas tran vdout0_57ck4 FIND v(dout0_57) AT=25.025n

* CHECK dout0_58 Vdout0_58ck4 = 0.9 time = 25
.meas tran vdout0_58ck4 FIND v(dout0_58) AT=25.025n

* CHECK dout0_59 Vdout0_59ck4 = 0 time = 25
.meas tran vdout0_59ck4 FIND v(dout0_59) AT=25.025n

* CHECK dout0_60 Vdout0_60ck4 = 0 time = 25
.meas tran vdout0_60ck4 FIND v(dout0_60) AT=25.025n

* CHECK dout0_61 Vdout0_61ck4 = 0.9 time = 25
.meas tran vdout0_61ck4 FIND v(dout0_61) AT=25.025n

* CHECK dout0_62 Vdout0_62ck4 = 0.9 time = 25
.meas tran vdout0_62ck4 FIND v(dout0_62) AT=25.025n

* CHECK dout0_63 Vdout0_63ck4 = 0.9 time = 25
.meas tran vdout0_63ck4 FIND v(dout0_63) AT=25.025n

* CHECK dout0_0 Vdout0_0ck6 = 0 time = 35
.meas tran vdout0_0ck6 FIND v(dout0_0) AT=35.025n

* CHECK dout0_1 Vdout0_1ck6 = 0 time = 35
.meas tran vdout0_1ck6 FIND v(dout0_1) AT=35.025n

* CHECK dout0_2 Vdout0_2ck6 = 0.9 time = 35
.meas tran vdout0_2ck6 FIND v(dout0_2) AT=35.025n

* CHECK dout0_3 Vdout0_3ck6 = 0 time = 35
.meas tran vdout0_3ck6 FIND v(dout0_3) AT=35.025n

* CHECK dout0_4 Vdout0_4ck6 = 0.9 time = 35
.meas tran vdout0_4ck6 FIND v(dout0_4) AT=35.025n

* CHECK dout0_5 Vdout0_5ck6 = 0 time = 35
.meas tran vdout0_5ck6 FIND v(dout0_5) AT=35.025n

* CHECK dout0_6 Vdout0_6ck6 = 0.9 time = 35
.meas tran vdout0_6ck6 FIND v(dout0_6) AT=35.025n

* CHECK dout0_7 Vdout0_7ck6 = 0 time = 35
.meas tran vdout0_7ck6 FIND v(dout0_7) AT=35.025n

* CHECK dout0_8 Vdout0_8ck6 = 0 time = 35
.meas tran vdout0_8ck6 FIND v(dout0_8) AT=35.025n

* CHECK dout0_9 Vdout0_9ck6 = 0.9 time = 35
.meas tran vdout0_9ck6 FIND v(dout0_9) AT=35.025n

* CHECK dout0_10 Vdout0_10ck6 = 0 time = 35
.meas tran vdout0_10ck6 FIND v(dout0_10) AT=35.025n

* CHECK dout0_11 Vdout0_11ck6 = 0.9 time = 35
.meas tran vdout0_11ck6 FIND v(dout0_11) AT=35.025n

* CHECK dout0_12 Vdout0_12ck6 = 0.9 time = 35
.meas tran vdout0_12ck6 FIND v(dout0_12) AT=35.025n

* CHECK dout0_13 Vdout0_13ck6 = 0.9 time = 35
.meas tran vdout0_13ck6 FIND v(dout0_13) AT=35.025n

* CHECK dout0_14 Vdout0_14ck6 = 0.9 time = 35
.meas tran vdout0_14ck6 FIND v(dout0_14) AT=35.025n

* CHECK dout0_15 Vdout0_15ck6 = 0.9 time = 35
.meas tran vdout0_15ck6 FIND v(dout0_15) AT=35.025n

* CHECK dout0_16 Vdout0_16ck6 = 0.9 time = 35
.meas tran vdout0_16ck6 FIND v(dout0_16) AT=35.025n

* CHECK dout0_17 Vdout0_17ck6 = 0 time = 35
.meas tran vdout0_17ck6 FIND v(dout0_17) AT=35.025n

* CHECK dout0_18 Vdout0_18ck6 = 0 time = 35
.meas tran vdout0_18ck6 FIND v(dout0_18) AT=35.025n

* CHECK dout0_19 Vdout0_19ck6 = 0 time = 35
.meas tran vdout0_19ck6 FIND v(dout0_19) AT=35.025n

* CHECK dout0_20 Vdout0_20ck6 = 0 time = 35
.meas tran vdout0_20ck6 FIND v(dout0_20) AT=35.025n

* CHECK dout0_21 Vdout0_21ck6 = 0.9 time = 35
.meas tran vdout0_21ck6 FIND v(dout0_21) AT=35.025n

* CHECK dout0_22 Vdout0_22ck6 = 0 time = 35
.meas tran vdout0_22ck6 FIND v(dout0_22) AT=35.025n

* CHECK dout0_23 Vdout0_23ck6 = 0 time = 35
.meas tran vdout0_23ck6 FIND v(dout0_23) AT=35.025n

* CHECK dout0_24 Vdout0_24ck6 = 0 time = 35
.meas tran vdout0_24ck6 FIND v(dout0_24) AT=35.025n

* CHECK dout0_25 Vdout0_25ck6 = 0 time = 35
.meas tran vdout0_25ck6 FIND v(dout0_25) AT=35.025n

* CHECK dout0_26 Vdout0_26ck6 = 0.9 time = 35
.meas tran vdout0_26ck6 FIND v(dout0_26) AT=35.025n

* CHECK dout0_27 Vdout0_27ck6 = 0 time = 35
.meas tran vdout0_27ck6 FIND v(dout0_27) AT=35.025n

* CHECK dout0_28 Vdout0_28ck6 = 0 time = 35
.meas tran vdout0_28ck6 FIND v(dout0_28) AT=35.025n

* CHECK dout0_29 Vdout0_29ck6 = 0.9 time = 35
.meas tran vdout0_29ck6 FIND v(dout0_29) AT=35.025n

* CHECK dout0_30 Vdout0_30ck6 = 0.9 time = 35
.meas tran vdout0_30ck6 FIND v(dout0_30) AT=35.025n

* CHECK dout0_31 Vdout0_31ck6 = 0.9 time = 35
.meas tran vdout0_31ck6 FIND v(dout0_31) AT=35.025n

* CHECK dout0_32 Vdout0_32ck6 = 0 time = 35
.meas tran vdout0_32ck6 FIND v(dout0_32) AT=35.025n

* CHECK dout0_33 Vdout0_33ck6 = 0.9 time = 35
.meas tran vdout0_33ck6 FIND v(dout0_33) AT=35.025n

* CHECK dout0_34 Vdout0_34ck6 = 0.9 time = 35
.meas tran vdout0_34ck6 FIND v(dout0_34) AT=35.025n

* CHECK dout0_35 Vdout0_35ck6 = 0.9 time = 35
.meas tran vdout0_35ck6 FIND v(dout0_35) AT=35.025n

* CHECK dout0_36 Vdout0_36ck6 = 0.9 time = 35
.meas tran vdout0_36ck6 FIND v(dout0_36) AT=35.025n

* CHECK dout0_37 Vdout0_37ck6 = 0.9 time = 35
.meas tran vdout0_37ck6 FIND v(dout0_37) AT=35.025n

* CHECK dout0_38 Vdout0_38ck6 = 0 time = 35
.meas tran vdout0_38ck6 FIND v(dout0_38) AT=35.025n

* CHECK dout0_39 Vdout0_39ck6 = 0.9 time = 35
.meas tran vdout0_39ck6 FIND v(dout0_39) AT=35.025n

* CHECK dout0_40 Vdout0_40ck6 = 0 time = 35
.meas tran vdout0_40ck6 FIND v(dout0_40) AT=35.025n

* CHECK dout0_41 Vdout0_41ck6 = 0.9 time = 35
.meas tran vdout0_41ck6 FIND v(dout0_41) AT=35.025n

* CHECK dout0_42 Vdout0_42ck6 = 0.9 time = 35
.meas tran vdout0_42ck6 FIND v(dout0_42) AT=35.025n

* CHECK dout0_43 Vdout0_43ck6 = 0 time = 35
.meas tran vdout0_43ck6 FIND v(dout0_43) AT=35.025n

* CHECK dout0_44 Vdout0_44ck6 = 0.9 time = 35
.meas tran vdout0_44ck6 FIND v(dout0_44) AT=35.025n

* CHECK dout0_45 Vdout0_45ck6 = 0 time = 35
.meas tran vdout0_45ck6 FIND v(dout0_45) AT=35.025n

* CHECK dout0_46 Vdout0_46ck6 = 0.9 time = 35
.meas tran vdout0_46ck6 FIND v(dout0_46) AT=35.025n

* CHECK dout0_47 Vdout0_47ck6 = 0 time = 35
.meas tran vdout0_47ck6 FIND v(dout0_47) AT=35.025n

* CHECK dout0_48 Vdout0_48ck6 = 0 time = 35
.meas tran vdout0_48ck6 FIND v(dout0_48) AT=35.025n

* CHECK dout0_49 Vdout0_49ck6 = 0.9 time = 35
.meas tran vdout0_49ck6 FIND v(dout0_49) AT=35.025n

* CHECK dout0_50 Vdout0_50ck6 = 0.9 time = 35
.meas tran vdout0_50ck6 FIND v(dout0_50) AT=35.025n

* CHECK dout0_51 Vdout0_51ck6 = 0.9 time = 35
.meas tran vdout0_51ck6 FIND v(dout0_51) AT=35.025n

* CHECK dout0_52 Vdout0_52ck6 = 0.9 time = 35
.meas tran vdout0_52ck6 FIND v(dout0_52) AT=35.025n

* CHECK dout0_53 Vdout0_53ck6 = 0.9 time = 35
.meas tran vdout0_53ck6 FIND v(dout0_53) AT=35.025n

* CHECK dout0_54 Vdout0_54ck6 = 0 time = 35
.meas tran vdout0_54ck6 FIND v(dout0_54) AT=35.025n

* CHECK dout0_55 Vdout0_55ck6 = 0.9 time = 35
.meas tran vdout0_55ck6 FIND v(dout0_55) AT=35.025n

* CHECK dout0_56 Vdout0_56ck6 = 0 time = 35
.meas tran vdout0_56ck6 FIND v(dout0_56) AT=35.025n

* CHECK dout0_57 Vdout0_57ck6 = 0 time = 35
.meas tran vdout0_57ck6 FIND v(dout0_57) AT=35.025n

* CHECK dout0_58 Vdout0_58ck6 = 0.9 time = 35
.meas tran vdout0_58ck6 FIND v(dout0_58) AT=35.025n

* CHECK dout0_59 Vdout0_59ck6 = 0.9 time = 35
.meas tran vdout0_59ck6 FIND v(dout0_59) AT=35.025n

* CHECK dout0_60 Vdout0_60ck6 = 0.9 time = 35
.meas tran vdout0_60ck6 FIND v(dout0_60) AT=35.025n

* CHECK dout0_61 Vdout0_61ck6 = 0 time = 35
.meas tran vdout0_61ck6 FIND v(dout0_61) AT=35.025n

* CHECK dout0_62 Vdout0_62ck6 = 0.9 time = 35
.meas tran vdout0_62ck6 FIND v(dout0_62) AT=35.025n

* CHECK dout0_63 Vdout0_63ck6 = 0 time = 35
.meas tran vdout0_63ck6 FIND v(dout0_63) AT=35.025n

* CHECK dout0_0 Vdout0_0ck8 = 0.9 time = 45
.meas tran vdout0_0ck8 FIND v(dout0_0) AT=45.025n

* CHECK dout0_1 Vdout0_1ck8 = 0 time = 45
.meas tran vdout0_1ck8 FIND v(dout0_1) AT=45.025n

* CHECK dout0_2 Vdout0_2ck8 = 0 time = 45
.meas tran vdout0_2ck8 FIND v(dout0_2) AT=45.025n

* CHECK dout0_3 Vdout0_3ck8 = 0 time = 45
.meas tran vdout0_3ck8 FIND v(dout0_3) AT=45.025n

* CHECK dout0_4 Vdout0_4ck8 = 0.9 time = 45
.meas tran vdout0_4ck8 FIND v(dout0_4) AT=45.025n

* CHECK dout0_5 Vdout0_5ck8 = 0 time = 45
.meas tran vdout0_5ck8 FIND v(dout0_5) AT=45.025n

* CHECK dout0_6 Vdout0_6ck8 = 0 time = 45
.meas tran vdout0_6ck8 FIND v(dout0_6) AT=45.025n

* CHECK dout0_7 Vdout0_7ck8 = 0.9 time = 45
.meas tran vdout0_7ck8 FIND v(dout0_7) AT=45.025n

* CHECK dout0_8 Vdout0_8ck8 = 0.9 time = 45
.meas tran vdout0_8ck8 FIND v(dout0_8) AT=45.025n

* CHECK dout0_9 Vdout0_9ck8 = 0.9 time = 45
.meas tran vdout0_9ck8 FIND v(dout0_9) AT=45.025n

* CHECK dout0_10 Vdout0_10ck8 = 0.9 time = 45
.meas tran vdout0_10ck8 FIND v(dout0_10) AT=45.025n

* CHECK dout0_11 Vdout0_11ck8 = 0.9 time = 45
.meas tran vdout0_11ck8 FIND v(dout0_11) AT=45.025n

* CHECK dout0_12 Vdout0_12ck8 = 0 time = 45
.meas tran vdout0_12ck8 FIND v(dout0_12) AT=45.025n

* CHECK dout0_13 Vdout0_13ck8 = 0.9 time = 45
.meas tran vdout0_13ck8 FIND v(dout0_13) AT=45.025n

* CHECK dout0_14 Vdout0_14ck8 = 0.9 time = 45
.meas tran vdout0_14ck8 FIND v(dout0_14) AT=45.025n

* CHECK dout0_15 Vdout0_15ck8 = 0.9 time = 45
.meas tran vdout0_15ck8 FIND v(dout0_15) AT=45.025n

* CHECK dout0_16 Vdout0_16ck8 = 0.9 time = 45
.meas tran vdout0_16ck8 FIND v(dout0_16) AT=45.025n

* CHECK dout0_17 Vdout0_17ck8 = 0.9 time = 45
.meas tran vdout0_17ck8 FIND v(dout0_17) AT=45.025n

* CHECK dout0_18 Vdout0_18ck8 = 0.9 time = 45
.meas tran vdout0_18ck8 FIND v(dout0_18) AT=45.025n

* CHECK dout0_19 Vdout0_19ck8 = 0 time = 45
.meas tran vdout0_19ck8 FIND v(dout0_19) AT=45.025n

* CHECK dout0_20 Vdout0_20ck8 = 0 time = 45
.meas tran vdout0_20ck8 FIND v(dout0_20) AT=45.025n

* CHECK dout0_21 Vdout0_21ck8 = 0 time = 45
.meas tran vdout0_21ck8 FIND v(dout0_21) AT=45.025n

* CHECK dout0_22 Vdout0_22ck8 = 0 time = 45
.meas tran vdout0_22ck8 FIND v(dout0_22) AT=45.025n

* CHECK dout0_23 Vdout0_23ck8 = 0.9 time = 45
.meas tran vdout0_23ck8 FIND v(dout0_23) AT=45.025n

* CHECK dout0_24 Vdout0_24ck8 = 0.9 time = 45
.meas tran vdout0_24ck8 FIND v(dout0_24) AT=45.025n

* CHECK dout0_25 Vdout0_25ck8 = 0 time = 45
.meas tran vdout0_25ck8 FIND v(dout0_25) AT=45.025n

* CHECK dout0_26 Vdout0_26ck8 = 0 time = 45
.meas tran vdout0_26ck8 FIND v(dout0_26) AT=45.025n

* CHECK dout0_27 Vdout0_27ck8 = 0.9 time = 45
.meas tran vdout0_27ck8 FIND v(dout0_27) AT=45.025n

* CHECK dout0_28 Vdout0_28ck8 = 0.9 time = 45
.meas tran vdout0_28ck8 FIND v(dout0_28) AT=45.025n

* CHECK dout0_29 Vdout0_29ck8 = 0 time = 45
.meas tran vdout0_29ck8 FIND v(dout0_29) AT=45.025n

* CHECK dout0_30 Vdout0_30ck8 = 0.9 time = 45
.meas tran vdout0_30ck8 FIND v(dout0_30) AT=45.025n

* CHECK dout0_31 Vdout0_31ck8 = 0.9 time = 45
.meas tran vdout0_31ck8 FIND v(dout0_31) AT=45.025n

* CHECK dout0_32 Vdout0_32ck8 = 0.9 time = 45
.meas tran vdout0_32ck8 FIND v(dout0_32) AT=45.025n

* CHECK dout0_33 Vdout0_33ck8 = 0 time = 45
.meas tran vdout0_33ck8 FIND v(dout0_33) AT=45.025n

* CHECK dout0_34 Vdout0_34ck8 = 0.9 time = 45
.meas tran vdout0_34ck8 FIND v(dout0_34) AT=45.025n

* CHECK dout0_35 Vdout0_35ck8 = 0.9 time = 45
.meas tran vdout0_35ck8 FIND v(dout0_35) AT=45.025n

* CHECK dout0_36 Vdout0_36ck8 = 0 time = 45
.meas tran vdout0_36ck8 FIND v(dout0_36) AT=45.025n

* CHECK dout0_37 Vdout0_37ck8 = 0 time = 45
.meas tran vdout0_37ck8 FIND v(dout0_37) AT=45.025n

* CHECK dout0_38 Vdout0_38ck8 = 0 time = 45
.meas tran vdout0_38ck8 FIND v(dout0_38) AT=45.025n

* CHECK dout0_39 Vdout0_39ck8 = 0.9 time = 45
.meas tran vdout0_39ck8 FIND v(dout0_39) AT=45.025n

* CHECK dout0_40 Vdout0_40ck8 = 0.9 time = 45
.meas tran vdout0_40ck8 FIND v(dout0_40) AT=45.025n

* CHECK dout0_41 Vdout0_41ck8 = 0 time = 45
.meas tran vdout0_41ck8 FIND v(dout0_41) AT=45.025n

* CHECK dout0_42 Vdout0_42ck8 = 0 time = 45
.meas tran vdout0_42ck8 FIND v(dout0_42) AT=45.025n

* CHECK dout0_43 Vdout0_43ck8 = 0.9 time = 45
.meas tran vdout0_43ck8 FIND v(dout0_43) AT=45.025n

* CHECK dout0_44 Vdout0_44ck8 = 0 time = 45
.meas tran vdout0_44ck8 FIND v(dout0_44) AT=45.025n

* CHECK dout0_45 Vdout0_45ck8 = 0 time = 45
.meas tran vdout0_45ck8 FIND v(dout0_45) AT=45.025n

* CHECK dout0_46 Vdout0_46ck8 = 0 time = 45
.meas tran vdout0_46ck8 FIND v(dout0_46) AT=45.025n

* CHECK dout0_47 Vdout0_47ck8 = 0.9 time = 45
.meas tran vdout0_47ck8 FIND v(dout0_47) AT=45.025n

* CHECK dout0_48 Vdout0_48ck8 = 0.9 time = 45
.meas tran vdout0_48ck8 FIND v(dout0_48) AT=45.025n

* CHECK dout0_49 Vdout0_49ck8 = 0.9 time = 45
.meas tran vdout0_49ck8 FIND v(dout0_49) AT=45.025n

* CHECK dout0_50 Vdout0_50ck8 = 0.9 time = 45
.meas tran vdout0_50ck8 FIND v(dout0_50) AT=45.025n

* CHECK dout0_51 Vdout0_51ck8 = 0.9 time = 45
.meas tran vdout0_51ck8 FIND v(dout0_51) AT=45.025n

* CHECK dout0_52 Vdout0_52ck8 = 0 time = 45
.meas tran vdout0_52ck8 FIND v(dout0_52) AT=45.025n

* CHECK dout0_53 Vdout0_53ck8 = 0 time = 45
.meas tran vdout0_53ck8 FIND v(dout0_53) AT=45.025n

* CHECK dout0_54 Vdout0_54ck8 = 0 time = 45
.meas tran vdout0_54ck8 FIND v(dout0_54) AT=45.025n

* CHECK dout0_55 Vdout0_55ck8 = 0.9 time = 45
.meas tran vdout0_55ck8 FIND v(dout0_55) AT=45.025n

* CHECK dout0_56 Vdout0_56ck8 = 0.9 time = 45
.meas tran vdout0_56ck8 FIND v(dout0_56) AT=45.025n

* CHECK dout0_57 Vdout0_57ck8 = 0 time = 45
.meas tran vdout0_57ck8 FIND v(dout0_57) AT=45.025n

* CHECK dout0_58 Vdout0_58ck8 = 0.9 time = 45
.meas tran vdout0_58ck8 FIND v(dout0_58) AT=45.025n

* CHECK dout0_59 Vdout0_59ck8 = 0 time = 45
.meas tran vdout0_59ck8 FIND v(dout0_59) AT=45.025n

* CHECK dout0_60 Vdout0_60ck8 = 0 time = 45
.meas tran vdout0_60ck8 FIND v(dout0_60) AT=45.025n

* CHECK dout0_61 Vdout0_61ck8 = 0.9 time = 45
.meas tran vdout0_61ck8 FIND v(dout0_61) AT=45.025n

* CHECK dout0_62 Vdout0_62ck8 = 0.9 time = 45
.meas tran vdout0_62ck8 FIND v(dout0_62) AT=45.025n

* CHECK dout0_63 Vdout0_63ck8 = 0.9 time = 45
.meas tran vdout0_63ck8 FIND v(dout0_63) AT=45.025n

* CHECK dout0_0 Vdout0_0ck9 = 0 time = 50
.meas tran vdout0_0ck9 FIND v(dout0_0) AT=50.025n

* CHECK dout0_1 Vdout0_1ck9 = 0 time = 50
.meas tran vdout0_1ck9 FIND v(dout0_1) AT=50.025n

* CHECK dout0_2 Vdout0_2ck9 = 0 time = 50
.meas tran vdout0_2ck9 FIND v(dout0_2) AT=50.025n

* CHECK dout0_3 Vdout0_3ck9 = 0.9 time = 50
.meas tran vdout0_3ck9 FIND v(dout0_3) AT=50.025n

* CHECK dout0_4 Vdout0_4ck9 = 0.9 time = 50
.meas tran vdout0_4ck9 FIND v(dout0_4) AT=50.025n

* CHECK dout0_5 Vdout0_5ck9 = 0 time = 50
.meas tran vdout0_5ck9 FIND v(dout0_5) AT=50.025n

* CHECK dout0_6 Vdout0_6ck9 = 0 time = 50
.meas tran vdout0_6ck9 FIND v(dout0_6) AT=50.025n

* CHECK dout0_7 Vdout0_7ck9 = 0 time = 50
.meas tran vdout0_7ck9 FIND v(dout0_7) AT=50.025n

* CHECK dout0_8 Vdout0_8ck9 = 0.9 time = 50
.meas tran vdout0_8ck9 FIND v(dout0_8) AT=50.025n

* CHECK dout0_9 Vdout0_9ck9 = 0 time = 50
.meas tran vdout0_9ck9 FIND v(dout0_9) AT=50.025n

* CHECK dout0_10 Vdout0_10ck9 = 0 time = 50
.meas tran vdout0_10ck9 FIND v(dout0_10) AT=50.025n

* CHECK dout0_11 Vdout0_11ck9 = 0 time = 50
.meas tran vdout0_11ck9 FIND v(dout0_11) AT=50.025n

* CHECK dout0_12 Vdout0_12ck9 = 0 time = 50
.meas tran vdout0_12ck9 FIND v(dout0_12) AT=50.025n

* CHECK dout0_13 Vdout0_13ck9 = 0.9 time = 50
.meas tran vdout0_13ck9 FIND v(dout0_13) AT=50.025n

* CHECK dout0_14 Vdout0_14ck9 = 0 time = 50
.meas tran vdout0_14ck9 FIND v(dout0_14) AT=50.025n

* CHECK dout0_15 Vdout0_15ck9 = 0 time = 50
.meas tran vdout0_15ck9 FIND v(dout0_15) AT=50.025n

* CHECK dout0_16 Vdout0_16ck9 = 0.9 time = 50
.meas tran vdout0_16ck9 FIND v(dout0_16) AT=50.025n

* CHECK dout0_17 Vdout0_17ck9 = 0.9 time = 50
.meas tran vdout0_17ck9 FIND v(dout0_17) AT=50.025n

* CHECK dout0_18 Vdout0_18ck9 = 0.9 time = 50
.meas tran vdout0_18ck9 FIND v(dout0_18) AT=50.025n

* CHECK dout0_19 Vdout0_19ck9 = 0.9 time = 50
.meas tran vdout0_19ck9 FIND v(dout0_19) AT=50.025n

* CHECK dout0_20 Vdout0_20ck9 = 0.9 time = 50
.meas tran vdout0_20ck9 FIND v(dout0_20) AT=50.025n

* CHECK dout0_21 Vdout0_21ck9 = 0 time = 50
.meas tran vdout0_21ck9 FIND v(dout0_21) AT=50.025n

* CHECK dout0_22 Vdout0_22ck9 = 0 time = 50
.meas tran vdout0_22ck9 FIND v(dout0_22) AT=50.025n

* CHECK dout0_23 Vdout0_23ck9 = 0.9 time = 50
.meas tran vdout0_23ck9 FIND v(dout0_23) AT=50.025n

* CHECK dout0_24 Vdout0_24ck9 = 0.9 time = 50
.meas tran vdout0_24ck9 FIND v(dout0_24) AT=50.025n

* CHECK dout0_25 Vdout0_25ck9 = 0 time = 50
.meas tran vdout0_25ck9 FIND v(dout0_25) AT=50.025n

* CHECK dout0_26 Vdout0_26ck9 = 0.9 time = 50
.meas tran vdout0_26ck9 FIND v(dout0_26) AT=50.025n

* CHECK dout0_27 Vdout0_27ck9 = 0 time = 50
.meas tran vdout0_27ck9 FIND v(dout0_27) AT=50.025n

* CHECK dout0_28 Vdout0_28ck9 = 0.9 time = 50
.meas tran vdout0_28ck9 FIND v(dout0_28) AT=50.025n

* CHECK dout0_29 Vdout0_29ck9 = 0.9 time = 50
.meas tran vdout0_29ck9 FIND v(dout0_29) AT=50.025n

* CHECK dout0_30 Vdout0_30ck9 = 0 time = 50
.meas tran vdout0_30ck9 FIND v(dout0_30) AT=50.025n

* CHECK dout0_31 Vdout0_31ck9 = 0 time = 50
.meas tran vdout0_31ck9 FIND v(dout0_31) AT=50.025n

* CHECK dout0_32 Vdout0_32ck9 = 0 time = 50
.meas tran vdout0_32ck9 FIND v(dout0_32) AT=50.025n

* CHECK dout0_33 Vdout0_33ck9 = 0 time = 50
.meas tran vdout0_33ck9 FIND v(dout0_33) AT=50.025n

* CHECK dout0_34 Vdout0_34ck9 = 0.9 time = 50
.meas tran vdout0_34ck9 FIND v(dout0_34) AT=50.025n

* CHECK dout0_35 Vdout0_35ck9 = 0.9 time = 50
.meas tran vdout0_35ck9 FIND v(dout0_35) AT=50.025n

* CHECK dout0_36 Vdout0_36ck9 = 0.9 time = 50
.meas tran vdout0_36ck9 FIND v(dout0_36) AT=50.025n

* CHECK dout0_37 Vdout0_37ck9 = 0.9 time = 50
.meas tran vdout0_37ck9 FIND v(dout0_37) AT=50.025n

* CHECK dout0_38 Vdout0_38ck9 = 0.9 time = 50
.meas tran vdout0_38ck9 FIND v(dout0_38) AT=50.025n

* CHECK dout0_39 Vdout0_39ck9 = 0.9 time = 50
.meas tran vdout0_39ck9 FIND v(dout0_39) AT=50.025n

* CHECK dout0_40 Vdout0_40ck9 = 0.9 time = 50
.meas tran vdout0_40ck9 FIND v(dout0_40) AT=50.025n

* CHECK dout0_41 Vdout0_41ck9 = 0 time = 50
.meas tran vdout0_41ck9 FIND v(dout0_41) AT=50.025n

* CHECK dout0_42 Vdout0_42ck9 = 0.9 time = 50
.meas tran vdout0_42ck9 FIND v(dout0_42) AT=50.025n

* CHECK dout0_43 Vdout0_43ck9 = 0.9 time = 50
.meas tran vdout0_43ck9 FIND v(dout0_43) AT=50.025n

* CHECK dout0_44 Vdout0_44ck9 = 0.9 time = 50
.meas tran vdout0_44ck9 FIND v(dout0_44) AT=50.025n

* CHECK dout0_45 Vdout0_45ck9 = 0.9 time = 50
.meas tran vdout0_45ck9 FIND v(dout0_45) AT=50.025n

* CHECK dout0_46 Vdout0_46ck9 = 0.9 time = 50
.meas tran vdout0_46ck9 FIND v(dout0_46) AT=50.025n

* CHECK dout0_47 Vdout0_47ck9 = 0.9 time = 50
.meas tran vdout0_47ck9 FIND v(dout0_47) AT=50.025n

* CHECK dout0_48 Vdout0_48ck9 = 0.9 time = 50
.meas tran vdout0_48ck9 FIND v(dout0_48) AT=50.025n

* CHECK dout0_49 Vdout0_49ck9 = 0.9 time = 50
.meas tran vdout0_49ck9 FIND v(dout0_49) AT=50.025n

* CHECK dout0_50 Vdout0_50ck9 = 0.9 time = 50
.meas tran vdout0_50ck9 FIND v(dout0_50) AT=50.025n

* CHECK dout0_51 Vdout0_51ck9 = 0.9 time = 50
.meas tran vdout0_51ck9 FIND v(dout0_51) AT=50.025n

* CHECK dout0_52 Vdout0_52ck9 = 0 time = 50
.meas tran vdout0_52ck9 FIND v(dout0_52) AT=50.025n

* CHECK dout0_53 Vdout0_53ck9 = 0 time = 50
.meas tran vdout0_53ck9 FIND v(dout0_53) AT=50.025n

* CHECK dout0_54 Vdout0_54ck9 = 0.9 time = 50
.meas tran vdout0_54ck9 FIND v(dout0_54) AT=50.025n

* CHECK dout0_55 Vdout0_55ck9 = 0.9 time = 50
.meas tran vdout0_55ck9 FIND v(dout0_55) AT=50.025n

* CHECK dout0_56 Vdout0_56ck9 = 0 time = 50
.meas tran vdout0_56ck9 FIND v(dout0_56) AT=50.025n

* CHECK dout0_57 Vdout0_57ck9 = 0.9 time = 50
.meas tran vdout0_57ck9 FIND v(dout0_57) AT=50.025n

* CHECK dout0_58 Vdout0_58ck9 = 0 time = 50
.meas tran vdout0_58ck9 FIND v(dout0_58) AT=50.025n

* CHECK dout0_59 Vdout0_59ck9 = 0 time = 50
.meas tran vdout0_59ck9 FIND v(dout0_59) AT=50.025n

* CHECK dout0_60 Vdout0_60ck9 = 0 time = 50
.meas tran vdout0_60ck9 FIND v(dout0_60) AT=50.025n

* CHECK dout0_61 Vdout0_61ck9 = 0.9 time = 50
.meas tran vdout0_61ck9 FIND v(dout0_61) AT=50.025n

* CHECK dout0_62 Vdout0_62ck9 = 0 time = 50
.meas tran vdout0_62ck9 FIND v(dout0_62) AT=50.025n

* CHECK dout0_63 Vdout0_63ck9 = 0.9 time = 50
.meas tran vdout0_63ck9 FIND v(dout0_63) AT=50.025n

* CHECK dout0_0 Vdout0_0ck10 = 0 time = 55
.meas tran vdout0_0ck10 FIND v(dout0_0) AT=55.025n

* CHECK dout0_1 Vdout0_1ck10 = 0 time = 55
.meas tran vdout0_1ck10 FIND v(dout0_1) AT=55.025n

* CHECK dout0_2 Vdout0_2ck10 = 0 time = 55
.meas tran vdout0_2ck10 FIND v(dout0_2) AT=55.025n

* CHECK dout0_3 Vdout0_3ck10 = 0.9 time = 55
.meas tran vdout0_3ck10 FIND v(dout0_3) AT=55.025n

* CHECK dout0_4 Vdout0_4ck10 = 0.9 time = 55
.meas tran vdout0_4ck10 FIND v(dout0_4) AT=55.025n

* CHECK dout0_5 Vdout0_5ck10 = 0 time = 55
.meas tran vdout0_5ck10 FIND v(dout0_5) AT=55.025n

* CHECK dout0_6 Vdout0_6ck10 = 0 time = 55
.meas tran vdout0_6ck10 FIND v(dout0_6) AT=55.025n

* CHECK dout0_7 Vdout0_7ck10 = 0 time = 55
.meas tran vdout0_7ck10 FIND v(dout0_7) AT=55.025n

* CHECK dout0_8 Vdout0_8ck10 = 0.9 time = 55
.meas tran vdout0_8ck10 FIND v(dout0_8) AT=55.025n

* CHECK dout0_9 Vdout0_9ck10 = 0 time = 55
.meas tran vdout0_9ck10 FIND v(dout0_9) AT=55.025n

* CHECK dout0_10 Vdout0_10ck10 = 0 time = 55
.meas tran vdout0_10ck10 FIND v(dout0_10) AT=55.025n

* CHECK dout0_11 Vdout0_11ck10 = 0 time = 55
.meas tran vdout0_11ck10 FIND v(dout0_11) AT=55.025n

* CHECK dout0_12 Vdout0_12ck10 = 0 time = 55
.meas tran vdout0_12ck10 FIND v(dout0_12) AT=55.025n

* CHECK dout0_13 Vdout0_13ck10 = 0.9 time = 55
.meas tran vdout0_13ck10 FIND v(dout0_13) AT=55.025n

* CHECK dout0_14 Vdout0_14ck10 = 0 time = 55
.meas tran vdout0_14ck10 FIND v(dout0_14) AT=55.025n

* CHECK dout0_15 Vdout0_15ck10 = 0 time = 55
.meas tran vdout0_15ck10 FIND v(dout0_15) AT=55.025n

* CHECK dout0_16 Vdout0_16ck10 = 0.9 time = 55
.meas tran vdout0_16ck10 FIND v(dout0_16) AT=55.025n

* CHECK dout0_17 Vdout0_17ck10 = 0.9 time = 55
.meas tran vdout0_17ck10 FIND v(dout0_17) AT=55.025n

* CHECK dout0_18 Vdout0_18ck10 = 0.9 time = 55
.meas tran vdout0_18ck10 FIND v(dout0_18) AT=55.025n

* CHECK dout0_19 Vdout0_19ck10 = 0.9 time = 55
.meas tran vdout0_19ck10 FIND v(dout0_19) AT=55.025n

* CHECK dout0_20 Vdout0_20ck10 = 0.9 time = 55
.meas tran vdout0_20ck10 FIND v(dout0_20) AT=55.025n

* CHECK dout0_21 Vdout0_21ck10 = 0 time = 55
.meas tran vdout0_21ck10 FIND v(dout0_21) AT=55.025n

* CHECK dout0_22 Vdout0_22ck10 = 0 time = 55
.meas tran vdout0_22ck10 FIND v(dout0_22) AT=55.025n

* CHECK dout0_23 Vdout0_23ck10 = 0.9 time = 55
.meas tran vdout0_23ck10 FIND v(dout0_23) AT=55.025n

* CHECK dout0_24 Vdout0_24ck10 = 0.9 time = 55
.meas tran vdout0_24ck10 FIND v(dout0_24) AT=55.025n

* CHECK dout0_25 Vdout0_25ck10 = 0 time = 55
.meas tran vdout0_25ck10 FIND v(dout0_25) AT=55.025n

* CHECK dout0_26 Vdout0_26ck10 = 0.9 time = 55
.meas tran vdout0_26ck10 FIND v(dout0_26) AT=55.025n

* CHECK dout0_27 Vdout0_27ck10 = 0 time = 55
.meas tran vdout0_27ck10 FIND v(dout0_27) AT=55.025n

* CHECK dout0_28 Vdout0_28ck10 = 0.9 time = 55
.meas tran vdout0_28ck10 FIND v(dout0_28) AT=55.025n

* CHECK dout0_29 Vdout0_29ck10 = 0.9 time = 55
.meas tran vdout0_29ck10 FIND v(dout0_29) AT=55.025n

* CHECK dout0_30 Vdout0_30ck10 = 0 time = 55
.meas tran vdout0_30ck10 FIND v(dout0_30) AT=55.025n

* CHECK dout0_31 Vdout0_31ck10 = 0 time = 55
.meas tran vdout0_31ck10 FIND v(dout0_31) AT=55.025n

* CHECK dout0_32 Vdout0_32ck10 = 0 time = 55
.meas tran vdout0_32ck10 FIND v(dout0_32) AT=55.025n

* CHECK dout0_33 Vdout0_33ck10 = 0 time = 55
.meas tran vdout0_33ck10 FIND v(dout0_33) AT=55.025n

* CHECK dout0_34 Vdout0_34ck10 = 0.9 time = 55
.meas tran vdout0_34ck10 FIND v(dout0_34) AT=55.025n

* CHECK dout0_35 Vdout0_35ck10 = 0.9 time = 55
.meas tran vdout0_35ck10 FIND v(dout0_35) AT=55.025n

* CHECK dout0_36 Vdout0_36ck10 = 0.9 time = 55
.meas tran vdout0_36ck10 FIND v(dout0_36) AT=55.025n

* CHECK dout0_37 Vdout0_37ck10 = 0.9 time = 55
.meas tran vdout0_37ck10 FIND v(dout0_37) AT=55.025n

* CHECK dout0_38 Vdout0_38ck10 = 0.9 time = 55
.meas tran vdout0_38ck10 FIND v(dout0_38) AT=55.025n

* CHECK dout0_39 Vdout0_39ck10 = 0.9 time = 55
.meas tran vdout0_39ck10 FIND v(dout0_39) AT=55.025n

* CHECK dout0_40 Vdout0_40ck10 = 0.9 time = 55
.meas tran vdout0_40ck10 FIND v(dout0_40) AT=55.025n

* CHECK dout0_41 Vdout0_41ck10 = 0 time = 55
.meas tran vdout0_41ck10 FIND v(dout0_41) AT=55.025n

* CHECK dout0_42 Vdout0_42ck10 = 0.9 time = 55
.meas tran vdout0_42ck10 FIND v(dout0_42) AT=55.025n

* CHECK dout0_43 Vdout0_43ck10 = 0.9 time = 55
.meas tran vdout0_43ck10 FIND v(dout0_43) AT=55.025n

* CHECK dout0_44 Vdout0_44ck10 = 0.9 time = 55
.meas tran vdout0_44ck10 FIND v(dout0_44) AT=55.025n

* CHECK dout0_45 Vdout0_45ck10 = 0.9 time = 55
.meas tran vdout0_45ck10 FIND v(dout0_45) AT=55.025n

* CHECK dout0_46 Vdout0_46ck10 = 0.9 time = 55
.meas tran vdout0_46ck10 FIND v(dout0_46) AT=55.025n

* CHECK dout0_47 Vdout0_47ck10 = 0.9 time = 55
.meas tran vdout0_47ck10 FIND v(dout0_47) AT=55.025n

* CHECK dout0_48 Vdout0_48ck10 = 0.9 time = 55
.meas tran vdout0_48ck10 FIND v(dout0_48) AT=55.025n

* CHECK dout0_49 Vdout0_49ck10 = 0.9 time = 55
.meas tran vdout0_49ck10 FIND v(dout0_49) AT=55.025n

* CHECK dout0_50 Vdout0_50ck10 = 0.9 time = 55
.meas tran vdout0_50ck10 FIND v(dout0_50) AT=55.025n

* CHECK dout0_51 Vdout0_51ck10 = 0.9 time = 55
.meas tran vdout0_51ck10 FIND v(dout0_51) AT=55.025n

* CHECK dout0_52 Vdout0_52ck10 = 0 time = 55
.meas tran vdout0_52ck10 FIND v(dout0_52) AT=55.025n

* CHECK dout0_53 Vdout0_53ck10 = 0 time = 55
.meas tran vdout0_53ck10 FIND v(dout0_53) AT=55.025n

* CHECK dout0_54 Vdout0_54ck10 = 0.9 time = 55
.meas tran vdout0_54ck10 FIND v(dout0_54) AT=55.025n

* CHECK dout0_55 Vdout0_55ck10 = 0.9 time = 55
.meas tran vdout0_55ck10 FIND v(dout0_55) AT=55.025n

* CHECK dout0_56 Vdout0_56ck10 = 0 time = 55
.meas tran vdout0_56ck10 FIND v(dout0_56) AT=55.025n

* CHECK dout0_57 Vdout0_57ck10 = 0.9 time = 55
.meas tran vdout0_57ck10 FIND v(dout0_57) AT=55.025n

* CHECK dout0_58 Vdout0_58ck10 = 0 time = 55
.meas tran vdout0_58ck10 FIND v(dout0_58) AT=55.025n

* CHECK dout0_59 Vdout0_59ck10 = 0 time = 55
.meas tran vdout0_59ck10 FIND v(dout0_59) AT=55.025n

* CHECK dout0_60 Vdout0_60ck10 = 0 time = 55
.meas tran vdout0_60ck10 FIND v(dout0_60) AT=55.025n

* CHECK dout0_61 Vdout0_61ck10 = 0.9 time = 55
.meas tran vdout0_61ck10 FIND v(dout0_61) AT=55.025n

* CHECK dout0_62 Vdout0_62ck10 = 0 time = 55
.meas tran vdout0_62ck10 FIND v(dout0_62) AT=55.025n

* CHECK dout0_63 Vdout0_63ck10 = 0.9 time = 55
.meas tran vdout0_63ck10 FIND v(dout0_63) AT=55.025n

* CHECK dout0_0 Vdout0_0ck11 = 0 time = 60
.meas tran vdout0_0ck11 FIND v(dout0_0) AT=60.025n

* CHECK dout0_1 Vdout0_1ck11 = 0 time = 60
.meas tran vdout0_1ck11 FIND v(dout0_1) AT=60.025n

* CHECK dout0_2 Vdout0_2ck11 = 0 time = 60
.meas tran vdout0_2ck11 FIND v(dout0_2) AT=60.025n

* CHECK dout0_3 Vdout0_3ck11 = 0.9 time = 60
.meas tran vdout0_3ck11 FIND v(dout0_3) AT=60.025n

* CHECK dout0_4 Vdout0_4ck11 = 0.9 time = 60
.meas tran vdout0_4ck11 FIND v(dout0_4) AT=60.025n

* CHECK dout0_5 Vdout0_5ck11 = 0 time = 60
.meas tran vdout0_5ck11 FIND v(dout0_5) AT=60.025n

* CHECK dout0_6 Vdout0_6ck11 = 0 time = 60
.meas tran vdout0_6ck11 FIND v(dout0_6) AT=60.025n

* CHECK dout0_7 Vdout0_7ck11 = 0 time = 60
.meas tran vdout0_7ck11 FIND v(dout0_7) AT=60.025n

* CHECK dout0_8 Vdout0_8ck11 = 0.9 time = 60
.meas tran vdout0_8ck11 FIND v(dout0_8) AT=60.025n

* CHECK dout0_9 Vdout0_9ck11 = 0 time = 60
.meas tran vdout0_9ck11 FIND v(dout0_9) AT=60.025n

* CHECK dout0_10 Vdout0_10ck11 = 0 time = 60
.meas tran vdout0_10ck11 FIND v(dout0_10) AT=60.025n

* CHECK dout0_11 Vdout0_11ck11 = 0 time = 60
.meas tran vdout0_11ck11 FIND v(dout0_11) AT=60.025n

* CHECK dout0_12 Vdout0_12ck11 = 0 time = 60
.meas tran vdout0_12ck11 FIND v(dout0_12) AT=60.025n

* CHECK dout0_13 Vdout0_13ck11 = 0.9 time = 60
.meas tran vdout0_13ck11 FIND v(dout0_13) AT=60.025n

* CHECK dout0_14 Vdout0_14ck11 = 0 time = 60
.meas tran vdout0_14ck11 FIND v(dout0_14) AT=60.025n

* CHECK dout0_15 Vdout0_15ck11 = 0 time = 60
.meas tran vdout0_15ck11 FIND v(dout0_15) AT=60.025n

* CHECK dout0_16 Vdout0_16ck11 = 0.9 time = 60
.meas tran vdout0_16ck11 FIND v(dout0_16) AT=60.025n

* CHECK dout0_17 Vdout0_17ck11 = 0.9 time = 60
.meas tran vdout0_17ck11 FIND v(dout0_17) AT=60.025n

* CHECK dout0_18 Vdout0_18ck11 = 0.9 time = 60
.meas tran vdout0_18ck11 FIND v(dout0_18) AT=60.025n

* CHECK dout0_19 Vdout0_19ck11 = 0.9 time = 60
.meas tran vdout0_19ck11 FIND v(dout0_19) AT=60.025n

* CHECK dout0_20 Vdout0_20ck11 = 0.9 time = 60
.meas tran vdout0_20ck11 FIND v(dout0_20) AT=60.025n

* CHECK dout0_21 Vdout0_21ck11 = 0 time = 60
.meas tran vdout0_21ck11 FIND v(dout0_21) AT=60.025n

* CHECK dout0_22 Vdout0_22ck11 = 0 time = 60
.meas tran vdout0_22ck11 FIND v(dout0_22) AT=60.025n

* CHECK dout0_23 Vdout0_23ck11 = 0.9 time = 60
.meas tran vdout0_23ck11 FIND v(dout0_23) AT=60.025n

* CHECK dout0_24 Vdout0_24ck11 = 0.9 time = 60
.meas tran vdout0_24ck11 FIND v(dout0_24) AT=60.025n

* CHECK dout0_25 Vdout0_25ck11 = 0 time = 60
.meas tran vdout0_25ck11 FIND v(dout0_25) AT=60.025n

* CHECK dout0_26 Vdout0_26ck11 = 0.9 time = 60
.meas tran vdout0_26ck11 FIND v(dout0_26) AT=60.025n

* CHECK dout0_27 Vdout0_27ck11 = 0 time = 60
.meas tran vdout0_27ck11 FIND v(dout0_27) AT=60.025n

* CHECK dout0_28 Vdout0_28ck11 = 0.9 time = 60
.meas tran vdout0_28ck11 FIND v(dout0_28) AT=60.025n

* CHECK dout0_29 Vdout0_29ck11 = 0.9 time = 60
.meas tran vdout0_29ck11 FIND v(dout0_29) AT=60.025n

* CHECK dout0_30 Vdout0_30ck11 = 0 time = 60
.meas tran vdout0_30ck11 FIND v(dout0_30) AT=60.025n

* CHECK dout0_31 Vdout0_31ck11 = 0 time = 60
.meas tran vdout0_31ck11 FIND v(dout0_31) AT=60.025n

* CHECK dout0_32 Vdout0_32ck11 = 0 time = 60
.meas tran vdout0_32ck11 FIND v(dout0_32) AT=60.025n

* CHECK dout0_33 Vdout0_33ck11 = 0 time = 60
.meas tran vdout0_33ck11 FIND v(dout0_33) AT=60.025n

* CHECK dout0_34 Vdout0_34ck11 = 0.9 time = 60
.meas tran vdout0_34ck11 FIND v(dout0_34) AT=60.025n

* CHECK dout0_35 Vdout0_35ck11 = 0.9 time = 60
.meas tran vdout0_35ck11 FIND v(dout0_35) AT=60.025n

* CHECK dout0_36 Vdout0_36ck11 = 0.9 time = 60
.meas tran vdout0_36ck11 FIND v(dout0_36) AT=60.025n

* CHECK dout0_37 Vdout0_37ck11 = 0.9 time = 60
.meas tran vdout0_37ck11 FIND v(dout0_37) AT=60.025n

* CHECK dout0_38 Vdout0_38ck11 = 0.9 time = 60
.meas tran vdout0_38ck11 FIND v(dout0_38) AT=60.025n

* CHECK dout0_39 Vdout0_39ck11 = 0.9 time = 60
.meas tran vdout0_39ck11 FIND v(dout0_39) AT=60.025n

* CHECK dout0_40 Vdout0_40ck11 = 0.9 time = 60
.meas tran vdout0_40ck11 FIND v(dout0_40) AT=60.025n

* CHECK dout0_41 Vdout0_41ck11 = 0 time = 60
.meas tran vdout0_41ck11 FIND v(dout0_41) AT=60.025n

* CHECK dout0_42 Vdout0_42ck11 = 0.9 time = 60
.meas tran vdout0_42ck11 FIND v(dout0_42) AT=60.025n

* CHECK dout0_43 Vdout0_43ck11 = 0.9 time = 60
.meas tran vdout0_43ck11 FIND v(dout0_43) AT=60.025n

* CHECK dout0_44 Vdout0_44ck11 = 0.9 time = 60
.meas tran vdout0_44ck11 FIND v(dout0_44) AT=60.025n

* CHECK dout0_45 Vdout0_45ck11 = 0.9 time = 60
.meas tran vdout0_45ck11 FIND v(dout0_45) AT=60.025n

* CHECK dout0_46 Vdout0_46ck11 = 0.9 time = 60
.meas tran vdout0_46ck11 FIND v(dout0_46) AT=60.025n

* CHECK dout0_47 Vdout0_47ck11 = 0.9 time = 60
.meas tran vdout0_47ck11 FIND v(dout0_47) AT=60.025n

* CHECK dout0_48 Vdout0_48ck11 = 0.9 time = 60
.meas tran vdout0_48ck11 FIND v(dout0_48) AT=60.025n

* CHECK dout0_49 Vdout0_49ck11 = 0.9 time = 60
.meas tran vdout0_49ck11 FIND v(dout0_49) AT=60.025n

* CHECK dout0_50 Vdout0_50ck11 = 0.9 time = 60
.meas tran vdout0_50ck11 FIND v(dout0_50) AT=60.025n

* CHECK dout0_51 Vdout0_51ck11 = 0.9 time = 60
.meas tran vdout0_51ck11 FIND v(dout0_51) AT=60.025n

* CHECK dout0_52 Vdout0_52ck11 = 0 time = 60
.meas tran vdout0_52ck11 FIND v(dout0_52) AT=60.025n

* CHECK dout0_53 Vdout0_53ck11 = 0 time = 60
.meas tran vdout0_53ck11 FIND v(dout0_53) AT=60.025n

* CHECK dout0_54 Vdout0_54ck11 = 0.9 time = 60
.meas tran vdout0_54ck11 FIND v(dout0_54) AT=60.025n

* CHECK dout0_55 Vdout0_55ck11 = 0.9 time = 60
.meas tran vdout0_55ck11 FIND v(dout0_55) AT=60.025n

* CHECK dout0_56 Vdout0_56ck11 = 0 time = 60
.meas tran vdout0_56ck11 FIND v(dout0_56) AT=60.025n

* CHECK dout0_57 Vdout0_57ck11 = 0.9 time = 60
.meas tran vdout0_57ck11 FIND v(dout0_57) AT=60.025n

* CHECK dout0_58 Vdout0_58ck11 = 0 time = 60
.meas tran vdout0_58ck11 FIND v(dout0_58) AT=60.025n

* CHECK dout0_59 Vdout0_59ck11 = 0 time = 60
.meas tran vdout0_59ck11 FIND v(dout0_59) AT=60.025n

* CHECK dout0_60 Vdout0_60ck11 = 0 time = 60
.meas tran vdout0_60ck11 FIND v(dout0_60) AT=60.025n

* CHECK dout0_61 Vdout0_61ck11 = 0.9 time = 60
.meas tran vdout0_61ck11 FIND v(dout0_61) AT=60.025n

* CHECK dout0_62 Vdout0_62ck11 = 0 time = 60
.meas tran vdout0_62ck11 FIND v(dout0_62) AT=60.025n

* CHECK dout0_63 Vdout0_63ck11 = 0.9 time = 60
.meas tran vdout0_63ck11 FIND v(dout0_63) AT=60.025n

* CHECK dout0_0 Vdout0_0ck12 = 0.9 time = 65
.meas tran vdout0_0ck12 FIND v(dout0_0) AT=65.025n

* CHECK dout0_1 Vdout0_1ck12 = 0 time = 65
.meas tran vdout0_1ck12 FIND v(dout0_1) AT=65.025n

* CHECK dout0_2 Vdout0_2ck12 = 0 time = 65
.meas tran vdout0_2ck12 FIND v(dout0_2) AT=65.025n

* CHECK dout0_3 Vdout0_3ck12 = 0 time = 65
.meas tran vdout0_3ck12 FIND v(dout0_3) AT=65.025n

* CHECK dout0_4 Vdout0_4ck12 = 0.9 time = 65
.meas tran vdout0_4ck12 FIND v(dout0_4) AT=65.025n

* CHECK dout0_5 Vdout0_5ck12 = 0 time = 65
.meas tran vdout0_5ck12 FIND v(dout0_5) AT=65.025n

* CHECK dout0_6 Vdout0_6ck12 = 0 time = 65
.meas tran vdout0_6ck12 FIND v(dout0_6) AT=65.025n

* CHECK dout0_7 Vdout0_7ck12 = 0.9 time = 65
.meas tran vdout0_7ck12 FIND v(dout0_7) AT=65.025n

* CHECK dout0_8 Vdout0_8ck12 = 0.9 time = 65
.meas tran vdout0_8ck12 FIND v(dout0_8) AT=65.025n

* CHECK dout0_9 Vdout0_9ck12 = 0.9 time = 65
.meas tran vdout0_9ck12 FIND v(dout0_9) AT=65.025n

* CHECK dout0_10 Vdout0_10ck12 = 0.9 time = 65
.meas tran vdout0_10ck12 FIND v(dout0_10) AT=65.025n

* CHECK dout0_11 Vdout0_11ck12 = 0.9 time = 65
.meas tran vdout0_11ck12 FIND v(dout0_11) AT=65.025n

* CHECK dout0_12 Vdout0_12ck12 = 0 time = 65
.meas tran vdout0_12ck12 FIND v(dout0_12) AT=65.025n

* CHECK dout0_13 Vdout0_13ck12 = 0.9 time = 65
.meas tran vdout0_13ck12 FIND v(dout0_13) AT=65.025n

* CHECK dout0_14 Vdout0_14ck12 = 0.9 time = 65
.meas tran vdout0_14ck12 FIND v(dout0_14) AT=65.025n

* CHECK dout0_15 Vdout0_15ck12 = 0.9 time = 65
.meas tran vdout0_15ck12 FIND v(dout0_15) AT=65.025n

* CHECK dout0_16 Vdout0_16ck12 = 0.9 time = 65
.meas tran vdout0_16ck12 FIND v(dout0_16) AT=65.025n

* CHECK dout0_17 Vdout0_17ck12 = 0.9 time = 65
.meas tran vdout0_17ck12 FIND v(dout0_17) AT=65.025n

* CHECK dout0_18 Vdout0_18ck12 = 0.9 time = 65
.meas tran vdout0_18ck12 FIND v(dout0_18) AT=65.025n

* CHECK dout0_19 Vdout0_19ck12 = 0 time = 65
.meas tran vdout0_19ck12 FIND v(dout0_19) AT=65.025n

* CHECK dout0_20 Vdout0_20ck12 = 0 time = 65
.meas tran vdout0_20ck12 FIND v(dout0_20) AT=65.025n

* CHECK dout0_21 Vdout0_21ck12 = 0 time = 65
.meas tran vdout0_21ck12 FIND v(dout0_21) AT=65.025n

* CHECK dout0_22 Vdout0_22ck12 = 0 time = 65
.meas tran vdout0_22ck12 FIND v(dout0_22) AT=65.025n

* CHECK dout0_23 Vdout0_23ck12 = 0.9 time = 65
.meas tran vdout0_23ck12 FIND v(dout0_23) AT=65.025n

* CHECK dout0_24 Vdout0_24ck12 = 0.9 time = 65
.meas tran vdout0_24ck12 FIND v(dout0_24) AT=65.025n

* CHECK dout0_25 Vdout0_25ck12 = 0 time = 65
.meas tran vdout0_25ck12 FIND v(dout0_25) AT=65.025n

* CHECK dout0_26 Vdout0_26ck12 = 0 time = 65
.meas tran vdout0_26ck12 FIND v(dout0_26) AT=65.025n

* CHECK dout0_27 Vdout0_27ck12 = 0.9 time = 65
.meas tran vdout0_27ck12 FIND v(dout0_27) AT=65.025n

* CHECK dout0_28 Vdout0_28ck12 = 0.9 time = 65
.meas tran vdout0_28ck12 FIND v(dout0_28) AT=65.025n

* CHECK dout0_29 Vdout0_29ck12 = 0 time = 65
.meas tran vdout0_29ck12 FIND v(dout0_29) AT=65.025n

* CHECK dout0_30 Vdout0_30ck12 = 0.9 time = 65
.meas tran vdout0_30ck12 FIND v(dout0_30) AT=65.025n

* CHECK dout0_31 Vdout0_31ck12 = 0.9 time = 65
.meas tran vdout0_31ck12 FIND v(dout0_31) AT=65.025n

* CHECK dout0_32 Vdout0_32ck12 = 0.9 time = 65
.meas tran vdout0_32ck12 FIND v(dout0_32) AT=65.025n

* CHECK dout0_33 Vdout0_33ck12 = 0 time = 65
.meas tran vdout0_33ck12 FIND v(dout0_33) AT=65.025n

* CHECK dout0_34 Vdout0_34ck12 = 0.9 time = 65
.meas tran vdout0_34ck12 FIND v(dout0_34) AT=65.025n

* CHECK dout0_35 Vdout0_35ck12 = 0.9 time = 65
.meas tran vdout0_35ck12 FIND v(dout0_35) AT=65.025n

* CHECK dout0_36 Vdout0_36ck12 = 0 time = 65
.meas tran vdout0_36ck12 FIND v(dout0_36) AT=65.025n

* CHECK dout0_37 Vdout0_37ck12 = 0 time = 65
.meas tran vdout0_37ck12 FIND v(dout0_37) AT=65.025n

* CHECK dout0_38 Vdout0_38ck12 = 0 time = 65
.meas tran vdout0_38ck12 FIND v(dout0_38) AT=65.025n

* CHECK dout0_39 Vdout0_39ck12 = 0.9 time = 65
.meas tran vdout0_39ck12 FIND v(dout0_39) AT=65.025n

* CHECK dout0_40 Vdout0_40ck12 = 0.9 time = 65
.meas tran vdout0_40ck12 FIND v(dout0_40) AT=65.025n

* CHECK dout0_41 Vdout0_41ck12 = 0 time = 65
.meas tran vdout0_41ck12 FIND v(dout0_41) AT=65.025n

* CHECK dout0_42 Vdout0_42ck12 = 0 time = 65
.meas tran vdout0_42ck12 FIND v(dout0_42) AT=65.025n

* CHECK dout0_43 Vdout0_43ck12 = 0.9 time = 65
.meas tran vdout0_43ck12 FIND v(dout0_43) AT=65.025n

* CHECK dout0_44 Vdout0_44ck12 = 0 time = 65
.meas tran vdout0_44ck12 FIND v(dout0_44) AT=65.025n

* CHECK dout0_45 Vdout0_45ck12 = 0 time = 65
.meas tran vdout0_45ck12 FIND v(dout0_45) AT=65.025n

* CHECK dout0_46 Vdout0_46ck12 = 0 time = 65
.meas tran vdout0_46ck12 FIND v(dout0_46) AT=65.025n

* CHECK dout0_47 Vdout0_47ck12 = 0.9 time = 65
.meas tran vdout0_47ck12 FIND v(dout0_47) AT=65.025n

* CHECK dout0_48 Vdout0_48ck12 = 0.9 time = 65
.meas tran vdout0_48ck12 FIND v(dout0_48) AT=65.025n

* CHECK dout0_49 Vdout0_49ck12 = 0.9 time = 65
.meas tran vdout0_49ck12 FIND v(dout0_49) AT=65.025n

* CHECK dout0_50 Vdout0_50ck12 = 0.9 time = 65
.meas tran vdout0_50ck12 FIND v(dout0_50) AT=65.025n

* CHECK dout0_51 Vdout0_51ck12 = 0.9 time = 65
.meas tran vdout0_51ck12 FIND v(dout0_51) AT=65.025n

* CHECK dout0_52 Vdout0_52ck12 = 0 time = 65
.meas tran vdout0_52ck12 FIND v(dout0_52) AT=65.025n

* CHECK dout0_53 Vdout0_53ck12 = 0 time = 65
.meas tran vdout0_53ck12 FIND v(dout0_53) AT=65.025n

* CHECK dout0_54 Vdout0_54ck12 = 0 time = 65
.meas tran vdout0_54ck12 FIND v(dout0_54) AT=65.025n

* CHECK dout0_55 Vdout0_55ck12 = 0.9 time = 65
.meas tran vdout0_55ck12 FIND v(dout0_55) AT=65.025n

* CHECK dout0_56 Vdout0_56ck12 = 0.9 time = 65
.meas tran vdout0_56ck12 FIND v(dout0_56) AT=65.025n

* CHECK dout0_57 Vdout0_57ck12 = 0 time = 65
.meas tran vdout0_57ck12 FIND v(dout0_57) AT=65.025n

* CHECK dout0_58 Vdout0_58ck12 = 0.9 time = 65
.meas tran vdout0_58ck12 FIND v(dout0_58) AT=65.025n

* CHECK dout0_59 Vdout0_59ck12 = 0 time = 65
.meas tran vdout0_59ck12 FIND v(dout0_59) AT=65.025n

* CHECK dout0_60 Vdout0_60ck12 = 0 time = 65
.meas tran vdout0_60ck12 FIND v(dout0_60) AT=65.025n

* CHECK dout0_61 Vdout0_61ck12 = 0.9 time = 65
.meas tran vdout0_61ck12 FIND v(dout0_61) AT=65.025n

* CHECK dout0_62 Vdout0_62ck12 = 0.9 time = 65
.meas tran vdout0_62ck12 FIND v(dout0_62) AT=65.025n

* CHECK dout0_63 Vdout0_63ck12 = 0.9 time = 65
.meas tran vdout0_63ck12 FIND v(dout0_63) AT=65.025n

* CHECK dout0_0 Vdout0_0ck13 = 0 time = 70
.meas tran vdout0_0ck13 FIND v(dout0_0) AT=70.025n

* CHECK dout0_1 Vdout0_1ck13 = 0 time = 70
.meas tran vdout0_1ck13 FIND v(dout0_1) AT=70.025n

* CHECK dout0_2 Vdout0_2ck13 = 0 time = 70
.meas tran vdout0_2ck13 FIND v(dout0_2) AT=70.025n

* CHECK dout0_3 Vdout0_3ck13 = 0.9 time = 70
.meas tran vdout0_3ck13 FIND v(dout0_3) AT=70.025n

* CHECK dout0_4 Vdout0_4ck13 = 0.9 time = 70
.meas tran vdout0_4ck13 FIND v(dout0_4) AT=70.025n

* CHECK dout0_5 Vdout0_5ck13 = 0 time = 70
.meas tran vdout0_5ck13 FIND v(dout0_5) AT=70.025n

* CHECK dout0_6 Vdout0_6ck13 = 0 time = 70
.meas tran vdout0_6ck13 FIND v(dout0_6) AT=70.025n

* CHECK dout0_7 Vdout0_7ck13 = 0 time = 70
.meas tran vdout0_7ck13 FIND v(dout0_7) AT=70.025n

* CHECK dout0_8 Vdout0_8ck13 = 0.9 time = 70
.meas tran vdout0_8ck13 FIND v(dout0_8) AT=70.025n

* CHECK dout0_9 Vdout0_9ck13 = 0 time = 70
.meas tran vdout0_9ck13 FIND v(dout0_9) AT=70.025n

* CHECK dout0_10 Vdout0_10ck13 = 0 time = 70
.meas tran vdout0_10ck13 FIND v(dout0_10) AT=70.025n

* CHECK dout0_11 Vdout0_11ck13 = 0 time = 70
.meas tran vdout0_11ck13 FIND v(dout0_11) AT=70.025n

* CHECK dout0_12 Vdout0_12ck13 = 0 time = 70
.meas tran vdout0_12ck13 FIND v(dout0_12) AT=70.025n

* CHECK dout0_13 Vdout0_13ck13 = 0.9 time = 70
.meas tran vdout0_13ck13 FIND v(dout0_13) AT=70.025n

* CHECK dout0_14 Vdout0_14ck13 = 0 time = 70
.meas tran vdout0_14ck13 FIND v(dout0_14) AT=70.025n

* CHECK dout0_15 Vdout0_15ck13 = 0 time = 70
.meas tran vdout0_15ck13 FIND v(dout0_15) AT=70.025n

* CHECK dout0_16 Vdout0_16ck13 = 0.9 time = 70
.meas tran vdout0_16ck13 FIND v(dout0_16) AT=70.025n

* CHECK dout0_17 Vdout0_17ck13 = 0.9 time = 70
.meas tran vdout0_17ck13 FIND v(dout0_17) AT=70.025n

* CHECK dout0_18 Vdout0_18ck13 = 0.9 time = 70
.meas tran vdout0_18ck13 FIND v(dout0_18) AT=70.025n

* CHECK dout0_19 Vdout0_19ck13 = 0.9 time = 70
.meas tran vdout0_19ck13 FIND v(dout0_19) AT=70.025n

* CHECK dout0_20 Vdout0_20ck13 = 0.9 time = 70
.meas tran vdout0_20ck13 FIND v(dout0_20) AT=70.025n

* CHECK dout0_21 Vdout0_21ck13 = 0 time = 70
.meas tran vdout0_21ck13 FIND v(dout0_21) AT=70.025n

* CHECK dout0_22 Vdout0_22ck13 = 0 time = 70
.meas tran vdout0_22ck13 FIND v(dout0_22) AT=70.025n

* CHECK dout0_23 Vdout0_23ck13 = 0.9 time = 70
.meas tran vdout0_23ck13 FIND v(dout0_23) AT=70.025n

* CHECK dout0_24 Vdout0_24ck13 = 0.9 time = 70
.meas tran vdout0_24ck13 FIND v(dout0_24) AT=70.025n

* CHECK dout0_25 Vdout0_25ck13 = 0 time = 70
.meas tran vdout0_25ck13 FIND v(dout0_25) AT=70.025n

* CHECK dout0_26 Vdout0_26ck13 = 0.9 time = 70
.meas tran vdout0_26ck13 FIND v(dout0_26) AT=70.025n

* CHECK dout0_27 Vdout0_27ck13 = 0 time = 70
.meas tran vdout0_27ck13 FIND v(dout0_27) AT=70.025n

* CHECK dout0_28 Vdout0_28ck13 = 0.9 time = 70
.meas tran vdout0_28ck13 FIND v(dout0_28) AT=70.025n

* CHECK dout0_29 Vdout0_29ck13 = 0.9 time = 70
.meas tran vdout0_29ck13 FIND v(dout0_29) AT=70.025n

* CHECK dout0_30 Vdout0_30ck13 = 0 time = 70
.meas tran vdout0_30ck13 FIND v(dout0_30) AT=70.025n

* CHECK dout0_31 Vdout0_31ck13 = 0 time = 70
.meas tran vdout0_31ck13 FIND v(dout0_31) AT=70.025n

* CHECK dout0_32 Vdout0_32ck13 = 0 time = 70
.meas tran vdout0_32ck13 FIND v(dout0_32) AT=70.025n

* CHECK dout0_33 Vdout0_33ck13 = 0 time = 70
.meas tran vdout0_33ck13 FIND v(dout0_33) AT=70.025n

* CHECK dout0_34 Vdout0_34ck13 = 0.9 time = 70
.meas tran vdout0_34ck13 FIND v(dout0_34) AT=70.025n

* CHECK dout0_35 Vdout0_35ck13 = 0.9 time = 70
.meas tran vdout0_35ck13 FIND v(dout0_35) AT=70.025n

* CHECK dout0_36 Vdout0_36ck13 = 0.9 time = 70
.meas tran vdout0_36ck13 FIND v(dout0_36) AT=70.025n

* CHECK dout0_37 Vdout0_37ck13 = 0.9 time = 70
.meas tran vdout0_37ck13 FIND v(dout0_37) AT=70.025n

* CHECK dout0_38 Vdout0_38ck13 = 0.9 time = 70
.meas tran vdout0_38ck13 FIND v(dout0_38) AT=70.025n

* CHECK dout0_39 Vdout0_39ck13 = 0.9 time = 70
.meas tran vdout0_39ck13 FIND v(dout0_39) AT=70.025n

* CHECK dout0_40 Vdout0_40ck13 = 0.9 time = 70
.meas tran vdout0_40ck13 FIND v(dout0_40) AT=70.025n

* CHECK dout0_41 Vdout0_41ck13 = 0 time = 70
.meas tran vdout0_41ck13 FIND v(dout0_41) AT=70.025n

* CHECK dout0_42 Vdout0_42ck13 = 0.9 time = 70
.meas tran vdout0_42ck13 FIND v(dout0_42) AT=70.025n

* CHECK dout0_43 Vdout0_43ck13 = 0.9 time = 70
.meas tran vdout0_43ck13 FIND v(dout0_43) AT=70.025n

* CHECK dout0_44 Vdout0_44ck13 = 0.9 time = 70
.meas tran vdout0_44ck13 FIND v(dout0_44) AT=70.025n

* CHECK dout0_45 Vdout0_45ck13 = 0.9 time = 70
.meas tran vdout0_45ck13 FIND v(dout0_45) AT=70.025n

* CHECK dout0_46 Vdout0_46ck13 = 0.9 time = 70
.meas tran vdout0_46ck13 FIND v(dout0_46) AT=70.025n

* CHECK dout0_47 Vdout0_47ck13 = 0.9 time = 70
.meas tran vdout0_47ck13 FIND v(dout0_47) AT=70.025n

* CHECK dout0_48 Vdout0_48ck13 = 0.9 time = 70
.meas tran vdout0_48ck13 FIND v(dout0_48) AT=70.025n

* CHECK dout0_49 Vdout0_49ck13 = 0.9 time = 70
.meas tran vdout0_49ck13 FIND v(dout0_49) AT=70.025n

* CHECK dout0_50 Vdout0_50ck13 = 0.9 time = 70
.meas tran vdout0_50ck13 FIND v(dout0_50) AT=70.025n

* CHECK dout0_51 Vdout0_51ck13 = 0.9 time = 70
.meas tran vdout0_51ck13 FIND v(dout0_51) AT=70.025n

* CHECK dout0_52 Vdout0_52ck13 = 0 time = 70
.meas tran vdout0_52ck13 FIND v(dout0_52) AT=70.025n

* CHECK dout0_53 Vdout0_53ck13 = 0 time = 70
.meas tran vdout0_53ck13 FIND v(dout0_53) AT=70.025n

* CHECK dout0_54 Vdout0_54ck13 = 0.9 time = 70
.meas tran vdout0_54ck13 FIND v(dout0_54) AT=70.025n

* CHECK dout0_55 Vdout0_55ck13 = 0.9 time = 70
.meas tran vdout0_55ck13 FIND v(dout0_55) AT=70.025n

* CHECK dout0_56 Vdout0_56ck13 = 0 time = 70
.meas tran vdout0_56ck13 FIND v(dout0_56) AT=70.025n

* CHECK dout0_57 Vdout0_57ck13 = 0.9 time = 70
.meas tran vdout0_57ck13 FIND v(dout0_57) AT=70.025n

* CHECK dout0_58 Vdout0_58ck13 = 0 time = 70
.meas tran vdout0_58ck13 FIND v(dout0_58) AT=70.025n

* CHECK dout0_59 Vdout0_59ck13 = 0 time = 70
.meas tran vdout0_59ck13 FIND v(dout0_59) AT=70.025n

* CHECK dout0_60 Vdout0_60ck13 = 0 time = 70
.meas tran vdout0_60ck13 FIND v(dout0_60) AT=70.025n

* CHECK dout0_61 Vdout0_61ck13 = 0.9 time = 70
.meas tran vdout0_61ck13 FIND v(dout0_61) AT=70.025n

* CHECK dout0_62 Vdout0_62ck13 = 0 time = 70
.meas tran vdout0_62ck13 FIND v(dout0_62) AT=70.025n

* CHECK dout0_63 Vdout0_63ck13 = 0.9 time = 70
.meas tran vdout0_63ck13 FIND v(dout0_63) AT=70.025n

* CHECK dout0_0 Vdout0_0ck18 = 0.9 time = 95
.meas tran vdout0_0ck18 FIND v(dout0_0) AT=95.025n

* CHECK dout0_1 Vdout0_1ck18 = 0 time = 95
.meas tran vdout0_1ck18 FIND v(dout0_1) AT=95.025n

* CHECK dout0_2 Vdout0_2ck18 = 0 time = 95
.meas tran vdout0_2ck18 FIND v(dout0_2) AT=95.025n

* CHECK dout0_3 Vdout0_3ck18 = 0 time = 95
.meas tran vdout0_3ck18 FIND v(dout0_3) AT=95.025n

* CHECK dout0_4 Vdout0_4ck18 = 0.9 time = 95
.meas tran vdout0_4ck18 FIND v(dout0_4) AT=95.025n

* CHECK dout0_5 Vdout0_5ck18 = 0 time = 95
.meas tran vdout0_5ck18 FIND v(dout0_5) AT=95.025n

* CHECK dout0_6 Vdout0_6ck18 = 0 time = 95
.meas tran vdout0_6ck18 FIND v(dout0_6) AT=95.025n

* CHECK dout0_7 Vdout0_7ck18 = 0.9 time = 95
.meas tran vdout0_7ck18 FIND v(dout0_7) AT=95.025n

* CHECK dout0_8 Vdout0_8ck18 = 0.9 time = 95
.meas tran vdout0_8ck18 FIND v(dout0_8) AT=95.025n

* CHECK dout0_9 Vdout0_9ck18 = 0.9 time = 95
.meas tran vdout0_9ck18 FIND v(dout0_9) AT=95.025n

* CHECK dout0_10 Vdout0_10ck18 = 0.9 time = 95
.meas tran vdout0_10ck18 FIND v(dout0_10) AT=95.025n

* CHECK dout0_11 Vdout0_11ck18 = 0.9 time = 95
.meas tran vdout0_11ck18 FIND v(dout0_11) AT=95.025n

* CHECK dout0_12 Vdout0_12ck18 = 0 time = 95
.meas tran vdout0_12ck18 FIND v(dout0_12) AT=95.025n

* CHECK dout0_13 Vdout0_13ck18 = 0.9 time = 95
.meas tran vdout0_13ck18 FIND v(dout0_13) AT=95.025n

* CHECK dout0_14 Vdout0_14ck18 = 0.9 time = 95
.meas tran vdout0_14ck18 FIND v(dout0_14) AT=95.025n

* CHECK dout0_15 Vdout0_15ck18 = 0.9 time = 95
.meas tran vdout0_15ck18 FIND v(dout0_15) AT=95.025n

* CHECK dout0_16 Vdout0_16ck18 = 0.9 time = 95
.meas tran vdout0_16ck18 FIND v(dout0_16) AT=95.025n

* CHECK dout0_17 Vdout0_17ck18 = 0.9 time = 95
.meas tran vdout0_17ck18 FIND v(dout0_17) AT=95.025n

* CHECK dout0_18 Vdout0_18ck18 = 0.9 time = 95
.meas tran vdout0_18ck18 FIND v(dout0_18) AT=95.025n

* CHECK dout0_19 Vdout0_19ck18 = 0 time = 95
.meas tran vdout0_19ck18 FIND v(dout0_19) AT=95.025n

* CHECK dout0_20 Vdout0_20ck18 = 0 time = 95
.meas tran vdout0_20ck18 FIND v(dout0_20) AT=95.025n

* CHECK dout0_21 Vdout0_21ck18 = 0 time = 95
.meas tran vdout0_21ck18 FIND v(dout0_21) AT=95.025n

* CHECK dout0_22 Vdout0_22ck18 = 0 time = 95
.meas tran vdout0_22ck18 FIND v(dout0_22) AT=95.025n

* CHECK dout0_23 Vdout0_23ck18 = 0.9 time = 95
.meas tran vdout0_23ck18 FIND v(dout0_23) AT=95.025n

* CHECK dout0_24 Vdout0_24ck18 = 0.9 time = 95
.meas tran vdout0_24ck18 FIND v(dout0_24) AT=95.025n

* CHECK dout0_25 Vdout0_25ck18 = 0 time = 95
.meas tran vdout0_25ck18 FIND v(dout0_25) AT=95.025n

* CHECK dout0_26 Vdout0_26ck18 = 0 time = 95
.meas tran vdout0_26ck18 FIND v(dout0_26) AT=95.025n

* CHECK dout0_27 Vdout0_27ck18 = 0.9 time = 95
.meas tran vdout0_27ck18 FIND v(dout0_27) AT=95.025n

* CHECK dout0_28 Vdout0_28ck18 = 0.9 time = 95
.meas tran vdout0_28ck18 FIND v(dout0_28) AT=95.025n

* CHECK dout0_29 Vdout0_29ck18 = 0 time = 95
.meas tran vdout0_29ck18 FIND v(dout0_29) AT=95.025n

* CHECK dout0_30 Vdout0_30ck18 = 0.9 time = 95
.meas tran vdout0_30ck18 FIND v(dout0_30) AT=95.025n

* CHECK dout0_31 Vdout0_31ck18 = 0.9 time = 95
.meas tran vdout0_31ck18 FIND v(dout0_31) AT=95.025n

* CHECK dout0_32 Vdout0_32ck18 = 0.9 time = 95
.meas tran vdout0_32ck18 FIND v(dout0_32) AT=95.025n

* CHECK dout0_33 Vdout0_33ck18 = 0 time = 95
.meas tran vdout0_33ck18 FIND v(dout0_33) AT=95.025n

* CHECK dout0_34 Vdout0_34ck18 = 0.9 time = 95
.meas tran vdout0_34ck18 FIND v(dout0_34) AT=95.025n

* CHECK dout0_35 Vdout0_35ck18 = 0.9 time = 95
.meas tran vdout0_35ck18 FIND v(dout0_35) AT=95.025n

* CHECK dout0_36 Vdout0_36ck18 = 0 time = 95
.meas tran vdout0_36ck18 FIND v(dout0_36) AT=95.025n

* CHECK dout0_37 Vdout0_37ck18 = 0 time = 95
.meas tran vdout0_37ck18 FIND v(dout0_37) AT=95.025n

* CHECK dout0_38 Vdout0_38ck18 = 0 time = 95
.meas tran vdout0_38ck18 FIND v(dout0_38) AT=95.025n

* CHECK dout0_39 Vdout0_39ck18 = 0.9 time = 95
.meas tran vdout0_39ck18 FIND v(dout0_39) AT=95.025n

* CHECK dout0_40 Vdout0_40ck18 = 0.9 time = 95
.meas tran vdout0_40ck18 FIND v(dout0_40) AT=95.025n

* CHECK dout0_41 Vdout0_41ck18 = 0 time = 95
.meas tran vdout0_41ck18 FIND v(dout0_41) AT=95.025n

* CHECK dout0_42 Vdout0_42ck18 = 0 time = 95
.meas tran vdout0_42ck18 FIND v(dout0_42) AT=95.025n

* CHECK dout0_43 Vdout0_43ck18 = 0.9 time = 95
.meas tran vdout0_43ck18 FIND v(dout0_43) AT=95.025n

* CHECK dout0_44 Vdout0_44ck18 = 0 time = 95
.meas tran vdout0_44ck18 FIND v(dout0_44) AT=95.025n

* CHECK dout0_45 Vdout0_45ck18 = 0 time = 95
.meas tran vdout0_45ck18 FIND v(dout0_45) AT=95.025n

* CHECK dout0_46 Vdout0_46ck18 = 0 time = 95
.meas tran vdout0_46ck18 FIND v(dout0_46) AT=95.025n

* CHECK dout0_47 Vdout0_47ck18 = 0.9 time = 95
.meas tran vdout0_47ck18 FIND v(dout0_47) AT=95.025n

* CHECK dout0_48 Vdout0_48ck18 = 0.9 time = 95
.meas tran vdout0_48ck18 FIND v(dout0_48) AT=95.025n

* CHECK dout0_49 Vdout0_49ck18 = 0.9 time = 95
.meas tran vdout0_49ck18 FIND v(dout0_49) AT=95.025n

* CHECK dout0_50 Vdout0_50ck18 = 0.9 time = 95
.meas tran vdout0_50ck18 FIND v(dout0_50) AT=95.025n

* CHECK dout0_51 Vdout0_51ck18 = 0.9 time = 95
.meas tran vdout0_51ck18 FIND v(dout0_51) AT=95.025n

* CHECK dout0_52 Vdout0_52ck18 = 0 time = 95
.meas tran vdout0_52ck18 FIND v(dout0_52) AT=95.025n

* CHECK dout0_53 Vdout0_53ck18 = 0 time = 95
.meas tran vdout0_53ck18 FIND v(dout0_53) AT=95.025n

* CHECK dout0_54 Vdout0_54ck18 = 0 time = 95
.meas tran vdout0_54ck18 FIND v(dout0_54) AT=95.025n

* CHECK dout0_55 Vdout0_55ck18 = 0.9 time = 95
.meas tran vdout0_55ck18 FIND v(dout0_55) AT=95.025n

* CHECK dout0_56 Vdout0_56ck18 = 0.9 time = 95
.meas tran vdout0_56ck18 FIND v(dout0_56) AT=95.025n

* CHECK dout0_57 Vdout0_57ck18 = 0 time = 95
.meas tran vdout0_57ck18 FIND v(dout0_57) AT=95.025n

* CHECK dout0_58 Vdout0_58ck18 = 0.9 time = 95
.meas tran vdout0_58ck18 FIND v(dout0_58) AT=95.025n

* CHECK dout0_59 Vdout0_59ck18 = 0 time = 95
.meas tran vdout0_59ck18 FIND v(dout0_59) AT=95.025n

* CHECK dout0_60 Vdout0_60ck18 = 0 time = 95
.meas tran vdout0_60ck18 FIND v(dout0_60) AT=95.025n

* CHECK dout0_61 Vdout0_61ck18 = 0.9 time = 95
.meas tran vdout0_61ck18 FIND v(dout0_61) AT=95.025n

* CHECK dout0_62 Vdout0_62ck18 = 0.9 time = 95
.meas tran vdout0_62ck18 FIND v(dout0_62) AT=95.025n

* CHECK dout0_63 Vdout0_63ck18 = 0.9 time = 95
.meas tran vdout0_63ck18 FIND v(dout0_63) AT=95.025n

* CHECK dout0_0 Vdout0_0ck20 = 0 time = 105
.meas tran vdout0_0ck20 FIND v(dout0_0) AT=105.025n

* CHECK dout0_1 Vdout0_1ck20 = 0 time = 105
.meas tran vdout0_1ck20 FIND v(dout0_1) AT=105.025n

* CHECK dout0_2 Vdout0_2ck20 = 0.9 time = 105
.meas tran vdout0_2ck20 FIND v(dout0_2) AT=105.025n

* CHECK dout0_3 Vdout0_3ck20 = 0 time = 105
.meas tran vdout0_3ck20 FIND v(dout0_3) AT=105.025n

* CHECK dout0_4 Vdout0_4ck20 = 0.9 time = 105
.meas tran vdout0_4ck20 FIND v(dout0_4) AT=105.025n

* CHECK dout0_5 Vdout0_5ck20 = 0.9 time = 105
.meas tran vdout0_5ck20 FIND v(dout0_5) AT=105.025n

* CHECK dout0_6 Vdout0_6ck20 = 0.9 time = 105
.meas tran vdout0_6ck20 FIND v(dout0_6) AT=105.025n

* CHECK dout0_7 Vdout0_7ck20 = 0 time = 105
.meas tran vdout0_7ck20 FIND v(dout0_7) AT=105.025n

* CHECK dout0_8 Vdout0_8ck20 = 0.9 time = 105
.meas tran vdout0_8ck20 FIND v(dout0_8) AT=105.025n

* CHECK dout0_9 Vdout0_9ck20 = 0.9 time = 105
.meas tran vdout0_9ck20 FIND v(dout0_9) AT=105.025n

* CHECK dout0_10 Vdout0_10ck20 = 0 time = 105
.meas tran vdout0_10ck20 FIND v(dout0_10) AT=105.025n

* CHECK dout0_11 Vdout0_11ck20 = 0 time = 105
.meas tran vdout0_11ck20 FIND v(dout0_11) AT=105.025n

* CHECK dout0_12 Vdout0_12ck20 = 0 time = 105
.meas tran vdout0_12ck20 FIND v(dout0_12) AT=105.025n

* CHECK dout0_13 Vdout0_13ck20 = 0 time = 105
.meas tran vdout0_13ck20 FIND v(dout0_13) AT=105.025n

* CHECK dout0_14 Vdout0_14ck20 = 0.9 time = 105
.meas tran vdout0_14ck20 FIND v(dout0_14) AT=105.025n

* CHECK dout0_15 Vdout0_15ck20 = 0 time = 105
.meas tran vdout0_15ck20 FIND v(dout0_15) AT=105.025n

* CHECK dout0_16 Vdout0_16ck20 = 0.9 time = 105
.meas tran vdout0_16ck20 FIND v(dout0_16) AT=105.025n

* CHECK dout0_17 Vdout0_17ck20 = 0.9 time = 105
.meas tran vdout0_17ck20 FIND v(dout0_17) AT=105.025n

* CHECK dout0_18 Vdout0_18ck20 = 0 time = 105
.meas tran vdout0_18ck20 FIND v(dout0_18) AT=105.025n

* CHECK dout0_19 Vdout0_19ck20 = 0.9 time = 105
.meas tran vdout0_19ck20 FIND v(dout0_19) AT=105.025n

* CHECK dout0_20 Vdout0_20ck20 = 0.9 time = 105
.meas tran vdout0_20ck20 FIND v(dout0_20) AT=105.025n

* CHECK dout0_21 Vdout0_21ck20 = 0 time = 105
.meas tran vdout0_21ck20 FIND v(dout0_21) AT=105.025n

* CHECK dout0_22 Vdout0_22ck20 = 0 time = 105
.meas tran vdout0_22ck20 FIND v(dout0_22) AT=105.025n

* CHECK dout0_23 Vdout0_23ck20 = 0.9 time = 105
.meas tran vdout0_23ck20 FIND v(dout0_23) AT=105.025n

* CHECK dout0_24 Vdout0_24ck20 = 0.9 time = 105
.meas tran vdout0_24ck20 FIND v(dout0_24) AT=105.025n

* CHECK dout0_25 Vdout0_25ck20 = 0 time = 105
.meas tran vdout0_25ck20 FIND v(dout0_25) AT=105.025n

* CHECK dout0_26 Vdout0_26ck20 = 0 time = 105
.meas tran vdout0_26ck20 FIND v(dout0_26) AT=105.025n

* CHECK dout0_27 Vdout0_27ck20 = 0.9 time = 105
.meas tran vdout0_27ck20 FIND v(dout0_27) AT=105.025n

* CHECK dout0_28 Vdout0_28ck20 = 0 time = 105
.meas tran vdout0_28ck20 FIND v(dout0_28) AT=105.025n

* CHECK dout0_29 Vdout0_29ck20 = 0.9 time = 105
.meas tran vdout0_29ck20 FIND v(dout0_29) AT=105.025n

* CHECK dout0_30 Vdout0_30ck20 = 0.9 time = 105
.meas tran vdout0_30ck20 FIND v(dout0_30) AT=105.025n

* CHECK dout0_31 Vdout0_31ck20 = 0.9 time = 105
.meas tran vdout0_31ck20 FIND v(dout0_31) AT=105.025n

* CHECK dout0_32 Vdout0_32ck20 = 0.9 time = 105
.meas tran vdout0_32ck20 FIND v(dout0_32) AT=105.025n

* CHECK dout0_33 Vdout0_33ck20 = 0.9 time = 105
.meas tran vdout0_33ck20 FIND v(dout0_33) AT=105.025n

* CHECK dout0_34 Vdout0_34ck20 = 0 time = 105
.meas tran vdout0_34ck20 FIND v(dout0_34) AT=105.025n

* CHECK dout0_35 Vdout0_35ck20 = 0 time = 105
.meas tran vdout0_35ck20 FIND v(dout0_35) AT=105.025n

* CHECK dout0_36 Vdout0_36ck20 = 0 time = 105
.meas tran vdout0_36ck20 FIND v(dout0_36) AT=105.025n

* CHECK dout0_37 Vdout0_37ck20 = 0 time = 105
.meas tran vdout0_37ck20 FIND v(dout0_37) AT=105.025n

* CHECK dout0_38 Vdout0_38ck20 = 0.9 time = 105
.meas tran vdout0_38ck20 FIND v(dout0_38) AT=105.025n

* CHECK dout0_39 Vdout0_39ck20 = 0.9 time = 105
.meas tran vdout0_39ck20 FIND v(dout0_39) AT=105.025n

* CHECK dout0_40 Vdout0_40ck20 = 0 time = 105
.meas tran vdout0_40ck20 FIND v(dout0_40) AT=105.025n

* CHECK dout0_41 Vdout0_41ck20 = 0.9 time = 105
.meas tran vdout0_41ck20 FIND v(dout0_41) AT=105.025n

* CHECK dout0_42 Vdout0_42ck20 = 0 time = 105
.meas tran vdout0_42ck20 FIND v(dout0_42) AT=105.025n

* CHECK dout0_43 Vdout0_43ck20 = 0.9 time = 105
.meas tran vdout0_43ck20 FIND v(dout0_43) AT=105.025n

* CHECK dout0_44 Vdout0_44ck20 = 0.9 time = 105
.meas tran vdout0_44ck20 FIND v(dout0_44) AT=105.025n

* CHECK dout0_45 Vdout0_45ck20 = 0.9 time = 105
.meas tran vdout0_45ck20 FIND v(dout0_45) AT=105.025n

* CHECK dout0_46 Vdout0_46ck20 = 0.9 time = 105
.meas tran vdout0_46ck20 FIND v(dout0_46) AT=105.025n

* CHECK dout0_47 Vdout0_47ck20 = 0.9 time = 105
.meas tran vdout0_47ck20 FIND v(dout0_47) AT=105.025n

* CHECK dout0_48 Vdout0_48ck20 = 0.9 time = 105
.meas tran vdout0_48ck20 FIND v(dout0_48) AT=105.025n

* CHECK dout0_49 Vdout0_49ck20 = 0 time = 105
.meas tran vdout0_49ck20 FIND v(dout0_49) AT=105.025n

* CHECK dout0_50 Vdout0_50ck20 = 0 time = 105
.meas tran vdout0_50ck20 FIND v(dout0_50) AT=105.025n

* CHECK dout0_51 Vdout0_51ck20 = 0.9 time = 105
.meas tran vdout0_51ck20 FIND v(dout0_51) AT=105.025n

* CHECK dout0_52 Vdout0_52ck20 = 0 time = 105
.meas tran vdout0_52ck20 FIND v(dout0_52) AT=105.025n

* CHECK dout0_53 Vdout0_53ck20 = 0.9 time = 105
.meas tran vdout0_53ck20 FIND v(dout0_53) AT=105.025n

* CHECK dout0_54 Vdout0_54ck20 = 0.9 time = 105
.meas tran vdout0_54ck20 FIND v(dout0_54) AT=105.025n

* CHECK dout0_55 Vdout0_55ck20 = 0.9 time = 105
.meas tran vdout0_55ck20 FIND v(dout0_55) AT=105.025n

* CHECK dout0_56 Vdout0_56ck20 = 0 time = 105
.meas tran vdout0_56ck20 FIND v(dout0_56) AT=105.025n

* CHECK dout0_57 Vdout0_57ck20 = 0 time = 105
.meas tran vdout0_57ck20 FIND v(dout0_57) AT=105.025n

* CHECK dout0_58 Vdout0_58ck20 = 0 time = 105
.meas tran vdout0_58ck20 FIND v(dout0_58) AT=105.025n

* CHECK dout0_59 Vdout0_59ck20 = 0 time = 105
.meas tran vdout0_59ck20 FIND v(dout0_59) AT=105.025n

* CHECK dout0_60 Vdout0_60ck20 = 0.9 time = 105
.meas tran vdout0_60ck20 FIND v(dout0_60) AT=105.025n

* CHECK dout0_61 Vdout0_61ck20 = 0 time = 105
.meas tran vdout0_61ck20 FIND v(dout0_61) AT=105.025n

* CHECK dout0_62 Vdout0_62ck20 = 0.9 time = 105
.meas tran vdout0_62ck20 FIND v(dout0_62) AT=105.025n

* CHECK dout0_63 Vdout0_63ck20 = 0.9 time = 105
.meas tran vdout0_63ck20 FIND v(dout0_63) AT=105.025n

* CHECK dout0_0 Vdout0_0ck21 = 0 time = 110
.meas tran vdout0_0ck21 FIND v(dout0_0) AT=110.025n

* CHECK dout0_1 Vdout0_1ck21 = 0 time = 110
.meas tran vdout0_1ck21 FIND v(dout0_1) AT=110.025n

* CHECK dout0_2 Vdout0_2ck21 = 0.9 time = 110
.meas tran vdout0_2ck21 FIND v(dout0_2) AT=110.025n

* CHECK dout0_3 Vdout0_3ck21 = 0 time = 110
.meas tran vdout0_3ck21 FIND v(dout0_3) AT=110.025n

* CHECK dout0_4 Vdout0_4ck21 = 0.9 time = 110
.meas tran vdout0_4ck21 FIND v(dout0_4) AT=110.025n

* CHECK dout0_5 Vdout0_5ck21 = 0.9 time = 110
.meas tran vdout0_5ck21 FIND v(dout0_5) AT=110.025n

* CHECK dout0_6 Vdout0_6ck21 = 0.9 time = 110
.meas tran vdout0_6ck21 FIND v(dout0_6) AT=110.025n

* CHECK dout0_7 Vdout0_7ck21 = 0 time = 110
.meas tran vdout0_7ck21 FIND v(dout0_7) AT=110.025n

* CHECK dout0_8 Vdout0_8ck21 = 0.9 time = 110
.meas tran vdout0_8ck21 FIND v(dout0_8) AT=110.025n

* CHECK dout0_9 Vdout0_9ck21 = 0.9 time = 110
.meas tran vdout0_9ck21 FIND v(dout0_9) AT=110.025n

* CHECK dout0_10 Vdout0_10ck21 = 0 time = 110
.meas tran vdout0_10ck21 FIND v(dout0_10) AT=110.025n

* CHECK dout0_11 Vdout0_11ck21 = 0 time = 110
.meas tran vdout0_11ck21 FIND v(dout0_11) AT=110.025n

* CHECK dout0_12 Vdout0_12ck21 = 0 time = 110
.meas tran vdout0_12ck21 FIND v(dout0_12) AT=110.025n

* CHECK dout0_13 Vdout0_13ck21 = 0 time = 110
.meas tran vdout0_13ck21 FIND v(dout0_13) AT=110.025n

* CHECK dout0_14 Vdout0_14ck21 = 0.9 time = 110
.meas tran vdout0_14ck21 FIND v(dout0_14) AT=110.025n

* CHECK dout0_15 Vdout0_15ck21 = 0 time = 110
.meas tran vdout0_15ck21 FIND v(dout0_15) AT=110.025n

* CHECK dout0_16 Vdout0_16ck21 = 0.9 time = 110
.meas tran vdout0_16ck21 FIND v(dout0_16) AT=110.025n

* CHECK dout0_17 Vdout0_17ck21 = 0.9 time = 110
.meas tran vdout0_17ck21 FIND v(dout0_17) AT=110.025n

* CHECK dout0_18 Vdout0_18ck21 = 0 time = 110
.meas tran vdout0_18ck21 FIND v(dout0_18) AT=110.025n

* CHECK dout0_19 Vdout0_19ck21 = 0.9 time = 110
.meas tran vdout0_19ck21 FIND v(dout0_19) AT=110.025n

* CHECK dout0_20 Vdout0_20ck21 = 0.9 time = 110
.meas tran vdout0_20ck21 FIND v(dout0_20) AT=110.025n

* CHECK dout0_21 Vdout0_21ck21 = 0 time = 110
.meas tran vdout0_21ck21 FIND v(dout0_21) AT=110.025n

* CHECK dout0_22 Vdout0_22ck21 = 0 time = 110
.meas tran vdout0_22ck21 FIND v(dout0_22) AT=110.025n

* CHECK dout0_23 Vdout0_23ck21 = 0.9 time = 110
.meas tran vdout0_23ck21 FIND v(dout0_23) AT=110.025n

* CHECK dout0_24 Vdout0_24ck21 = 0.9 time = 110
.meas tran vdout0_24ck21 FIND v(dout0_24) AT=110.025n

* CHECK dout0_25 Vdout0_25ck21 = 0 time = 110
.meas tran vdout0_25ck21 FIND v(dout0_25) AT=110.025n

* CHECK dout0_26 Vdout0_26ck21 = 0 time = 110
.meas tran vdout0_26ck21 FIND v(dout0_26) AT=110.025n

* CHECK dout0_27 Vdout0_27ck21 = 0.9 time = 110
.meas tran vdout0_27ck21 FIND v(dout0_27) AT=110.025n

* CHECK dout0_28 Vdout0_28ck21 = 0 time = 110
.meas tran vdout0_28ck21 FIND v(dout0_28) AT=110.025n

* CHECK dout0_29 Vdout0_29ck21 = 0.9 time = 110
.meas tran vdout0_29ck21 FIND v(dout0_29) AT=110.025n

* CHECK dout0_30 Vdout0_30ck21 = 0.9 time = 110
.meas tran vdout0_30ck21 FIND v(dout0_30) AT=110.025n

* CHECK dout0_31 Vdout0_31ck21 = 0.9 time = 110
.meas tran vdout0_31ck21 FIND v(dout0_31) AT=110.025n

* CHECK dout0_32 Vdout0_32ck21 = 0.9 time = 110
.meas tran vdout0_32ck21 FIND v(dout0_32) AT=110.025n

* CHECK dout0_33 Vdout0_33ck21 = 0.9 time = 110
.meas tran vdout0_33ck21 FIND v(dout0_33) AT=110.025n

* CHECK dout0_34 Vdout0_34ck21 = 0 time = 110
.meas tran vdout0_34ck21 FIND v(dout0_34) AT=110.025n

* CHECK dout0_35 Vdout0_35ck21 = 0 time = 110
.meas tran vdout0_35ck21 FIND v(dout0_35) AT=110.025n

* CHECK dout0_36 Vdout0_36ck21 = 0 time = 110
.meas tran vdout0_36ck21 FIND v(dout0_36) AT=110.025n

* CHECK dout0_37 Vdout0_37ck21 = 0 time = 110
.meas tran vdout0_37ck21 FIND v(dout0_37) AT=110.025n

* CHECK dout0_38 Vdout0_38ck21 = 0.9 time = 110
.meas tran vdout0_38ck21 FIND v(dout0_38) AT=110.025n

* CHECK dout0_39 Vdout0_39ck21 = 0.9 time = 110
.meas tran vdout0_39ck21 FIND v(dout0_39) AT=110.025n

* CHECK dout0_40 Vdout0_40ck21 = 0 time = 110
.meas tran vdout0_40ck21 FIND v(dout0_40) AT=110.025n

* CHECK dout0_41 Vdout0_41ck21 = 0.9 time = 110
.meas tran vdout0_41ck21 FIND v(dout0_41) AT=110.025n

* CHECK dout0_42 Vdout0_42ck21 = 0 time = 110
.meas tran vdout0_42ck21 FIND v(dout0_42) AT=110.025n

* CHECK dout0_43 Vdout0_43ck21 = 0.9 time = 110
.meas tran vdout0_43ck21 FIND v(dout0_43) AT=110.025n

* CHECK dout0_44 Vdout0_44ck21 = 0.9 time = 110
.meas tran vdout0_44ck21 FIND v(dout0_44) AT=110.025n

* CHECK dout0_45 Vdout0_45ck21 = 0.9 time = 110
.meas tran vdout0_45ck21 FIND v(dout0_45) AT=110.025n

* CHECK dout0_46 Vdout0_46ck21 = 0.9 time = 110
.meas tran vdout0_46ck21 FIND v(dout0_46) AT=110.025n

* CHECK dout0_47 Vdout0_47ck21 = 0.9 time = 110
.meas tran vdout0_47ck21 FIND v(dout0_47) AT=110.025n

* CHECK dout0_48 Vdout0_48ck21 = 0.9 time = 110
.meas tran vdout0_48ck21 FIND v(dout0_48) AT=110.025n

* CHECK dout0_49 Vdout0_49ck21 = 0 time = 110
.meas tran vdout0_49ck21 FIND v(dout0_49) AT=110.025n

* CHECK dout0_50 Vdout0_50ck21 = 0 time = 110
.meas tran vdout0_50ck21 FIND v(dout0_50) AT=110.025n

* CHECK dout0_51 Vdout0_51ck21 = 0.9 time = 110
.meas tran vdout0_51ck21 FIND v(dout0_51) AT=110.025n

* CHECK dout0_52 Vdout0_52ck21 = 0 time = 110
.meas tran vdout0_52ck21 FIND v(dout0_52) AT=110.025n

* CHECK dout0_53 Vdout0_53ck21 = 0.9 time = 110
.meas tran vdout0_53ck21 FIND v(dout0_53) AT=110.025n

* CHECK dout0_54 Vdout0_54ck21 = 0.9 time = 110
.meas tran vdout0_54ck21 FIND v(dout0_54) AT=110.025n

* CHECK dout0_55 Vdout0_55ck21 = 0.9 time = 110
.meas tran vdout0_55ck21 FIND v(dout0_55) AT=110.025n

* CHECK dout0_56 Vdout0_56ck21 = 0 time = 110
.meas tran vdout0_56ck21 FIND v(dout0_56) AT=110.025n

* CHECK dout0_57 Vdout0_57ck21 = 0 time = 110
.meas tran vdout0_57ck21 FIND v(dout0_57) AT=110.025n

* CHECK dout0_58 Vdout0_58ck21 = 0 time = 110
.meas tran vdout0_58ck21 FIND v(dout0_58) AT=110.025n

* CHECK dout0_59 Vdout0_59ck21 = 0 time = 110
.meas tran vdout0_59ck21 FIND v(dout0_59) AT=110.025n

* CHECK dout0_60 Vdout0_60ck21 = 0.9 time = 110
.meas tran vdout0_60ck21 FIND v(dout0_60) AT=110.025n

* CHECK dout0_61 Vdout0_61ck21 = 0 time = 110
.meas tran vdout0_61ck21 FIND v(dout0_61) AT=110.025n

* CHECK dout0_62 Vdout0_62ck21 = 0.9 time = 110
.meas tran vdout0_62ck21 FIND v(dout0_62) AT=110.025n

* CHECK dout0_63 Vdout0_63ck21 = 0.9 time = 110
.meas tran vdout0_63ck21 FIND v(dout0_63) AT=110.025n

* CHECK dout0_0 Vdout0_0ck22 = 0 time = 115
.meas tran vdout0_0ck22 FIND v(dout0_0) AT=115.025n

* CHECK dout0_1 Vdout0_1ck22 = 0 time = 115
.meas tran vdout0_1ck22 FIND v(dout0_1) AT=115.025n

* CHECK dout0_2 Vdout0_2ck22 = 0.9 time = 115
.meas tran vdout0_2ck22 FIND v(dout0_2) AT=115.025n

* CHECK dout0_3 Vdout0_3ck22 = 0 time = 115
.meas tran vdout0_3ck22 FIND v(dout0_3) AT=115.025n

* CHECK dout0_4 Vdout0_4ck22 = 0.9 time = 115
.meas tran vdout0_4ck22 FIND v(dout0_4) AT=115.025n

* CHECK dout0_5 Vdout0_5ck22 = 0 time = 115
.meas tran vdout0_5ck22 FIND v(dout0_5) AT=115.025n

* CHECK dout0_6 Vdout0_6ck22 = 0.9 time = 115
.meas tran vdout0_6ck22 FIND v(dout0_6) AT=115.025n

* CHECK dout0_7 Vdout0_7ck22 = 0 time = 115
.meas tran vdout0_7ck22 FIND v(dout0_7) AT=115.025n

* CHECK dout0_8 Vdout0_8ck22 = 0 time = 115
.meas tran vdout0_8ck22 FIND v(dout0_8) AT=115.025n

* CHECK dout0_9 Vdout0_9ck22 = 0.9 time = 115
.meas tran vdout0_9ck22 FIND v(dout0_9) AT=115.025n

* CHECK dout0_10 Vdout0_10ck22 = 0 time = 115
.meas tran vdout0_10ck22 FIND v(dout0_10) AT=115.025n

* CHECK dout0_11 Vdout0_11ck22 = 0.9 time = 115
.meas tran vdout0_11ck22 FIND v(dout0_11) AT=115.025n

* CHECK dout0_12 Vdout0_12ck22 = 0.9 time = 115
.meas tran vdout0_12ck22 FIND v(dout0_12) AT=115.025n

* CHECK dout0_13 Vdout0_13ck22 = 0.9 time = 115
.meas tran vdout0_13ck22 FIND v(dout0_13) AT=115.025n

* CHECK dout0_14 Vdout0_14ck22 = 0.9 time = 115
.meas tran vdout0_14ck22 FIND v(dout0_14) AT=115.025n

* CHECK dout0_15 Vdout0_15ck22 = 0.9 time = 115
.meas tran vdout0_15ck22 FIND v(dout0_15) AT=115.025n

* CHECK dout0_16 Vdout0_16ck22 = 0.9 time = 115
.meas tran vdout0_16ck22 FIND v(dout0_16) AT=115.025n

* CHECK dout0_17 Vdout0_17ck22 = 0 time = 115
.meas tran vdout0_17ck22 FIND v(dout0_17) AT=115.025n

* CHECK dout0_18 Vdout0_18ck22 = 0 time = 115
.meas tran vdout0_18ck22 FIND v(dout0_18) AT=115.025n

* CHECK dout0_19 Vdout0_19ck22 = 0 time = 115
.meas tran vdout0_19ck22 FIND v(dout0_19) AT=115.025n

* CHECK dout0_20 Vdout0_20ck22 = 0 time = 115
.meas tran vdout0_20ck22 FIND v(dout0_20) AT=115.025n

* CHECK dout0_21 Vdout0_21ck22 = 0.9 time = 115
.meas tran vdout0_21ck22 FIND v(dout0_21) AT=115.025n

* CHECK dout0_22 Vdout0_22ck22 = 0 time = 115
.meas tran vdout0_22ck22 FIND v(dout0_22) AT=115.025n

* CHECK dout0_23 Vdout0_23ck22 = 0 time = 115
.meas tran vdout0_23ck22 FIND v(dout0_23) AT=115.025n

* CHECK dout0_24 Vdout0_24ck22 = 0 time = 115
.meas tran vdout0_24ck22 FIND v(dout0_24) AT=115.025n

* CHECK dout0_25 Vdout0_25ck22 = 0 time = 115
.meas tran vdout0_25ck22 FIND v(dout0_25) AT=115.025n

* CHECK dout0_26 Vdout0_26ck22 = 0.9 time = 115
.meas tran vdout0_26ck22 FIND v(dout0_26) AT=115.025n

* CHECK dout0_27 Vdout0_27ck22 = 0 time = 115
.meas tran vdout0_27ck22 FIND v(dout0_27) AT=115.025n

* CHECK dout0_28 Vdout0_28ck22 = 0 time = 115
.meas tran vdout0_28ck22 FIND v(dout0_28) AT=115.025n

* CHECK dout0_29 Vdout0_29ck22 = 0.9 time = 115
.meas tran vdout0_29ck22 FIND v(dout0_29) AT=115.025n

* CHECK dout0_30 Vdout0_30ck22 = 0.9 time = 115
.meas tran vdout0_30ck22 FIND v(dout0_30) AT=115.025n

* CHECK dout0_31 Vdout0_31ck22 = 0.9 time = 115
.meas tran vdout0_31ck22 FIND v(dout0_31) AT=115.025n

* CHECK dout0_32 Vdout0_32ck22 = 0 time = 115
.meas tran vdout0_32ck22 FIND v(dout0_32) AT=115.025n

* CHECK dout0_33 Vdout0_33ck22 = 0.9 time = 115
.meas tran vdout0_33ck22 FIND v(dout0_33) AT=115.025n

* CHECK dout0_34 Vdout0_34ck22 = 0.9 time = 115
.meas tran vdout0_34ck22 FIND v(dout0_34) AT=115.025n

* CHECK dout0_35 Vdout0_35ck22 = 0.9 time = 115
.meas tran vdout0_35ck22 FIND v(dout0_35) AT=115.025n

* CHECK dout0_36 Vdout0_36ck22 = 0.9 time = 115
.meas tran vdout0_36ck22 FIND v(dout0_36) AT=115.025n

* CHECK dout0_37 Vdout0_37ck22 = 0.9 time = 115
.meas tran vdout0_37ck22 FIND v(dout0_37) AT=115.025n

* CHECK dout0_38 Vdout0_38ck22 = 0 time = 115
.meas tran vdout0_38ck22 FIND v(dout0_38) AT=115.025n

* CHECK dout0_39 Vdout0_39ck22 = 0.9 time = 115
.meas tran vdout0_39ck22 FIND v(dout0_39) AT=115.025n

* CHECK dout0_40 Vdout0_40ck22 = 0 time = 115
.meas tran vdout0_40ck22 FIND v(dout0_40) AT=115.025n

* CHECK dout0_41 Vdout0_41ck22 = 0.9 time = 115
.meas tran vdout0_41ck22 FIND v(dout0_41) AT=115.025n

* CHECK dout0_42 Vdout0_42ck22 = 0.9 time = 115
.meas tran vdout0_42ck22 FIND v(dout0_42) AT=115.025n

* CHECK dout0_43 Vdout0_43ck22 = 0 time = 115
.meas tran vdout0_43ck22 FIND v(dout0_43) AT=115.025n

* CHECK dout0_44 Vdout0_44ck22 = 0.9 time = 115
.meas tran vdout0_44ck22 FIND v(dout0_44) AT=115.025n

* CHECK dout0_45 Vdout0_45ck22 = 0 time = 115
.meas tran vdout0_45ck22 FIND v(dout0_45) AT=115.025n

* CHECK dout0_46 Vdout0_46ck22 = 0.9 time = 115
.meas tran vdout0_46ck22 FIND v(dout0_46) AT=115.025n

* CHECK dout0_47 Vdout0_47ck22 = 0 time = 115
.meas tran vdout0_47ck22 FIND v(dout0_47) AT=115.025n

* CHECK dout0_48 Vdout0_48ck22 = 0 time = 115
.meas tran vdout0_48ck22 FIND v(dout0_48) AT=115.025n

* CHECK dout0_49 Vdout0_49ck22 = 0.9 time = 115
.meas tran vdout0_49ck22 FIND v(dout0_49) AT=115.025n

* CHECK dout0_50 Vdout0_50ck22 = 0.9 time = 115
.meas tran vdout0_50ck22 FIND v(dout0_50) AT=115.025n

* CHECK dout0_51 Vdout0_51ck22 = 0.9 time = 115
.meas tran vdout0_51ck22 FIND v(dout0_51) AT=115.025n

* CHECK dout0_52 Vdout0_52ck22 = 0.9 time = 115
.meas tran vdout0_52ck22 FIND v(dout0_52) AT=115.025n

* CHECK dout0_53 Vdout0_53ck22 = 0.9 time = 115
.meas tran vdout0_53ck22 FIND v(dout0_53) AT=115.025n

* CHECK dout0_54 Vdout0_54ck22 = 0 time = 115
.meas tran vdout0_54ck22 FIND v(dout0_54) AT=115.025n

* CHECK dout0_55 Vdout0_55ck22 = 0.9 time = 115
.meas tran vdout0_55ck22 FIND v(dout0_55) AT=115.025n

* CHECK dout0_56 Vdout0_56ck22 = 0 time = 115
.meas tran vdout0_56ck22 FIND v(dout0_56) AT=115.025n

* CHECK dout0_57 Vdout0_57ck22 = 0 time = 115
.meas tran vdout0_57ck22 FIND v(dout0_57) AT=115.025n

* CHECK dout0_58 Vdout0_58ck22 = 0.9 time = 115
.meas tran vdout0_58ck22 FIND v(dout0_58) AT=115.025n

* CHECK dout0_59 Vdout0_59ck22 = 0.9 time = 115
.meas tran vdout0_59ck22 FIND v(dout0_59) AT=115.025n

* CHECK dout0_60 Vdout0_60ck22 = 0.9 time = 115
.meas tran vdout0_60ck22 FIND v(dout0_60) AT=115.025n

* CHECK dout0_61 Vdout0_61ck22 = 0 time = 115
.meas tran vdout0_61ck22 FIND v(dout0_61) AT=115.025n

* CHECK dout0_62 Vdout0_62ck22 = 0.9 time = 115
.meas tran vdout0_62ck22 FIND v(dout0_62) AT=115.025n

* CHECK dout0_63 Vdout0_63ck22 = 0 time = 115
.meas tran vdout0_63ck22 FIND v(dout0_63) AT=115.025n

* CHECK dout0_0 Vdout0_0ck23 = 0.9 time = 120
.meas tran vdout0_0ck23 FIND v(dout0_0) AT=120.025n

* CHECK dout0_1 Vdout0_1ck23 = 0 time = 120
.meas tran vdout0_1ck23 FIND v(dout0_1) AT=120.025n

* CHECK dout0_2 Vdout0_2ck23 = 0 time = 120
.meas tran vdout0_2ck23 FIND v(dout0_2) AT=120.025n

* CHECK dout0_3 Vdout0_3ck23 = 0 time = 120
.meas tran vdout0_3ck23 FIND v(dout0_3) AT=120.025n

* CHECK dout0_4 Vdout0_4ck23 = 0.9 time = 120
.meas tran vdout0_4ck23 FIND v(dout0_4) AT=120.025n

* CHECK dout0_5 Vdout0_5ck23 = 0 time = 120
.meas tran vdout0_5ck23 FIND v(dout0_5) AT=120.025n

* CHECK dout0_6 Vdout0_6ck23 = 0 time = 120
.meas tran vdout0_6ck23 FIND v(dout0_6) AT=120.025n

* CHECK dout0_7 Vdout0_7ck23 = 0.9 time = 120
.meas tran vdout0_7ck23 FIND v(dout0_7) AT=120.025n

* CHECK dout0_8 Vdout0_8ck23 = 0.9 time = 120
.meas tran vdout0_8ck23 FIND v(dout0_8) AT=120.025n

* CHECK dout0_9 Vdout0_9ck23 = 0.9 time = 120
.meas tran vdout0_9ck23 FIND v(dout0_9) AT=120.025n

* CHECK dout0_10 Vdout0_10ck23 = 0.9 time = 120
.meas tran vdout0_10ck23 FIND v(dout0_10) AT=120.025n

* CHECK dout0_11 Vdout0_11ck23 = 0.9 time = 120
.meas tran vdout0_11ck23 FIND v(dout0_11) AT=120.025n

* CHECK dout0_12 Vdout0_12ck23 = 0 time = 120
.meas tran vdout0_12ck23 FIND v(dout0_12) AT=120.025n

* CHECK dout0_13 Vdout0_13ck23 = 0.9 time = 120
.meas tran vdout0_13ck23 FIND v(dout0_13) AT=120.025n

* CHECK dout0_14 Vdout0_14ck23 = 0.9 time = 120
.meas tran vdout0_14ck23 FIND v(dout0_14) AT=120.025n

* CHECK dout0_15 Vdout0_15ck23 = 0.9 time = 120
.meas tran vdout0_15ck23 FIND v(dout0_15) AT=120.025n

* CHECK dout0_16 Vdout0_16ck23 = 0.9 time = 120
.meas tran vdout0_16ck23 FIND v(dout0_16) AT=120.025n

* CHECK dout0_17 Vdout0_17ck23 = 0.9 time = 120
.meas tran vdout0_17ck23 FIND v(dout0_17) AT=120.025n

* CHECK dout0_18 Vdout0_18ck23 = 0.9 time = 120
.meas tran vdout0_18ck23 FIND v(dout0_18) AT=120.025n

* CHECK dout0_19 Vdout0_19ck23 = 0 time = 120
.meas tran vdout0_19ck23 FIND v(dout0_19) AT=120.025n

* CHECK dout0_20 Vdout0_20ck23 = 0 time = 120
.meas tran vdout0_20ck23 FIND v(dout0_20) AT=120.025n

* CHECK dout0_21 Vdout0_21ck23 = 0 time = 120
.meas tran vdout0_21ck23 FIND v(dout0_21) AT=120.025n

* CHECK dout0_22 Vdout0_22ck23 = 0 time = 120
.meas tran vdout0_22ck23 FIND v(dout0_22) AT=120.025n

* CHECK dout0_23 Vdout0_23ck23 = 0.9 time = 120
.meas tran vdout0_23ck23 FIND v(dout0_23) AT=120.025n

* CHECK dout0_24 Vdout0_24ck23 = 0.9 time = 120
.meas tran vdout0_24ck23 FIND v(dout0_24) AT=120.025n

* CHECK dout0_25 Vdout0_25ck23 = 0 time = 120
.meas tran vdout0_25ck23 FIND v(dout0_25) AT=120.025n

* CHECK dout0_26 Vdout0_26ck23 = 0 time = 120
.meas tran vdout0_26ck23 FIND v(dout0_26) AT=120.025n

* CHECK dout0_27 Vdout0_27ck23 = 0.9 time = 120
.meas tran vdout0_27ck23 FIND v(dout0_27) AT=120.025n

* CHECK dout0_28 Vdout0_28ck23 = 0.9 time = 120
.meas tran vdout0_28ck23 FIND v(dout0_28) AT=120.025n

* CHECK dout0_29 Vdout0_29ck23 = 0 time = 120
.meas tran vdout0_29ck23 FIND v(dout0_29) AT=120.025n

* CHECK dout0_30 Vdout0_30ck23 = 0.9 time = 120
.meas tran vdout0_30ck23 FIND v(dout0_30) AT=120.025n

* CHECK dout0_31 Vdout0_31ck23 = 0.9 time = 120
.meas tran vdout0_31ck23 FIND v(dout0_31) AT=120.025n

* CHECK dout0_32 Vdout0_32ck23 = 0.9 time = 120
.meas tran vdout0_32ck23 FIND v(dout0_32) AT=120.025n

* CHECK dout0_33 Vdout0_33ck23 = 0 time = 120
.meas tran vdout0_33ck23 FIND v(dout0_33) AT=120.025n

* CHECK dout0_34 Vdout0_34ck23 = 0.9 time = 120
.meas tran vdout0_34ck23 FIND v(dout0_34) AT=120.025n

* CHECK dout0_35 Vdout0_35ck23 = 0.9 time = 120
.meas tran vdout0_35ck23 FIND v(dout0_35) AT=120.025n

* CHECK dout0_36 Vdout0_36ck23 = 0 time = 120
.meas tran vdout0_36ck23 FIND v(dout0_36) AT=120.025n

* CHECK dout0_37 Vdout0_37ck23 = 0 time = 120
.meas tran vdout0_37ck23 FIND v(dout0_37) AT=120.025n

* CHECK dout0_38 Vdout0_38ck23 = 0 time = 120
.meas tran vdout0_38ck23 FIND v(dout0_38) AT=120.025n

* CHECK dout0_39 Vdout0_39ck23 = 0.9 time = 120
.meas tran vdout0_39ck23 FIND v(dout0_39) AT=120.025n

* CHECK dout0_40 Vdout0_40ck23 = 0.9 time = 120
.meas tran vdout0_40ck23 FIND v(dout0_40) AT=120.025n

* CHECK dout0_41 Vdout0_41ck23 = 0 time = 120
.meas tran vdout0_41ck23 FIND v(dout0_41) AT=120.025n

* CHECK dout0_42 Vdout0_42ck23 = 0 time = 120
.meas tran vdout0_42ck23 FIND v(dout0_42) AT=120.025n

* CHECK dout0_43 Vdout0_43ck23 = 0.9 time = 120
.meas tran vdout0_43ck23 FIND v(dout0_43) AT=120.025n

* CHECK dout0_44 Vdout0_44ck23 = 0 time = 120
.meas tran vdout0_44ck23 FIND v(dout0_44) AT=120.025n

* CHECK dout0_45 Vdout0_45ck23 = 0 time = 120
.meas tran vdout0_45ck23 FIND v(dout0_45) AT=120.025n

* CHECK dout0_46 Vdout0_46ck23 = 0 time = 120
.meas tran vdout0_46ck23 FIND v(dout0_46) AT=120.025n

* CHECK dout0_47 Vdout0_47ck23 = 0.9 time = 120
.meas tran vdout0_47ck23 FIND v(dout0_47) AT=120.025n

* CHECK dout0_48 Vdout0_48ck23 = 0.9 time = 120
.meas tran vdout0_48ck23 FIND v(dout0_48) AT=120.025n

* CHECK dout0_49 Vdout0_49ck23 = 0.9 time = 120
.meas tran vdout0_49ck23 FIND v(dout0_49) AT=120.025n

* CHECK dout0_50 Vdout0_50ck23 = 0.9 time = 120
.meas tran vdout0_50ck23 FIND v(dout0_50) AT=120.025n

* CHECK dout0_51 Vdout0_51ck23 = 0.9 time = 120
.meas tran vdout0_51ck23 FIND v(dout0_51) AT=120.025n

* CHECK dout0_52 Vdout0_52ck23 = 0 time = 120
.meas tran vdout0_52ck23 FIND v(dout0_52) AT=120.025n

* CHECK dout0_53 Vdout0_53ck23 = 0 time = 120
.meas tran vdout0_53ck23 FIND v(dout0_53) AT=120.025n

* CHECK dout0_54 Vdout0_54ck23 = 0 time = 120
.meas tran vdout0_54ck23 FIND v(dout0_54) AT=120.025n

* CHECK dout0_55 Vdout0_55ck23 = 0.9 time = 120
.meas tran vdout0_55ck23 FIND v(dout0_55) AT=120.025n

* CHECK dout0_56 Vdout0_56ck23 = 0.9 time = 120
.meas tran vdout0_56ck23 FIND v(dout0_56) AT=120.025n

* CHECK dout0_57 Vdout0_57ck23 = 0 time = 120
.meas tran vdout0_57ck23 FIND v(dout0_57) AT=120.025n

* CHECK dout0_58 Vdout0_58ck23 = 0.9 time = 120
.meas tran vdout0_58ck23 FIND v(dout0_58) AT=120.025n

* CHECK dout0_59 Vdout0_59ck23 = 0 time = 120
.meas tran vdout0_59ck23 FIND v(dout0_59) AT=120.025n

* CHECK dout0_60 Vdout0_60ck23 = 0 time = 120
.meas tran vdout0_60ck23 FIND v(dout0_60) AT=120.025n

* CHECK dout0_61 Vdout0_61ck23 = 0.9 time = 120
.meas tran vdout0_61ck23 FIND v(dout0_61) AT=120.025n

* CHECK dout0_62 Vdout0_62ck23 = 0.9 time = 120
.meas tran vdout0_62ck23 FIND v(dout0_62) AT=120.025n

* CHECK dout0_63 Vdout0_63ck23 = 0.9 time = 120
.meas tran vdout0_63ck23 FIND v(dout0_63) AT=120.025n

* CHECK dout0_0 Vdout0_0ck24 = 0 time = 125
.meas tran vdout0_0ck24 FIND v(dout0_0) AT=125.025n

* CHECK dout0_1 Vdout0_1ck24 = 0 time = 125
.meas tran vdout0_1ck24 FIND v(dout0_1) AT=125.025n

* CHECK dout0_2 Vdout0_2ck24 = 0 time = 125
.meas tran vdout0_2ck24 FIND v(dout0_2) AT=125.025n

* CHECK dout0_3 Vdout0_3ck24 = 0.9 time = 125
.meas tran vdout0_3ck24 FIND v(dout0_3) AT=125.025n

* CHECK dout0_4 Vdout0_4ck24 = 0.9 time = 125
.meas tran vdout0_4ck24 FIND v(dout0_4) AT=125.025n

* CHECK dout0_5 Vdout0_5ck24 = 0 time = 125
.meas tran vdout0_5ck24 FIND v(dout0_5) AT=125.025n

* CHECK dout0_6 Vdout0_6ck24 = 0 time = 125
.meas tran vdout0_6ck24 FIND v(dout0_6) AT=125.025n

* CHECK dout0_7 Vdout0_7ck24 = 0 time = 125
.meas tran vdout0_7ck24 FIND v(dout0_7) AT=125.025n

* CHECK dout0_8 Vdout0_8ck24 = 0.9 time = 125
.meas tran vdout0_8ck24 FIND v(dout0_8) AT=125.025n

* CHECK dout0_9 Vdout0_9ck24 = 0 time = 125
.meas tran vdout0_9ck24 FIND v(dout0_9) AT=125.025n

* CHECK dout0_10 Vdout0_10ck24 = 0 time = 125
.meas tran vdout0_10ck24 FIND v(dout0_10) AT=125.025n

* CHECK dout0_11 Vdout0_11ck24 = 0 time = 125
.meas tran vdout0_11ck24 FIND v(dout0_11) AT=125.025n

* CHECK dout0_12 Vdout0_12ck24 = 0 time = 125
.meas tran vdout0_12ck24 FIND v(dout0_12) AT=125.025n

* CHECK dout0_13 Vdout0_13ck24 = 0.9 time = 125
.meas tran vdout0_13ck24 FIND v(dout0_13) AT=125.025n

* CHECK dout0_14 Vdout0_14ck24 = 0 time = 125
.meas tran vdout0_14ck24 FIND v(dout0_14) AT=125.025n

* CHECK dout0_15 Vdout0_15ck24 = 0 time = 125
.meas tran vdout0_15ck24 FIND v(dout0_15) AT=125.025n

* CHECK dout0_16 Vdout0_16ck24 = 0.9 time = 125
.meas tran vdout0_16ck24 FIND v(dout0_16) AT=125.025n

* CHECK dout0_17 Vdout0_17ck24 = 0.9 time = 125
.meas tran vdout0_17ck24 FIND v(dout0_17) AT=125.025n

* CHECK dout0_18 Vdout0_18ck24 = 0.9 time = 125
.meas tran vdout0_18ck24 FIND v(dout0_18) AT=125.025n

* CHECK dout0_19 Vdout0_19ck24 = 0.9 time = 125
.meas tran vdout0_19ck24 FIND v(dout0_19) AT=125.025n

* CHECK dout0_20 Vdout0_20ck24 = 0.9 time = 125
.meas tran vdout0_20ck24 FIND v(dout0_20) AT=125.025n

* CHECK dout0_21 Vdout0_21ck24 = 0 time = 125
.meas tran vdout0_21ck24 FIND v(dout0_21) AT=125.025n

* CHECK dout0_22 Vdout0_22ck24 = 0 time = 125
.meas tran vdout0_22ck24 FIND v(dout0_22) AT=125.025n

* CHECK dout0_23 Vdout0_23ck24 = 0.9 time = 125
.meas tran vdout0_23ck24 FIND v(dout0_23) AT=125.025n

* CHECK dout0_24 Vdout0_24ck24 = 0.9 time = 125
.meas tran vdout0_24ck24 FIND v(dout0_24) AT=125.025n

* CHECK dout0_25 Vdout0_25ck24 = 0 time = 125
.meas tran vdout0_25ck24 FIND v(dout0_25) AT=125.025n

* CHECK dout0_26 Vdout0_26ck24 = 0.9 time = 125
.meas tran vdout0_26ck24 FIND v(dout0_26) AT=125.025n

* CHECK dout0_27 Vdout0_27ck24 = 0 time = 125
.meas tran vdout0_27ck24 FIND v(dout0_27) AT=125.025n

* CHECK dout0_28 Vdout0_28ck24 = 0.9 time = 125
.meas tran vdout0_28ck24 FIND v(dout0_28) AT=125.025n

* CHECK dout0_29 Vdout0_29ck24 = 0.9 time = 125
.meas tran vdout0_29ck24 FIND v(dout0_29) AT=125.025n

* CHECK dout0_30 Vdout0_30ck24 = 0 time = 125
.meas tran vdout0_30ck24 FIND v(dout0_30) AT=125.025n

* CHECK dout0_31 Vdout0_31ck24 = 0 time = 125
.meas tran vdout0_31ck24 FIND v(dout0_31) AT=125.025n

* CHECK dout0_32 Vdout0_32ck24 = 0 time = 125
.meas tran vdout0_32ck24 FIND v(dout0_32) AT=125.025n

* CHECK dout0_33 Vdout0_33ck24 = 0 time = 125
.meas tran vdout0_33ck24 FIND v(dout0_33) AT=125.025n

* CHECK dout0_34 Vdout0_34ck24 = 0.9 time = 125
.meas tran vdout0_34ck24 FIND v(dout0_34) AT=125.025n

* CHECK dout0_35 Vdout0_35ck24 = 0.9 time = 125
.meas tran vdout0_35ck24 FIND v(dout0_35) AT=125.025n

* CHECK dout0_36 Vdout0_36ck24 = 0.9 time = 125
.meas tran vdout0_36ck24 FIND v(dout0_36) AT=125.025n

* CHECK dout0_37 Vdout0_37ck24 = 0.9 time = 125
.meas tran vdout0_37ck24 FIND v(dout0_37) AT=125.025n

* CHECK dout0_38 Vdout0_38ck24 = 0.9 time = 125
.meas tran vdout0_38ck24 FIND v(dout0_38) AT=125.025n

* CHECK dout0_39 Vdout0_39ck24 = 0.9 time = 125
.meas tran vdout0_39ck24 FIND v(dout0_39) AT=125.025n

* CHECK dout0_40 Vdout0_40ck24 = 0.9 time = 125
.meas tran vdout0_40ck24 FIND v(dout0_40) AT=125.025n

* CHECK dout0_41 Vdout0_41ck24 = 0 time = 125
.meas tran vdout0_41ck24 FIND v(dout0_41) AT=125.025n

* CHECK dout0_42 Vdout0_42ck24 = 0.9 time = 125
.meas tran vdout0_42ck24 FIND v(dout0_42) AT=125.025n

* CHECK dout0_43 Vdout0_43ck24 = 0.9 time = 125
.meas tran vdout0_43ck24 FIND v(dout0_43) AT=125.025n

* CHECK dout0_44 Vdout0_44ck24 = 0.9 time = 125
.meas tran vdout0_44ck24 FIND v(dout0_44) AT=125.025n

* CHECK dout0_45 Vdout0_45ck24 = 0.9 time = 125
.meas tran vdout0_45ck24 FIND v(dout0_45) AT=125.025n

* CHECK dout0_46 Vdout0_46ck24 = 0.9 time = 125
.meas tran vdout0_46ck24 FIND v(dout0_46) AT=125.025n

* CHECK dout0_47 Vdout0_47ck24 = 0.9 time = 125
.meas tran vdout0_47ck24 FIND v(dout0_47) AT=125.025n

* CHECK dout0_48 Vdout0_48ck24 = 0.9 time = 125
.meas tran vdout0_48ck24 FIND v(dout0_48) AT=125.025n

* CHECK dout0_49 Vdout0_49ck24 = 0.9 time = 125
.meas tran vdout0_49ck24 FIND v(dout0_49) AT=125.025n

* CHECK dout0_50 Vdout0_50ck24 = 0.9 time = 125
.meas tran vdout0_50ck24 FIND v(dout0_50) AT=125.025n

* CHECK dout0_51 Vdout0_51ck24 = 0.9 time = 125
.meas tran vdout0_51ck24 FIND v(dout0_51) AT=125.025n

* CHECK dout0_52 Vdout0_52ck24 = 0 time = 125
.meas tran vdout0_52ck24 FIND v(dout0_52) AT=125.025n

* CHECK dout0_53 Vdout0_53ck24 = 0 time = 125
.meas tran vdout0_53ck24 FIND v(dout0_53) AT=125.025n

* CHECK dout0_54 Vdout0_54ck24 = 0.9 time = 125
.meas tran vdout0_54ck24 FIND v(dout0_54) AT=125.025n

* CHECK dout0_55 Vdout0_55ck24 = 0.9 time = 125
.meas tran vdout0_55ck24 FIND v(dout0_55) AT=125.025n

* CHECK dout0_56 Vdout0_56ck24 = 0 time = 125
.meas tran vdout0_56ck24 FIND v(dout0_56) AT=125.025n

* CHECK dout0_57 Vdout0_57ck24 = 0.9 time = 125
.meas tran vdout0_57ck24 FIND v(dout0_57) AT=125.025n

* CHECK dout0_58 Vdout0_58ck24 = 0 time = 125
.meas tran vdout0_58ck24 FIND v(dout0_58) AT=125.025n

* CHECK dout0_59 Vdout0_59ck24 = 0 time = 125
.meas tran vdout0_59ck24 FIND v(dout0_59) AT=125.025n

* CHECK dout0_60 Vdout0_60ck24 = 0 time = 125
.meas tran vdout0_60ck24 FIND v(dout0_60) AT=125.025n

* CHECK dout0_61 Vdout0_61ck24 = 0.9 time = 125
.meas tran vdout0_61ck24 FIND v(dout0_61) AT=125.025n

* CHECK dout0_62 Vdout0_62ck24 = 0 time = 125
.meas tran vdout0_62ck24 FIND v(dout0_62) AT=125.025n

* CHECK dout0_63 Vdout0_63ck24 = 0.9 time = 125
.meas tran vdout0_63ck24 FIND v(dout0_63) AT=125.025n

* CHECK dout0_0 Vdout0_0ck28 = 0 time = 145
.meas tran vdout0_0ck28 FIND v(dout0_0) AT=145.025n

* CHECK dout0_1 Vdout0_1ck28 = 0 time = 145
.meas tran vdout0_1ck28 FIND v(dout0_1) AT=145.025n

* CHECK dout0_2 Vdout0_2ck28 = 0.9 time = 145
.meas tran vdout0_2ck28 FIND v(dout0_2) AT=145.025n

* CHECK dout0_3 Vdout0_3ck28 = 0 time = 145
.meas tran vdout0_3ck28 FIND v(dout0_3) AT=145.025n

* CHECK dout0_4 Vdout0_4ck28 = 0.9 time = 145
.meas tran vdout0_4ck28 FIND v(dout0_4) AT=145.025n

* CHECK dout0_5 Vdout0_5ck28 = 0 time = 145
.meas tran vdout0_5ck28 FIND v(dout0_5) AT=145.025n

* CHECK dout0_6 Vdout0_6ck28 = 0.9 time = 145
.meas tran vdout0_6ck28 FIND v(dout0_6) AT=145.025n

* CHECK dout0_7 Vdout0_7ck28 = 0 time = 145
.meas tran vdout0_7ck28 FIND v(dout0_7) AT=145.025n

* CHECK dout0_8 Vdout0_8ck28 = 0 time = 145
.meas tran vdout0_8ck28 FIND v(dout0_8) AT=145.025n

* CHECK dout0_9 Vdout0_9ck28 = 0.9 time = 145
.meas tran vdout0_9ck28 FIND v(dout0_9) AT=145.025n

* CHECK dout0_10 Vdout0_10ck28 = 0 time = 145
.meas tran vdout0_10ck28 FIND v(dout0_10) AT=145.025n

* CHECK dout0_11 Vdout0_11ck28 = 0.9 time = 145
.meas tran vdout0_11ck28 FIND v(dout0_11) AT=145.025n

* CHECK dout0_12 Vdout0_12ck28 = 0.9 time = 145
.meas tran vdout0_12ck28 FIND v(dout0_12) AT=145.025n

* CHECK dout0_13 Vdout0_13ck28 = 0.9 time = 145
.meas tran vdout0_13ck28 FIND v(dout0_13) AT=145.025n

* CHECK dout0_14 Vdout0_14ck28 = 0.9 time = 145
.meas tran vdout0_14ck28 FIND v(dout0_14) AT=145.025n

* CHECK dout0_15 Vdout0_15ck28 = 0.9 time = 145
.meas tran vdout0_15ck28 FIND v(dout0_15) AT=145.025n

* CHECK dout0_16 Vdout0_16ck28 = 0.9 time = 145
.meas tran vdout0_16ck28 FIND v(dout0_16) AT=145.025n

* CHECK dout0_17 Vdout0_17ck28 = 0 time = 145
.meas tran vdout0_17ck28 FIND v(dout0_17) AT=145.025n

* CHECK dout0_18 Vdout0_18ck28 = 0 time = 145
.meas tran vdout0_18ck28 FIND v(dout0_18) AT=145.025n

* CHECK dout0_19 Vdout0_19ck28 = 0 time = 145
.meas tran vdout0_19ck28 FIND v(dout0_19) AT=145.025n

* CHECK dout0_20 Vdout0_20ck28 = 0 time = 145
.meas tran vdout0_20ck28 FIND v(dout0_20) AT=145.025n

* CHECK dout0_21 Vdout0_21ck28 = 0.9 time = 145
.meas tran vdout0_21ck28 FIND v(dout0_21) AT=145.025n

* CHECK dout0_22 Vdout0_22ck28 = 0 time = 145
.meas tran vdout0_22ck28 FIND v(dout0_22) AT=145.025n

* CHECK dout0_23 Vdout0_23ck28 = 0 time = 145
.meas tran vdout0_23ck28 FIND v(dout0_23) AT=145.025n

* CHECK dout0_24 Vdout0_24ck28 = 0 time = 145
.meas tran vdout0_24ck28 FIND v(dout0_24) AT=145.025n

* CHECK dout0_25 Vdout0_25ck28 = 0 time = 145
.meas tran vdout0_25ck28 FIND v(dout0_25) AT=145.025n

* CHECK dout0_26 Vdout0_26ck28 = 0.9 time = 145
.meas tran vdout0_26ck28 FIND v(dout0_26) AT=145.025n

* CHECK dout0_27 Vdout0_27ck28 = 0 time = 145
.meas tran vdout0_27ck28 FIND v(dout0_27) AT=145.025n

* CHECK dout0_28 Vdout0_28ck28 = 0 time = 145
.meas tran vdout0_28ck28 FIND v(dout0_28) AT=145.025n

* CHECK dout0_29 Vdout0_29ck28 = 0.9 time = 145
.meas tran vdout0_29ck28 FIND v(dout0_29) AT=145.025n

* CHECK dout0_30 Vdout0_30ck28 = 0.9 time = 145
.meas tran vdout0_30ck28 FIND v(dout0_30) AT=145.025n

* CHECK dout0_31 Vdout0_31ck28 = 0.9 time = 145
.meas tran vdout0_31ck28 FIND v(dout0_31) AT=145.025n

* CHECK dout0_32 Vdout0_32ck28 = 0 time = 145
.meas tran vdout0_32ck28 FIND v(dout0_32) AT=145.025n

* CHECK dout0_33 Vdout0_33ck28 = 0.9 time = 145
.meas tran vdout0_33ck28 FIND v(dout0_33) AT=145.025n

* CHECK dout0_34 Vdout0_34ck28 = 0.9 time = 145
.meas tran vdout0_34ck28 FIND v(dout0_34) AT=145.025n

* CHECK dout0_35 Vdout0_35ck28 = 0.9 time = 145
.meas tran vdout0_35ck28 FIND v(dout0_35) AT=145.025n

* CHECK dout0_36 Vdout0_36ck28 = 0.9 time = 145
.meas tran vdout0_36ck28 FIND v(dout0_36) AT=145.025n

* CHECK dout0_37 Vdout0_37ck28 = 0.9 time = 145
.meas tran vdout0_37ck28 FIND v(dout0_37) AT=145.025n

* CHECK dout0_38 Vdout0_38ck28 = 0 time = 145
.meas tran vdout0_38ck28 FIND v(dout0_38) AT=145.025n

* CHECK dout0_39 Vdout0_39ck28 = 0.9 time = 145
.meas tran vdout0_39ck28 FIND v(dout0_39) AT=145.025n

* CHECK dout0_40 Vdout0_40ck28 = 0 time = 145
.meas tran vdout0_40ck28 FIND v(dout0_40) AT=145.025n

* CHECK dout0_41 Vdout0_41ck28 = 0.9 time = 145
.meas tran vdout0_41ck28 FIND v(dout0_41) AT=145.025n

* CHECK dout0_42 Vdout0_42ck28 = 0.9 time = 145
.meas tran vdout0_42ck28 FIND v(dout0_42) AT=145.025n

* CHECK dout0_43 Vdout0_43ck28 = 0 time = 145
.meas tran vdout0_43ck28 FIND v(dout0_43) AT=145.025n

* CHECK dout0_44 Vdout0_44ck28 = 0.9 time = 145
.meas tran vdout0_44ck28 FIND v(dout0_44) AT=145.025n

* CHECK dout0_45 Vdout0_45ck28 = 0 time = 145
.meas tran vdout0_45ck28 FIND v(dout0_45) AT=145.025n

* CHECK dout0_46 Vdout0_46ck28 = 0.9 time = 145
.meas tran vdout0_46ck28 FIND v(dout0_46) AT=145.025n

* CHECK dout0_47 Vdout0_47ck28 = 0 time = 145
.meas tran vdout0_47ck28 FIND v(dout0_47) AT=145.025n

* CHECK dout0_48 Vdout0_48ck28 = 0 time = 145
.meas tran vdout0_48ck28 FIND v(dout0_48) AT=145.025n

* CHECK dout0_49 Vdout0_49ck28 = 0.9 time = 145
.meas tran vdout0_49ck28 FIND v(dout0_49) AT=145.025n

* CHECK dout0_50 Vdout0_50ck28 = 0.9 time = 145
.meas tran vdout0_50ck28 FIND v(dout0_50) AT=145.025n

* CHECK dout0_51 Vdout0_51ck28 = 0.9 time = 145
.meas tran vdout0_51ck28 FIND v(dout0_51) AT=145.025n

* CHECK dout0_52 Vdout0_52ck28 = 0.9 time = 145
.meas tran vdout0_52ck28 FIND v(dout0_52) AT=145.025n

* CHECK dout0_53 Vdout0_53ck28 = 0.9 time = 145
.meas tran vdout0_53ck28 FIND v(dout0_53) AT=145.025n

* CHECK dout0_54 Vdout0_54ck28 = 0 time = 145
.meas tran vdout0_54ck28 FIND v(dout0_54) AT=145.025n

* CHECK dout0_55 Vdout0_55ck28 = 0.9 time = 145
.meas tran vdout0_55ck28 FIND v(dout0_55) AT=145.025n

* CHECK dout0_56 Vdout0_56ck28 = 0 time = 145
.meas tran vdout0_56ck28 FIND v(dout0_56) AT=145.025n

* CHECK dout0_57 Vdout0_57ck28 = 0 time = 145
.meas tran vdout0_57ck28 FIND v(dout0_57) AT=145.025n

* CHECK dout0_58 Vdout0_58ck28 = 0.9 time = 145
.meas tran vdout0_58ck28 FIND v(dout0_58) AT=145.025n

* CHECK dout0_59 Vdout0_59ck28 = 0.9 time = 145
.meas tran vdout0_59ck28 FIND v(dout0_59) AT=145.025n

* CHECK dout0_60 Vdout0_60ck28 = 0.9 time = 145
.meas tran vdout0_60ck28 FIND v(dout0_60) AT=145.025n

* CHECK dout0_61 Vdout0_61ck28 = 0 time = 145
.meas tran vdout0_61ck28 FIND v(dout0_61) AT=145.025n

* CHECK dout0_62 Vdout0_62ck28 = 0.9 time = 145
.meas tran vdout0_62ck28 FIND v(dout0_62) AT=145.025n

* CHECK dout0_63 Vdout0_63ck28 = 0 time = 145
.meas tran vdout0_63ck28 FIND v(dout0_63) AT=145.025n

* CHECK dout0_0 Vdout0_0ck29 = 0 time = 150
.meas tran vdout0_0ck29 FIND v(dout0_0) AT=150.025n

* CHECK dout0_1 Vdout0_1ck29 = 0 time = 150
.meas tran vdout0_1ck29 FIND v(dout0_1) AT=150.025n

* CHECK dout0_2 Vdout0_2ck29 = 0 time = 150
.meas tran vdout0_2ck29 FIND v(dout0_2) AT=150.025n

* CHECK dout0_3 Vdout0_3ck29 = 0.9 time = 150
.meas tran vdout0_3ck29 FIND v(dout0_3) AT=150.025n

* CHECK dout0_4 Vdout0_4ck29 = 0.9 time = 150
.meas tran vdout0_4ck29 FIND v(dout0_4) AT=150.025n

* CHECK dout0_5 Vdout0_5ck29 = 0 time = 150
.meas tran vdout0_5ck29 FIND v(dout0_5) AT=150.025n

* CHECK dout0_6 Vdout0_6ck29 = 0 time = 150
.meas tran vdout0_6ck29 FIND v(dout0_6) AT=150.025n

* CHECK dout0_7 Vdout0_7ck29 = 0 time = 150
.meas tran vdout0_7ck29 FIND v(dout0_7) AT=150.025n

* CHECK dout0_8 Vdout0_8ck29 = 0.9 time = 150
.meas tran vdout0_8ck29 FIND v(dout0_8) AT=150.025n

* CHECK dout0_9 Vdout0_9ck29 = 0 time = 150
.meas tran vdout0_9ck29 FIND v(dout0_9) AT=150.025n

* CHECK dout0_10 Vdout0_10ck29 = 0 time = 150
.meas tran vdout0_10ck29 FIND v(dout0_10) AT=150.025n

* CHECK dout0_11 Vdout0_11ck29 = 0 time = 150
.meas tran vdout0_11ck29 FIND v(dout0_11) AT=150.025n

* CHECK dout0_12 Vdout0_12ck29 = 0 time = 150
.meas tran vdout0_12ck29 FIND v(dout0_12) AT=150.025n

* CHECK dout0_13 Vdout0_13ck29 = 0.9 time = 150
.meas tran vdout0_13ck29 FIND v(dout0_13) AT=150.025n

* CHECK dout0_14 Vdout0_14ck29 = 0 time = 150
.meas tran vdout0_14ck29 FIND v(dout0_14) AT=150.025n

* CHECK dout0_15 Vdout0_15ck29 = 0 time = 150
.meas tran vdout0_15ck29 FIND v(dout0_15) AT=150.025n

* CHECK dout0_16 Vdout0_16ck29 = 0.9 time = 150
.meas tran vdout0_16ck29 FIND v(dout0_16) AT=150.025n

* CHECK dout0_17 Vdout0_17ck29 = 0.9 time = 150
.meas tran vdout0_17ck29 FIND v(dout0_17) AT=150.025n

* CHECK dout0_18 Vdout0_18ck29 = 0.9 time = 150
.meas tran vdout0_18ck29 FIND v(dout0_18) AT=150.025n

* CHECK dout0_19 Vdout0_19ck29 = 0.9 time = 150
.meas tran vdout0_19ck29 FIND v(dout0_19) AT=150.025n

* CHECK dout0_20 Vdout0_20ck29 = 0.9 time = 150
.meas tran vdout0_20ck29 FIND v(dout0_20) AT=150.025n

* CHECK dout0_21 Vdout0_21ck29 = 0 time = 150
.meas tran vdout0_21ck29 FIND v(dout0_21) AT=150.025n

* CHECK dout0_22 Vdout0_22ck29 = 0 time = 150
.meas tran vdout0_22ck29 FIND v(dout0_22) AT=150.025n

* CHECK dout0_23 Vdout0_23ck29 = 0.9 time = 150
.meas tran vdout0_23ck29 FIND v(dout0_23) AT=150.025n

* CHECK dout0_24 Vdout0_24ck29 = 0.9 time = 150
.meas tran vdout0_24ck29 FIND v(dout0_24) AT=150.025n

* CHECK dout0_25 Vdout0_25ck29 = 0 time = 150
.meas tran vdout0_25ck29 FIND v(dout0_25) AT=150.025n

* CHECK dout0_26 Vdout0_26ck29 = 0.9 time = 150
.meas tran vdout0_26ck29 FIND v(dout0_26) AT=150.025n

* CHECK dout0_27 Vdout0_27ck29 = 0 time = 150
.meas tran vdout0_27ck29 FIND v(dout0_27) AT=150.025n

* CHECK dout0_28 Vdout0_28ck29 = 0.9 time = 150
.meas tran vdout0_28ck29 FIND v(dout0_28) AT=150.025n

* CHECK dout0_29 Vdout0_29ck29 = 0.9 time = 150
.meas tran vdout0_29ck29 FIND v(dout0_29) AT=150.025n

* CHECK dout0_30 Vdout0_30ck29 = 0 time = 150
.meas tran vdout0_30ck29 FIND v(dout0_30) AT=150.025n

* CHECK dout0_31 Vdout0_31ck29 = 0 time = 150
.meas tran vdout0_31ck29 FIND v(dout0_31) AT=150.025n

* CHECK dout0_32 Vdout0_32ck29 = 0 time = 150
.meas tran vdout0_32ck29 FIND v(dout0_32) AT=150.025n

* CHECK dout0_33 Vdout0_33ck29 = 0 time = 150
.meas tran vdout0_33ck29 FIND v(dout0_33) AT=150.025n

* CHECK dout0_34 Vdout0_34ck29 = 0.9 time = 150
.meas tran vdout0_34ck29 FIND v(dout0_34) AT=150.025n

* CHECK dout0_35 Vdout0_35ck29 = 0.9 time = 150
.meas tran vdout0_35ck29 FIND v(dout0_35) AT=150.025n

* CHECK dout0_36 Vdout0_36ck29 = 0.9 time = 150
.meas tran vdout0_36ck29 FIND v(dout0_36) AT=150.025n

* CHECK dout0_37 Vdout0_37ck29 = 0.9 time = 150
.meas tran vdout0_37ck29 FIND v(dout0_37) AT=150.025n

* CHECK dout0_38 Vdout0_38ck29 = 0.9 time = 150
.meas tran vdout0_38ck29 FIND v(dout0_38) AT=150.025n

* CHECK dout0_39 Vdout0_39ck29 = 0.9 time = 150
.meas tran vdout0_39ck29 FIND v(dout0_39) AT=150.025n

* CHECK dout0_40 Vdout0_40ck29 = 0.9 time = 150
.meas tran vdout0_40ck29 FIND v(dout0_40) AT=150.025n

* CHECK dout0_41 Vdout0_41ck29 = 0 time = 150
.meas tran vdout0_41ck29 FIND v(dout0_41) AT=150.025n

* CHECK dout0_42 Vdout0_42ck29 = 0.9 time = 150
.meas tran vdout0_42ck29 FIND v(dout0_42) AT=150.025n

* CHECK dout0_43 Vdout0_43ck29 = 0.9 time = 150
.meas tran vdout0_43ck29 FIND v(dout0_43) AT=150.025n

* CHECK dout0_44 Vdout0_44ck29 = 0.9 time = 150
.meas tran vdout0_44ck29 FIND v(dout0_44) AT=150.025n

* CHECK dout0_45 Vdout0_45ck29 = 0.9 time = 150
.meas tran vdout0_45ck29 FIND v(dout0_45) AT=150.025n

* CHECK dout0_46 Vdout0_46ck29 = 0.9 time = 150
.meas tran vdout0_46ck29 FIND v(dout0_46) AT=150.025n

* CHECK dout0_47 Vdout0_47ck29 = 0.9 time = 150
.meas tran vdout0_47ck29 FIND v(dout0_47) AT=150.025n

* CHECK dout0_48 Vdout0_48ck29 = 0.9 time = 150
.meas tran vdout0_48ck29 FIND v(dout0_48) AT=150.025n

* CHECK dout0_49 Vdout0_49ck29 = 0.9 time = 150
.meas tran vdout0_49ck29 FIND v(dout0_49) AT=150.025n

* CHECK dout0_50 Vdout0_50ck29 = 0.9 time = 150
.meas tran vdout0_50ck29 FIND v(dout0_50) AT=150.025n

* CHECK dout0_51 Vdout0_51ck29 = 0.9 time = 150
.meas tran vdout0_51ck29 FIND v(dout0_51) AT=150.025n

* CHECK dout0_52 Vdout0_52ck29 = 0 time = 150
.meas tran vdout0_52ck29 FIND v(dout0_52) AT=150.025n

* CHECK dout0_53 Vdout0_53ck29 = 0 time = 150
.meas tran vdout0_53ck29 FIND v(dout0_53) AT=150.025n

* CHECK dout0_54 Vdout0_54ck29 = 0.9 time = 150
.meas tran vdout0_54ck29 FIND v(dout0_54) AT=150.025n

* CHECK dout0_55 Vdout0_55ck29 = 0.9 time = 150
.meas tran vdout0_55ck29 FIND v(dout0_55) AT=150.025n

* CHECK dout0_56 Vdout0_56ck29 = 0 time = 150
.meas tran vdout0_56ck29 FIND v(dout0_56) AT=150.025n

* CHECK dout0_57 Vdout0_57ck29 = 0.9 time = 150
.meas tran vdout0_57ck29 FIND v(dout0_57) AT=150.025n

* CHECK dout0_58 Vdout0_58ck29 = 0 time = 150
.meas tran vdout0_58ck29 FIND v(dout0_58) AT=150.025n

* CHECK dout0_59 Vdout0_59ck29 = 0 time = 150
.meas tran vdout0_59ck29 FIND v(dout0_59) AT=150.025n

* CHECK dout0_60 Vdout0_60ck29 = 0 time = 150
.meas tran vdout0_60ck29 FIND v(dout0_60) AT=150.025n

* CHECK dout0_61 Vdout0_61ck29 = 0.9 time = 150
.meas tran vdout0_61ck29 FIND v(dout0_61) AT=150.025n

* CHECK dout0_62 Vdout0_62ck29 = 0 time = 150
.meas tran vdout0_62ck29 FIND v(dout0_62) AT=150.025n

* CHECK dout0_63 Vdout0_63ck29 = 0.9 time = 150
.meas tran vdout0_63ck29 FIND v(dout0_63) AT=150.025n

* CHECK dout0_0 Vdout0_0ck30 = 0.9 time = 155
.meas tran vdout0_0ck30 FIND v(dout0_0) AT=155.025n

* CHECK dout0_1 Vdout0_1ck30 = 0 time = 155
.meas tran vdout0_1ck30 FIND v(dout0_1) AT=155.025n

* CHECK dout0_2 Vdout0_2ck30 = 0 time = 155
.meas tran vdout0_2ck30 FIND v(dout0_2) AT=155.025n

* CHECK dout0_3 Vdout0_3ck30 = 0 time = 155
.meas tran vdout0_3ck30 FIND v(dout0_3) AT=155.025n

* CHECK dout0_4 Vdout0_4ck30 = 0.9 time = 155
.meas tran vdout0_4ck30 FIND v(dout0_4) AT=155.025n

* CHECK dout0_5 Vdout0_5ck30 = 0 time = 155
.meas tran vdout0_5ck30 FIND v(dout0_5) AT=155.025n

* CHECK dout0_6 Vdout0_6ck30 = 0 time = 155
.meas tran vdout0_6ck30 FIND v(dout0_6) AT=155.025n

* CHECK dout0_7 Vdout0_7ck30 = 0.9 time = 155
.meas tran vdout0_7ck30 FIND v(dout0_7) AT=155.025n

* CHECK dout0_8 Vdout0_8ck30 = 0.9 time = 155
.meas tran vdout0_8ck30 FIND v(dout0_8) AT=155.025n

* CHECK dout0_9 Vdout0_9ck30 = 0.9 time = 155
.meas tran vdout0_9ck30 FIND v(dout0_9) AT=155.025n

* CHECK dout0_10 Vdout0_10ck30 = 0.9 time = 155
.meas tran vdout0_10ck30 FIND v(dout0_10) AT=155.025n

* CHECK dout0_11 Vdout0_11ck30 = 0.9 time = 155
.meas tran vdout0_11ck30 FIND v(dout0_11) AT=155.025n

* CHECK dout0_12 Vdout0_12ck30 = 0 time = 155
.meas tran vdout0_12ck30 FIND v(dout0_12) AT=155.025n

* CHECK dout0_13 Vdout0_13ck30 = 0.9 time = 155
.meas tran vdout0_13ck30 FIND v(dout0_13) AT=155.025n

* CHECK dout0_14 Vdout0_14ck30 = 0.9 time = 155
.meas tran vdout0_14ck30 FIND v(dout0_14) AT=155.025n

* CHECK dout0_15 Vdout0_15ck30 = 0.9 time = 155
.meas tran vdout0_15ck30 FIND v(dout0_15) AT=155.025n

* CHECK dout0_16 Vdout0_16ck30 = 0.9 time = 155
.meas tran vdout0_16ck30 FIND v(dout0_16) AT=155.025n

* CHECK dout0_17 Vdout0_17ck30 = 0.9 time = 155
.meas tran vdout0_17ck30 FIND v(dout0_17) AT=155.025n

* CHECK dout0_18 Vdout0_18ck30 = 0.9 time = 155
.meas tran vdout0_18ck30 FIND v(dout0_18) AT=155.025n

* CHECK dout0_19 Vdout0_19ck30 = 0 time = 155
.meas tran vdout0_19ck30 FIND v(dout0_19) AT=155.025n

* CHECK dout0_20 Vdout0_20ck30 = 0 time = 155
.meas tran vdout0_20ck30 FIND v(dout0_20) AT=155.025n

* CHECK dout0_21 Vdout0_21ck30 = 0 time = 155
.meas tran vdout0_21ck30 FIND v(dout0_21) AT=155.025n

* CHECK dout0_22 Vdout0_22ck30 = 0 time = 155
.meas tran vdout0_22ck30 FIND v(dout0_22) AT=155.025n

* CHECK dout0_23 Vdout0_23ck30 = 0.9 time = 155
.meas tran vdout0_23ck30 FIND v(dout0_23) AT=155.025n

* CHECK dout0_24 Vdout0_24ck30 = 0.9 time = 155
.meas tran vdout0_24ck30 FIND v(dout0_24) AT=155.025n

* CHECK dout0_25 Vdout0_25ck30 = 0 time = 155
.meas tran vdout0_25ck30 FIND v(dout0_25) AT=155.025n

* CHECK dout0_26 Vdout0_26ck30 = 0 time = 155
.meas tran vdout0_26ck30 FIND v(dout0_26) AT=155.025n

* CHECK dout0_27 Vdout0_27ck30 = 0.9 time = 155
.meas tran vdout0_27ck30 FIND v(dout0_27) AT=155.025n

* CHECK dout0_28 Vdout0_28ck30 = 0.9 time = 155
.meas tran vdout0_28ck30 FIND v(dout0_28) AT=155.025n

* CHECK dout0_29 Vdout0_29ck30 = 0 time = 155
.meas tran vdout0_29ck30 FIND v(dout0_29) AT=155.025n

* CHECK dout0_30 Vdout0_30ck30 = 0.9 time = 155
.meas tran vdout0_30ck30 FIND v(dout0_30) AT=155.025n

* CHECK dout0_31 Vdout0_31ck30 = 0.9 time = 155
.meas tran vdout0_31ck30 FIND v(dout0_31) AT=155.025n

* CHECK dout0_32 Vdout0_32ck30 = 0.9 time = 155
.meas tran vdout0_32ck30 FIND v(dout0_32) AT=155.025n

* CHECK dout0_33 Vdout0_33ck30 = 0 time = 155
.meas tran vdout0_33ck30 FIND v(dout0_33) AT=155.025n

* CHECK dout0_34 Vdout0_34ck30 = 0.9 time = 155
.meas tran vdout0_34ck30 FIND v(dout0_34) AT=155.025n

* CHECK dout0_35 Vdout0_35ck30 = 0.9 time = 155
.meas tran vdout0_35ck30 FIND v(dout0_35) AT=155.025n

* CHECK dout0_36 Vdout0_36ck30 = 0 time = 155
.meas tran vdout0_36ck30 FIND v(dout0_36) AT=155.025n

* CHECK dout0_37 Vdout0_37ck30 = 0 time = 155
.meas tran vdout0_37ck30 FIND v(dout0_37) AT=155.025n

* CHECK dout0_38 Vdout0_38ck30 = 0 time = 155
.meas tran vdout0_38ck30 FIND v(dout0_38) AT=155.025n

* CHECK dout0_39 Vdout0_39ck30 = 0.9 time = 155
.meas tran vdout0_39ck30 FIND v(dout0_39) AT=155.025n

* CHECK dout0_40 Vdout0_40ck30 = 0.9 time = 155
.meas tran vdout0_40ck30 FIND v(dout0_40) AT=155.025n

* CHECK dout0_41 Vdout0_41ck30 = 0 time = 155
.meas tran vdout0_41ck30 FIND v(dout0_41) AT=155.025n

* CHECK dout0_42 Vdout0_42ck30 = 0 time = 155
.meas tran vdout0_42ck30 FIND v(dout0_42) AT=155.025n

* CHECK dout0_43 Vdout0_43ck30 = 0.9 time = 155
.meas tran vdout0_43ck30 FIND v(dout0_43) AT=155.025n

* CHECK dout0_44 Vdout0_44ck30 = 0 time = 155
.meas tran vdout0_44ck30 FIND v(dout0_44) AT=155.025n

* CHECK dout0_45 Vdout0_45ck30 = 0 time = 155
.meas tran vdout0_45ck30 FIND v(dout0_45) AT=155.025n

* CHECK dout0_46 Vdout0_46ck30 = 0 time = 155
.meas tran vdout0_46ck30 FIND v(dout0_46) AT=155.025n

* CHECK dout0_47 Vdout0_47ck30 = 0.9 time = 155
.meas tran vdout0_47ck30 FIND v(dout0_47) AT=155.025n

* CHECK dout0_48 Vdout0_48ck30 = 0.9 time = 155
.meas tran vdout0_48ck30 FIND v(dout0_48) AT=155.025n

* CHECK dout0_49 Vdout0_49ck30 = 0.9 time = 155
.meas tran vdout0_49ck30 FIND v(dout0_49) AT=155.025n

* CHECK dout0_50 Vdout0_50ck30 = 0.9 time = 155
.meas tran vdout0_50ck30 FIND v(dout0_50) AT=155.025n

* CHECK dout0_51 Vdout0_51ck30 = 0.9 time = 155
.meas tran vdout0_51ck30 FIND v(dout0_51) AT=155.025n

* CHECK dout0_52 Vdout0_52ck30 = 0 time = 155
.meas tran vdout0_52ck30 FIND v(dout0_52) AT=155.025n

* CHECK dout0_53 Vdout0_53ck30 = 0 time = 155
.meas tran vdout0_53ck30 FIND v(dout0_53) AT=155.025n

* CHECK dout0_54 Vdout0_54ck30 = 0 time = 155
.meas tran vdout0_54ck30 FIND v(dout0_54) AT=155.025n

* CHECK dout0_55 Vdout0_55ck30 = 0.9 time = 155
.meas tran vdout0_55ck30 FIND v(dout0_55) AT=155.025n

* CHECK dout0_56 Vdout0_56ck30 = 0.9 time = 155
.meas tran vdout0_56ck30 FIND v(dout0_56) AT=155.025n

* CHECK dout0_57 Vdout0_57ck30 = 0 time = 155
.meas tran vdout0_57ck30 FIND v(dout0_57) AT=155.025n

* CHECK dout0_58 Vdout0_58ck30 = 0.9 time = 155
.meas tran vdout0_58ck30 FIND v(dout0_58) AT=155.025n

* CHECK dout0_59 Vdout0_59ck30 = 0 time = 155
.meas tran vdout0_59ck30 FIND v(dout0_59) AT=155.025n

* CHECK dout0_60 Vdout0_60ck30 = 0 time = 155
.meas tran vdout0_60ck30 FIND v(dout0_60) AT=155.025n

* CHECK dout0_61 Vdout0_61ck30 = 0.9 time = 155
.meas tran vdout0_61ck30 FIND v(dout0_61) AT=155.025n

* CHECK dout0_62 Vdout0_62ck30 = 0.9 time = 155
.meas tran vdout0_62ck30 FIND v(dout0_62) AT=155.025n

* CHECK dout0_63 Vdout0_63ck30 = 0.9 time = 155
.meas tran vdout0_63ck30 FIND v(dout0_63) AT=155.025n

* CHECK dout0_0 Vdout0_0ck32 = 0.9 time = 165
.meas tran vdout0_0ck32 FIND v(dout0_0) AT=165.025n

* CHECK dout0_1 Vdout0_1ck32 = 0.9 time = 165
.meas tran vdout0_1ck32 FIND v(dout0_1) AT=165.025n

* CHECK dout0_2 Vdout0_2ck32 = 0 time = 165
.meas tran vdout0_2ck32 FIND v(dout0_2) AT=165.025n

* CHECK dout0_3 Vdout0_3ck32 = 0 time = 165
.meas tran vdout0_3ck32 FIND v(dout0_3) AT=165.025n

* CHECK dout0_4 Vdout0_4ck32 = 0.9 time = 165
.meas tran vdout0_4ck32 FIND v(dout0_4) AT=165.025n

* CHECK dout0_5 Vdout0_5ck32 = 0.9 time = 165
.meas tran vdout0_5ck32 FIND v(dout0_5) AT=165.025n

* CHECK dout0_6 Vdout0_6ck32 = 0 time = 165
.meas tran vdout0_6ck32 FIND v(dout0_6) AT=165.025n

* CHECK dout0_7 Vdout0_7ck32 = 0.9 time = 165
.meas tran vdout0_7ck32 FIND v(dout0_7) AT=165.025n

* CHECK dout0_8 Vdout0_8ck32 = 0.9 time = 165
.meas tran vdout0_8ck32 FIND v(dout0_8) AT=165.025n

* CHECK dout0_9 Vdout0_9ck32 = 0 time = 165
.meas tran vdout0_9ck32 FIND v(dout0_9) AT=165.025n

* CHECK dout0_10 Vdout0_10ck32 = 0 time = 165
.meas tran vdout0_10ck32 FIND v(dout0_10) AT=165.025n

* CHECK dout0_11 Vdout0_11ck32 = 0 time = 165
.meas tran vdout0_11ck32 FIND v(dout0_11) AT=165.025n

* CHECK dout0_12 Vdout0_12ck32 = 0 time = 165
.meas tran vdout0_12ck32 FIND v(dout0_12) AT=165.025n

* CHECK dout0_13 Vdout0_13ck32 = 0 time = 165
.meas tran vdout0_13ck32 FIND v(dout0_13) AT=165.025n

* CHECK dout0_14 Vdout0_14ck32 = 0 time = 165
.meas tran vdout0_14ck32 FIND v(dout0_14) AT=165.025n

* CHECK dout0_15 Vdout0_15ck32 = 0.9 time = 165
.meas tran vdout0_15ck32 FIND v(dout0_15) AT=165.025n

* CHECK dout0_16 Vdout0_16ck32 = 0.9 time = 165
.meas tran vdout0_16ck32 FIND v(dout0_16) AT=165.025n

* CHECK dout0_17 Vdout0_17ck32 = 0.9 time = 165
.meas tran vdout0_17ck32 FIND v(dout0_17) AT=165.025n

* CHECK dout0_18 Vdout0_18ck32 = 0.9 time = 165
.meas tran vdout0_18ck32 FIND v(dout0_18) AT=165.025n

* CHECK dout0_19 Vdout0_19ck32 = 0 time = 165
.meas tran vdout0_19ck32 FIND v(dout0_19) AT=165.025n

* CHECK dout0_20 Vdout0_20ck32 = 0.9 time = 165
.meas tran vdout0_20ck32 FIND v(dout0_20) AT=165.025n

* CHECK dout0_21 Vdout0_21ck32 = 0.9 time = 165
.meas tran vdout0_21ck32 FIND v(dout0_21) AT=165.025n

* CHECK dout0_22 Vdout0_22ck32 = 0.9 time = 165
.meas tran vdout0_22ck32 FIND v(dout0_22) AT=165.025n

* CHECK dout0_23 Vdout0_23ck32 = 0.9 time = 165
.meas tran vdout0_23ck32 FIND v(dout0_23) AT=165.025n

* CHECK dout0_24 Vdout0_24ck32 = 0 time = 165
.meas tran vdout0_24ck32 FIND v(dout0_24) AT=165.025n

* CHECK dout0_25 Vdout0_25ck32 = 0 time = 165
.meas tran vdout0_25ck32 FIND v(dout0_25) AT=165.025n

* CHECK dout0_26 Vdout0_26ck32 = 0 time = 165
.meas tran vdout0_26ck32 FIND v(dout0_26) AT=165.025n

* CHECK dout0_27 Vdout0_27ck32 = 0 time = 165
.meas tran vdout0_27ck32 FIND v(dout0_27) AT=165.025n

* CHECK dout0_28 Vdout0_28ck32 = 0 time = 165
.meas tran vdout0_28ck32 FIND v(dout0_28) AT=165.025n

* CHECK dout0_29 Vdout0_29ck32 = 0 time = 165
.meas tran vdout0_29ck32 FIND v(dout0_29) AT=165.025n

* CHECK dout0_30 Vdout0_30ck32 = 0.9 time = 165
.meas tran vdout0_30ck32 FIND v(dout0_30) AT=165.025n

* CHECK dout0_31 Vdout0_31ck32 = 0 time = 165
.meas tran vdout0_31ck32 FIND v(dout0_31) AT=165.025n

* CHECK dout0_32 Vdout0_32ck32 = 0 time = 165
.meas tran vdout0_32ck32 FIND v(dout0_32) AT=165.025n

* CHECK dout0_33 Vdout0_33ck32 = 0.9 time = 165
.meas tran vdout0_33ck32 FIND v(dout0_33) AT=165.025n

* CHECK dout0_34 Vdout0_34ck32 = 0.9 time = 165
.meas tran vdout0_34ck32 FIND v(dout0_34) AT=165.025n

* CHECK dout0_35 Vdout0_35ck32 = 0 time = 165
.meas tran vdout0_35ck32 FIND v(dout0_35) AT=165.025n

* CHECK dout0_36 Vdout0_36ck32 = 0 time = 165
.meas tran vdout0_36ck32 FIND v(dout0_36) AT=165.025n

* CHECK dout0_37 Vdout0_37ck32 = 0 time = 165
.meas tran vdout0_37ck32 FIND v(dout0_37) AT=165.025n

* CHECK dout0_38 Vdout0_38ck32 = 0.9 time = 165
.meas tran vdout0_38ck32 FIND v(dout0_38) AT=165.025n

* CHECK dout0_39 Vdout0_39ck32 = 0 time = 165
.meas tran vdout0_39ck32 FIND v(dout0_39) AT=165.025n

* CHECK dout0_40 Vdout0_40ck32 = 0 time = 165
.meas tran vdout0_40ck32 FIND v(dout0_40) AT=165.025n

* CHECK dout0_41 Vdout0_41ck32 = 0 time = 165
.meas tran vdout0_41ck32 FIND v(dout0_41) AT=165.025n

* CHECK dout0_42 Vdout0_42ck32 = 0.9 time = 165
.meas tran vdout0_42ck32 FIND v(dout0_42) AT=165.025n

* CHECK dout0_43 Vdout0_43ck32 = 0.9 time = 165
.meas tran vdout0_43ck32 FIND v(dout0_43) AT=165.025n

* CHECK dout0_44 Vdout0_44ck32 = 0.9 time = 165
.meas tran vdout0_44ck32 FIND v(dout0_44) AT=165.025n

* CHECK dout0_45 Vdout0_45ck32 = 0 time = 165
.meas tran vdout0_45ck32 FIND v(dout0_45) AT=165.025n

* CHECK dout0_46 Vdout0_46ck32 = 0 time = 165
.meas tran vdout0_46ck32 FIND v(dout0_46) AT=165.025n

* CHECK dout0_47 Vdout0_47ck32 = 0 time = 165
.meas tran vdout0_47ck32 FIND v(dout0_47) AT=165.025n

* CHECK dout0_48 Vdout0_48ck32 = 0.9 time = 165
.meas tran vdout0_48ck32 FIND v(dout0_48) AT=165.025n

* CHECK dout0_49 Vdout0_49ck32 = 0 time = 165
.meas tran vdout0_49ck32 FIND v(dout0_49) AT=165.025n

* CHECK dout0_50 Vdout0_50ck32 = 0 time = 165
.meas tran vdout0_50ck32 FIND v(dout0_50) AT=165.025n

* CHECK dout0_51 Vdout0_51ck32 = 0 time = 165
.meas tran vdout0_51ck32 FIND v(dout0_51) AT=165.025n

* CHECK dout0_52 Vdout0_52ck32 = 0 time = 165
.meas tran vdout0_52ck32 FIND v(dout0_52) AT=165.025n

* CHECK dout0_53 Vdout0_53ck32 = 0 time = 165
.meas tran vdout0_53ck32 FIND v(dout0_53) AT=165.025n

* CHECK dout0_54 Vdout0_54ck32 = 0 time = 165
.meas tran vdout0_54ck32 FIND v(dout0_54) AT=165.025n

* CHECK dout0_55 Vdout0_55ck32 = 0.9 time = 165
.meas tran vdout0_55ck32 FIND v(dout0_55) AT=165.025n

* CHECK dout0_56 Vdout0_56ck32 = 0 time = 165
.meas tran vdout0_56ck32 FIND v(dout0_56) AT=165.025n

* CHECK dout0_57 Vdout0_57ck32 = 0.9 time = 165
.meas tran vdout0_57ck32 FIND v(dout0_57) AT=165.025n

* CHECK dout0_58 Vdout0_58ck32 = 0 time = 165
.meas tran vdout0_58ck32 FIND v(dout0_58) AT=165.025n

* CHECK dout0_59 Vdout0_59ck32 = 0.9 time = 165
.meas tran vdout0_59ck32 FIND v(dout0_59) AT=165.025n

* CHECK dout0_60 Vdout0_60ck32 = 0 time = 165
.meas tran vdout0_60ck32 FIND v(dout0_60) AT=165.025n

* CHECK dout0_61 Vdout0_61ck32 = 0.9 time = 165
.meas tran vdout0_61ck32 FIND v(dout0_61) AT=165.025n

* CHECK dout0_62 Vdout0_62ck32 = 0.9 time = 165
.meas tran vdout0_62ck32 FIND v(dout0_62) AT=165.025n

* CHECK dout0_63 Vdout0_63ck32 = 0 time = 165
.meas tran vdout0_63ck32 FIND v(dout0_63) AT=165.025n

* CHECK dout0_0 Vdout0_0ck33 = 0.9 time = 170
.meas tran vdout0_0ck33 FIND v(dout0_0) AT=170.025n

* CHECK dout0_1 Vdout0_1ck33 = 0.9 time = 170
.meas tran vdout0_1ck33 FIND v(dout0_1) AT=170.025n

* CHECK dout0_2 Vdout0_2ck33 = 0 time = 170
.meas tran vdout0_2ck33 FIND v(dout0_2) AT=170.025n

* CHECK dout0_3 Vdout0_3ck33 = 0 time = 170
.meas tran vdout0_3ck33 FIND v(dout0_3) AT=170.025n

* CHECK dout0_4 Vdout0_4ck33 = 0.9 time = 170
.meas tran vdout0_4ck33 FIND v(dout0_4) AT=170.025n

* CHECK dout0_5 Vdout0_5ck33 = 0.9 time = 170
.meas tran vdout0_5ck33 FIND v(dout0_5) AT=170.025n

* CHECK dout0_6 Vdout0_6ck33 = 0 time = 170
.meas tran vdout0_6ck33 FIND v(dout0_6) AT=170.025n

* CHECK dout0_7 Vdout0_7ck33 = 0.9 time = 170
.meas tran vdout0_7ck33 FIND v(dout0_7) AT=170.025n

* CHECK dout0_8 Vdout0_8ck33 = 0.9 time = 170
.meas tran vdout0_8ck33 FIND v(dout0_8) AT=170.025n

* CHECK dout0_9 Vdout0_9ck33 = 0 time = 170
.meas tran vdout0_9ck33 FIND v(dout0_9) AT=170.025n

* CHECK dout0_10 Vdout0_10ck33 = 0 time = 170
.meas tran vdout0_10ck33 FIND v(dout0_10) AT=170.025n

* CHECK dout0_11 Vdout0_11ck33 = 0 time = 170
.meas tran vdout0_11ck33 FIND v(dout0_11) AT=170.025n

* CHECK dout0_12 Vdout0_12ck33 = 0 time = 170
.meas tran vdout0_12ck33 FIND v(dout0_12) AT=170.025n

* CHECK dout0_13 Vdout0_13ck33 = 0 time = 170
.meas tran vdout0_13ck33 FIND v(dout0_13) AT=170.025n

* CHECK dout0_14 Vdout0_14ck33 = 0 time = 170
.meas tran vdout0_14ck33 FIND v(dout0_14) AT=170.025n

* CHECK dout0_15 Vdout0_15ck33 = 0.9 time = 170
.meas tran vdout0_15ck33 FIND v(dout0_15) AT=170.025n

* CHECK dout0_16 Vdout0_16ck33 = 0.9 time = 170
.meas tran vdout0_16ck33 FIND v(dout0_16) AT=170.025n

* CHECK dout0_17 Vdout0_17ck33 = 0.9 time = 170
.meas tran vdout0_17ck33 FIND v(dout0_17) AT=170.025n

* CHECK dout0_18 Vdout0_18ck33 = 0.9 time = 170
.meas tran vdout0_18ck33 FIND v(dout0_18) AT=170.025n

* CHECK dout0_19 Vdout0_19ck33 = 0 time = 170
.meas tran vdout0_19ck33 FIND v(dout0_19) AT=170.025n

* CHECK dout0_20 Vdout0_20ck33 = 0.9 time = 170
.meas tran vdout0_20ck33 FIND v(dout0_20) AT=170.025n

* CHECK dout0_21 Vdout0_21ck33 = 0.9 time = 170
.meas tran vdout0_21ck33 FIND v(dout0_21) AT=170.025n

* CHECK dout0_22 Vdout0_22ck33 = 0.9 time = 170
.meas tran vdout0_22ck33 FIND v(dout0_22) AT=170.025n

* CHECK dout0_23 Vdout0_23ck33 = 0.9 time = 170
.meas tran vdout0_23ck33 FIND v(dout0_23) AT=170.025n

* CHECK dout0_24 Vdout0_24ck33 = 0 time = 170
.meas tran vdout0_24ck33 FIND v(dout0_24) AT=170.025n

* CHECK dout0_25 Vdout0_25ck33 = 0 time = 170
.meas tran vdout0_25ck33 FIND v(dout0_25) AT=170.025n

* CHECK dout0_26 Vdout0_26ck33 = 0 time = 170
.meas tran vdout0_26ck33 FIND v(dout0_26) AT=170.025n

* CHECK dout0_27 Vdout0_27ck33 = 0 time = 170
.meas tran vdout0_27ck33 FIND v(dout0_27) AT=170.025n

* CHECK dout0_28 Vdout0_28ck33 = 0 time = 170
.meas tran vdout0_28ck33 FIND v(dout0_28) AT=170.025n

* CHECK dout0_29 Vdout0_29ck33 = 0 time = 170
.meas tran vdout0_29ck33 FIND v(dout0_29) AT=170.025n

* CHECK dout0_30 Vdout0_30ck33 = 0.9 time = 170
.meas tran vdout0_30ck33 FIND v(dout0_30) AT=170.025n

* CHECK dout0_31 Vdout0_31ck33 = 0 time = 170
.meas tran vdout0_31ck33 FIND v(dout0_31) AT=170.025n

* CHECK dout0_32 Vdout0_32ck33 = 0 time = 170
.meas tran vdout0_32ck33 FIND v(dout0_32) AT=170.025n

* CHECK dout0_33 Vdout0_33ck33 = 0.9 time = 170
.meas tran vdout0_33ck33 FIND v(dout0_33) AT=170.025n

* CHECK dout0_34 Vdout0_34ck33 = 0.9 time = 170
.meas tran vdout0_34ck33 FIND v(dout0_34) AT=170.025n

* CHECK dout0_35 Vdout0_35ck33 = 0 time = 170
.meas tran vdout0_35ck33 FIND v(dout0_35) AT=170.025n

* CHECK dout0_36 Vdout0_36ck33 = 0 time = 170
.meas tran vdout0_36ck33 FIND v(dout0_36) AT=170.025n

* CHECK dout0_37 Vdout0_37ck33 = 0 time = 170
.meas tran vdout0_37ck33 FIND v(dout0_37) AT=170.025n

* CHECK dout0_38 Vdout0_38ck33 = 0.9 time = 170
.meas tran vdout0_38ck33 FIND v(dout0_38) AT=170.025n

* CHECK dout0_39 Vdout0_39ck33 = 0 time = 170
.meas tran vdout0_39ck33 FIND v(dout0_39) AT=170.025n

* CHECK dout0_40 Vdout0_40ck33 = 0 time = 170
.meas tran vdout0_40ck33 FIND v(dout0_40) AT=170.025n

* CHECK dout0_41 Vdout0_41ck33 = 0 time = 170
.meas tran vdout0_41ck33 FIND v(dout0_41) AT=170.025n

* CHECK dout0_42 Vdout0_42ck33 = 0.9 time = 170
.meas tran vdout0_42ck33 FIND v(dout0_42) AT=170.025n

* CHECK dout0_43 Vdout0_43ck33 = 0.9 time = 170
.meas tran vdout0_43ck33 FIND v(dout0_43) AT=170.025n

* CHECK dout0_44 Vdout0_44ck33 = 0.9 time = 170
.meas tran vdout0_44ck33 FIND v(dout0_44) AT=170.025n

* CHECK dout0_45 Vdout0_45ck33 = 0 time = 170
.meas tran vdout0_45ck33 FIND v(dout0_45) AT=170.025n

* CHECK dout0_46 Vdout0_46ck33 = 0 time = 170
.meas tran vdout0_46ck33 FIND v(dout0_46) AT=170.025n

* CHECK dout0_47 Vdout0_47ck33 = 0 time = 170
.meas tran vdout0_47ck33 FIND v(dout0_47) AT=170.025n

* CHECK dout0_48 Vdout0_48ck33 = 0.9 time = 170
.meas tran vdout0_48ck33 FIND v(dout0_48) AT=170.025n

* CHECK dout0_49 Vdout0_49ck33 = 0 time = 170
.meas tran vdout0_49ck33 FIND v(dout0_49) AT=170.025n

* CHECK dout0_50 Vdout0_50ck33 = 0 time = 170
.meas tran vdout0_50ck33 FIND v(dout0_50) AT=170.025n

* CHECK dout0_51 Vdout0_51ck33 = 0 time = 170
.meas tran vdout0_51ck33 FIND v(dout0_51) AT=170.025n

* CHECK dout0_52 Vdout0_52ck33 = 0 time = 170
.meas tran vdout0_52ck33 FIND v(dout0_52) AT=170.025n

* CHECK dout0_53 Vdout0_53ck33 = 0 time = 170
.meas tran vdout0_53ck33 FIND v(dout0_53) AT=170.025n

* CHECK dout0_54 Vdout0_54ck33 = 0 time = 170
.meas tran vdout0_54ck33 FIND v(dout0_54) AT=170.025n

* CHECK dout0_55 Vdout0_55ck33 = 0.9 time = 170
.meas tran vdout0_55ck33 FIND v(dout0_55) AT=170.025n

* CHECK dout0_56 Vdout0_56ck33 = 0 time = 170
.meas tran vdout0_56ck33 FIND v(dout0_56) AT=170.025n

* CHECK dout0_57 Vdout0_57ck33 = 0.9 time = 170
.meas tran vdout0_57ck33 FIND v(dout0_57) AT=170.025n

* CHECK dout0_58 Vdout0_58ck33 = 0 time = 170
.meas tran vdout0_58ck33 FIND v(dout0_58) AT=170.025n

* CHECK dout0_59 Vdout0_59ck33 = 0.9 time = 170
.meas tran vdout0_59ck33 FIND v(dout0_59) AT=170.025n

* CHECK dout0_60 Vdout0_60ck33 = 0 time = 170
.meas tran vdout0_60ck33 FIND v(dout0_60) AT=170.025n

* CHECK dout0_61 Vdout0_61ck33 = 0.9 time = 170
.meas tran vdout0_61ck33 FIND v(dout0_61) AT=170.025n

* CHECK dout0_62 Vdout0_62ck33 = 0.9 time = 170
.meas tran vdout0_62ck33 FIND v(dout0_62) AT=170.025n

* CHECK dout0_63 Vdout0_63ck33 = 0 time = 170
.meas tran vdout0_63ck33 FIND v(dout0_63) AT=170.025n

* CHECK dout0_0 Vdout0_0ck35 = 0.9 time = 180
.meas tran vdout0_0ck35 FIND v(dout0_0) AT=180.025n

* CHECK dout0_1 Vdout0_1ck35 = 0.9 time = 180
.meas tran vdout0_1ck35 FIND v(dout0_1) AT=180.025n

* CHECK dout0_2 Vdout0_2ck35 = 0 time = 180
.meas tran vdout0_2ck35 FIND v(dout0_2) AT=180.025n

* CHECK dout0_3 Vdout0_3ck35 = 0 time = 180
.meas tran vdout0_3ck35 FIND v(dout0_3) AT=180.025n

* CHECK dout0_4 Vdout0_4ck35 = 0.9 time = 180
.meas tran vdout0_4ck35 FIND v(dout0_4) AT=180.025n

* CHECK dout0_5 Vdout0_5ck35 = 0.9 time = 180
.meas tran vdout0_5ck35 FIND v(dout0_5) AT=180.025n

* CHECK dout0_6 Vdout0_6ck35 = 0 time = 180
.meas tran vdout0_6ck35 FIND v(dout0_6) AT=180.025n

* CHECK dout0_7 Vdout0_7ck35 = 0.9 time = 180
.meas tran vdout0_7ck35 FIND v(dout0_7) AT=180.025n

* CHECK dout0_8 Vdout0_8ck35 = 0.9 time = 180
.meas tran vdout0_8ck35 FIND v(dout0_8) AT=180.025n

* CHECK dout0_9 Vdout0_9ck35 = 0 time = 180
.meas tran vdout0_9ck35 FIND v(dout0_9) AT=180.025n

* CHECK dout0_10 Vdout0_10ck35 = 0 time = 180
.meas tran vdout0_10ck35 FIND v(dout0_10) AT=180.025n

* CHECK dout0_11 Vdout0_11ck35 = 0 time = 180
.meas tran vdout0_11ck35 FIND v(dout0_11) AT=180.025n

* CHECK dout0_12 Vdout0_12ck35 = 0 time = 180
.meas tran vdout0_12ck35 FIND v(dout0_12) AT=180.025n

* CHECK dout0_13 Vdout0_13ck35 = 0 time = 180
.meas tran vdout0_13ck35 FIND v(dout0_13) AT=180.025n

* CHECK dout0_14 Vdout0_14ck35 = 0 time = 180
.meas tran vdout0_14ck35 FIND v(dout0_14) AT=180.025n

* CHECK dout0_15 Vdout0_15ck35 = 0.9 time = 180
.meas tran vdout0_15ck35 FIND v(dout0_15) AT=180.025n

* CHECK dout0_16 Vdout0_16ck35 = 0.9 time = 180
.meas tran vdout0_16ck35 FIND v(dout0_16) AT=180.025n

* CHECK dout0_17 Vdout0_17ck35 = 0.9 time = 180
.meas tran vdout0_17ck35 FIND v(dout0_17) AT=180.025n

* CHECK dout0_18 Vdout0_18ck35 = 0.9 time = 180
.meas tran vdout0_18ck35 FIND v(dout0_18) AT=180.025n

* CHECK dout0_19 Vdout0_19ck35 = 0 time = 180
.meas tran vdout0_19ck35 FIND v(dout0_19) AT=180.025n

* CHECK dout0_20 Vdout0_20ck35 = 0.9 time = 180
.meas tran vdout0_20ck35 FIND v(dout0_20) AT=180.025n

* CHECK dout0_21 Vdout0_21ck35 = 0.9 time = 180
.meas tran vdout0_21ck35 FIND v(dout0_21) AT=180.025n

* CHECK dout0_22 Vdout0_22ck35 = 0.9 time = 180
.meas tran vdout0_22ck35 FIND v(dout0_22) AT=180.025n

* CHECK dout0_23 Vdout0_23ck35 = 0.9 time = 180
.meas tran vdout0_23ck35 FIND v(dout0_23) AT=180.025n

* CHECK dout0_24 Vdout0_24ck35 = 0 time = 180
.meas tran vdout0_24ck35 FIND v(dout0_24) AT=180.025n

* CHECK dout0_25 Vdout0_25ck35 = 0 time = 180
.meas tran vdout0_25ck35 FIND v(dout0_25) AT=180.025n

* CHECK dout0_26 Vdout0_26ck35 = 0 time = 180
.meas tran vdout0_26ck35 FIND v(dout0_26) AT=180.025n

* CHECK dout0_27 Vdout0_27ck35 = 0 time = 180
.meas tran vdout0_27ck35 FIND v(dout0_27) AT=180.025n

* CHECK dout0_28 Vdout0_28ck35 = 0 time = 180
.meas tran vdout0_28ck35 FIND v(dout0_28) AT=180.025n

* CHECK dout0_29 Vdout0_29ck35 = 0 time = 180
.meas tran vdout0_29ck35 FIND v(dout0_29) AT=180.025n

* CHECK dout0_30 Vdout0_30ck35 = 0.9 time = 180
.meas tran vdout0_30ck35 FIND v(dout0_30) AT=180.025n

* CHECK dout0_31 Vdout0_31ck35 = 0 time = 180
.meas tran vdout0_31ck35 FIND v(dout0_31) AT=180.025n

* CHECK dout0_32 Vdout0_32ck35 = 0 time = 180
.meas tran vdout0_32ck35 FIND v(dout0_32) AT=180.025n

* CHECK dout0_33 Vdout0_33ck35 = 0.9 time = 180
.meas tran vdout0_33ck35 FIND v(dout0_33) AT=180.025n

* CHECK dout0_34 Vdout0_34ck35 = 0.9 time = 180
.meas tran vdout0_34ck35 FIND v(dout0_34) AT=180.025n

* CHECK dout0_35 Vdout0_35ck35 = 0 time = 180
.meas tran vdout0_35ck35 FIND v(dout0_35) AT=180.025n

* CHECK dout0_36 Vdout0_36ck35 = 0 time = 180
.meas tran vdout0_36ck35 FIND v(dout0_36) AT=180.025n

* CHECK dout0_37 Vdout0_37ck35 = 0 time = 180
.meas tran vdout0_37ck35 FIND v(dout0_37) AT=180.025n

* CHECK dout0_38 Vdout0_38ck35 = 0.9 time = 180
.meas tran vdout0_38ck35 FIND v(dout0_38) AT=180.025n

* CHECK dout0_39 Vdout0_39ck35 = 0 time = 180
.meas tran vdout0_39ck35 FIND v(dout0_39) AT=180.025n

* CHECK dout0_40 Vdout0_40ck35 = 0 time = 180
.meas tran vdout0_40ck35 FIND v(dout0_40) AT=180.025n

* CHECK dout0_41 Vdout0_41ck35 = 0 time = 180
.meas tran vdout0_41ck35 FIND v(dout0_41) AT=180.025n

* CHECK dout0_42 Vdout0_42ck35 = 0.9 time = 180
.meas tran vdout0_42ck35 FIND v(dout0_42) AT=180.025n

* CHECK dout0_43 Vdout0_43ck35 = 0.9 time = 180
.meas tran vdout0_43ck35 FIND v(dout0_43) AT=180.025n

* CHECK dout0_44 Vdout0_44ck35 = 0.9 time = 180
.meas tran vdout0_44ck35 FIND v(dout0_44) AT=180.025n

* CHECK dout0_45 Vdout0_45ck35 = 0 time = 180
.meas tran vdout0_45ck35 FIND v(dout0_45) AT=180.025n

* CHECK dout0_46 Vdout0_46ck35 = 0 time = 180
.meas tran vdout0_46ck35 FIND v(dout0_46) AT=180.025n

* CHECK dout0_47 Vdout0_47ck35 = 0 time = 180
.meas tran vdout0_47ck35 FIND v(dout0_47) AT=180.025n

* CHECK dout0_48 Vdout0_48ck35 = 0.9 time = 180
.meas tran vdout0_48ck35 FIND v(dout0_48) AT=180.025n

* CHECK dout0_49 Vdout0_49ck35 = 0 time = 180
.meas tran vdout0_49ck35 FIND v(dout0_49) AT=180.025n

* CHECK dout0_50 Vdout0_50ck35 = 0 time = 180
.meas tran vdout0_50ck35 FIND v(dout0_50) AT=180.025n

* CHECK dout0_51 Vdout0_51ck35 = 0 time = 180
.meas tran vdout0_51ck35 FIND v(dout0_51) AT=180.025n

* CHECK dout0_52 Vdout0_52ck35 = 0 time = 180
.meas tran vdout0_52ck35 FIND v(dout0_52) AT=180.025n

* CHECK dout0_53 Vdout0_53ck35 = 0 time = 180
.meas tran vdout0_53ck35 FIND v(dout0_53) AT=180.025n

* CHECK dout0_54 Vdout0_54ck35 = 0 time = 180
.meas tran vdout0_54ck35 FIND v(dout0_54) AT=180.025n

* CHECK dout0_55 Vdout0_55ck35 = 0.9 time = 180
.meas tran vdout0_55ck35 FIND v(dout0_55) AT=180.025n

* CHECK dout0_56 Vdout0_56ck35 = 0 time = 180
.meas tran vdout0_56ck35 FIND v(dout0_56) AT=180.025n

* CHECK dout0_57 Vdout0_57ck35 = 0.9 time = 180
.meas tran vdout0_57ck35 FIND v(dout0_57) AT=180.025n

* CHECK dout0_58 Vdout0_58ck35 = 0 time = 180
.meas tran vdout0_58ck35 FIND v(dout0_58) AT=180.025n

* CHECK dout0_59 Vdout0_59ck35 = 0.9 time = 180
.meas tran vdout0_59ck35 FIND v(dout0_59) AT=180.025n

* CHECK dout0_60 Vdout0_60ck35 = 0 time = 180
.meas tran vdout0_60ck35 FIND v(dout0_60) AT=180.025n

* CHECK dout0_61 Vdout0_61ck35 = 0.9 time = 180
.meas tran vdout0_61ck35 FIND v(dout0_61) AT=180.025n

* CHECK dout0_62 Vdout0_62ck35 = 0.9 time = 180
.meas tran vdout0_62ck35 FIND v(dout0_62) AT=180.025n

* CHECK dout0_63 Vdout0_63ck35 = 0 time = 180
.meas tran vdout0_63ck35 FIND v(dout0_63) AT=180.025n

* CHECK dout0_0 Vdout0_0ck39 = 0.9 time = 200
.meas tran vdout0_0ck39 FIND v(dout0_0) AT=200.025n

* CHECK dout0_1 Vdout0_1ck39 = 0.9 time = 200
.meas tran vdout0_1ck39 FIND v(dout0_1) AT=200.025n

* CHECK dout0_2 Vdout0_2ck39 = 0 time = 200
.meas tran vdout0_2ck39 FIND v(dout0_2) AT=200.025n

* CHECK dout0_3 Vdout0_3ck39 = 0 time = 200
.meas tran vdout0_3ck39 FIND v(dout0_3) AT=200.025n

* CHECK dout0_4 Vdout0_4ck39 = 0.9 time = 200
.meas tran vdout0_4ck39 FIND v(dout0_4) AT=200.025n

* CHECK dout0_5 Vdout0_5ck39 = 0.9 time = 200
.meas tran vdout0_5ck39 FIND v(dout0_5) AT=200.025n

* CHECK dout0_6 Vdout0_6ck39 = 0 time = 200
.meas tran vdout0_6ck39 FIND v(dout0_6) AT=200.025n

* CHECK dout0_7 Vdout0_7ck39 = 0.9 time = 200
.meas tran vdout0_7ck39 FIND v(dout0_7) AT=200.025n

* CHECK dout0_8 Vdout0_8ck39 = 0.9 time = 200
.meas tran vdout0_8ck39 FIND v(dout0_8) AT=200.025n

* CHECK dout0_9 Vdout0_9ck39 = 0 time = 200
.meas tran vdout0_9ck39 FIND v(dout0_9) AT=200.025n

* CHECK dout0_10 Vdout0_10ck39 = 0 time = 200
.meas tran vdout0_10ck39 FIND v(dout0_10) AT=200.025n

* CHECK dout0_11 Vdout0_11ck39 = 0 time = 200
.meas tran vdout0_11ck39 FIND v(dout0_11) AT=200.025n

* CHECK dout0_12 Vdout0_12ck39 = 0 time = 200
.meas tran vdout0_12ck39 FIND v(dout0_12) AT=200.025n

* CHECK dout0_13 Vdout0_13ck39 = 0 time = 200
.meas tran vdout0_13ck39 FIND v(dout0_13) AT=200.025n

* CHECK dout0_14 Vdout0_14ck39 = 0 time = 200
.meas tran vdout0_14ck39 FIND v(dout0_14) AT=200.025n

* CHECK dout0_15 Vdout0_15ck39 = 0.9 time = 200
.meas tran vdout0_15ck39 FIND v(dout0_15) AT=200.025n

* CHECK dout0_16 Vdout0_16ck39 = 0.9 time = 200
.meas tran vdout0_16ck39 FIND v(dout0_16) AT=200.025n

* CHECK dout0_17 Vdout0_17ck39 = 0.9 time = 200
.meas tran vdout0_17ck39 FIND v(dout0_17) AT=200.025n

* CHECK dout0_18 Vdout0_18ck39 = 0.9 time = 200
.meas tran vdout0_18ck39 FIND v(dout0_18) AT=200.025n

* CHECK dout0_19 Vdout0_19ck39 = 0 time = 200
.meas tran vdout0_19ck39 FIND v(dout0_19) AT=200.025n

* CHECK dout0_20 Vdout0_20ck39 = 0.9 time = 200
.meas tran vdout0_20ck39 FIND v(dout0_20) AT=200.025n

* CHECK dout0_21 Vdout0_21ck39 = 0.9 time = 200
.meas tran vdout0_21ck39 FIND v(dout0_21) AT=200.025n

* CHECK dout0_22 Vdout0_22ck39 = 0.9 time = 200
.meas tran vdout0_22ck39 FIND v(dout0_22) AT=200.025n

* CHECK dout0_23 Vdout0_23ck39 = 0.9 time = 200
.meas tran vdout0_23ck39 FIND v(dout0_23) AT=200.025n

* CHECK dout0_24 Vdout0_24ck39 = 0 time = 200
.meas tran vdout0_24ck39 FIND v(dout0_24) AT=200.025n

* CHECK dout0_25 Vdout0_25ck39 = 0 time = 200
.meas tran vdout0_25ck39 FIND v(dout0_25) AT=200.025n

* CHECK dout0_26 Vdout0_26ck39 = 0 time = 200
.meas tran vdout0_26ck39 FIND v(dout0_26) AT=200.025n

* CHECK dout0_27 Vdout0_27ck39 = 0 time = 200
.meas tran vdout0_27ck39 FIND v(dout0_27) AT=200.025n

* CHECK dout0_28 Vdout0_28ck39 = 0 time = 200
.meas tran vdout0_28ck39 FIND v(dout0_28) AT=200.025n

* CHECK dout0_29 Vdout0_29ck39 = 0 time = 200
.meas tran vdout0_29ck39 FIND v(dout0_29) AT=200.025n

* CHECK dout0_30 Vdout0_30ck39 = 0.9 time = 200
.meas tran vdout0_30ck39 FIND v(dout0_30) AT=200.025n

* CHECK dout0_31 Vdout0_31ck39 = 0 time = 200
.meas tran vdout0_31ck39 FIND v(dout0_31) AT=200.025n

* CHECK dout0_32 Vdout0_32ck39 = 0 time = 200
.meas tran vdout0_32ck39 FIND v(dout0_32) AT=200.025n

* CHECK dout0_33 Vdout0_33ck39 = 0.9 time = 200
.meas tran vdout0_33ck39 FIND v(dout0_33) AT=200.025n

* CHECK dout0_34 Vdout0_34ck39 = 0.9 time = 200
.meas tran vdout0_34ck39 FIND v(dout0_34) AT=200.025n

* CHECK dout0_35 Vdout0_35ck39 = 0 time = 200
.meas tran vdout0_35ck39 FIND v(dout0_35) AT=200.025n

* CHECK dout0_36 Vdout0_36ck39 = 0 time = 200
.meas tran vdout0_36ck39 FIND v(dout0_36) AT=200.025n

* CHECK dout0_37 Vdout0_37ck39 = 0 time = 200
.meas tran vdout0_37ck39 FIND v(dout0_37) AT=200.025n

* CHECK dout0_38 Vdout0_38ck39 = 0.9 time = 200
.meas tran vdout0_38ck39 FIND v(dout0_38) AT=200.025n

* CHECK dout0_39 Vdout0_39ck39 = 0 time = 200
.meas tran vdout0_39ck39 FIND v(dout0_39) AT=200.025n

* CHECK dout0_40 Vdout0_40ck39 = 0 time = 200
.meas tran vdout0_40ck39 FIND v(dout0_40) AT=200.025n

* CHECK dout0_41 Vdout0_41ck39 = 0 time = 200
.meas tran vdout0_41ck39 FIND v(dout0_41) AT=200.025n

* CHECK dout0_42 Vdout0_42ck39 = 0.9 time = 200
.meas tran vdout0_42ck39 FIND v(dout0_42) AT=200.025n

* CHECK dout0_43 Vdout0_43ck39 = 0.9 time = 200
.meas tran vdout0_43ck39 FIND v(dout0_43) AT=200.025n

* CHECK dout0_44 Vdout0_44ck39 = 0.9 time = 200
.meas tran vdout0_44ck39 FIND v(dout0_44) AT=200.025n

* CHECK dout0_45 Vdout0_45ck39 = 0 time = 200
.meas tran vdout0_45ck39 FIND v(dout0_45) AT=200.025n

* CHECK dout0_46 Vdout0_46ck39 = 0 time = 200
.meas tran vdout0_46ck39 FIND v(dout0_46) AT=200.025n

* CHECK dout0_47 Vdout0_47ck39 = 0 time = 200
.meas tran vdout0_47ck39 FIND v(dout0_47) AT=200.025n

* CHECK dout0_48 Vdout0_48ck39 = 0.9 time = 200
.meas tran vdout0_48ck39 FIND v(dout0_48) AT=200.025n

* CHECK dout0_49 Vdout0_49ck39 = 0 time = 200
.meas tran vdout0_49ck39 FIND v(dout0_49) AT=200.025n

* CHECK dout0_50 Vdout0_50ck39 = 0 time = 200
.meas tran vdout0_50ck39 FIND v(dout0_50) AT=200.025n

* CHECK dout0_51 Vdout0_51ck39 = 0 time = 200
.meas tran vdout0_51ck39 FIND v(dout0_51) AT=200.025n

* CHECK dout0_52 Vdout0_52ck39 = 0 time = 200
.meas tran vdout0_52ck39 FIND v(dout0_52) AT=200.025n

* CHECK dout0_53 Vdout0_53ck39 = 0 time = 200
.meas tran vdout0_53ck39 FIND v(dout0_53) AT=200.025n

* CHECK dout0_54 Vdout0_54ck39 = 0 time = 200
.meas tran vdout0_54ck39 FIND v(dout0_54) AT=200.025n

* CHECK dout0_55 Vdout0_55ck39 = 0.9 time = 200
.meas tran vdout0_55ck39 FIND v(dout0_55) AT=200.025n

* CHECK dout0_56 Vdout0_56ck39 = 0 time = 200
.meas tran vdout0_56ck39 FIND v(dout0_56) AT=200.025n

* CHECK dout0_57 Vdout0_57ck39 = 0.9 time = 200
.meas tran vdout0_57ck39 FIND v(dout0_57) AT=200.025n

* CHECK dout0_58 Vdout0_58ck39 = 0 time = 200
.meas tran vdout0_58ck39 FIND v(dout0_58) AT=200.025n

* CHECK dout0_59 Vdout0_59ck39 = 0.9 time = 200
.meas tran vdout0_59ck39 FIND v(dout0_59) AT=200.025n

* CHECK dout0_60 Vdout0_60ck39 = 0 time = 200
.meas tran vdout0_60ck39 FIND v(dout0_60) AT=200.025n

* CHECK dout0_61 Vdout0_61ck39 = 0.9 time = 200
.meas tran vdout0_61ck39 FIND v(dout0_61) AT=200.025n

* CHECK dout0_62 Vdout0_62ck39 = 0.9 time = 200
.meas tran vdout0_62ck39 FIND v(dout0_62) AT=200.025n

* CHECK dout0_63 Vdout0_63ck39 = 0 time = 200
.meas tran vdout0_63ck39 FIND v(dout0_63) AT=200.025n

* CHECK dout0_0 Vdout0_0ck40 = 0 time = 205
.meas tran vdout0_0ck40 FIND v(dout0_0) AT=205.025n

* CHECK dout0_1 Vdout0_1ck40 = 0.9 time = 205
.meas tran vdout0_1ck40 FIND v(dout0_1) AT=205.025n

* CHECK dout0_2 Vdout0_2ck40 = 0 time = 205
.meas tran vdout0_2ck40 FIND v(dout0_2) AT=205.025n

* CHECK dout0_3 Vdout0_3ck40 = 0.9 time = 205
.meas tran vdout0_3ck40 FIND v(dout0_3) AT=205.025n

* CHECK dout0_4 Vdout0_4ck40 = 0 time = 205
.meas tran vdout0_4ck40 FIND v(dout0_4) AT=205.025n

* CHECK dout0_5 Vdout0_5ck40 = 0.9 time = 205
.meas tran vdout0_5ck40 FIND v(dout0_5) AT=205.025n

* CHECK dout0_6 Vdout0_6ck40 = 0.9 time = 205
.meas tran vdout0_6ck40 FIND v(dout0_6) AT=205.025n

* CHECK dout0_7 Vdout0_7ck40 = 0.9 time = 205
.meas tran vdout0_7ck40 FIND v(dout0_7) AT=205.025n

* CHECK dout0_8 Vdout0_8ck40 = 0.9 time = 205
.meas tran vdout0_8ck40 FIND v(dout0_8) AT=205.025n

* CHECK dout0_9 Vdout0_9ck40 = 0 time = 205
.meas tran vdout0_9ck40 FIND v(dout0_9) AT=205.025n

* CHECK dout0_10 Vdout0_10ck40 = 0 time = 205
.meas tran vdout0_10ck40 FIND v(dout0_10) AT=205.025n

* CHECK dout0_11 Vdout0_11ck40 = 0.9 time = 205
.meas tran vdout0_11ck40 FIND v(dout0_11) AT=205.025n

* CHECK dout0_12 Vdout0_12ck40 = 0 time = 205
.meas tran vdout0_12ck40 FIND v(dout0_12) AT=205.025n

* CHECK dout0_13 Vdout0_13ck40 = 0 time = 205
.meas tran vdout0_13ck40 FIND v(dout0_13) AT=205.025n

* CHECK dout0_14 Vdout0_14ck40 = 0 time = 205
.meas tran vdout0_14ck40 FIND v(dout0_14) AT=205.025n

* CHECK dout0_15 Vdout0_15ck40 = 0.9 time = 205
.meas tran vdout0_15ck40 FIND v(dout0_15) AT=205.025n

* CHECK dout0_16 Vdout0_16ck40 = 0 time = 205
.meas tran vdout0_16ck40 FIND v(dout0_16) AT=205.025n

* CHECK dout0_17 Vdout0_17ck40 = 0 time = 205
.meas tran vdout0_17ck40 FIND v(dout0_17) AT=205.025n

* CHECK dout0_18 Vdout0_18ck40 = 0.9 time = 205
.meas tran vdout0_18ck40 FIND v(dout0_18) AT=205.025n

* CHECK dout0_19 Vdout0_19ck40 = 0.9 time = 205
.meas tran vdout0_19ck40 FIND v(dout0_19) AT=205.025n

* CHECK dout0_20 Vdout0_20ck40 = 0.9 time = 205
.meas tran vdout0_20ck40 FIND v(dout0_20) AT=205.025n

* CHECK dout0_21 Vdout0_21ck40 = 0.9 time = 205
.meas tran vdout0_21ck40 FIND v(dout0_21) AT=205.025n

* CHECK dout0_22 Vdout0_22ck40 = 0 time = 205
.meas tran vdout0_22ck40 FIND v(dout0_22) AT=205.025n

* CHECK dout0_23 Vdout0_23ck40 = 0 time = 205
.meas tran vdout0_23ck40 FIND v(dout0_23) AT=205.025n

* CHECK dout0_24 Vdout0_24ck40 = 0.9 time = 205
.meas tran vdout0_24ck40 FIND v(dout0_24) AT=205.025n

* CHECK dout0_25 Vdout0_25ck40 = 0.9 time = 205
.meas tran vdout0_25ck40 FIND v(dout0_25) AT=205.025n

* CHECK dout0_26 Vdout0_26ck40 = 0.9 time = 205
.meas tran vdout0_26ck40 FIND v(dout0_26) AT=205.025n

* CHECK dout0_27 Vdout0_27ck40 = 0 time = 205
.meas tran vdout0_27ck40 FIND v(dout0_27) AT=205.025n

* CHECK dout0_28 Vdout0_28ck40 = 0.9 time = 205
.meas tran vdout0_28ck40 FIND v(dout0_28) AT=205.025n

* CHECK dout0_29 Vdout0_29ck40 = 0.9 time = 205
.meas tran vdout0_29ck40 FIND v(dout0_29) AT=205.025n

* CHECK dout0_30 Vdout0_30ck40 = 0 time = 205
.meas tran vdout0_30ck40 FIND v(dout0_30) AT=205.025n

* CHECK dout0_31 Vdout0_31ck40 = 0 time = 205
.meas tran vdout0_31ck40 FIND v(dout0_31) AT=205.025n

* CHECK dout0_32 Vdout0_32ck40 = 0 time = 205
.meas tran vdout0_32ck40 FIND v(dout0_32) AT=205.025n

* CHECK dout0_33 Vdout0_33ck40 = 0 time = 205
.meas tran vdout0_33ck40 FIND v(dout0_33) AT=205.025n

* CHECK dout0_34 Vdout0_34ck40 = 0 time = 205
.meas tran vdout0_34ck40 FIND v(dout0_34) AT=205.025n

* CHECK dout0_35 Vdout0_35ck40 = 0 time = 205
.meas tran vdout0_35ck40 FIND v(dout0_35) AT=205.025n

* CHECK dout0_36 Vdout0_36ck40 = 0.9 time = 205
.meas tran vdout0_36ck40 FIND v(dout0_36) AT=205.025n

* CHECK dout0_37 Vdout0_37ck40 = 0 time = 205
.meas tran vdout0_37ck40 FIND v(dout0_37) AT=205.025n

* CHECK dout0_38 Vdout0_38ck40 = 0.9 time = 205
.meas tran vdout0_38ck40 FIND v(dout0_38) AT=205.025n

* CHECK dout0_39 Vdout0_39ck40 = 0 time = 205
.meas tran vdout0_39ck40 FIND v(dout0_39) AT=205.025n

* CHECK dout0_40 Vdout0_40ck40 = 0 time = 205
.meas tran vdout0_40ck40 FIND v(dout0_40) AT=205.025n

* CHECK dout0_41 Vdout0_41ck40 = 0 time = 205
.meas tran vdout0_41ck40 FIND v(dout0_41) AT=205.025n

* CHECK dout0_42 Vdout0_42ck40 = 0 time = 205
.meas tran vdout0_42ck40 FIND v(dout0_42) AT=205.025n

* CHECK dout0_43 Vdout0_43ck40 = 0.9 time = 205
.meas tran vdout0_43ck40 FIND v(dout0_43) AT=205.025n

* CHECK dout0_44 Vdout0_44ck40 = 0 time = 205
.meas tran vdout0_44ck40 FIND v(dout0_44) AT=205.025n

* CHECK dout0_45 Vdout0_45ck40 = 0.9 time = 205
.meas tran vdout0_45ck40 FIND v(dout0_45) AT=205.025n

* CHECK dout0_46 Vdout0_46ck40 = 0.9 time = 205
.meas tran vdout0_46ck40 FIND v(dout0_46) AT=205.025n

* CHECK dout0_47 Vdout0_47ck40 = 0 time = 205
.meas tran vdout0_47ck40 FIND v(dout0_47) AT=205.025n

* CHECK dout0_48 Vdout0_48ck40 = 0 time = 205
.meas tran vdout0_48ck40 FIND v(dout0_48) AT=205.025n

* CHECK dout0_49 Vdout0_49ck40 = 0.9 time = 205
.meas tran vdout0_49ck40 FIND v(dout0_49) AT=205.025n

* CHECK dout0_50 Vdout0_50ck40 = 0 time = 205
.meas tran vdout0_50ck40 FIND v(dout0_50) AT=205.025n

* CHECK dout0_51 Vdout0_51ck40 = 0 time = 205
.meas tran vdout0_51ck40 FIND v(dout0_51) AT=205.025n

* CHECK dout0_52 Vdout0_52ck40 = 0 time = 205
.meas tran vdout0_52ck40 FIND v(dout0_52) AT=205.025n

* CHECK dout0_53 Vdout0_53ck40 = 0.9 time = 205
.meas tran vdout0_53ck40 FIND v(dout0_53) AT=205.025n

* CHECK dout0_54 Vdout0_54ck40 = 0 time = 205
.meas tran vdout0_54ck40 FIND v(dout0_54) AT=205.025n

* CHECK dout0_55 Vdout0_55ck40 = 0 time = 205
.meas tran vdout0_55ck40 FIND v(dout0_55) AT=205.025n

* CHECK dout0_56 Vdout0_56ck40 = 0 time = 205
.meas tran vdout0_56ck40 FIND v(dout0_56) AT=205.025n

* CHECK dout0_57 Vdout0_57ck40 = 0 time = 205
.meas tran vdout0_57ck40 FIND v(dout0_57) AT=205.025n

* CHECK dout0_58 Vdout0_58ck40 = 0 time = 205
.meas tran vdout0_58ck40 FIND v(dout0_58) AT=205.025n

* CHECK dout0_59 Vdout0_59ck40 = 0 time = 205
.meas tran vdout0_59ck40 FIND v(dout0_59) AT=205.025n

* CHECK dout0_60 Vdout0_60ck40 = 0 time = 205
.meas tran vdout0_60ck40 FIND v(dout0_60) AT=205.025n

* CHECK dout0_61 Vdout0_61ck40 = 0.9 time = 205
.meas tran vdout0_61ck40 FIND v(dout0_61) AT=205.025n

* CHECK dout0_62 Vdout0_62ck40 = 0 time = 205
.meas tran vdout0_62ck40 FIND v(dout0_62) AT=205.025n

* CHECK dout0_63 Vdout0_63ck40 = 0.9 time = 205
.meas tran vdout0_63ck40 FIND v(dout0_63) AT=205.025n

* CHECK dout0_0 Vdout0_0ck43 = 0 time = 220
.meas tran vdout0_0ck43 FIND v(dout0_0) AT=220.025n

* CHECK dout0_1 Vdout0_1ck43 = 0 time = 220
.meas tran vdout0_1ck43 FIND v(dout0_1) AT=220.025n

* CHECK dout0_2 Vdout0_2ck43 = 0.9 time = 220
.meas tran vdout0_2ck43 FIND v(dout0_2) AT=220.025n

* CHECK dout0_3 Vdout0_3ck43 = 0 time = 220
.meas tran vdout0_3ck43 FIND v(dout0_3) AT=220.025n

* CHECK dout0_4 Vdout0_4ck43 = 0.9 time = 220
.meas tran vdout0_4ck43 FIND v(dout0_4) AT=220.025n

* CHECK dout0_5 Vdout0_5ck43 = 0.9 time = 220
.meas tran vdout0_5ck43 FIND v(dout0_5) AT=220.025n

* CHECK dout0_6 Vdout0_6ck43 = 0.9 time = 220
.meas tran vdout0_6ck43 FIND v(dout0_6) AT=220.025n

* CHECK dout0_7 Vdout0_7ck43 = 0 time = 220
.meas tran vdout0_7ck43 FIND v(dout0_7) AT=220.025n

* CHECK dout0_8 Vdout0_8ck43 = 0.9 time = 220
.meas tran vdout0_8ck43 FIND v(dout0_8) AT=220.025n

* CHECK dout0_9 Vdout0_9ck43 = 0.9 time = 220
.meas tran vdout0_9ck43 FIND v(dout0_9) AT=220.025n

* CHECK dout0_10 Vdout0_10ck43 = 0 time = 220
.meas tran vdout0_10ck43 FIND v(dout0_10) AT=220.025n

* CHECK dout0_11 Vdout0_11ck43 = 0 time = 220
.meas tran vdout0_11ck43 FIND v(dout0_11) AT=220.025n

* CHECK dout0_12 Vdout0_12ck43 = 0 time = 220
.meas tran vdout0_12ck43 FIND v(dout0_12) AT=220.025n

* CHECK dout0_13 Vdout0_13ck43 = 0 time = 220
.meas tran vdout0_13ck43 FIND v(dout0_13) AT=220.025n

* CHECK dout0_14 Vdout0_14ck43 = 0.9 time = 220
.meas tran vdout0_14ck43 FIND v(dout0_14) AT=220.025n

* CHECK dout0_15 Vdout0_15ck43 = 0 time = 220
.meas tran vdout0_15ck43 FIND v(dout0_15) AT=220.025n

* CHECK dout0_16 Vdout0_16ck43 = 0.9 time = 220
.meas tran vdout0_16ck43 FIND v(dout0_16) AT=220.025n

* CHECK dout0_17 Vdout0_17ck43 = 0.9 time = 220
.meas tran vdout0_17ck43 FIND v(dout0_17) AT=220.025n

* CHECK dout0_18 Vdout0_18ck43 = 0 time = 220
.meas tran vdout0_18ck43 FIND v(dout0_18) AT=220.025n

* CHECK dout0_19 Vdout0_19ck43 = 0.9 time = 220
.meas tran vdout0_19ck43 FIND v(dout0_19) AT=220.025n

* CHECK dout0_20 Vdout0_20ck43 = 0.9 time = 220
.meas tran vdout0_20ck43 FIND v(dout0_20) AT=220.025n

* CHECK dout0_21 Vdout0_21ck43 = 0 time = 220
.meas tran vdout0_21ck43 FIND v(dout0_21) AT=220.025n

* CHECK dout0_22 Vdout0_22ck43 = 0 time = 220
.meas tran vdout0_22ck43 FIND v(dout0_22) AT=220.025n

* CHECK dout0_23 Vdout0_23ck43 = 0.9 time = 220
.meas tran vdout0_23ck43 FIND v(dout0_23) AT=220.025n

* CHECK dout0_24 Vdout0_24ck43 = 0.9 time = 220
.meas tran vdout0_24ck43 FIND v(dout0_24) AT=220.025n

* CHECK dout0_25 Vdout0_25ck43 = 0 time = 220
.meas tran vdout0_25ck43 FIND v(dout0_25) AT=220.025n

* CHECK dout0_26 Vdout0_26ck43 = 0 time = 220
.meas tran vdout0_26ck43 FIND v(dout0_26) AT=220.025n

* CHECK dout0_27 Vdout0_27ck43 = 0.9 time = 220
.meas tran vdout0_27ck43 FIND v(dout0_27) AT=220.025n

* CHECK dout0_28 Vdout0_28ck43 = 0 time = 220
.meas tran vdout0_28ck43 FIND v(dout0_28) AT=220.025n

* CHECK dout0_29 Vdout0_29ck43 = 0.9 time = 220
.meas tran vdout0_29ck43 FIND v(dout0_29) AT=220.025n

* CHECK dout0_30 Vdout0_30ck43 = 0.9 time = 220
.meas tran vdout0_30ck43 FIND v(dout0_30) AT=220.025n

* CHECK dout0_31 Vdout0_31ck43 = 0.9 time = 220
.meas tran vdout0_31ck43 FIND v(dout0_31) AT=220.025n

* CHECK dout0_32 Vdout0_32ck43 = 0.9 time = 220
.meas tran vdout0_32ck43 FIND v(dout0_32) AT=220.025n

* CHECK dout0_33 Vdout0_33ck43 = 0.9 time = 220
.meas tran vdout0_33ck43 FIND v(dout0_33) AT=220.025n

* CHECK dout0_34 Vdout0_34ck43 = 0 time = 220
.meas tran vdout0_34ck43 FIND v(dout0_34) AT=220.025n

* CHECK dout0_35 Vdout0_35ck43 = 0 time = 220
.meas tran vdout0_35ck43 FIND v(dout0_35) AT=220.025n

* CHECK dout0_36 Vdout0_36ck43 = 0 time = 220
.meas tran vdout0_36ck43 FIND v(dout0_36) AT=220.025n

* CHECK dout0_37 Vdout0_37ck43 = 0 time = 220
.meas tran vdout0_37ck43 FIND v(dout0_37) AT=220.025n

* CHECK dout0_38 Vdout0_38ck43 = 0.9 time = 220
.meas tran vdout0_38ck43 FIND v(dout0_38) AT=220.025n

* CHECK dout0_39 Vdout0_39ck43 = 0.9 time = 220
.meas tran vdout0_39ck43 FIND v(dout0_39) AT=220.025n

* CHECK dout0_40 Vdout0_40ck43 = 0 time = 220
.meas tran vdout0_40ck43 FIND v(dout0_40) AT=220.025n

* CHECK dout0_41 Vdout0_41ck43 = 0.9 time = 220
.meas tran vdout0_41ck43 FIND v(dout0_41) AT=220.025n

* CHECK dout0_42 Vdout0_42ck43 = 0 time = 220
.meas tran vdout0_42ck43 FIND v(dout0_42) AT=220.025n

* CHECK dout0_43 Vdout0_43ck43 = 0.9 time = 220
.meas tran vdout0_43ck43 FIND v(dout0_43) AT=220.025n

* CHECK dout0_44 Vdout0_44ck43 = 0.9 time = 220
.meas tran vdout0_44ck43 FIND v(dout0_44) AT=220.025n

* CHECK dout0_45 Vdout0_45ck43 = 0.9 time = 220
.meas tran vdout0_45ck43 FIND v(dout0_45) AT=220.025n

* CHECK dout0_46 Vdout0_46ck43 = 0.9 time = 220
.meas tran vdout0_46ck43 FIND v(dout0_46) AT=220.025n

* CHECK dout0_47 Vdout0_47ck43 = 0.9 time = 220
.meas tran vdout0_47ck43 FIND v(dout0_47) AT=220.025n

* CHECK dout0_48 Vdout0_48ck43 = 0.9 time = 220
.meas tran vdout0_48ck43 FIND v(dout0_48) AT=220.025n

* CHECK dout0_49 Vdout0_49ck43 = 0 time = 220
.meas tran vdout0_49ck43 FIND v(dout0_49) AT=220.025n

* CHECK dout0_50 Vdout0_50ck43 = 0 time = 220
.meas tran vdout0_50ck43 FIND v(dout0_50) AT=220.025n

* CHECK dout0_51 Vdout0_51ck43 = 0.9 time = 220
.meas tran vdout0_51ck43 FIND v(dout0_51) AT=220.025n

* CHECK dout0_52 Vdout0_52ck43 = 0 time = 220
.meas tran vdout0_52ck43 FIND v(dout0_52) AT=220.025n

* CHECK dout0_53 Vdout0_53ck43 = 0.9 time = 220
.meas tran vdout0_53ck43 FIND v(dout0_53) AT=220.025n

* CHECK dout0_54 Vdout0_54ck43 = 0.9 time = 220
.meas tran vdout0_54ck43 FIND v(dout0_54) AT=220.025n

* CHECK dout0_55 Vdout0_55ck43 = 0.9 time = 220
.meas tran vdout0_55ck43 FIND v(dout0_55) AT=220.025n

* CHECK dout0_56 Vdout0_56ck43 = 0 time = 220
.meas tran vdout0_56ck43 FIND v(dout0_56) AT=220.025n

* CHECK dout0_57 Vdout0_57ck43 = 0 time = 220
.meas tran vdout0_57ck43 FIND v(dout0_57) AT=220.025n

* CHECK dout0_58 Vdout0_58ck43 = 0 time = 220
.meas tran vdout0_58ck43 FIND v(dout0_58) AT=220.025n

* CHECK dout0_59 Vdout0_59ck43 = 0 time = 220
.meas tran vdout0_59ck43 FIND v(dout0_59) AT=220.025n

* CHECK dout0_60 Vdout0_60ck43 = 0.9 time = 220
.meas tran vdout0_60ck43 FIND v(dout0_60) AT=220.025n

* CHECK dout0_61 Vdout0_61ck43 = 0 time = 220
.meas tran vdout0_61ck43 FIND v(dout0_61) AT=220.025n

* CHECK dout0_62 Vdout0_62ck43 = 0.9 time = 220
.meas tran vdout0_62ck43 FIND v(dout0_62) AT=220.025n

* CHECK dout0_63 Vdout0_63ck43 = 0.9 time = 220
.meas tran vdout0_63ck43 FIND v(dout0_63) AT=220.025n

* CHECK dout0_0 Vdout0_0ck44 = 0.9 time = 225
.meas tran vdout0_0ck44 FIND v(dout0_0) AT=225.025n

* CHECK dout0_1 Vdout0_1ck44 = 0.9 time = 225
.meas tran vdout0_1ck44 FIND v(dout0_1) AT=225.025n

* CHECK dout0_2 Vdout0_2ck44 = 0 time = 225
.meas tran vdout0_2ck44 FIND v(dout0_2) AT=225.025n

* CHECK dout0_3 Vdout0_3ck44 = 0 time = 225
.meas tran vdout0_3ck44 FIND v(dout0_3) AT=225.025n

* CHECK dout0_4 Vdout0_4ck44 = 0.9 time = 225
.meas tran vdout0_4ck44 FIND v(dout0_4) AT=225.025n

* CHECK dout0_5 Vdout0_5ck44 = 0.9 time = 225
.meas tran vdout0_5ck44 FIND v(dout0_5) AT=225.025n

* CHECK dout0_6 Vdout0_6ck44 = 0 time = 225
.meas tran vdout0_6ck44 FIND v(dout0_6) AT=225.025n

* CHECK dout0_7 Vdout0_7ck44 = 0.9 time = 225
.meas tran vdout0_7ck44 FIND v(dout0_7) AT=225.025n

* CHECK dout0_8 Vdout0_8ck44 = 0.9 time = 225
.meas tran vdout0_8ck44 FIND v(dout0_8) AT=225.025n

* CHECK dout0_9 Vdout0_9ck44 = 0 time = 225
.meas tran vdout0_9ck44 FIND v(dout0_9) AT=225.025n

* CHECK dout0_10 Vdout0_10ck44 = 0 time = 225
.meas tran vdout0_10ck44 FIND v(dout0_10) AT=225.025n

* CHECK dout0_11 Vdout0_11ck44 = 0 time = 225
.meas tran vdout0_11ck44 FIND v(dout0_11) AT=225.025n

* CHECK dout0_12 Vdout0_12ck44 = 0 time = 225
.meas tran vdout0_12ck44 FIND v(dout0_12) AT=225.025n

* CHECK dout0_13 Vdout0_13ck44 = 0 time = 225
.meas tran vdout0_13ck44 FIND v(dout0_13) AT=225.025n

* CHECK dout0_14 Vdout0_14ck44 = 0 time = 225
.meas tran vdout0_14ck44 FIND v(dout0_14) AT=225.025n

* CHECK dout0_15 Vdout0_15ck44 = 0.9 time = 225
.meas tran vdout0_15ck44 FIND v(dout0_15) AT=225.025n

* CHECK dout0_16 Vdout0_16ck44 = 0.9 time = 225
.meas tran vdout0_16ck44 FIND v(dout0_16) AT=225.025n

* CHECK dout0_17 Vdout0_17ck44 = 0.9 time = 225
.meas tran vdout0_17ck44 FIND v(dout0_17) AT=225.025n

* CHECK dout0_18 Vdout0_18ck44 = 0.9 time = 225
.meas tran vdout0_18ck44 FIND v(dout0_18) AT=225.025n

* CHECK dout0_19 Vdout0_19ck44 = 0 time = 225
.meas tran vdout0_19ck44 FIND v(dout0_19) AT=225.025n

* CHECK dout0_20 Vdout0_20ck44 = 0.9 time = 225
.meas tran vdout0_20ck44 FIND v(dout0_20) AT=225.025n

* CHECK dout0_21 Vdout0_21ck44 = 0.9 time = 225
.meas tran vdout0_21ck44 FIND v(dout0_21) AT=225.025n

* CHECK dout0_22 Vdout0_22ck44 = 0.9 time = 225
.meas tran vdout0_22ck44 FIND v(dout0_22) AT=225.025n

* CHECK dout0_23 Vdout0_23ck44 = 0.9 time = 225
.meas tran vdout0_23ck44 FIND v(dout0_23) AT=225.025n

* CHECK dout0_24 Vdout0_24ck44 = 0 time = 225
.meas tran vdout0_24ck44 FIND v(dout0_24) AT=225.025n

* CHECK dout0_25 Vdout0_25ck44 = 0 time = 225
.meas tran vdout0_25ck44 FIND v(dout0_25) AT=225.025n

* CHECK dout0_26 Vdout0_26ck44 = 0 time = 225
.meas tran vdout0_26ck44 FIND v(dout0_26) AT=225.025n

* CHECK dout0_27 Vdout0_27ck44 = 0 time = 225
.meas tran vdout0_27ck44 FIND v(dout0_27) AT=225.025n

* CHECK dout0_28 Vdout0_28ck44 = 0 time = 225
.meas tran vdout0_28ck44 FIND v(dout0_28) AT=225.025n

* CHECK dout0_29 Vdout0_29ck44 = 0 time = 225
.meas tran vdout0_29ck44 FIND v(dout0_29) AT=225.025n

* CHECK dout0_30 Vdout0_30ck44 = 0.9 time = 225
.meas tran vdout0_30ck44 FIND v(dout0_30) AT=225.025n

* CHECK dout0_31 Vdout0_31ck44 = 0 time = 225
.meas tran vdout0_31ck44 FIND v(dout0_31) AT=225.025n

* CHECK dout0_32 Vdout0_32ck44 = 0 time = 225
.meas tran vdout0_32ck44 FIND v(dout0_32) AT=225.025n

* CHECK dout0_33 Vdout0_33ck44 = 0.9 time = 225
.meas tran vdout0_33ck44 FIND v(dout0_33) AT=225.025n

* CHECK dout0_34 Vdout0_34ck44 = 0.9 time = 225
.meas tran vdout0_34ck44 FIND v(dout0_34) AT=225.025n

* CHECK dout0_35 Vdout0_35ck44 = 0 time = 225
.meas tran vdout0_35ck44 FIND v(dout0_35) AT=225.025n

* CHECK dout0_36 Vdout0_36ck44 = 0 time = 225
.meas tran vdout0_36ck44 FIND v(dout0_36) AT=225.025n

* CHECK dout0_37 Vdout0_37ck44 = 0 time = 225
.meas tran vdout0_37ck44 FIND v(dout0_37) AT=225.025n

* CHECK dout0_38 Vdout0_38ck44 = 0.9 time = 225
.meas tran vdout0_38ck44 FIND v(dout0_38) AT=225.025n

* CHECK dout0_39 Vdout0_39ck44 = 0 time = 225
.meas tran vdout0_39ck44 FIND v(dout0_39) AT=225.025n

* CHECK dout0_40 Vdout0_40ck44 = 0 time = 225
.meas tran vdout0_40ck44 FIND v(dout0_40) AT=225.025n

* CHECK dout0_41 Vdout0_41ck44 = 0 time = 225
.meas tran vdout0_41ck44 FIND v(dout0_41) AT=225.025n

* CHECK dout0_42 Vdout0_42ck44 = 0.9 time = 225
.meas tran vdout0_42ck44 FIND v(dout0_42) AT=225.025n

* CHECK dout0_43 Vdout0_43ck44 = 0.9 time = 225
.meas tran vdout0_43ck44 FIND v(dout0_43) AT=225.025n

* CHECK dout0_44 Vdout0_44ck44 = 0.9 time = 225
.meas tran vdout0_44ck44 FIND v(dout0_44) AT=225.025n

* CHECK dout0_45 Vdout0_45ck44 = 0 time = 225
.meas tran vdout0_45ck44 FIND v(dout0_45) AT=225.025n

* CHECK dout0_46 Vdout0_46ck44 = 0 time = 225
.meas tran vdout0_46ck44 FIND v(dout0_46) AT=225.025n

* CHECK dout0_47 Vdout0_47ck44 = 0 time = 225
.meas tran vdout0_47ck44 FIND v(dout0_47) AT=225.025n

* CHECK dout0_48 Vdout0_48ck44 = 0.9 time = 225
.meas tran vdout0_48ck44 FIND v(dout0_48) AT=225.025n

* CHECK dout0_49 Vdout0_49ck44 = 0 time = 225
.meas tran vdout0_49ck44 FIND v(dout0_49) AT=225.025n

* CHECK dout0_50 Vdout0_50ck44 = 0 time = 225
.meas tran vdout0_50ck44 FIND v(dout0_50) AT=225.025n

* CHECK dout0_51 Vdout0_51ck44 = 0 time = 225
.meas tran vdout0_51ck44 FIND v(dout0_51) AT=225.025n

* CHECK dout0_52 Vdout0_52ck44 = 0 time = 225
.meas tran vdout0_52ck44 FIND v(dout0_52) AT=225.025n

* CHECK dout0_53 Vdout0_53ck44 = 0 time = 225
.meas tran vdout0_53ck44 FIND v(dout0_53) AT=225.025n

* CHECK dout0_54 Vdout0_54ck44 = 0 time = 225
.meas tran vdout0_54ck44 FIND v(dout0_54) AT=225.025n

* CHECK dout0_55 Vdout0_55ck44 = 0.9 time = 225
.meas tran vdout0_55ck44 FIND v(dout0_55) AT=225.025n

* CHECK dout0_56 Vdout0_56ck44 = 0 time = 225
.meas tran vdout0_56ck44 FIND v(dout0_56) AT=225.025n

* CHECK dout0_57 Vdout0_57ck44 = 0.9 time = 225
.meas tran vdout0_57ck44 FIND v(dout0_57) AT=225.025n

* CHECK dout0_58 Vdout0_58ck44 = 0 time = 225
.meas tran vdout0_58ck44 FIND v(dout0_58) AT=225.025n

* CHECK dout0_59 Vdout0_59ck44 = 0.9 time = 225
.meas tran vdout0_59ck44 FIND v(dout0_59) AT=225.025n

* CHECK dout0_60 Vdout0_60ck44 = 0 time = 225
.meas tran vdout0_60ck44 FIND v(dout0_60) AT=225.025n

* CHECK dout0_61 Vdout0_61ck44 = 0.9 time = 225
.meas tran vdout0_61ck44 FIND v(dout0_61) AT=225.025n

* CHECK dout0_62 Vdout0_62ck44 = 0.9 time = 225
.meas tran vdout0_62ck44 FIND v(dout0_62) AT=225.025n

* CHECK dout0_63 Vdout0_63ck44 = 0 time = 225
.meas tran vdout0_63ck44 FIND v(dout0_63) AT=225.025n

* CHECK dout0_0 Vdout0_0ck47 = 0 time = 240
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=240.025n

* CHECK dout0_1 Vdout0_1ck47 = 0.9 time = 240
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=240.025n

* CHECK dout0_2 Vdout0_2ck47 = 0 time = 240
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=240.025n

* CHECK dout0_3 Vdout0_3ck47 = 0.9 time = 240
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=240.025n

* CHECK dout0_4 Vdout0_4ck47 = 0.9 time = 240
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=240.025n

* CHECK dout0_5 Vdout0_5ck47 = 0.9 time = 240
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=240.025n

* CHECK dout0_6 Vdout0_6ck47 = 0.9 time = 240
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=240.025n

* CHECK dout0_7 Vdout0_7ck47 = 0 time = 240
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=240.025n

* CHECK dout0_8 Vdout0_8ck47 = 0 time = 240
.meas tran vdout0_8ck47 FIND v(dout0_8) AT=240.025n

* CHECK dout0_9 Vdout0_9ck47 = 0 time = 240
.meas tran vdout0_9ck47 FIND v(dout0_9) AT=240.025n

* CHECK dout0_10 Vdout0_10ck47 = 0 time = 240
.meas tran vdout0_10ck47 FIND v(dout0_10) AT=240.025n

* CHECK dout0_11 Vdout0_11ck47 = 0 time = 240
.meas tran vdout0_11ck47 FIND v(dout0_11) AT=240.025n

* CHECK dout0_12 Vdout0_12ck47 = 0 time = 240
.meas tran vdout0_12ck47 FIND v(dout0_12) AT=240.025n

* CHECK dout0_13 Vdout0_13ck47 = 0 time = 240
.meas tran vdout0_13ck47 FIND v(dout0_13) AT=240.025n

* CHECK dout0_14 Vdout0_14ck47 = 0 time = 240
.meas tran vdout0_14ck47 FIND v(dout0_14) AT=240.025n

* CHECK dout0_15 Vdout0_15ck47 = 0.9 time = 240
.meas tran vdout0_15ck47 FIND v(dout0_15) AT=240.025n

* CHECK dout0_16 Vdout0_16ck47 = 0.9 time = 240
.meas tran vdout0_16ck47 FIND v(dout0_16) AT=240.025n

* CHECK dout0_17 Vdout0_17ck47 = 0 time = 240
.meas tran vdout0_17ck47 FIND v(dout0_17) AT=240.025n

* CHECK dout0_18 Vdout0_18ck47 = 0.9 time = 240
.meas tran vdout0_18ck47 FIND v(dout0_18) AT=240.025n

* CHECK dout0_19 Vdout0_19ck47 = 0 time = 240
.meas tran vdout0_19ck47 FIND v(dout0_19) AT=240.025n

* CHECK dout0_20 Vdout0_20ck47 = 0.9 time = 240
.meas tran vdout0_20ck47 FIND v(dout0_20) AT=240.025n

* CHECK dout0_21 Vdout0_21ck47 = 0.9 time = 240
.meas tran vdout0_21ck47 FIND v(dout0_21) AT=240.025n

* CHECK dout0_22 Vdout0_22ck47 = 0 time = 240
.meas tran vdout0_22ck47 FIND v(dout0_22) AT=240.025n

* CHECK dout0_23 Vdout0_23ck47 = 0 time = 240
.meas tran vdout0_23ck47 FIND v(dout0_23) AT=240.025n

* CHECK dout0_24 Vdout0_24ck47 = 0.9 time = 240
.meas tran vdout0_24ck47 FIND v(dout0_24) AT=240.025n

* CHECK dout0_25 Vdout0_25ck47 = 0.9 time = 240
.meas tran vdout0_25ck47 FIND v(dout0_25) AT=240.025n

* CHECK dout0_26 Vdout0_26ck47 = 0 time = 240
.meas tran vdout0_26ck47 FIND v(dout0_26) AT=240.025n

* CHECK dout0_27 Vdout0_27ck47 = 0 time = 240
.meas tran vdout0_27ck47 FIND v(dout0_27) AT=240.025n

* CHECK dout0_28 Vdout0_28ck47 = 0 time = 240
.meas tran vdout0_28ck47 FIND v(dout0_28) AT=240.025n

* CHECK dout0_29 Vdout0_29ck47 = 0.9 time = 240
.meas tran vdout0_29ck47 FIND v(dout0_29) AT=240.025n

* CHECK dout0_30 Vdout0_30ck47 = 0 time = 240
.meas tran vdout0_30ck47 FIND v(dout0_30) AT=240.025n

* CHECK dout0_31 Vdout0_31ck47 = 0 time = 240
.meas tran vdout0_31ck47 FIND v(dout0_31) AT=240.025n

* CHECK dout0_32 Vdout0_32ck47 = 0 time = 240
.meas tran vdout0_32ck47 FIND v(dout0_32) AT=240.025n

* CHECK dout0_33 Vdout0_33ck47 = 0 time = 240
.meas tran vdout0_33ck47 FIND v(dout0_33) AT=240.025n

* CHECK dout0_34 Vdout0_34ck47 = 0 time = 240
.meas tran vdout0_34ck47 FIND v(dout0_34) AT=240.025n

* CHECK dout0_35 Vdout0_35ck47 = 0 time = 240
.meas tran vdout0_35ck47 FIND v(dout0_35) AT=240.025n

* CHECK dout0_36 Vdout0_36ck47 = 0 time = 240
.meas tran vdout0_36ck47 FIND v(dout0_36) AT=240.025n

* CHECK dout0_37 Vdout0_37ck47 = 0.9 time = 240
.meas tran vdout0_37ck47 FIND v(dout0_37) AT=240.025n

* CHECK dout0_38 Vdout0_38ck47 = 0 time = 240
.meas tran vdout0_38ck47 FIND v(dout0_38) AT=240.025n

* CHECK dout0_39 Vdout0_39ck47 = 0 time = 240
.meas tran vdout0_39ck47 FIND v(dout0_39) AT=240.025n

* CHECK dout0_40 Vdout0_40ck47 = 0 time = 240
.meas tran vdout0_40ck47 FIND v(dout0_40) AT=240.025n

* CHECK dout0_41 Vdout0_41ck47 = 0.9 time = 240
.meas tran vdout0_41ck47 FIND v(dout0_41) AT=240.025n

* CHECK dout0_42 Vdout0_42ck47 = 0 time = 240
.meas tran vdout0_42ck47 FIND v(dout0_42) AT=240.025n

* CHECK dout0_43 Vdout0_43ck47 = 0.9 time = 240
.meas tran vdout0_43ck47 FIND v(dout0_43) AT=240.025n

* CHECK dout0_44 Vdout0_44ck47 = 0 time = 240
.meas tran vdout0_44ck47 FIND v(dout0_44) AT=240.025n

* CHECK dout0_45 Vdout0_45ck47 = 0.9 time = 240
.meas tran vdout0_45ck47 FIND v(dout0_45) AT=240.025n

* CHECK dout0_46 Vdout0_46ck47 = 0 time = 240
.meas tran vdout0_46ck47 FIND v(dout0_46) AT=240.025n

* CHECK dout0_47 Vdout0_47ck47 = 0.9 time = 240
.meas tran vdout0_47ck47 FIND v(dout0_47) AT=240.025n

* CHECK dout0_48 Vdout0_48ck47 = 0.9 time = 240
.meas tran vdout0_48ck47 FIND v(dout0_48) AT=240.025n

* CHECK dout0_49 Vdout0_49ck47 = 0 time = 240
.meas tran vdout0_49ck47 FIND v(dout0_49) AT=240.025n

* CHECK dout0_50 Vdout0_50ck47 = 0 time = 240
.meas tran vdout0_50ck47 FIND v(dout0_50) AT=240.025n

* CHECK dout0_51 Vdout0_51ck47 = 0.9 time = 240
.meas tran vdout0_51ck47 FIND v(dout0_51) AT=240.025n

* CHECK dout0_52 Vdout0_52ck47 = 0 time = 240
.meas tran vdout0_52ck47 FIND v(dout0_52) AT=240.025n

* CHECK dout0_53 Vdout0_53ck47 = 0 time = 240
.meas tran vdout0_53ck47 FIND v(dout0_53) AT=240.025n

* CHECK dout0_54 Vdout0_54ck47 = 0.9 time = 240
.meas tran vdout0_54ck47 FIND v(dout0_54) AT=240.025n

* CHECK dout0_55 Vdout0_55ck47 = 0.9 time = 240
.meas tran vdout0_55ck47 FIND v(dout0_55) AT=240.025n

* CHECK dout0_56 Vdout0_56ck47 = 0.9 time = 240
.meas tran vdout0_56ck47 FIND v(dout0_56) AT=240.025n

* CHECK dout0_57 Vdout0_57ck47 = 0.9 time = 240
.meas tran vdout0_57ck47 FIND v(dout0_57) AT=240.025n

* CHECK dout0_58 Vdout0_58ck47 = 0 time = 240
.meas tran vdout0_58ck47 FIND v(dout0_58) AT=240.025n

* CHECK dout0_59 Vdout0_59ck47 = 0.9 time = 240
.meas tran vdout0_59ck47 FIND v(dout0_59) AT=240.025n

* CHECK dout0_60 Vdout0_60ck47 = 0 time = 240
.meas tran vdout0_60ck47 FIND v(dout0_60) AT=240.025n

* CHECK dout0_61 Vdout0_61ck47 = 0.9 time = 240
.meas tran vdout0_61ck47 FIND v(dout0_61) AT=240.025n

* CHECK dout0_62 Vdout0_62ck47 = 0.9 time = 240
.meas tran vdout0_62ck47 FIND v(dout0_62) AT=240.025n

* CHECK dout0_63 Vdout0_63ck47 = 0.9 time = 240
.meas tran vdout0_63ck47 FIND v(dout0_63) AT=240.025n

* CHECK dout0_0 Vdout0_0ck48 = 0 time = 245
.meas tran vdout0_0ck48 FIND v(dout0_0) AT=245.025n

* CHECK dout0_1 Vdout0_1ck48 = 0.9 time = 245
.meas tran vdout0_1ck48 FIND v(dout0_1) AT=245.025n

* CHECK dout0_2 Vdout0_2ck48 = 0 time = 245
.meas tran vdout0_2ck48 FIND v(dout0_2) AT=245.025n

* CHECK dout0_3 Vdout0_3ck48 = 0.9 time = 245
.meas tran vdout0_3ck48 FIND v(dout0_3) AT=245.025n

* CHECK dout0_4 Vdout0_4ck48 = 0.9 time = 245
.meas tran vdout0_4ck48 FIND v(dout0_4) AT=245.025n

* CHECK dout0_5 Vdout0_5ck48 = 0.9 time = 245
.meas tran vdout0_5ck48 FIND v(dout0_5) AT=245.025n

* CHECK dout0_6 Vdout0_6ck48 = 0.9 time = 245
.meas tran vdout0_6ck48 FIND v(dout0_6) AT=245.025n

* CHECK dout0_7 Vdout0_7ck48 = 0 time = 245
.meas tran vdout0_7ck48 FIND v(dout0_7) AT=245.025n

* CHECK dout0_8 Vdout0_8ck48 = 0 time = 245
.meas tran vdout0_8ck48 FIND v(dout0_8) AT=245.025n

* CHECK dout0_9 Vdout0_9ck48 = 0 time = 245
.meas tran vdout0_9ck48 FIND v(dout0_9) AT=245.025n

* CHECK dout0_10 Vdout0_10ck48 = 0 time = 245
.meas tran vdout0_10ck48 FIND v(dout0_10) AT=245.025n

* CHECK dout0_11 Vdout0_11ck48 = 0 time = 245
.meas tran vdout0_11ck48 FIND v(dout0_11) AT=245.025n

* CHECK dout0_12 Vdout0_12ck48 = 0 time = 245
.meas tran vdout0_12ck48 FIND v(dout0_12) AT=245.025n

* CHECK dout0_13 Vdout0_13ck48 = 0 time = 245
.meas tran vdout0_13ck48 FIND v(dout0_13) AT=245.025n

* CHECK dout0_14 Vdout0_14ck48 = 0 time = 245
.meas tran vdout0_14ck48 FIND v(dout0_14) AT=245.025n

* CHECK dout0_15 Vdout0_15ck48 = 0.9 time = 245
.meas tran vdout0_15ck48 FIND v(dout0_15) AT=245.025n

* CHECK dout0_16 Vdout0_16ck48 = 0.9 time = 245
.meas tran vdout0_16ck48 FIND v(dout0_16) AT=245.025n

* CHECK dout0_17 Vdout0_17ck48 = 0 time = 245
.meas tran vdout0_17ck48 FIND v(dout0_17) AT=245.025n

* CHECK dout0_18 Vdout0_18ck48 = 0.9 time = 245
.meas tran vdout0_18ck48 FIND v(dout0_18) AT=245.025n

* CHECK dout0_19 Vdout0_19ck48 = 0 time = 245
.meas tran vdout0_19ck48 FIND v(dout0_19) AT=245.025n

* CHECK dout0_20 Vdout0_20ck48 = 0.9 time = 245
.meas tran vdout0_20ck48 FIND v(dout0_20) AT=245.025n

* CHECK dout0_21 Vdout0_21ck48 = 0.9 time = 245
.meas tran vdout0_21ck48 FIND v(dout0_21) AT=245.025n

* CHECK dout0_22 Vdout0_22ck48 = 0 time = 245
.meas tran vdout0_22ck48 FIND v(dout0_22) AT=245.025n

* CHECK dout0_23 Vdout0_23ck48 = 0 time = 245
.meas tran vdout0_23ck48 FIND v(dout0_23) AT=245.025n

* CHECK dout0_24 Vdout0_24ck48 = 0.9 time = 245
.meas tran vdout0_24ck48 FIND v(dout0_24) AT=245.025n

* CHECK dout0_25 Vdout0_25ck48 = 0.9 time = 245
.meas tran vdout0_25ck48 FIND v(dout0_25) AT=245.025n

* CHECK dout0_26 Vdout0_26ck48 = 0 time = 245
.meas tran vdout0_26ck48 FIND v(dout0_26) AT=245.025n

* CHECK dout0_27 Vdout0_27ck48 = 0 time = 245
.meas tran vdout0_27ck48 FIND v(dout0_27) AT=245.025n

* CHECK dout0_28 Vdout0_28ck48 = 0 time = 245
.meas tran vdout0_28ck48 FIND v(dout0_28) AT=245.025n

* CHECK dout0_29 Vdout0_29ck48 = 0.9 time = 245
.meas tran vdout0_29ck48 FIND v(dout0_29) AT=245.025n

* CHECK dout0_30 Vdout0_30ck48 = 0 time = 245
.meas tran vdout0_30ck48 FIND v(dout0_30) AT=245.025n

* CHECK dout0_31 Vdout0_31ck48 = 0 time = 245
.meas tran vdout0_31ck48 FIND v(dout0_31) AT=245.025n

* CHECK dout0_32 Vdout0_32ck48 = 0 time = 245
.meas tran vdout0_32ck48 FIND v(dout0_32) AT=245.025n

* CHECK dout0_33 Vdout0_33ck48 = 0 time = 245
.meas tran vdout0_33ck48 FIND v(dout0_33) AT=245.025n

* CHECK dout0_34 Vdout0_34ck48 = 0 time = 245
.meas tran vdout0_34ck48 FIND v(dout0_34) AT=245.025n

* CHECK dout0_35 Vdout0_35ck48 = 0 time = 245
.meas tran vdout0_35ck48 FIND v(dout0_35) AT=245.025n

* CHECK dout0_36 Vdout0_36ck48 = 0 time = 245
.meas tran vdout0_36ck48 FIND v(dout0_36) AT=245.025n

* CHECK dout0_37 Vdout0_37ck48 = 0.9 time = 245
.meas tran vdout0_37ck48 FIND v(dout0_37) AT=245.025n

* CHECK dout0_38 Vdout0_38ck48 = 0 time = 245
.meas tran vdout0_38ck48 FIND v(dout0_38) AT=245.025n

* CHECK dout0_39 Vdout0_39ck48 = 0 time = 245
.meas tran vdout0_39ck48 FIND v(dout0_39) AT=245.025n

* CHECK dout0_40 Vdout0_40ck48 = 0 time = 245
.meas tran vdout0_40ck48 FIND v(dout0_40) AT=245.025n

* CHECK dout0_41 Vdout0_41ck48 = 0.9 time = 245
.meas tran vdout0_41ck48 FIND v(dout0_41) AT=245.025n

* CHECK dout0_42 Vdout0_42ck48 = 0 time = 245
.meas tran vdout0_42ck48 FIND v(dout0_42) AT=245.025n

* CHECK dout0_43 Vdout0_43ck48 = 0.9 time = 245
.meas tran vdout0_43ck48 FIND v(dout0_43) AT=245.025n

* CHECK dout0_44 Vdout0_44ck48 = 0 time = 245
.meas tran vdout0_44ck48 FIND v(dout0_44) AT=245.025n

* CHECK dout0_45 Vdout0_45ck48 = 0.9 time = 245
.meas tran vdout0_45ck48 FIND v(dout0_45) AT=245.025n

* CHECK dout0_46 Vdout0_46ck48 = 0 time = 245
.meas tran vdout0_46ck48 FIND v(dout0_46) AT=245.025n

* CHECK dout0_47 Vdout0_47ck48 = 0.9 time = 245
.meas tran vdout0_47ck48 FIND v(dout0_47) AT=245.025n

* CHECK dout0_48 Vdout0_48ck48 = 0.9 time = 245
.meas tran vdout0_48ck48 FIND v(dout0_48) AT=245.025n

* CHECK dout0_49 Vdout0_49ck48 = 0 time = 245
.meas tran vdout0_49ck48 FIND v(dout0_49) AT=245.025n

* CHECK dout0_50 Vdout0_50ck48 = 0 time = 245
.meas tran vdout0_50ck48 FIND v(dout0_50) AT=245.025n

* CHECK dout0_51 Vdout0_51ck48 = 0.9 time = 245
.meas tran vdout0_51ck48 FIND v(dout0_51) AT=245.025n

* CHECK dout0_52 Vdout0_52ck48 = 0 time = 245
.meas tran vdout0_52ck48 FIND v(dout0_52) AT=245.025n

* CHECK dout0_53 Vdout0_53ck48 = 0 time = 245
.meas tran vdout0_53ck48 FIND v(dout0_53) AT=245.025n

* CHECK dout0_54 Vdout0_54ck48 = 0.9 time = 245
.meas tran vdout0_54ck48 FIND v(dout0_54) AT=245.025n

* CHECK dout0_55 Vdout0_55ck48 = 0.9 time = 245
.meas tran vdout0_55ck48 FIND v(dout0_55) AT=245.025n

* CHECK dout0_56 Vdout0_56ck48 = 0.9 time = 245
.meas tran vdout0_56ck48 FIND v(dout0_56) AT=245.025n

* CHECK dout0_57 Vdout0_57ck48 = 0.9 time = 245
.meas tran vdout0_57ck48 FIND v(dout0_57) AT=245.025n

* CHECK dout0_58 Vdout0_58ck48 = 0 time = 245
.meas tran vdout0_58ck48 FIND v(dout0_58) AT=245.025n

* CHECK dout0_59 Vdout0_59ck48 = 0.9 time = 245
.meas tran vdout0_59ck48 FIND v(dout0_59) AT=245.025n

* CHECK dout0_60 Vdout0_60ck48 = 0 time = 245
.meas tran vdout0_60ck48 FIND v(dout0_60) AT=245.025n

* CHECK dout0_61 Vdout0_61ck48 = 0.9 time = 245
.meas tran vdout0_61ck48 FIND v(dout0_61) AT=245.025n

* CHECK dout0_62 Vdout0_62ck48 = 0.9 time = 245
.meas tran vdout0_62ck48 FIND v(dout0_62) AT=245.025n

* CHECK dout0_63 Vdout0_63ck48 = 0.9 time = 245
.meas tran vdout0_63ck48 FIND v(dout0_63) AT=245.025n

* CHECK dout0_0 Vdout0_0ck50 = 0 time = 255
.meas tran vdout0_0ck50 FIND v(dout0_0) AT=255.025n

* CHECK dout0_1 Vdout0_1ck50 = 0.9 time = 255
.meas tran vdout0_1ck50 FIND v(dout0_1) AT=255.025n

* CHECK dout0_2 Vdout0_2ck50 = 0 time = 255
.meas tran vdout0_2ck50 FIND v(dout0_2) AT=255.025n

* CHECK dout0_3 Vdout0_3ck50 = 0.9 time = 255
.meas tran vdout0_3ck50 FIND v(dout0_3) AT=255.025n

* CHECK dout0_4 Vdout0_4ck50 = 0 time = 255
.meas tran vdout0_4ck50 FIND v(dout0_4) AT=255.025n

* CHECK dout0_5 Vdout0_5ck50 = 0.9 time = 255
.meas tran vdout0_5ck50 FIND v(dout0_5) AT=255.025n

* CHECK dout0_6 Vdout0_6ck50 = 0.9 time = 255
.meas tran vdout0_6ck50 FIND v(dout0_6) AT=255.025n

* CHECK dout0_7 Vdout0_7ck50 = 0.9 time = 255
.meas tran vdout0_7ck50 FIND v(dout0_7) AT=255.025n

* CHECK dout0_8 Vdout0_8ck50 = 0.9 time = 255
.meas tran vdout0_8ck50 FIND v(dout0_8) AT=255.025n

* CHECK dout0_9 Vdout0_9ck50 = 0 time = 255
.meas tran vdout0_9ck50 FIND v(dout0_9) AT=255.025n

* CHECK dout0_10 Vdout0_10ck50 = 0 time = 255
.meas tran vdout0_10ck50 FIND v(dout0_10) AT=255.025n

* CHECK dout0_11 Vdout0_11ck50 = 0.9 time = 255
.meas tran vdout0_11ck50 FIND v(dout0_11) AT=255.025n

* CHECK dout0_12 Vdout0_12ck50 = 0 time = 255
.meas tran vdout0_12ck50 FIND v(dout0_12) AT=255.025n

* CHECK dout0_13 Vdout0_13ck50 = 0 time = 255
.meas tran vdout0_13ck50 FIND v(dout0_13) AT=255.025n

* CHECK dout0_14 Vdout0_14ck50 = 0 time = 255
.meas tran vdout0_14ck50 FIND v(dout0_14) AT=255.025n

* CHECK dout0_15 Vdout0_15ck50 = 0.9 time = 255
.meas tran vdout0_15ck50 FIND v(dout0_15) AT=255.025n

* CHECK dout0_16 Vdout0_16ck50 = 0 time = 255
.meas tran vdout0_16ck50 FIND v(dout0_16) AT=255.025n

* CHECK dout0_17 Vdout0_17ck50 = 0 time = 255
.meas tran vdout0_17ck50 FIND v(dout0_17) AT=255.025n

* CHECK dout0_18 Vdout0_18ck50 = 0.9 time = 255
.meas tran vdout0_18ck50 FIND v(dout0_18) AT=255.025n

* CHECK dout0_19 Vdout0_19ck50 = 0.9 time = 255
.meas tran vdout0_19ck50 FIND v(dout0_19) AT=255.025n

* CHECK dout0_20 Vdout0_20ck50 = 0.9 time = 255
.meas tran vdout0_20ck50 FIND v(dout0_20) AT=255.025n

* CHECK dout0_21 Vdout0_21ck50 = 0.9 time = 255
.meas tran vdout0_21ck50 FIND v(dout0_21) AT=255.025n

* CHECK dout0_22 Vdout0_22ck50 = 0 time = 255
.meas tran vdout0_22ck50 FIND v(dout0_22) AT=255.025n

* CHECK dout0_23 Vdout0_23ck50 = 0 time = 255
.meas tran vdout0_23ck50 FIND v(dout0_23) AT=255.025n

* CHECK dout0_24 Vdout0_24ck50 = 0.9 time = 255
.meas tran vdout0_24ck50 FIND v(dout0_24) AT=255.025n

* CHECK dout0_25 Vdout0_25ck50 = 0.9 time = 255
.meas tran vdout0_25ck50 FIND v(dout0_25) AT=255.025n

* CHECK dout0_26 Vdout0_26ck50 = 0.9 time = 255
.meas tran vdout0_26ck50 FIND v(dout0_26) AT=255.025n

* CHECK dout0_27 Vdout0_27ck50 = 0 time = 255
.meas tran vdout0_27ck50 FIND v(dout0_27) AT=255.025n

* CHECK dout0_28 Vdout0_28ck50 = 0.9 time = 255
.meas tran vdout0_28ck50 FIND v(dout0_28) AT=255.025n

* CHECK dout0_29 Vdout0_29ck50 = 0.9 time = 255
.meas tran vdout0_29ck50 FIND v(dout0_29) AT=255.025n

* CHECK dout0_30 Vdout0_30ck50 = 0 time = 255
.meas tran vdout0_30ck50 FIND v(dout0_30) AT=255.025n

* CHECK dout0_31 Vdout0_31ck50 = 0 time = 255
.meas tran vdout0_31ck50 FIND v(dout0_31) AT=255.025n

* CHECK dout0_32 Vdout0_32ck50 = 0 time = 255
.meas tran vdout0_32ck50 FIND v(dout0_32) AT=255.025n

* CHECK dout0_33 Vdout0_33ck50 = 0 time = 255
.meas tran vdout0_33ck50 FIND v(dout0_33) AT=255.025n

* CHECK dout0_34 Vdout0_34ck50 = 0 time = 255
.meas tran vdout0_34ck50 FIND v(dout0_34) AT=255.025n

* CHECK dout0_35 Vdout0_35ck50 = 0 time = 255
.meas tran vdout0_35ck50 FIND v(dout0_35) AT=255.025n

* CHECK dout0_36 Vdout0_36ck50 = 0.9 time = 255
.meas tran vdout0_36ck50 FIND v(dout0_36) AT=255.025n

* CHECK dout0_37 Vdout0_37ck50 = 0 time = 255
.meas tran vdout0_37ck50 FIND v(dout0_37) AT=255.025n

* CHECK dout0_38 Vdout0_38ck50 = 0.9 time = 255
.meas tran vdout0_38ck50 FIND v(dout0_38) AT=255.025n

* CHECK dout0_39 Vdout0_39ck50 = 0 time = 255
.meas tran vdout0_39ck50 FIND v(dout0_39) AT=255.025n

* CHECK dout0_40 Vdout0_40ck50 = 0 time = 255
.meas tran vdout0_40ck50 FIND v(dout0_40) AT=255.025n

* CHECK dout0_41 Vdout0_41ck50 = 0 time = 255
.meas tran vdout0_41ck50 FIND v(dout0_41) AT=255.025n

* CHECK dout0_42 Vdout0_42ck50 = 0 time = 255
.meas tran vdout0_42ck50 FIND v(dout0_42) AT=255.025n

* CHECK dout0_43 Vdout0_43ck50 = 0.9 time = 255
.meas tran vdout0_43ck50 FIND v(dout0_43) AT=255.025n

* CHECK dout0_44 Vdout0_44ck50 = 0 time = 255
.meas tran vdout0_44ck50 FIND v(dout0_44) AT=255.025n

* CHECK dout0_45 Vdout0_45ck50 = 0.9 time = 255
.meas tran vdout0_45ck50 FIND v(dout0_45) AT=255.025n

* CHECK dout0_46 Vdout0_46ck50 = 0.9 time = 255
.meas tran vdout0_46ck50 FIND v(dout0_46) AT=255.025n

* CHECK dout0_47 Vdout0_47ck50 = 0 time = 255
.meas tran vdout0_47ck50 FIND v(dout0_47) AT=255.025n

* CHECK dout0_48 Vdout0_48ck50 = 0 time = 255
.meas tran vdout0_48ck50 FIND v(dout0_48) AT=255.025n

* CHECK dout0_49 Vdout0_49ck50 = 0.9 time = 255
.meas tran vdout0_49ck50 FIND v(dout0_49) AT=255.025n

* CHECK dout0_50 Vdout0_50ck50 = 0 time = 255
.meas tran vdout0_50ck50 FIND v(dout0_50) AT=255.025n

* CHECK dout0_51 Vdout0_51ck50 = 0 time = 255
.meas tran vdout0_51ck50 FIND v(dout0_51) AT=255.025n

* CHECK dout0_52 Vdout0_52ck50 = 0 time = 255
.meas tran vdout0_52ck50 FIND v(dout0_52) AT=255.025n

* CHECK dout0_53 Vdout0_53ck50 = 0.9 time = 255
.meas tran vdout0_53ck50 FIND v(dout0_53) AT=255.025n

* CHECK dout0_54 Vdout0_54ck50 = 0 time = 255
.meas tran vdout0_54ck50 FIND v(dout0_54) AT=255.025n

* CHECK dout0_55 Vdout0_55ck50 = 0 time = 255
.meas tran vdout0_55ck50 FIND v(dout0_55) AT=255.025n

* CHECK dout0_56 Vdout0_56ck50 = 0 time = 255
.meas tran vdout0_56ck50 FIND v(dout0_56) AT=255.025n

* CHECK dout0_57 Vdout0_57ck50 = 0 time = 255
.meas tran vdout0_57ck50 FIND v(dout0_57) AT=255.025n

* CHECK dout0_58 Vdout0_58ck50 = 0 time = 255
.meas tran vdout0_58ck50 FIND v(dout0_58) AT=255.025n

* CHECK dout0_59 Vdout0_59ck50 = 0 time = 255
.meas tran vdout0_59ck50 FIND v(dout0_59) AT=255.025n

* CHECK dout0_60 Vdout0_60ck50 = 0 time = 255
.meas tran vdout0_60ck50 FIND v(dout0_60) AT=255.025n

* CHECK dout0_61 Vdout0_61ck50 = 0.9 time = 255
.meas tran vdout0_61ck50 FIND v(dout0_61) AT=255.025n

* CHECK dout0_62 Vdout0_62ck50 = 0 time = 255
.meas tran vdout0_62ck50 FIND v(dout0_62) AT=255.025n

* CHECK dout0_63 Vdout0_63ck50 = 0.9 time = 255
.meas tran vdout0_63ck50 FIND v(dout0_63) AT=255.025n

* CHECK dout0_0 Vdout0_0ck54 = 0.9 time = 275
.meas tran vdout0_0ck54 FIND v(dout0_0) AT=275.025n

* CHECK dout0_1 Vdout0_1ck54 = 0.9 time = 275
.meas tran vdout0_1ck54 FIND v(dout0_1) AT=275.025n

* CHECK dout0_2 Vdout0_2ck54 = 0 time = 275
.meas tran vdout0_2ck54 FIND v(dout0_2) AT=275.025n

* CHECK dout0_3 Vdout0_3ck54 = 0 time = 275
.meas tran vdout0_3ck54 FIND v(dout0_3) AT=275.025n

* CHECK dout0_4 Vdout0_4ck54 = 0.9 time = 275
.meas tran vdout0_4ck54 FIND v(dout0_4) AT=275.025n

* CHECK dout0_5 Vdout0_5ck54 = 0.9 time = 275
.meas tran vdout0_5ck54 FIND v(dout0_5) AT=275.025n

* CHECK dout0_6 Vdout0_6ck54 = 0 time = 275
.meas tran vdout0_6ck54 FIND v(dout0_6) AT=275.025n

* CHECK dout0_7 Vdout0_7ck54 = 0.9 time = 275
.meas tran vdout0_7ck54 FIND v(dout0_7) AT=275.025n

* CHECK dout0_8 Vdout0_8ck54 = 0.9 time = 275
.meas tran vdout0_8ck54 FIND v(dout0_8) AT=275.025n

* CHECK dout0_9 Vdout0_9ck54 = 0 time = 275
.meas tran vdout0_9ck54 FIND v(dout0_9) AT=275.025n

* CHECK dout0_10 Vdout0_10ck54 = 0 time = 275
.meas tran vdout0_10ck54 FIND v(dout0_10) AT=275.025n

* CHECK dout0_11 Vdout0_11ck54 = 0 time = 275
.meas tran vdout0_11ck54 FIND v(dout0_11) AT=275.025n

* CHECK dout0_12 Vdout0_12ck54 = 0 time = 275
.meas tran vdout0_12ck54 FIND v(dout0_12) AT=275.025n

* CHECK dout0_13 Vdout0_13ck54 = 0 time = 275
.meas tran vdout0_13ck54 FIND v(dout0_13) AT=275.025n

* CHECK dout0_14 Vdout0_14ck54 = 0 time = 275
.meas tran vdout0_14ck54 FIND v(dout0_14) AT=275.025n

* CHECK dout0_15 Vdout0_15ck54 = 0.9 time = 275
.meas tran vdout0_15ck54 FIND v(dout0_15) AT=275.025n

* CHECK dout0_16 Vdout0_16ck54 = 0.9 time = 275
.meas tran vdout0_16ck54 FIND v(dout0_16) AT=275.025n

* CHECK dout0_17 Vdout0_17ck54 = 0.9 time = 275
.meas tran vdout0_17ck54 FIND v(dout0_17) AT=275.025n

* CHECK dout0_18 Vdout0_18ck54 = 0.9 time = 275
.meas tran vdout0_18ck54 FIND v(dout0_18) AT=275.025n

* CHECK dout0_19 Vdout0_19ck54 = 0 time = 275
.meas tran vdout0_19ck54 FIND v(dout0_19) AT=275.025n

* CHECK dout0_20 Vdout0_20ck54 = 0.9 time = 275
.meas tran vdout0_20ck54 FIND v(dout0_20) AT=275.025n

* CHECK dout0_21 Vdout0_21ck54 = 0.9 time = 275
.meas tran vdout0_21ck54 FIND v(dout0_21) AT=275.025n

* CHECK dout0_22 Vdout0_22ck54 = 0.9 time = 275
.meas tran vdout0_22ck54 FIND v(dout0_22) AT=275.025n

* CHECK dout0_23 Vdout0_23ck54 = 0.9 time = 275
.meas tran vdout0_23ck54 FIND v(dout0_23) AT=275.025n

* CHECK dout0_24 Vdout0_24ck54 = 0 time = 275
.meas tran vdout0_24ck54 FIND v(dout0_24) AT=275.025n

* CHECK dout0_25 Vdout0_25ck54 = 0 time = 275
.meas tran vdout0_25ck54 FIND v(dout0_25) AT=275.025n

* CHECK dout0_26 Vdout0_26ck54 = 0 time = 275
.meas tran vdout0_26ck54 FIND v(dout0_26) AT=275.025n

* CHECK dout0_27 Vdout0_27ck54 = 0 time = 275
.meas tran vdout0_27ck54 FIND v(dout0_27) AT=275.025n

* CHECK dout0_28 Vdout0_28ck54 = 0 time = 275
.meas tran vdout0_28ck54 FIND v(dout0_28) AT=275.025n

* CHECK dout0_29 Vdout0_29ck54 = 0 time = 275
.meas tran vdout0_29ck54 FIND v(dout0_29) AT=275.025n

* CHECK dout0_30 Vdout0_30ck54 = 0.9 time = 275
.meas tran vdout0_30ck54 FIND v(dout0_30) AT=275.025n

* CHECK dout0_31 Vdout0_31ck54 = 0 time = 275
.meas tran vdout0_31ck54 FIND v(dout0_31) AT=275.025n

* CHECK dout0_32 Vdout0_32ck54 = 0 time = 275
.meas tran vdout0_32ck54 FIND v(dout0_32) AT=275.025n

* CHECK dout0_33 Vdout0_33ck54 = 0.9 time = 275
.meas tran vdout0_33ck54 FIND v(dout0_33) AT=275.025n

* CHECK dout0_34 Vdout0_34ck54 = 0.9 time = 275
.meas tran vdout0_34ck54 FIND v(dout0_34) AT=275.025n

* CHECK dout0_35 Vdout0_35ck54 = 0 time = 275
.meas tran vdout0_35ck54 FIND v(dout0_35) AT=275.025n

* CHECK dout0_36 Vdout0_36ck54 = 0 time = 275
.meas tran vdout0_36ck54 FIND v(dout0_36) AT=275.025n

* CHECK dout0_37 Vdout0_37ck54 = 0 time = 275
.meas tran vdout0_37ck54 FIND v(dout0_37) AT=275.025n

* CHECK dout0_38 Vdout0_38ck54 = 0.9 time = 275
.meas tran vdout0_38ck54 FIND v(dout0_38) AT=275.025n

* CHECK dout0_39 Vdout0_39ck54 = 0 time = 275
.meas tran vdout0_39ck54 FIND v(dout0_39) AT=275.025n

* CHECK dout0_40 Vdout0_40ck54 = 0 time = 275
.meas tran vdout0_40ck54 FIND v(dout0_40) AT=275.025n

* CHECK dout0_41 Vdout0_41ck54 = 0 time = 275
.meas tran vdout0_41ck54 FIND v(dout0_41) AT=275.025n

* CHECK dout0_42 Vdout0_42ck54 = 0.9 time = 275
.meas tran vdout0_42ck54 FIND v(dout0_42) AT=275.025n

* CHECK dout0_43 Vdout0_43ck54 = 0.9 time = 275
.meas tran vdout0_43ck54 FIND v(dout0_43) AT=275.025n

* CHECK dout0_44 Vdout0_44ck54 = 0.9 time = 275
.meas tran vdout0_44ck54 FIND v(dout0_44) AT=275.025n

* CHECK dout0_45 Vdout0_45ck54 = 0 time = 275
.meas tran vdout0_45ck54 FIND v(dout0_45) AT=275.025n

* CHECK dout0_46 Vdout0_46ck54 = 0 time = 275
.meas tran vdout0_46ck54 FIND v(dout0_46) AT=275.025n

* CHECK dout0_47 Vdout0_47ck54 = 0 time = 275
.meas tran vdout0_47ck54 FIND v(dout0_47) AT=275.025n

* CHECK dout0_48 Vdout0_48ck54 = 0.9 time = 275
.meas tran vdout0_48ck54 FIND v(dout0_48) AT=275.025n

* CHECK dout0_49 Vdout0_49ck54 = 0 time = 275
.meas tran vdout0_49ck54 FIND v(dout0_49) AT=275.025n

* CHECK dout0_50 Vdout0_50ck54 = 0 time = 275
.meas tran vdout0_50ck54 FIND v(dout0_50) AT=275.025n

* CHECK dout0_51 Vdout0_51ck54 = 0 time = 275
.meas tran vdout0_51ck54 FIND v(dout0_51) AT=275.025n

* CHECK dout0_52 Vdout0_52ck54 = 0 time = 275
.meas tran vdout0_52ck54 FIND v(dout0_52) AT=275.025n

* CHECK dout0_53 Vdout0_53ck54 = 0 time = 275
.meas tran vdout0_53ck54 FIND v(dout0_53) AT=275.025n

* CHECK dout0_54 Vdout0_54ck54 = 0 time = 275
.meas tran vdout0_54ck54 FIND v(dout0_54) AT=275.025n

* CHECK dout0_55 Vdout0_55ck54 = 0.9 time = 275
.meas tran vdout0_55ck54 FIND v(dout0_55) AT=275.025n

* CHECK dout0_56 Vdout0_56ck54 = 0 time = 275
.meas tran vdout0_56ck54 FIND v(dout0_56) AT=275.025n

* CHECK dout0_57 Vdout0_57ck54 = 0.9 time = 275
.meas tran vdout0_57ck54 FIND v(dout0_57) AT=275.025n

* CHECK dout0_58 Vdout0_58ck54 = 0 time = 275
.meas tran vdout0_58ck54 FIND v(dout0_58) AT=275.025n

* CHECK dout0_59 Vdout0_59ck54 = 0.9 time = 275
.meas tran vdout0_59ck54 FIND v(dout0_59) AT=275.025n

* CHECK dout0_60 Vdout0_60ck54 = 0 time = 275
.meas tran vdout0_60ck54 FIND v(dout0_60) AT=275.025n

* CHECK dout0_61 Vdout0_61ck54 = 0.9 time = 275
.meas tran vdout0_61ck54 FIND v(dout0_61) AT=275.025n

* CHECK dout0_62 Vdout0_62ck54 = 0.9 time = 275
.meas tran vdout0_62ck54 FIND v(dout0_62) AT=275.025n

* CHECK dout0_63 Vdout0_63ck54 = 0 time = 275
.meas tran vdout0_63ck54 FIND v(dout0_63) AT=275.025n

* CHECK dout0_0 Vdout0_0ck56 = 0.9 time = 285
.meas tran vdout0_0ck56 FIND v(dout0_0) AT=285.025n

* CHECK dout0_1 Vdout0_1ck56 = 0.9 time = 285
.meas tran vdout0_1ck56 FIND v(dout0_1) AT=285.025n

* CHECK dout0_2 Vdout0_2ck56 = 0 time = 285
.meas tran vdout0_2ck56 FIND v(dout0_2) AT=285.025n

* CHECK dout0_3 Vdout0_3ck56 = 0 time = 285
.meas tran vdout0_3ck56 FIND v(dout0_3) AT=285.025n

* CHECK dout0_4 Vdout0_4ck56 = 0.9 time = 285
.meas tran vdout0_4ck56 FIND v(dout0_4) AT=285.025n

* CHECK dout0_5 Vdout0_5ck56 = 0.9 time = 285
.meas tran vdout0_5ck56 FIND v(dout0_5) AT=285.025n

* CHECK dout0_6 Vdout0_6ck56 = 0 time = 285
.meas tran vdout0_6ck56 FIND v(dout0_6) AT=285.025n

* CHECK dout0_7 Vdout0_7ck56 = 0.9 time = 285
.meas tran vdout0_7ck56 FIND v(dout0_7) AT=285.025n

* CHECK dout0_8 Vdout0_8ck56 = 0.9 time = 285
.meas tran vdout0_8ck56 FIND v(dout0_8) AT=285.025n

* CHECK dout0_9 Vdout0_9ck56 = 0 time = 285
.meas tran vdout0_9ck56 FIND v(dout0_9) AT=285.025n

* CHECK dout0_10 Vdout0_10ck56 = 0 time = 285
.meas tran vdout0_10ck56 FIND v(dout0_10) AT=285.025n

* CHECK dout0_11 Vdout0_11ck56 = 0 time = 285
.meas tran vdout0_11ck56 FIND v(dout0_11) AT=285.025n

* CHECK dout0_12 Vdout0_12ck56 = 0 time = 285
.meas tran vdout0_12ck56 FIND v(dout0_12) AT=285.025n

* CHECK dout0_13 Vdout0_13ck56 = 0 time = 285
.meas tran vdout0_13ck56 FIND v(dout0_13) AT=285.025n

* CHECK dout0_14 Vdout0_14ck56 = 0 time = 285
.meas tran vdout0_14ck56 FIND v(dout0_14) AT=285.025n

* CHECK dout0_15 Vdout0_15ck56 = 0.9 time = 285
.meas tran vdout0_15ck56 FIND v(dout0_15) AT=285.025n

* CHECK dout0_16 Vdout0_16ck56 = 0.9 time = 285
.meas tran vdout0_16ck56 FIND v(dout0_16) AT=285.025n

* CHECK dout0_17 Vdout0_17ck56 = 0.9 time = 285
.meas tran vdout0_17ck56 FIND v(dout0_17) AT=285.025n

* CHECK dout0_18 Vdout0_18ck56 = 0.9 time = 285
.meas tran vdout0_18ck56 FIND v(dout0_18) AT=285.025n

* CHECK dout0_19 Vdout0_19ck56 = 0 time = 285
.meas tran vdout0_19ck56 FIND v(dout0_19) AT=285.025n

* CHECK dout0_20 Vdout0_20ck56 = 0.9 time = 285
.meas tran vdout0_20ck56 FIND v(dout0_20) AT=285.025n

* CHECK dout0_21 Vdout0_21ck56 = 0.9 time = 285
.meas tran vdout0_21ck56 FIND v(dout0_21) AT=285.025n

* CHECK dout0_22 Vdout0_22ck56 = 0.9 time = 285
.meas tran vdout0_22ck56 FIND v(dout0_22) AT=285.025n

* CHECK dout0_23 Vdout0_23ck56 = 0.9 time = 285
.meas tran vdout0_23ck56 FIND v(dout0_23) AT=285.025n

* CHECK dout0_24 Vdout0_24ck56 = 0 time = 285
.meas tran vdout0_24ck56 FIND v(dout0_24) AT=285.025n

* CHECK dout0_25 Vdout0_25ck56 = 0 time = 285
.meas tran vdout0_25ck56 FIND v(dout0_25) AT=285.025n

* CHECK dout0_26 Vdout0_26ck56 = 0 time = 285
.meas tran vdout0_26ck56 FIND v(dout0_26) AT=285.025n

* CHECK dout0_27 Vdout0_27ck56 = 0 time = 285
.meas tran vdout0_27ck56 FIND v(dout0_27) AT=285.025n

* CHECK dout0_28 Vdout0_28ck56 = 0 time = 285
.meas tran vdout0_28ck56 FIND v(dout0_28) AT=285.025n

* CHECK dout0_29 Vdout0_29ck56 = 0 time = 285
.meas tran vdout0_29ck56 FIND v(dout0_29) AT=285.025n

* CHECK dout0_30 Vdout0_30ck56 = 0.9 time = 285
.meas tran vdout0_30ck56 FIND v(dout0_30) AT=285.025n

* CHECK dout0_31 Vdout0_31ck56 = 0 time = 285
.meas tran vdout0_31ck56 FIND v(dout0_31) AT=285.025n

* CHECK dout0_32 Vdout0_32ck56 = 0 time = 285
.meas tran vdout0_32ck56 FIND v(dout0_32) AT=285.025n

* CHECK dout0_33 Vdout0_33ck56 = 0.9 time = 285
.meas tran vdout0_33ck56 FIND v(dout0_33) AT=285.025n

* CHECK dout0_34 Vdout0_34ck56 = 0.9 time = 285
.meas tran vdout0_34ck56 FIND v(dout0_34) AT=285.025n

* CHECK dout0_35 Vdout0_35ck56 = 0 time = 285
.meas tran vdout0_35ck56 FIND v(dout0_35) AT=285.025n

* CHECK dout0_36 Vdout0_36ck56 = 0 time = 285
.meas tran vdout0_36ck56 FIND v(dout0_36) AT=285.025n

* CHECK dout0_37 Vdout0_37ck56 = 0 time = 285
.meas tran vdout0_37ck56 FIND v(dout0_37) AT=285.025n

* CHECK dout0_38 Vdout0_38ck56 = 0.9 time = 285
.meas tran vdout0_38ck56 FIND v(dout0_38) AT=285.025n

* CHECK dout0_39 Vdout0_39ck56 = 0 time = 285
.meas tran vdout0_39ck56 FIND v(dout0_39) AT=285.025n

* CHECK dout0_40 Vdout0_40ck56 = 0 time = 285
.meas tran vdout0_40ck56 FIND v(dout0_40) AT=285.025n

* CHECK dout0_41 Vdout0_41ck56 = 0 time = 285
.meas tran vdout0_41ck56 FIND v(dout0_41) AT=285.025n

* CHECK dout0_42 Vdout0_42ck56 = 0.9 time = 285
.meas tran vdout0_42ck56 FIND v(dout0_42) AT=285.025n

* CHECK dout0_43 Vdout0_43ck56 = 0.9 time = 285
.meas tran vdout0_43ck56 FIND v(dout0_43) AT=285.025n

* CHECK dout0_44 Vdout0_44ck56 = 0.9 time = 285
.meas tran vdout0_44ck56 FIND v(dout0_44) AT=285.025n

* CHECK dout0_45 Vdout0_45ck56 = 0 time = 285
.meas tran vdout0_45ck56 FIND v(dout0_45) AT=285.025n

* CHECK dout0_46 Vdout0_46ck56 = 0 time = 285
.meas tran vdout0_46ck56 FIND v(dout0_46) AT=285.025n

* CHECK dout0_47 Vdout0_47ck56 = 0 time = 285
.meas tran vdout0_47ck56 FIND v(dout0_47) AT=285.025n

* CHECK dout0_48 Vdout0_48ck56 = 0.9 time = 285
.meas tran vdout0_48ck56 FIND v(dout0_48) AT=285.025n

* CHECK dout0_49 Vdout0_49ck56 = 0 time = 285
.meas tran vdout0_49ck56 FIND v(dout0_49) AT=285.025n

* CHECK dout0_50 Vdout0_50ck56 = 0 time = 285
.meas tran vdout0_50ck56 FIND v(dout0_50) AT=285.025n

* CHECK dout0_51 Vdout0_51ck56 = 0 time = 285
.meas tran vdout0_51ck56 FIND v(dout0_51) AT=285.025n

* CHECK dout0_52 Vdout0_52ck56 = 0 time = 285
.meas tran vdout0_52ck56 FIND v(dout0_52) AT=285.025n

* CHECK dout0_53 Vdout0_53ck56 = 0 time = 285
.meas tran vdout0_53ck56 FIND v(dout0_53) AT=285.025n

* CHECK dout0_54 Vdout0_54ck56 = 0 time = 285
.meas tran vdout0_54ck56 FIND v(dout0_54) AT=285.025n

* CHECK dout0_55 Vdout0_55ck56 = 0.9 time = 285
.meas tran vdout0_55ck56 FIND v(dout0_55) AT=285.025n

* CHECK dout0_56 Vdout0_56ck56 = 0 time = 285
.meas tran vdout0_56ck56 FIND v(dout0_56) AT=285.025n

* CHECK dout0_57 Vdout0_57ck56 = 0.9 time = 285
.meas tran vdout0_57ck56 FIND v(dout0_57) AT=285.025n

* CHECK dout0_58 Vdout0_58ck56 = 0 time = 285
.meas tran vdout0_58ck56 FIND v(dout0_58) AT=285.025n

* CHECK dout0_59 Vdout0_59ck56 = 0.9 time = 285
.meas tran vdout0_59ck56 FIND v(dout0_59) AT=285.025n

* CHECK dout0_60 Vdout0_60ck56 = 0 time = 285
.meas tran vdout0_60ck56 FIND v(dout0_60) AT=285.025n

* CHECK dout0_61 Vdout0_61ck56 = 0.9 time = 285
.meas tran vdout0_61ck56 FIND v(dout0_61) AT=285.025n

* CHECK dout0_62 Vdout0_62ck56 = 0.9 time = 285
.meas tran vdout0_62ck56 FIND v(dout0_62) AT=285.025n

* CHECK dout0_63 Vdout0_63ck56 = 0 time = 285
.meas tran vdout0_63ck56 FIND v(dout0_63) AT=285.025n

* CHECK dout0_0 Vdout0_0ck61 = 0.9 time = 310
.meas tran vdout0_0ck61 FIND v(dout0_0) AT=310.025n

* CHECK dout0_1 Vdout0_1ck61 = 0 time = 310
.meas tran vdout0_1ck61 FIND v(dout0_1) AT=310.025n

* CHECK dout0_2 Vdout0_2ck61 = 0 time = 310
.meas tran vdout0_2ck61 FIND v(dout0_2) AT=310.025n

* CHECK dout0_3 Vdout0_3ck61 = 0 time = 310
.meas tran vdout0_3ck61 FIND v(dout0_3) AT=310.025n

* CHECK dout0_4 Vdout0_4ck61 = 0.9 time = 310
.meas tran vdout0_4ck61 FIND v(dout0_4) AT=310.025n

* CHECK dout0_5 Vdout0_5ck61 = 0 time = 310
.meas tran vdout0_5ck61 FIND v(dout0_5) AT=310.025n

* CHECK dout0_6 Vdout0_6ck61 = 0 time = 310
.meas tran vdout0_6ck61 FIND v(dout0_6) AT=310.025n

* CHECK dout0_7 Vdout0_7ck61 = 0.9 time = 310
.meas tran vdout0_7ck61 FIND v(dout0_7) AT=310.025n

* CHECK dout0_8 Vdout0_8ck61 = 0.9 time = 310
.meas tran vdout0_8ck61 FIND v(dout0_8) AT=310.025n

* CHECK dout0_9 Vdout0_9ck61 = 0.9 time = 310
.meas tran vdout0_9ck61 FIND v(dout0_9) AT=310.025n

* CHECK dout0_10 Vdout0_10ck61 = 0.9 time = 310
.meas tran vdout0_10ck61 FIND v(dout0_10) AT=310.025n

* CHECK dout0_11 Vdout0_11ck61 = 0.9 time = 310
.meas tran vdout0_11ck61 FIND v(dout0_11) AT=310.025n

* CHECK dout0_12 Vdout0_12ck61 = 0 time = 310
.meas tran vdout0_12ck61 FIND v(dout0_12) AT=310.025n

* CHECK dout0_13 Vdout0_13ck61 = 0.9 time = 310
.meas tran vdout0_13ck61 FIND v(dout0_13) AT=310.025n

* CHECK dout0_14 Vdout0_14ck61 = 0.9 time = 310
.meas tran vdout0_14ck61 FIND v(dout0_14) AT=310.025n

* CHECK dout0_15 Vdout0_15ck61 = 0.9 time = 310
.meas tran vdout0_15ck61 FIND v(dout0_15) AT=310.025n

* CHECK dout0_16 Vdout0_16ck61 = 0.9 time = 310
.meas tran vdout0_16ck61 FIND v(dout0_16) AT=310.025n

* CHECK dout0_17 Vdout0_17ck61 = 0.9 time = 310
.meas tran vdout0_17ck61 FIND v(dout0_17) AT=310.025n

* CHECK dout0_18 Vdout0_18ck61 = 0.9 time = 310
.meas tran vdout0_18ck61 FIND v(dout0_18) AT=310.025n

* CHECK dout0_19 Vdout0_19ck61 = 0 time = 310
.meas tran vdout0_19ck61 FIND v(dout0_19) AT=310.025n

* CHECK dout0_20 Vdout0_20ck61 = 0 time = 310
.meas tran vdout0_20ck61 FIND v(dout0_20) AT=310.025n

* CHECK dout0_21 Vdout0_21ck61 = 0 time = 310
.meas tran vdout0_21ck61 FIND v(dout0_21) AT=310.025n

* CHECK dout0_22 Vdout0_22ck61 = 0 time = 310
.meas tran vdout0_22ck61 FIND v(dout0_22) AT=310.025n

* CHECK dout0_23 Vdout0_23ck61 = 0.9 time = 310
.meas tran vdout0_23ck61 FIND v(dout0_23) AT=310.025n

* CHECK dout0_24 Vdout0_24ck61 = 0.9 time = 310
.meas tran vdout0_24ck61 FIND v(dout0_24) AT=310.025n

* CHECK dout0_25 Vdout0_25ck61 = 0 time = 310
.meas tran vdout0_25ck61 FIND v(dout0_25) AT=310.025n

* CHECK dout0_26 Vdout0_26ck61 = 0 time = 310
.meas tran vdout0_26ck61 FIND v(dout0_26) AT=310.025n

* CHECK dout0_27 Vdout0_27ck61 = 0.9 time = 310
.meas tran vdout0_27ck61 FIND v(dout0_27) AT=310.025n

* CHECK dout0_28 Vdout0_28ck61 = 0.9 time = 310
.meas tran vdout0_28ck61 FIND v(dout0_28) AT=310.025n

* CHECK dout0_29 Vdout0_29ck61 = 0 time = 310
.meas tran vdout0_29ck61 FIND v(dout0_29) AT=310.025n

* CHECK dout0_30 Vdout0_30ck61 = 0.9 time = 310
.meas tran vdout0_30ck61 FIND v(dout0_30) AT=310.025n

* CHECK dout0_31 Vdout0_31ck61 = 0.9 time = 310
.meas tran vdout0_31ck61 FIND v(dout0_31) AT=310.025n

* CHECK dout0_32 Vdout0_32ck61 = 0.9 time = 310
.meas tran vdout0_32ck61 FIND v(dout0_32) AT=310.025n

* CHECK dout0_33 Vdout0_33ck61 = 0 time = 310
.meas tran vdout0_33ck61 FIND v(dout0_33) AT=310.025n

* CHECK dout0_34 Vdout0_34ck61 = 0.9 time = 310
.meas tran vdout0_34ck61 FIND v(dout0_34) AT=310.025n

* CHECK dout0_35 Vdout0_35ck61 = 0.9 time = 310
.meas tran vdout0_35ck61 FIND v(dout0_35) AT=310.025n

* CHECK dout0_36 Vdout0_36ck61 = 0 time = 310
.meas tran vdout0_36ck61 FIND v(dout0_36) AT=310.025n

* CHECK dout0_37 Vdout0_37ck61 = 0 time = 310
.meas tran vdout0_37ck61 FIND v(dout0_37) AT=310.025n

* CHECK dout0_38 Vdout0_38ck61 = 0 time = 310
.meas tran vdout0_38ck61 FIND v(dout0_38) AT=310.025n

* CHECK dout0_39 Vdout0_39ck61 = 0.9 time = 310
.meas tran vdout0_39ck61 FIND v(dout0_39) AT=310.025n

* CHECK dout0_40 Vdout0_40ck61 = 0.9 time = 310
.meas tran vdout0_40ck61 FIND v(dout0_40) AT=310.025n

* CHECK dout0_41 Vdout0_41ck61 = 0 time = 310
.meas tran vdout0_41ck61 FIND v(dout0_41) AT=310.025n

* CHECK dout0_42 Vdout0_42ck61 = 0 time = 310
.meas tran vdout0_42ck61 FIND v(dout0_42) AT=310.025n

* CHECK dout0_43 Vdout0_43ck61 = 0.9 time = 310
.meas tran vdout0_43ck61 FIND v(dout0_43) AT=310.025n

* CHECK dout0_44 Vdout0_44ck61 = 0 time = 310
.meas tran vdout0_44ck61 FIND v(dout0_44) AT=310.025n

* CHECK dout0_45 Vdout0_45ck61 = 0 time = 310
.meas tran vdout0_45ck61 FIND v(dout0_45) AT=310.025n

* CHECK dout0_46 Vdout0_46ck61 = 0 time = 310
.meas tran vdout0_46ck61 FIND v(dout0_46) AT=310.025n

* CHECK dout0_47 Vdout0_47ck61 = 0.9 time = 310
.meas tran vdout0_47ck61 FIND v(dout0_47) AT=310.025n

* CHECK dout0_48 Vdout0_48ck61 = 0.9 time = 310
.meas tran vdout0_48ck61 FIND v(dout0_48) AT=310.025n

* CHECK dout0_49 Vdout0_49ck61 = 0.9 time = 310
.meas tran vdout0_49ck61 FIND v(dout0_49) AT=310.025n

* CHECK dout0_50 Vdout0_50ck61 = 0.9 time = 310
.meas tran vdout0_50ck61 FIND v(dout0_50) AT=310.025n

* CHECK dout0_51 Vdout0_51ck61 = 0.9 time = 310
.meas tran vdout0_51ck61 FIND v(dout0_51) AT=310.025n

* CHECK dout0_52 Vdout0_52ck61 = 0 time = 310
.meas tran vdout0_52ck61 FIND v(dout0_52) AT=310.025n

* CHECK dout0_53 Vdout0_53ck61 = 0 time = 310
.meas tran vdout0_53ck61 FIND v(dout0_53) AT=310.025n

* CHECK dout0_54 Vdout0_54ck61 = 0 time = 310
.meas tran vdout0_54ck61 FIND v(dout0_54) AT=310.025n

* CHECK dout0_55 Vdout0_55ck61 = 0.9 time = 310
.meas tran vdout0_55ck61 FIND v(dout0_55) AT=310.025n

* CHECK dout0_56 Vdout0_56ck61 = 0.9 time = 310
.meas tran vdout0_56ck61 FIND v(dout0_56) AT=310.025n

* CHECK dout0_57 Vdout0_57ck61 = 0 time = 310
.meas tran vdout0_57ck61 FIND v(dout0_57) AT=310.025n

* CHECK dout0_58 Vdout0_58ck61 = 0.9 time = 310
.meas tran vdout0_58ck61 FIND v(dout0_58) AT=310.025n

* CHECK dout0_59 Vdout0_59ck61 = 0 time = 310
.meas tran vdout0_59ck61 FIND v(dout0_59) AT=310.025n

* CHECK dout0_60 Vdout0_60ck61 = 0 time = 310
.meas tran vdout0_60ck61 FIND v(dout0_60) AT=310.025n

* CHECK dout0_61 Vdout0_61ck61 = 0.9 time = 310
.meas tran vdout0_61ck61 FIND v(dout0_61) AT=310.025n

* CHECK dout0_62 Vdout0_62ck61 = 0.9 time = 310
.meas tran vdout0_62ck61 FIND v(dout0_62) AT=310.025n

* CHECK dout0_63 Vdout0_63ck61 = 0.9 time = 310
.meas tran vdout0_63ck61 FIND v(dout0_63) AT=310.025n

* CHECK dout0_0 Vdout0_0ck65 = 0.9 time = 330
.meas tran vdout0_0ck65 FIND v(dout0_0) AT=330.025n

* CHECK dout0_1 Vdout0_1ck65 = 0 time = 330
.meas tran vdout0_1ck65 FIND v(dout0_1) AT=330.025n

* CHECK dout0_2 Vdout0_2ck65 = 0 time = 330
.meas tran vdout0_2ck65 FIND v(dout0_2) AT=330.025n

* CHECK dout0_3 Vdout0_3ck65 = 0 time = 330
.meas tran vdout0_3ck65 FIND v(dout0_3) AT=330.025n

* CHECK dout0_4 Vdout0_4ck65 = 0.9 time = 330
.meas tran vdout0_4ck65 FIND v(dout0_4) AT=330.025n

* CHECK dout0_5 Vdout0_5ck65 = 0 time = 330
.meas tran vdout0_5ck65 FIND v(dout0_5) AT=330.025n

* CHECK dout0_6 Vdout0_6ck65 = 0 time = 330
.meas tran vdout0_6ck65 FIND v(dout0_6) AT=330.025n

* CHECK dout0_7 Vdout0_7ck65 = 0.9 time = 330
.meas tran vdout0_7ck65 FIND v(dout0_7) AT=330.025n

* CHECK dout0_8 Vdout0_8ck65 = 0.9 time = 330
.meas tran vdout0_8ck65 FIND v(dout0_8) AT=330.025n

* CHECK dout0_9 Vdout0_9ck65 = 0.9 time = 330
.meas tran vdout0_9ck65 FIND v(dout0_9) AT=330.025n

* CHECK dout0_10 Vdout0_10ck65 = 0.9 time = 330
.meas tran vdout0_10ck65 FIND v(dout0_10) AT=330.025n

* CHECK dout0_11 Vdout0_11ck65 = 0.9 time = 330
.meas tran vdout0_11ck65 FIND v(dout0_11) AT=330.025n

* CHECK dout0_12 Vdout0_12ck65 = 0 time = 330
.meas tran vdout0_12ck65 FIND v(dout0_12) AT=330.025n

* CHECK dout0_13 Vdout0_13ck65 = 0.9 time = 330
.meas tran vdout0_13ck65 FIND v(dout0_13) AT=330.025n

* CHECK dout0_14 Vdout0_14ck65 = 0.9 time = 330
.meas tran vdout0_14ck65 FIND v(dout0_14) AT=330.025n

* CHECK dout0_15 Vdout0_15ck65 = 0.9 time = 330
.meas tran vdout0_15ck65 FIND v(dout0_15) AT=330.025n

* CHECK dout0_16 Vdout0_16ck65 = 0.9 time = 330
.meas tran vdout0_16ck65 FIND v(dout0_16) AT=330.025n

* CHECK dout0_17 Vdout0_17ck65 = 0.9 time = 330
.meas tran vdout0_17ck65 FIND v(dout0_17) AT=330.025n

* CHECK dout0_18 Vdout0_18ck65 = 0.9 time = 330
.meas tran vdout0_18ck65 FIND v(dout0_18) AT=330.025n

* CHECK dout0_19 Vdout0_19ck65 = 0 time = 330
.meas tran vdout0_19ck65 FIND v(dout0_19) AT=330.025n

* CHECK dout0_20 Vdout0_20ck65 = 0 time = 330
.meas tran vdout0_20ck65 FIND v(dout0_20) AT=330.025n

* CHECK dout0_21 Vdout0_21ck65 = 0 time = 330
.meas tran vdout0_21ck65 FIND v(dout0_21) AT=330.025n

* CHECK dout0_22 Vdout0_22ck65 = 0 time = 330
.meas tran vdout0_22ck65 FIND v(dout0_22) AT=330.025n

* CHECK dout0_23 Vdout0_23ck65 = 0.9 time = 330
.meas tran vdout0_23ck65 FIND v(dout0_23) AT=330.025n

* CHECK dout0_24 Vdout0_24ck65 = 0.9 time = 330
.meas tran vdout0_24ck65 FIND v(dout0_24) AT=330.025n

* CHECK dout0_25 Vdout0_25ck65 = 0 time = 330
.meas tran vdout0_25ck65 FIND v(dout0_25) AT=330.025n

* CHECK dout0_26 Vdout0_26ck65 = 0 time = 330
.meas tran vdout0_26ck65 FIND v(dout0_26) AT=330.025n

* CHECK dout0_27 Vdout0_27ck65 = 0.9 time = 330
.meas tran vdout0_27ck65 FIND v(dout0_27) AT=330.025n

* CHECK dout0_28 Vdout0_28ck65 = 0.9 time = 330
.meas tran vdout0_28ck65 FIND v(dout0_28) AT=330.025n

* CHECK dout0_29 Vdout0_29ck65 = 0 time = 330
.meas tran vdout0_29ck65 FIND v(dout0_29) AT=330.025n

* CHECK dout0_30 Vdout0_30ck65 = 0.9 time = 330
.meas tran vdout0_30ck65 FIND v(dout0_30) AT=330.025n

* CHECK dout0_31 Vdout0_31ck65 = 0.9 time = 330
.meas tran vdout0_31ck65 FIND v(dout0_31) AT=330.025n

* CHECK dout0_32 Vdout0_32ck65 = 0.9 time = 330
.meas tran vdout0_32ck65 FIND v(dout0_32) AT=330.025n

* CHECK dout0_33 Vdout0_33ck65 = 0 time = 330
.meas tran vdout0_33ck65 FIND v(dout0_33) AT=330.025n

* CHECK dout0_34 Vdout0_34ck65 = 0.9 time = 330
.meas tran vdout0_34ck65 FIND v(dout0_34) AT=330.025n

* CHECK dout0_35 Vdout0_35ck65 = 0.9 time = 330
.meas tran vdout0_35ck65 FIND v(dout0_35) AT=330.025n

* CHECK dout0_36 Vdout0_36ck65 = 0 time = 330
.meas tran vdout0_36ck65 FIND v(dout0_36) AT=330.025n

* CHECK dout0_37 Vdout0_37ck65 = 0 time = 330
.meas tran vdout0_37ck65 FIND v(dout0_37) AT=330.025n

* CHECK dout0_38 Vdout0_38ck65 = 0 time = 330
.meas tran vdout0_38ck65 FIND v(dout0_38) AT=330.025n

* CHECK dout0_39 Vdout0_39ck65 = 0.9 time = 330
.meas tran vdout0_39ck65 FIND v(dout0_39) AT=330.025n

* CHECK dout0_40 Vdout0_40ck65 = 0.9 time = 330
.meas tran vdout0_40ck65 FIND v(dout0_40) AT=330.025n

* CHECK dout0_41 Vdout0_41ck65 = 0 time = 330
.meas tran vdout0_41ck65 FIND v(dout0_41) AT=330.025n

* CHECK dout0_42 Vdout0_42ck65 = 0 time = 330
.meas tran vdout0_42ck65 FIND v(dout0_42) AT=330.025n

* CHECK dout0_43 Vdout0_43ck65 = 0.9 time = 330
.meas tran vdout0_43ck65 FIND v(dout0_43) AT=330.025n

* CHECK dout0_44 Vdout0_44ck65 = 0 time = 330
.meas tran vdout0_44ck65 FIND v(dout0_44) AT=330.025n

* CHECK dout0_45 Vdout0_45ck65 = 0 time = 330
.meas tran vdout0_45ck65 FIND v(dout0_45) AT=330.025n

* CHECK dout0_46 Vdout0_46ck65 = 0 time = 330
.meas tran vdout0_46ck65 FIND v(dout0_46) AT=330.025n

* CHECK dout0_47 Vdout0_47ck65 = 0.9 time = 330
.meas tran vdout0_47ck65 FIND v(dout0_47) AT=330.025n

* CHECK dout0_48 Vdout0_48ck65 = 0.9 time = 330
.meas tran vdout0_48ck65 FIND v(dout0_48) AT=330.025n

* CHECK dout0_49 Vdout0_49ck65 = 0.9 time = 330
.meas tran vdout0_49ck65 FIND v(dout0_49) AT=330.025n

* CHECK dout0_50 Vdout0_50ck65 = 0.9 time = 330
.meas tran vdout0_50ck65 FIND v(dout0_50) AT=330.025n

* CHECK dout0_51 Vdout0_51ck65 = 0.9 time = 330
.meas tran vdout0_51ck65 FIND v(dout0_51) AT=330.025n

* CHECK dout0_52 Vdout0_52ck65 = 0 time = 330
.meas tran vdout0_52ck65 FIND v(dout0_52) AT=330.025n

* CHECK dout0_53 Vdout0_53ck65 = 0 time = 330
.meas tran vdout0_53ck65 FIND v(dout0_53) AT=330.025n

* CHECK dout0_54 Vdout0_54ck65 = 0 time = 330
.meas tran vdout0_54ck65 FIND v(dout0_54) AT=330.025n

* CHECK dout0_55 Vdout0_55ck65 = 0.9 time = 330
.meas tran vdout0_55ck65 FIND v(dout0_55) AT=330.025n

* CHECK dout0_56 Vdout0_56ck65 = 0.9 time = 330
.meas tran vdout0_56ck65 FIND v(dout0_56) AT=330.025n

* CHECK dout0_57 Vdout0_57ck65 = 0 time = 330
.meas tran vdout0_57ck65 FIND v(dout0_57) AT=330.025n

* CHECK dout0_58 Vdout0_58ck65 = 0.9 time = 330
.meas tran vdout0_58ck65 FIND v(dout0_58) AT=330.025n

* CHECK dout0_59 Vdout0_59ck65 = 0 time = 330
.meas tran vdout0_59ck65 FIND v(dout0_59) AT=330.025n

* CHECK dout0_60 Vdout0_60ck65 = 0 time = 330
.meas tran vdout0_60ck65 FIND v(dout0_60) AT=330.025n

* CHECK dout0_61 Vdout0_61ck65 = 0.9 time = 330
.meas tran vdout0_61ck65 FIND v(dout0_61) AT=330.025n

* CHECK dout0_62 Vdout0_62ck65 = 0.9 time = 330
.meas tran vdout0_62ck65 FIND v(dout0_62) AT=330.025n

* CHECK dout0_63 Vdout0_63ck65 = 0.9 time = 330
.meas tran vdout0_63ck65 FIND v(dout0_63) AT=330.025n

* CHECK dout0_0 Vdout0_0ck66 = 0 time = 335
.meas tran vdout0_0ck66 FIND v(dout0_0) AT=335.025n

* CHECK dout0_1 Vdout0_1ck66 = 0.9 time = 335
.meas tran vdout0_1ck66 FIND v(dout0_1) AT=335.025n

* CHECK dout0_2 Vdout0_2ck66 = 0 time = 335
.meas tran vdout0_2ck66 FIND v(dout0_2) AT=335.025n

* CHECK dout0_3 Vdout0_3ck66 = 0.9 time = 335
.meas tran vdout0_3ck66 FIND v(dout0_3) AT=335.025n

* CHECK dout0_4 Vdout0_4ck66 = 0 time = 335
.meas tran vdout0_4ck66 FIND v(dout0_4) AT=335.025n

* CHECK dout0_5 Vdout0_5ck66 = 0 time = 335
.meas tran vdout0_5ck66 FIND v(dout0_5) AT=335.025n

* CHECK dout0_6 Vdout0_6ck66 = 0 time = 335
.meas tran vdout0_6ck66 FIND v(dout0_6) AT=335.025n

* CHECK dout0_7 Vdout0_7ck66 = 0.9 time = 335
.meas tran vdout0_7ck66 FIND v(dout0_7) AT=335.025n

* CHECK dout0_8 Vdout0_8ck66 = 0.9 time = 335
.meas tran vdout0_8ck66 FIND v(dout0_8) AT=335.025n

* CHECK dout0_9 Vdout0_9ck66 = 0 time = 335
.meas tran vdout0_9ck66 FIND v(dout0_9) AT=335.025n

* CHECK dout0_10 Vdout0_10ck66 = 0 time = 335
.meas tran vdout0_10ck66 FIND v(dout0_10) AT=335.025n

* CHECK dout0_11 Vdout0_11ck66 = 0.9 time = 335
.meas tran vdout0_11ck66 FIND v(dout0_11) AT=335.025n

* CHECK dout0_12 Vdout0_12ck66 = 0.9 time = 335
.meas tran vdout0_12ck66 FIND v(dout0_12) AT=335.025n

* CHECK dout0_13 Vdout0_13ck66 = 0 time = 335
.meas tran vdout0_13ck66 FIND v(dout0_13) AT=335.025n

* CHECK dout0_14 Vdout0_14ck66 = 0 time = 335
.meas tran vdout0_14ck66 FIND v(dout0_14) AT=335.025n

* CHECK dout0_15 Vdout0_15ck66 = 0.9 time = 335
.meas tran vdout0_15ck66 FIND v(dout0_15) AT=335.025n

* CHECK dout0_16 Vdout0_16ck66 = 0.9 time = 335
.meas tran vdout0_16ck66 FIND v(dout0_16) AT=335.025n

* CHECK dout0_17 Vdout0_17ck66 = 0.9 time = 335
.meas tran vdout0_17ck66 FIND v(dout0_17) AT=335.025n

* CHECK dout0_18 Vdout0_18ck66 = 0.9 time = 335
.meas tran vdout0_18ck66 FIND v(dout0_18) AT=335.025n

* CHECK dout0_19 Vdout0_19ck66 = 0.9 time = 335
.meas tran vdout0_19ck66 FIND v(dout0_19) AT=335.025n

* CHECK dout0_20 Vdout0_20ck66 = 0.9 time = 335
.meas tran vdout0_20ck66 FIND v(dout0_20) AT=335.025n

* CHECK dout0_21 Vdout0_21ck66 = 0.9 time = 335
.meas tran vdout0_21ck66 FIND v(dout0_21) AT=335.025n

* CHECK dout0_22 Vdout0_22ck66 = 0 time = 335
.meas tran vdout0_22ck66 FIND v(dout0_22) AT=335.025n

* CHECK dout0_23 Vdout0_23ck66 = 0.9 time = 335
.meas tran vdout0_23ck66 FIND v(dout0_23) AT=335.025n

* CHECK dout0_24 Vdout0_24ck66 = 0.9 time = 335
.meas tran vdout0_24ck66 FIND v(dout0_24) AT=335.025n

* CHECK dout0_25 Vdout0_25ck66 = 0.9 time = 335
.meas tran vdout0_25ck66 FIND v(dout0_25) AT=335.025n

* CHECK dout0_26 Vdout0_26ck66 = 0.9 time = 335
.meas tran vdout0_26ck66 FIND v(dout0_26) AT=335.025n

* CHECK dout0_27 Vdout0_27ck66 = 0.9 time = 335
.meas tran vdout0_27ck66 FIND v(dout0_27) AT=335.025n

* CHECK dout0_28 Vdout0_28ck66 = 0 time = 335
.meas tran vdout0_28ck66 FIND v(dout0_28) AT=335.025n

* CHECK dout0_29 Vdout0_29ck66 = 0.9 time = 335
.meas tran vdout0_29ck66 FIND v(dout0_29) AT=335.025n

* CHECK dout0_30 Vdout0_30ck66 = 0.9 time = 335
.meas tran vdout0_30ck66 FIND v(dout0_30) AT=335.025n

* CHECK dout0_31 Vdout0_31ck66 = 0.9 time = 335
.meas tran vdout0_31ck66 FIND v(dout0_31) AT=335.025n

* CHECK dout0_32 Vdout0_32ck66 = 0.9 time = 335
.meas tran vdout0_32ck66 FIND v(dout0_32) AT=335.025n

* CHECK dout0_33 Vdout0_33ck66 = 0 time = 335
.meas tran vdout0_33ck66 FIND v(dout0_33) AT=335.025n

* CHECK dout0_34 Vdout0_34ck66 = 0 time = 335
.meas tran vdout0_34ck66 FIND v(dout0_34) AT=335.025n

* CHECK dout0_35 Vdout0_35ck66 = 0.9 time = 335
.meas tran vdout0_35ck66 FIND v(dout0_35) AT=335.025n

* CHECK dout0_36 Vdout0_36ck66 = 0 time = 335
.meas tran vdout0_36ck66 FIND v(dout0_36) AT=335.025n

* CHECK dout0_37 Vdout0_37ck66 = 0 time = 335
.meas tran vdout0_37ck66 FIND v(dout0_37) AT=335.025n

* CHECK dout0_38 Vdout0_38ck66 = 0 time = 335
.meas tran vdout0_38ck66 FIND v(dout0_38) AT=335.025n

* CHECK dout0_39 Vdout0_39ck66 = 0 time = 335
.meas tran vdout0_39ck66 FIND v(dout0_39) AT=335.025n

* CHECK dout0_40 Vdout0_40ck66 = 0 time = 335
.meas tran vdout0_40ck66 FIND v(dout0_40) AT=335.025n

* CHECK dout0_41 Vdout0_41ck66 = 0.9 time = 335
.meas tran vdout0_41ck66 FIND v(dout0_41) AT=335.025n

* CHECK dout0_42 Vdout0_42ck66 = 0 time = 335
.meas tran vdout0_42ck66 FIND v(dout0_42) AT=335.025n

* CHECK dout0_43 Vdout0_43ck66 = 0 time = 335
.meas tran vdout0_43ck66 FIND v(dout0_43) AT=335.025n

* CHECK dout0_44 Vdout0_44ck66 = 0 time = 335
.meas tran vdout0_44ck66 FIND v(dout0_44) AT=335.025n

* CHECK dout0_45 Vdout0_45ck66 = 0 time = 335
.meas tran vdout0_45ck66 FIND v(dout0_45) AT=335.025n

* CHECK dout0_46 Vdout0_46ck66 = 0.9 time = 335
.meas tran vdout0_46ck66 FIND v(dout0_46) AT=335.025n

* CHECK dout0_47 Vdout0_47ck66 = 0 time = 335
.meas tran vdout0_47ck66 FIND v(dout0_47) AT=335.025n

* CHECK dout0_48 Vdout0_48ck66 = 0 time = 335
.meas tran vdout0_48ck66 FIND v(dout0_48) AT=335.025n

* CHECK dout0_49 Vdout0_49ck66 = 0.9 time = 335
.meas tran vdout0_49ck66 FIND v(dout0_49) AT=335.025n

* CHECK dout0_50 Vdout0_50ck66 = 0 time = 335
.meas tran vdout0_50ck66 FIND v(dout0_50) AT=335.025n

* CHECK dout0_51 Vdout0_51ck66 = 0.9 time = 335
.meas tran vdout0_51ck66 FIND v(dout0_51) AT=335.025n

* CHECK dout0_52 Vdout0_52ck66 = 0 time = 335
.meas tran vdout0_52ck66 FIND v(dout0_52) AT=335.025n

* CHECK dout0_53 Vdout0_53ck66 = 0.9 time = 335
.meas tran vdout0_53ck66 FIND v(dout0_53) AT=335.025n

* CHECK dout0_54 Vdout0_54ck66 = 0.9 time = 335
.meas tran vdout0_54ck66 FIND v(dout0_54) AT=335.025n

* CHECK dout0_55 Vdout0_55ck66 = 0.9 time = 335
.meas tran vdout0_55ck66 FIND v(dout0_55) AT=335.025n

* CHECK dout0_56 Vdout0_56ck66 = 0 time = 335
.meas tran vdout0_56ck66 FIND v(dout0_56) AT=335.025n

* CHECK dout0_57 Vdout0_57ck66 = 0 time = 335
.meas tran vdout0_57ck66 FIND v(dout0_57) AT=335.025n

* CHECK dout0_58 Vdout0_58ck66 = 0 time = 335
.meas tran vdout0_58ck66 FIND v(dout0_58) AT=335.025n

* CHECK dout0_59 Vdout0_59ck66 = 0 time = 335
.meas tran vdout0_59ck66 FIND v(dout0_59) AT=335.025n

* CHECK dout0_60 Vdout0_60ck66 = 0 time = 335
.meas tran vdout0_60ck66 FIND v(dout0_60) AT=335.025n

* CHECK dout0_61 Vdout0_61ck66 = 0.9 time = 335
.meas tran vdout0_61ck66 FIND v(dout0_61) AT=335.025n

* CHECK dout0_62 Vdout0_62ck66 = 0.9 time = 335
.meas tran vdout0_62ck66 FIND v(dout0_62) AT=335.025n

* CHECK dout0_63 Vdout0_63ck66 = 0 time = 335
.meas tran vdout0_63ck66 FIND v(dout0_63) AT=335.025n

* CHECK dout0_0 Vdout0_0ck67 = 0 time = 340
.meas tran vdout0_0ck67 FIND v(dout0_0) AT=340.025n

* CHECK dout0_1 Vdout0_1ck67 = 0.9 time = 340
.meas tran vdout0_1ck67 FIND v(dout0_1) AT=340.025n

* CHECK dout0_2 Vdout0_2ck67 = 0 time = 340
.meas tran vdout0_2ck67 FIND v(dout0_2) AT=340.025n

* CHECK dout0_3 Vdout0_3ck67 = 0.9 time = 340
.meas tran vdout0_3ck67 FIND v(dout0_3) AT=340.025n

* CHECK dout0_4 Vdout0_4ck67 = 0.9 time = 340
.meas tran vdout0_4ck67 FIND v(dout0_4) AT=340.025n

* CHECK dout0_5 Vdout0_5ck67 = 0.9 time = 340
.meas tran vdout0_5ck67 FIND v(dout0_5) AT=340.025n

* CHECK dout0_6 Vdout0_6ck67 = 0.9 time = 340
.meas tran vdout0_6ck67 FIND v(dout0_6) AT=340.025n

* CHECK dout0_7 Vdout0_7ck67 = 0 time = 340
.meas tran vdout0_7ck67 FIND v(dout0_7) AT=340.025n

* CHECK dout0_8 Vdout0_8ck67 = 0 time = 340
.meas tran vdout0_8ck67 FIND v(dout0_8) AT=340.025n

* CHECK dout0_9 Vdout0_9ck67 = 0 time = 340
.meas tran vdout0_9ck67 FIND v(dout0_9) AT=340.025n

* CHECK dout0_10 Vdout0_10ck67 = 0 time = 340
.meas tran vdout0_10ck67 FIND v(dout0_10) AT=340.025n

* CHECK dout0_11 Vdout0_11ck67 = 0 time = 340
.meas tran vdout0_11ck67 FIND v(dout0_11) AT=340.025n

* CHECK dout0_12 Vdout0_12ck67 = 0 time = 340
.meas tran vdout0_12ck67 FIND v(dout0_12) AT=340.025n

* CHECK dout0_13 Vdout0_13ck67 = 0 time = 340
.meas tran vdout0_13ck67 FIND v(dout0_13) AT=340.025n

* CHECK dout0_14 Vdout0_14ck67 = 0 time = 340
.meas tran vdout0_14ck67 FIND v(dout0_14) AT=340.025n

* CHECK dout0_15 Vdout0_15ck67 = 0.9 time = 340
.meas tran vdout0_15ck67 FIND v(dout0_15) AT=340.025n

* CHECK dout0_16 Vdout0_16ck67 = 0.9 time = 340
.meas tran vdout0_16ck67 FIND v(dout0_16) AT=340.025n

* CHECK dout0_17 Vdout0_17ck67 = 0 time = 340
.meas tran vdout0_17ck67 FIND v(dout0_17) AT=340.025n

* CHECK dout0_18 Vdout0_18ck67 = 0.9 time = 340
.meas tran vdout0_18ck67 FIND v(dout0_18) AT=340.025n

* CHECK dout0_19 Vdout0_19ck67 = 0 time = 340
.meas tran vdout0_19ck67 FIND v(dout0_19) AT=340.025n

* CHECK dout0_20 Vdout0_20ck67 = 0.9 time = 340
.meas tran vdout0_20ck67 FIND v(dout0_20) AT=340.025n

* CHECK dout0_21 Vdout0_21ck67 = 0.9 time = 340
.meas tran vdout0_21ck67 FIND v(dout0_21) AT=340.025n

* CHECK dout0_22 Vdout0_22ck67 = 0 time = 340
.meas tran vdout0_22ck67 FIND v(dout0_22) AT=340.025n

* CHECK dout0_23 Vdout0_23ck67 = 0 time = 340
.meas tran vdout0_23ck67 FIND v(dout0_23) AT=340.025n

* CHECK dout0_24 Vdout0_24ck67 = 0.9 time = 340
.meas tran vdout0_24ck67 FIND v(dout0_24) AT=340.025n

* CHECK dout0_25 Vdout0_25ck67 = 0.9 time = 340
.meas tran vdout0_25ck67 FIND v(dout0_25) AT=340.025n

* CHECK dout0_26 Vdout0_26ck67 = 0 time = 340
.meas tran vdout0_26ck67 FIND v(dout0_26) AT=340.025n

* CHECK dout0_27 Vdout0_27ck67 = 0 time = 340
.meas tran vdout0_27ck67 FIND v(dout0_27) AT=340.025n

* CHECK dout0_28 Vdout0_28ck67 = 0 time = 340
.meas tran vdout0_28ck67 FIND v(dout0_28) AT=340.025n

* CHECK dout0_29 Vdout0_29ck67 = 0.9 time = 340
.meas tran vdout0_29ck67 FIND v(dout0_29) AT=340.025n

* CHECK dout0_30 Vdout0_30ck67 = 0 time = 340
.meas tran vdout0_30ck67 FIND v(dout0_30) AT=340.025n

* CHECK dout0_31 Vdout0_31ck67 = 0 time = 340
.meas tran vdout0_31ck67 FIND v(dout0_31) AT=340.025n

* CHECK dout0_32 Vdout0_32ck67 = 0 time = 340
.meas tran vdout0_32ck67 FIND v(dout0_32) AT=340.025n

* CHECK dout0_33 Vdout0_33ck67 = 0 time = 340
.meas tran vdout0_33ck67 FIND v(dout0_33) AT=340.025n

* CHECK dout0_34 Vdout0_34ck67 = 0 time = 340
.meas tran vdout0_34ck67 FIND v(dout0_34) AT=340.025n

* CHECK dout0_35 Vdout0_35ck67 = 0 time = 340
.meas tran vdout0_35ck67 FIND v(dout0_35) AT=340.025n

* CHECK dout0_36 Vdout0_36ck67 = 0 time = 340
.meas tran vdout0_36ck67 FIND v(dout0_36) AT=340.025n

* CHECK dout0_37 Vdout0_37ck67 = 0.9 time = 340
.meas tran vdout0_37ck67 FIND v(dout0_37) AT=340.025n

* CHECK dout0_38 Vdout0_38ck67 = 0 time = 340
.meas tran vdout0_38ck67 FIND v(dout0_38) AT=340.025n

* CHECK dout0_39 Vdout0_39ck67 = 0 time = 340
.meas tran vdout0_39ck67 FIND v(dout0_39) AT=340.025n

* CHECK dout0_40 Vdout0_40ck67 = 0 time = 340
.meas tran vdout0_40ck67 FIND v(dout0_40) AT=340.025n

* CHECK dout0_41 Vdout0_41ck67 = 0.9 time = 340
.meas tran vdout0_41ck67 FIND v(dout0_41) AT=340.025n

* CHECK dout0_42 Vdout0_42ck67 = 0 time = 340
.meas tran vdout0_42ck67 FIND v(dout0_42) AT=340.025n

* CHECK dout0_43 Vdout0_43ck67 = 0.9 time = 340
.meas tran vdout0_43ck67 FIND v(dout0_43) AT=340.025n

* CHECK dout0_44 Vdout0_44ck67 = 0 time = 340
.meas tran vdout0_44ck67 FIND v(dout0_44) AT=340.025n

* CHECK dout0_45 Vdout0_45ck67 = 0.9 time = 340
.meas tran vdout0_45ck67 FIND v(dout0_45) AT=340.025n

* CHECK dout0_46 Vdout0_46ck67 = 0 time = 340
.meas tran vdout0_46ck67 FIND v(dout0_46) AT=340.025n

* CHECK dout0_47 Vdout0_47ck67 = 0.9 time = 340
.meas tran vdout0_47ck67 FIND v(dout0_47) AT=340.025n

* CHECK dout0_48 Vdout0_48ck67 = 0.9 time = 340
.meas tran vdout0_48ck67 FIND v(dout0_48) AT=340.025n

* CHECK dout0_49 Vdout0_49ck67 = 0 time = 340
.meas tran vdout0_49ck67 FIND v(dout0_49) AT=340.025n

* CHECK dout0_50 Vdout0_50ck67 = 0 time = 340
.meas tran vdout0_50ck67 FIND v(dout0_50) AT=340.025n

* CHECK dout0_51 Vdout0_51ck67 = 0.9 time = 340
.meas tran vdout0_51ck67 FIND v(dout0_51) AT=340.025n

* CHECK dout0_52 Vdout0_52ck67 = 0 time = 340
.meas tran vdout0_52ck67 FIND v(dout0_52) AT=340.025n

* CHECK dout0_53 Vdout0_53ck67 = 0 time = 340
.meas tran vdout0_53ck67 FIND v(dout0_53) AT=340.025n

* CHECK dout0_54 Vdout0_54ck67 = 0.9 time = 340
.meas tran vdout0_54ck67 FIND v(dout0_54) AT=340.025n

* CHECK dout0_55 Vdout0_55ck67 = 0.9 time = 340
.meas tran vdout0_55ck67 FIND v(dout0_55) AT=340.025n

* CHECK dout0_56 Vdout0_56ck67 = 0.9 time = 340
.meas tran vdout0_56ck67 FIND v(dout0_56) AT=340.025n

* CHECK dout0_57 Vdout0_57ck67 = 0.9 time = 340
.meas tran vdout0_57ck67 FIND v(dout0_57) AT=340.025n

* CHECK dout0_58 Vdout0_58ck67 = 0 time = 340
.meas tran vdout0_58ck67 FIND v(dout0_58) AT=340.025n

* CHECK dout0_59 Vdout0_59ck67 = 0.9 time = 340
.meas tran vdout0_59ck67 FIND v(dout0_59) AT=340.025n

* CHECK dout0_60 Vdout0_60ck67 = 0 time = 340
.meas tran vdout0_60ck67 FIND v(dout0_60) AT=340.025n

* CHECK dout0_61 Vdout0_61ck67 = 0.9 time = 340
.meas tran vdout0_61ck67 FIND v(dout0_61) AT=340.025n

* CHECK dout0_62 Vdout0_62ck67 = 0.9 time = 340
.meas tran vdout0_62ck67 FIND v(dout0_62) AT=340.025n

* CHECK dout0_63 Vdout0_63ck67 = 0.9 time = 340
.meas tran vdout0_63ck67 FIND v(dout0_63) AT=340.025n

* CHECK dout0_0 Vdout0_0ck70 = 0 time = 355
.meas tran vdout0_0ck70 FIND v(dout0_0) AT=355.025n

* CHECK dout0_1 Vdout0_1ck70 = 0.9 time = 355
.meas tran vdout0_1ck70 FIND v(dout0_1) AT=355.025n

* CHECK dout0_2 Vdout0_2ck70 = 0 time = 355
.meas tran vdout0_2ck70 FIND v(dout0_2) AT=355.025n

* CHECK dout0_3 Vdout0_3ck70 = 0.9 time = 355
.meas tran vdout0_3ck70 FIND v(dout0_3) AT=355.025n

* CHECK dout0_4 Vdout0_4ck70 = 0.9 time = 355
.meas tran vdout0_4ck70 FIND v(dout0_4) AT=355.025n

* CHECK dout0_5 Vdout0_5ck70 = 0.9 time = 355
.meas tran vdout0_5ck70 FIND v(dout0_5) AT=355.025n

* CHECK dout0_6 Vdout0_6ck70 = 0.9 time = 355
.meas tran vdout0_6ck70 FIND v(dout0_6) AT=355.025n

* CHECK dout0_7 Vdout0_7ck70 = 0 time = 355
.meas tran vdout0_7ck70 FIND v(dout0_7) AT=355.025n

* CHECK dout0_8 Vdout0_8ck70 = 0 time = 355
.meas tran vdout0_8ck70 FIND v(dout0_8) AT=355.025n

* CHECK dout0_9 Vdout0_9ck70 = 0 time = 355
.meas tran vdout0_9ck70 FIND v(dout0_9) AT=355.025n

* CHECK dout0_10 Vdout0_10ck70 = 0 time = 355
.meas tran vdout0_10ck70 FIND v(dout0_10) AT=355.025n

* CHECK dout0_11 Vdout0_11ck70 = 0 time = 355
.meas tran vdout0_11ck70 FIND v(dout0_11) AT=355.025n

* CHECK dout0_12 Vdout0_12ck70 = 0 time = 355
.meas tran vdout0_12ck70 FIND v(dout0_12) AT=355.025n

* CHECK dout0_13 Vdout0_13ck70 = 0 time = 355
.meas tran vdout0_13ck70 FIND v(dout0_13) AT=355.025n

* CHECK dout0_14 Vdout0_14ck70 = 0 time = 355
.meas tran vdout0_14ck70 FIND v(dout0_14) AT=355.025n

* CHECK dout0_15 Vdout0_15ck70 = 0.9 time = 355
.meas tran vdout0_15ck70 FIND v(dout0_15) AT=355.025n

* CHECK dout0_16 Vdout0_16ck70 = 0.9 time = 355
.meas tran vdout0_16ck70 FIND v(dout0_16) AT=355.025n

* CHECK dout0_17 Vdout0_17ck70 = 0 time = 355
.meas tran vdout0_17ck70 FIND v(dout0_17) AT=355.025n

* CHECK dout0_18 Vdout0_18ck70 = 0.9 time = 355
.meas tran vdout0_18ck70 FIND v(dout0_18) AT=355.025n

* CHECK dout0_19 Vdout0_19ck70 = 0 time = 355
.meas tran vdout0_19ck70 FIND v(dout0_19) AT=355.025n

* CHECK dout0_20 Vdout0_20ck70 = 0.9 time = 355
.meas tran vdout0_20ck70 FIND v(dout0_20) AT=355.025n

* CHECK dout0_21 Vdout0_21ck70 = 0.9 time = 355
.meas tran vdout0_21ck70 FIND v(dout0_21) AT=355.025n

* CHECK dout0_22 Vdout0_22ck70 = 0 time = 355
.meas tran vdout0_22ck70 FIND v(dout0_22) AT=355.025n

* CHECK dout0_23 Vdout0_23ck70 = 0 time = 355
.meas tran vdout0_23ck70 FIND v(dout0_23) AT=355.025n

* CHECK dout0_24 Vdout0_24ck70 = 0.9 time = 355
.meas tran vdout0_24ck70 FIND v(dout0_24) AT=355.025n

* CHECK dout0_25 Vdout0_25ck70 = 0.9 time = 355
.meas tran vdout0_25ck70 FIND v(dout0_25) AT=355.025n

* CHECK dout0_26 Vdout0_26ck70 = 0 time = 355
.meas tran vdout0_26ck70 FIND v(dout0_26) AT=355.025n

* CHECK dout0_27 Vdout0_27ck70 = 0 time = 355
.meas tran vdout0_27ck70 FIND v(dout0_27) AT=355.025n

* CHECK dout0_28 Vdout0_28ck70 = 0 time = 355
.meas tran vdout0_28ck70 FIND v(dout0_28) AT=355.025n

* CHECK dout0_29 Vdout0_29ck70 = 0.9 time = 355
.meas tran vdout0_29ck70 FIND v(dout0_29) AT=355.025n

* CHECK dout0_30 Vdout0_30ck70 = 0 time = 355
.meas tran vdout0_30ck70 FIND v(dout0_30) AT=355.025n

* CHECK dout0_31 Vdout0_31ck70 = 0 time = 355
.meas tran vdout0_31ck70 FIND v(dout0_31) AT=355.025n

* CHECK dout0_32 Vdout0_32ck70 = 0 time = 355
.meas tran vdout0_32ck70 FIND v(dout0_32) AT=355.025n

* CHECK dout0_33 Vdout0_33ck70 = 0 time = 355
.meas tran vdout0_33ck70 FIND v(dout0_33) AT=355.025n

* CHECK dout0_34 Vdout0_34ck70 = 0 time = 355
.meas tran vdout0_34ck70 FIND v(dout0_34) AT=355.025n

* CHECK dout0_35 Vdout0_35ck70 = 0 time = 355
.meas tran vdout0_35ck70 FIND v(dout0_35) AT=355.025n

* CHECK dout0_36 Vdout0_36ck70 = 0 time = 355
.meas tran vdout0_36ck70 FIND v(dout0_36) AT=355.025n

* CHECK dout0_37 Vdout0_37ck70 = 0.9 time = 355
.meas tran vdout0_37ck70 FIND v(dout0_37) AT=355.025n

* CHECK dout0_38 Vdout0_38ck70 = 0 time = 355
.meas tran vdout0_38ck70 FIND v(dout0_38) AT=355.025n

* CHECK dout0_39 Vdout0_39ck70 = 0 time = 355
.meas tran vdout0_39ck70 FIND v(dout0_39) AT=355.025n

* CHECK dout0_40 Vdout0_40ck70 = 0 time = 355
.meas tran vdout0_40ck70 FIND v(dout0_40) AT=355.025n

* CHECK dout0_41 Vdout0_41ck70 = 0.9 time = 355
.meas tran vdout0_41ck70 FIND v(dout0_41) AT=355.025n

* CHECK dout0_42 Vdout0_42ck70 = 0 time = 355
.meas tran vdout0_42ck70 FIND v(dout0_42) AT=355.025n

* CHECK dout0_43 Vdout0_43ck70 = 0.9 time = 355
.meas tran vdout0_43ck70 FIND v(dout0_43) AT=355.025n

* CHECK dout0_44 Vdout0_44ck70 = 0 time = 355
.meas tran vdout0_44ck70 FIND v(dout0_44) AT=355.025n

* CHECK dout0_45 Vdout0_45ck70 = 0.9 time = 355
.meas tran vdout0_45ck70 FIND v(dout0_45) AT=355.025n

* CHECK dout0_46 Vdout0_46ck70 = 0 time = 355
.meas tran vdout0_46ck70 FIND v(dout0_46) AT=355.025n

* CHECK dout0_47 Vdout0_47ck70 = 0.9 time = 355
.meas tran vdout0_47ck70 FIND v(dout0_47) AT=355.025n

* CHECK dout0_48 Vdout0_48ck70 = 0.9 time = 355
.meas tran vdout0_48ck70 FIND v(dout0_48) AT=355.025n

* CHECK dout0_49 Vdout0_49ck70 = 0 time = 355
.meas tran vdout0_49ck70 FIND v(dout0_49) AT=355.025n

* CHECK dout0_50 Vdout0_50ck70 = 0 time = 355
.meas tran vdout0_50ck70 FIND v(dout0_50) AT=355.025n

* CHECK dout0_51 Vdout0_51ck70 = 0.9 time = 355
.meas tran vdout0_51ck70 FIND v(dout0_51) AT=355.025n

* CHECK dout0_52 Vdout0_52ck70 = 0 time = 355
.meas tran vdout0_52ck70 FIND v(dout0_52) AT=355.025n

* CHECK dout0_53 Vdout0_53ck70 = 0 time = 355
.meas tran vdout0_53ck70 FIND v(dout0_53) AT=355.025n

* CHECK dout0_54 Vdout0_54ck70 = 0.9 time = 355
.meas tran vdout0_54ck70 FIND v(dout0_54) AT=355.025n

* CHECK dout0_55 Vdout0_55ck70 = 0.9 time = 355
.meas tran vdout0_55ck70 FIND v(dout0_55) AT=355.025n

* CHECK dout0_56 Vdout0_56ck70 = 0.9 time = 355
.meas tran vdout0_56ck70 FIND v(dout0_56) AT=355.025n

* CHECK dout0_57 Vdout0_57ck70 = 0.9 time = 355
.meas tran vdout0_57ck70 FIND v(dout0_57) AT=355.025n

* CHECK dout0_58 Vdout0_58ck70 = 0 time = 355
.meas tran vdout0_58ck70 FIND v(dout0_58) AT=355.025n

* CHECK dout0_59 Vdout0_59ck70 = 0.9 time = 355
.meas tran vdout0_59ck70 FIND v(dout0_59) AT=355.025n

* CHECK dout0_60 Vdout0_60ck70 = 0 time = 355
.meas tran vdout0_60ck70 FIND v(dout0_60) AT=355.025n

* CHECK dout0_61 Vdout0_61ck70 = 0.9 time = 355
.meas tran vdout0_61ck70 FIND v(dout0_61) AT=355.025n

* CHECK dout0_62 Vdout0_62ck70 = 0.9 time = 355
.meas tran vdout0_62ck70 FIND v(dout0_62) AT=355.025n

* CHECK dout0_63 Vdout0_63ck70 = 0.9 time = 355
.meas tran vdout0_63ck70 FIND v(dout0_63) AT=355.025n

* CHECK dout0_0 Vdout0_0ck75 = 0 time = 380
.meas tran vdout0_0ck75 FIND v(dout0_0) AT=380.025n

* CHECK dout0_1 Vdout0_1ck75 = 0.9 time = 380
.meas tran vdout0_1ck75 FIND v(dout0_1) AT=380.025n

* CHECK dout0_2 Vdout0_2ck75 = 0.9 time = 380
.meas tran vdout0_2ck75 FIND v(dout0_2) AT=380.025n

* CHECK dout0_3 Vdout0_3ck75 = 0.9 time = 380
.meas tran vdout0_3ck75 FIND v(dout0_3) AT=380.025n

* CHECK dout0_4 Vdout0_4ck75 = 0 time = 380
.meas tran vdout0_4ck75 FIND v(dout0_4) AT=380.025n

* CHECK dout0_5 Vdout0_5ck75 = 0.9 time = 380
.meas tran vdout0_5ck75 FIND v(dout0_5) AT=380.025n

* CHECK dout0_6 Vdout0_6ck75 = 0 time = 380
.meas tran vdout0_6ck75 FIND v(dout0_6) AT=380.025n

* CHECK dout0_7 Vdout0_7ck75 = 0 time = 380
.meas tran vdout0_7ck75 FIND v(dout0_7) AT=380.025n

* CHECK dout0_8 Vdout0_8ck75 = 0.9 time = 380
.meas tran vdout0_8ck75 FIND v(dout0_8) AT=380.025n

* CHECK dout0_9 Vdout0_9ck75 = 0.9 time = 380
.meas tran vdout0_9ck75 FIND v(dout0_9) AT=380.025n

* CHECK dout0_10 Vdout0_10ck75 = 0.9 time = 380
.meas tran vdout0_10ck75 FIND v(dout0_10) AT=380.025n

* CHECK dout0_11 Vdout0_11ck75 = 0.9 time = 380
.meas tran vdout0_11ck75 FIND v(dout0_11) AT=380.025n

* CHECK dout0_12 Vdout0_12ck75 = 0.9 time = 380
.meas tran vdout0_12ck75 FIND v(dout0_12) AT=380.025n

* CHECK dout0_13 Vdout0_13ck75 = 0.9 time = 380
.meas tran vdout0_13ck75 FIND v(dout0_13) AT=380.025n

* CHECK dout0_14 Vdout0_14ck75 = 0 time = 380
.meas tran vdout0_14ck75 FIND v(dout0_14) AT=380.025n

* CHECK dout0_15 Vdout0_15ck75 = 0 time = 380
.meas tran vdout0_15ck75 FIND v(dout0_15) AT=380.025n

* CHECK dout0_16 Vdout0_16ck75 = 0.9 time = 380
.meas tran vdout0_16ck75 FIND v(dout0_16) AT=380.025n

* CHECK dout0_17 Vdout0_17ck75 = 0.9 time = 380
.meas tran vdout0_17ck75 FIND v(dout0_17) AT=380.025n

* CHECK dout0_18 Vdout0_18ck75 = 0 time = 380
.meas tran vdout0_18ck75 FIND v(dout0_18) AT=380.025n

* CHECK dout0_19 Vdout0_19ck75 = 0 time = 380
.meas tran vdout0_19ck75 FIND v(dout0_19) AT=380.025n

* CHECK dout0_20 Vdout0_20ck75 = 0.9 time = 380
.meas tran vdout0_20ck75 FIND v(dout0_20) AT=380.025n

* CHECK dout0_21 Vdout0_21ck75 = 0 time = 380
.meas tran vdout0_21ck75 FIND v(dout0_21) AT=380.025n

* CHECK dout0_22 Vdout0_22ck75 = 0 time = 380
.meas tran vdout0_22ck75 FIND v(dout0_22) AT=380.025n

* CHECK dout0_23 Vdout0_23ck75 = 0 time = 380
.meas tran vdout0_23ck75 FIND v(dout0_23) AT=380.025n

* CHECK dout0_24 Vdout0_24ck75 = 0 time = 380
.meas tran vdout0_24ck75 FIND v(dout0_24) AT=380.025n

* CHECK dout0_25 Vdout0_25ck75 = 0.9 time = 380
.meas tran vdout0_25ck75 FIND v(dout0_25) AT=380.025n

* CHECK dout0_26 Vdout0_26ck75 = 0 time = 380
.meas tran vdout0_26ck75 FIND v(dout0_26) AT=380.025n

* CHECK dout0_27 Vdout0_27ck75 = 0.9 time = 380
.meas tran vdout0_27ck75 FIND v(dout0_27) AT=380.025n

* CHECK dout0_28 Vdout0_28ck75 = 0 time = 380
.meas tran vdout0_28ck75 FIND v(dout0_28) AT=380.025n

* CHECK dout0_29 Vdout0_29ck75 = 0.9 time = 380
.meas tran vdout0_29ck75 FIND v(dout0_29) AT=380.025n

* CHECK dout0_30 Vdout0_30ck75 = 0.9 time = 380
.meas tran vdout0_30ck75 FIND v(dout0_30) AT=380.025n

* CHECK dout0_31 Vdout0_31ck75 = 0 time = 380
.meas tran vdout0_31ck75 FIND v(dout0_31) AT=380.025n

* CHECK dout0_32 Vdout0_32ck75 = 0.9 time = 380
.meas tran vdout0_32ck75 FIND v(dout0_32) AT=380.025n

* CHECK dout0_33 Vdout0_33ck75 = 0.9 time = 380
.meas tran vdout0_33ck75 FIND v(dout0_33) AT=380.025n

* CHECK dout0_34 Vdout0_34ck75 = 0.9 time = 380
.meas tran vdout0_34ck75 FIND v(dout0_34) AT=380.025n

* CHECK dout0_35 Vdout0_35ck75 = 0 time = 380
.meas tran vdout0_35ck75 FIND v(dout0_35) AT=380.025n

* CHECK dout0_36 Vdout0_36ck75 = 0 time = 380
.meas tran vdout0_36ck75 FIND v(dout0_36) AT=380.025n

* CHECK dout0_37 Vdout0_37ck75 = 0 time = 380
.meas tran vdout0_37ck75 FIND v(dout0_37) AT=380.025n

* CHECK dout0_38 Vdout0_38ck75 = 0.9 time = 380
.meas tran vdout0_38ck75 FIND v(dout0_38) AT=380.025n

* CHECK dout0_39 Vdout0_39ck75 = 0 time = 380
.meas tran vdout0_39ck75 FIND v(dout0_39) AT=380.025n

* CHECK dout0_40 Vdout0_40ck75 = 0.9 time = 380
.meas tran vdout0_40ck75 FIND v(dout0_40) AT=380.025n

* CHECK dout0_41 Vdout0_41ck75 = 0.9 time = 380
.meas tran vdout0_41ck75 FIND v(dout0_41) AT=380.025n

* CHECK dout0_42 Vdout0_42ck75 = 0.9 time = 380
.meas tran vdout0_42ck75 FIND v(dout0_42) AT=380.025n

* CHECK dout0_43 Vdout0_43ck75 = 0 time = 380
.meas tran vdout0_43ck75 FIND v(dout0_43) AT=380.025n

* CHECK dout0_44 Vdout0_44ck75 = 0.9 time = 380
.meas tran vdout0_44ck75 FIND v(dout0_44) AT=380.025n

* CHECK dout0_45 Vdout0_45ck75 = 0 time = 380
.meas tran vdout0_45ck75 FIND v(dout0_45) AT=380.025n

* CHECK dout0_46 Vdout0_46ck75 = 0.9 time = 380
.meas tran vdout0_46ck75 FIND v(dout0_46) AT=380.025n

* CHECK dout0_47 Vdout0_47ck75 = 0 time = 380
.meas tran vdout0_47ck75 FIND v(dout0_47) AT=380.025n

* CHECK dout0_48 Vdout0_48ck75 = 0 time = 380
.meas tran vdout0_48ck75 FIND v(dout0_48) AT=380.025n

* CHECK dout0_49 Vdout0_49ck75 = 0.9 time = 380
.meas tran vdout0_49ck75 FIND v(dout0_49) AT=380.025n

* CHECK dout0_50 Vdout0_50ck75 = 0.9 time = 380
.meas tran vdout0_50ck75 FIND v(dout0_50) AT=380.025n

* CHECK dout0_51 Vdout0_51ck75 = 0 time = 380
.meas tran vdout0_51ck75 FIND v(dout0_51) AT=380.025n

* CHECK dout0_52 Vdout0_52ck75 = 0.9 time = 380
.meas tran vdout0_52ck75 FIND v(dout0_52) AT=380.025n

* CHECK dout0_53 Vdout0_53ck75 = 0.9 time = 380
.meas tran vdout0_53ck75 FIND v(dout0_53) AT=380.025n

* CHECK dout0_54 Vdout0_54ck75 = 0 time = 380
.meas tran vdout0_54ck75 FIND v(dout0_54) AT=380.025n

* CHECK dout0_55 Vdout0_55ck75 = 0 time = 380
.meas tran vdout0_55ck75 FIND v(dout0_55) AT=380.025n

* CHECK dout0_56 Vdout0_56ck75 = 0.9 time = 380
.meas tran vdout0_56ck75 FIND v(dout0_56) AT=380.025n

* CHECK dout0_57 Vdout0_57ck75 = 0.9 time = 380
.meas tran vdout0_57ck75 FIND v(dout0_57) AT=380.025n

* CHECK dout0_58 Vdout0_58ck75 = 0.9 time = 380
.meas tran vdout0_58ck75 FIND v(dout0_58) AT=380.025n

* CHECK dout0_59 Vdout0_59ck75 = 0.9 time = 380
.meas tran vdout0_59ck75 FIND v(dout0_59) AT=380.025n

* CHECK dout0_60 Vdout0_60ck75 = 0 time = 380
.meas tran vdout0_60ck75 FIND v(dout0_60) AT=380.025n

* CHECK dout0_61 Vdout0_61ck75 = 0.9 time = 380
.meas tran vdout0_61ck75 FIND v(dout0_61) AT=380.025n

* CHECK dout0_62 Vdout0_62ck75 = 0.9 time = 380
.meas tran vdout0_62ck75 FIND v(dout0_62) AT=380.025n

* CHECK dout0_63 Vdout0_63ck75 = 0.9 time = 380
.meas tran vdout0_63ck75 FIND v(dout0_63) AT=380.025n

* CHECK dout0_0 Vdout0_0ck77 = 0 time = 390
.meas tran vdout0_0ck77 FIND v(dout0_0) AT=390.025n

* CHECK dout0_1 Vdout0_1ck77 = 0.9 time = 390
.meas tran vdout0_1ck77 FIND v(dout0_1) AT=390.025n

* CHECK dout0_2 Vdout0_2ck77 = 0.9 time = 390
.meas tran vdout0_2ck77 FIND v(dout0_2) AT=390.025n

* CHECK dout0_3 Vdout0_3ck77 = 0.9 time = 390
.meas tran vdout0_3ck77 FIND v(dout0_3) AT=390.025n

* CHECK dout0_4 Vdout0_4ck77 = 0 time = 390
.meas tran vdout0_4ck77 FIND v(dout0_4) AT=390.025n

* CHECK dout0_5 Vdout0_5ck77 = 0.9 time = 390
.meas tran vdout0_5ck77 FIND v(dout0_5) AT=390.025n

* CHECK dout0_6 Vdout0_6ck77 = 0 time = 390
.meas tran vdout0_6ck77 FIND v(dout0_6) AT=390.025n

* CHECK dout0_7 Vdout0_7ck77 = 0 time = 390
.meas tran vdout0_7ck77 FIND v(dout0_7) AT=390.025n

* CHECK dout0_8 Vdout0_8ck77 = 0.9 time = 390
.meas tran vdout0_8ck77 FIND v(dout0_8) AT=390.025n

* CHECK dout0_9 Vdout0_9ck77 = 0.9 time = 390
.meas tran vdout0_9ck77 FIND v(dout0_9) AT=390.025n

* CHECK dout0_10 Vdout0_10ck77 = 0.9 time = 390
.meas tran vdout0_10ck77 FIND v(dout0_10) AT=390.025n

* CHECK dout0_11 Vdout0_11ck77 = 0.9 time = 390
.meas tran vdout0_11ck77 FIND v(dout0_11) AT=390.025n

* CHECK dout0_12 Vdout0_12ck77 = 0.9 time = 390
.meas tran vdout0_12ck77 FIND v(dout0_12) AT=390.025n

* CHECK dout0_13 Vdout0_13ck77 = 0.9 time = 390
.meas tran vdout0_13ck77 FIND v(dout0_13) AT=390.025n

* CHECK dout0_14 Vdout0_14ck77 = 0 time = 390
.meas tran vdout0_14ck77 FIND v(dout0_14) AT=390.025n

* CHECK dout0_15 Vdout0_15ck77 = 0 time = 390
.meas tran vdout0_15ck77 FIND v(dout0_15) AT=390.025n

* CHECK dout0_16 Vdout0_16ck77 = 0.9 time = 390
.meas tran vdout0_16ck77 FIND v(dout0_16) AT=390.025n

* CHECK dout0_17 Vdout0_17ck77 = 0.9 time = 390
.meas tran vdout0_17ck77 FIND v(dout0_17) AT=390.025n

* CHECK dout0_18 Vdout0_18ck77 = 0 time = 390
.meas tran vdout0_18ck77 FIND v(dout0_18) AT=390.025n

* CHECK dout0_19 Vdout0_19ck77 = 0 time = 390
.meas tran vdout0_19ck77 FIND v(dout0_19) AT=390.025n

* CHECK dout0_20 Vdout0_20ck77 = 0.9 time = 390
.meas tran vdout0_20ck77 FIND v(dout0_20) AT=390.025n

* CHECK dout0_21 Vdout0_21ck77 = 0 time = 390
.meas tran vdout0_21ck77 FIND v(dout0_21) AT=390.025n

* CHECK dout0_22 Vdout0_22ck77 = 0 time = 390
.meas tran vdout0_22ck77 FIND v(dout0_22) AT=390.025n

* CHECK dout0_23 Vdout0_23ck77 = 0 time = 390
.meas tran vdout0_23ck77 FIND v(dout0_23) AT=390.025n

* CHECK dout0_24 Vdout0_24ck77 = 0 time = 390
.meas tran vdout0_24ck77 FIND v(dout0_24) AT=390.025n

* CHECK dout0_25 Vdout0_25ck77 = 0.9 time = 390
.meas tran vdout0_25ck77 FIND v(dout0_25) AT=390.025n

* CHECK dout0_26 Vdout0_26ck77 = 0 time = 390
.meas tran vdout0_26ck77 FIND v(dout0_26) AT=390.025n

* CHECK dout0_27 Vdout0_27ck77 = 0.9 time = 390
.meas tran vdout0_27ck77 FIND v(dout0_27) AT=390.025n

* CHECK dout0_28 Vdout0_28ck77 = 0 time = 390
.meas tran vdout0_28ck77 FIND v(dout0_28) AT=390.025n

* CHECK dout0_29 Vdout0_29ck77 = 0.9 time = 390
.meas tran vdout0_29ck77 FIND v(dout0_29) AT=390.025n

* CHECK dout0_30 Vdout0_30ck77 = 0.9 time = 390
.meas tran vdout0_30ck77 FIND v(dout0_30) AT=390.025n

* CHECK dout0_31 Vdout0_31ck77 = 0 time = 390
.meas tran vdout0_31ck77 FIND v(dout0_31) AT=390.025n

* CHECK dout0_32 Vdout0_32ck77 = 0.9 time = 390
.meas tran vdout0_32ck77 FIND v(dout0_32) AT=390.025n

* CHECK dout0_33 Vdout0_33ck77 = 0.9 time = 390
.meas tran vdout0_33ck77 FIND v(dout0_33) AT=390.025n

* CHECK dout0_34 Vdout0_34ck77 = 0.9 time = 390
.meas tran vdout0_34ck77 FIND v(dout0_34) AT=390.025n

* CHECK dout0_35 Vdout0_35ck77 = 0 time = 390
.meas tran vdout0_35ck77 FIND v(dout0_35) AT=390.025n

* CHECK dout0_36 Vdout0_36ck77 = 0 time = 390
.meas tran vdout0_36ck77 FIND v(dout0_36) AT=390.025n

* CHECK dout0_37 Vdout0_37ck77 = 0 time = 390
.meas tran vdout0_37ck77 FIND v(dout0_37) AT=390.025n

* CHECK dout0_38 Vdout0_38ck77 = 0.9 time = 390
.meas tran vdout0_38ck77 FIND v(dout0_38) AT=390.025n

* CHECK dout0_39 Vdout0_39ck77 = 0 time = 390
.meas tran vdout0_39ck77 FIND v(dout0_39) AT=390.025n

* CHECK dout0_40 Vdout0_40ck77 = 0.9 time = 390
.meas tran vdout0_40ck77 FIND v(dout0_40) AT=390.025n

* CHECK dout0_41 Vdout0_41ck77 = 0.9 time = 390
.meas tran vdout0_41ck77 FIND v(dout0_41) AT=390.025n

* CHECK dout0_42 Vdout0_42ck77 = 0.9 time = 390
.meas tran vdout0_42ck77 FIND v(dout0_42) AT=390.025n

* CHECK dout0_43 Vdout0_43ck77 = 0 time = 390
.meas tran vdout0_43ck77 FIND v(dout0_43) AT=390.025n

* CHECK dout0_44 Vdout0_44ck77 = 0.9 time = 390
.meas tran vdout0_44ck77 FIND v(dout0_44) AT=390.025n

* CHECK dout0_45 Vdout0_45ck77 = 0 time = 390
.meas tran vdout0_45ck77 FIND v(dout0_45) AT=390.025n

* CHECK dout0_46 Vdout0_46ck77 = 0.9 time = 390
.meas tran vdout0_46ck77 FIND v(dout0_46) AT=390.025n

* CHECK dout0_47 Vdout0_47ck77 = 0 time = 390
.meas tran vdout0_47ck77 FIND v(dout0_47) AT=390.025n

* CHECK dout0_48 Vdout0_48ck77 = 0 time = 390
.meas tran vdout0_48ck77 FIND v(dout0_48) AT=390.025n

* CHECK dout0_49 Vdout0_49ck77 = 0.9 time = 390
.meas tran vdout0_49ck77 FIND v(dout0_49) AT=390.025n

* CHECK dout0_50 Vdout0_50ck77 = 0.9 time = 390
.meas tran vdout0_50ck77 FIND v(dout0_50) AT=390.025n

* CHECK dout0_51 Vdout0_51ck77 = 0 time = 390
.meas tran vdout0_51ck77 FIND v(dout0_51) AT=390.025n

* CHECK dout0_52 Vdout0_52ck77 = 0.9 time = 390
.meas tran vdout0_52ck77 FIND v(dout0_52) AT=390.025n

* CHECK dout0_53 Vdout0_53ck77 = 0.9 time = 390
.meas tran vdout0_53ck77 FIND v(dout0_53) AT=390.025n

* CHECK dout0_54 Vdout0_54ck77 = 0 time = 390
.meas tran vdout0_54ck77 FIND v(dout0_54) AT=390.025n

* CHECK dout0_55 Vdout0_55ck77 = 0 time = 390
.meas tran vdout0_55ck77 FIND v(dout0_55) AT=390.025n

* CHECK dout0_56 Vdout0_56ck77 = 0.9 time = 390
.meas tran vdout0_56ck77 FIND v(dout0_56) AT=390.025n

* CHECK dout0_57 Vdout0_57ck77 = 0.9 time = 390
.meas tran vdout0_57ck77 FIND v(dout0_57) AT=390.025n

* CHECK dout0_58 Vdout0_58ck77 = 0.9 time = 390
.meas tran vdout0_58ck77 FIND v(dout0_58) AT=390.025n

* CHECK dout0_59 Vdout0_59ck77 = 0.9 time = 390
.meas tran vdout0_59ck77 FIND v(dout0_59) AT=390.025n

* CHECK dout0_60 Vdout0_60ck77 = 0 time = 390
.meas tran vdout0_60ck77 FIND v(dout0_60) AT=390.025n

* CHECK dout0_61 Vdout0_61ck77 = 0.9 time = 390
.meas tran vdout0_61ck77 FIND v(dout0_61) AT=390.025n

* CHECK dout0_62 Vdout0_62ck77 = 0.9 time = 390
.meas tran vdout0_62ck77 FIND v(dout0_62) AT=390.025n

* CHECK dout0_63 Vdout0_63ck77 = 0.9 time = 390
.meas tran vdout0_63ck77 FIND v(dout0_63) AT=390.025n

* CHECK dout0_0 Vdout0_0ck78 = 0 time = 395
.meas tran vdout0_0ck78 FIND v(dout0_0) AT=395.025n

* CHECK dout0_1 Vdout0_1ck78 = 0.9 time = 395
.meas tran vdout0_1ck78 FIND v(dout0_1) AT=395.025n

* CHECK dout0_2 Vdout0_2ck78 = 0 time = 395
.meas tran vdout0_2ck78 FIND v(dout0_2) AT=395.025n

* CHECK dout0_3 Vdout0_3ck78 = 0.9 time = 395
.meas tran vdout0_3ck78 FIND v(dout0_3) AT=395.025n

* CHECK dout0_4 Vdout0_4ck78 = 0 time = 395
.meas tran vdout0_4ck78 FIND v(dout0_4) AT=395.025n

* CHECK dout0_5 Vdout0_5ck78 = 0 time = 395
.meas tran vdout0_5ck78 FIND v(dout0_5) AT=395.025n

* CHECK dout0_6 Vdout0_6ck78 = 0.9 time = 395
.meas tran vdout0_6ck78 FIND v(dout0_6) AT=395.025n

* CHECK dout0_7 Vdout0_7ck78 = 0 time = 395
.meas tran vdout0_7ck78 FIND v(dout0_7) AT=395.025n

* CHECK dout0_8 Vdout0_8ck78 = 0.9 time = 395
.meas tran vdout0_8ck78 FIND v(dout0_8) AT=395.025n

* CHECK dout0_9 Vdout0_9ck78 = 0.9 time = 395
.meas tran vdout0_9ck78 FIND v(dout0_9) AT=395.025n

* CHECK dout0_10 Vdout0_10ck78 = 0 time = 395
.meas tran vdout0_10ck78 FIND v(dout0_10) AT=395.025n

* CHECK dout0_11 Vdout0_11ck78 = 0.9 time = 395
.meas tran vdout0_11ck78 FIND v(dout0_11) AT=395.025n

* CHECK dout0_12 Vdout0_12ck78 = 0.9 time = 395
.meas tran vdout0_12ck78 FIND v(dout0_12) AT=395.025n

* CHECK dout0_13 Vdout0_13ck78 = 0 time = 395
.meas tran vdout0_13ck78 FIND v(dout0_13) AT=395.025n

* CHECK dout0_14 Vdout0_14ck78 = 0 time = 395
.meas tran vdout0_14ck78 FIND v(dout0_14) AT=395.025n

* CHECK dout0_15 Vdout0_15ck78 = 0 time = 395
.meas tran vdout0_15ck78 FIND v(dout0_15) AT=395.025n

* CHECK dout0_16 Vdout0_16ck78 = 0.9 time = 395
.meas tran vdout0_16ck78 FIND v(dout0_16) AT=395.025n

* CHECK dout0_17 Vdout0_17ck78 = 0.9 time = 395
.meas tran vdout0_17ck78 FIND v(dout0_17) AT=395.025n

* CHECK dout0_18 Vdout0_18ck78 = 0 time = 395
.meas tran vdout0_18ck78 FIND v(dout0_18) AT=395.025n

* CHECK dout0_19 Vdout0_19ck78 = 0 time = 395
.meas tran vdout0_19ck78 FIND v(dout0_19) AT=395.025n

* CHECK dout0_20 Vdout0_20ck78 = 0.9 time = 395
.meas tran vdout0_20ck78 FIND v(dout0_20) AT=395.025n

* CHECK dout0_21 Vdout0_21ck78 = 0.9 time = 395
.meas tran vdout0_21ck78 FIND v(dout0_21) AT=395.025n

* CHECK dout0_22 Vdout0_22ck78 = 0.9 time = 395
.meas tran vdout0_22ck78 FIND v(dout0_22) AT=395.025n

* CHECK dout0_23 Vdout0_23ck78 = 0.9 time = 395
.meas tran vdout0_23ck78 FIND v(dout0_23) AT=395.025n

* CHECK dout0_24 Vdout0_24ck78 = 0 time = 395
.meas tran vdout0_24ck78 FIND v(dout0_24) AT=395.025n

* CHECK dout0_25 Vdout0_25ck78 = 0.9 time = 395
.meas tran vdout0_25ck78 FIND v(dout0_25) AT=395.025n

* CHECK dout0_26 Vdout0_26ck78 = 0.9 time = 395
.meas tran vdout0_26ck78 FIND v(dout0_26) AT=395.025n

* CHECK dout0_27 Vdout0_27ck78 = 0.9 time = 395
.meas tran vdout0_27ck78 FIND v(dout0_27) AT=395.025n

* CHECK dout0_28 Vdout0_28ck78 = 0 time = 395
.meas tran vdout0_28ck78 FIND v(dout0_28) AT=395.025n

* CHECK dout0_29 Vdout0_29ck78 = 0 time = 395
.meas tran vdout0_29ck78 FIND v(dout0_29) AT=395.025n

* CHECK dout0_30 Vdout0_30ck78 = 0 time = 395
.meas tran vdout0_30ck78 FIND v(dout0_30) AT=395.025n

* CHECK dout0_31 Vdout0_31ck78 = 0.9 time = 395
.meas tran vdout0_31ck78 FIND v(dout0_31) AT=395.025n

* CHECK dout0_32 Vdout0_32ck78 = 0.9 time = 395
.meas tran vdout0_32ck78 FIND v(dout0_32) AT=395.025n

* CHECK dout0_33 Vdout0_33ck78 = 0 time = 395
.meas tran vdout0_33ck78 FIND v(dout0_33) AT=395.025n

* CHECK dout0_34 Vdout0_34ck78 = 0.9 time = 395
.meas tran vdout0_34ck78 FIND v(dout0_34) AT=395.025n

* CHECK dout0_35 Vdout0_35ck78 = 0 time = 395
.meas tran vdout0_35ck78 FIND v(dout0_35) AT=395.025n

* CHECK dout0_36 Vdout0_36ck78 = 0 time = 395
.meas tran vdout0_36ck78 FIND v(dout0_36) AT=395.025n

* CHECK dout0_37 Vdout0_37ck78 = 0.9 time = 395
.meas tran vdout0_37ck78 FIND v(dout0_37) AT=395.025n

* CHECK dout0_38 Vdout0_38ck78 = 0.9 time = 395
.meas tran vdout0_38ck78 FIND v(dout0_38) AT=395.025n

* CHECK dout0_39 Vdout0_39ck78 = 0.9 time = 395
.meas tran vdout0_39ck78 FIND v(dout0_39) AT=395.025n

* CHECK dout0_40 Vdout0_40ck78 = 0 time = 395
.meas tran vdout0_40ck78 FIND v(dout0_40) AT=395.025n

* CHECK dout0_41 Vdout0_41ck78 = 0.9 time = 395
.meas tran vdout0_41ck78 FIND v(dout0_41) AT=395.025n

* CHECK dout0_42 Vdout0_42ck78 = 0 time = 395
.meas tran vdout0_42ck78 FIND v(dout0_42) AT=395.025n

* CHECK dout0_43 Vdout0_43ck78 = 0.9 time = 395
.meas tran vdout0_43ck78 FIND v(dout0_43) AT=395.025n

* CHECK dout0_44 Vdout0_44ck78 = 0.9 time = 395
.meas tran vdout0_44ck78 FIND v(dout0_44) AT=395.025n

* CHECK dout0_45 Vdout0_45ck78 = 0.9 time = 395
.meas tran vdout0_45ck78 FIND v(dout0_45) AT=395.025n

* CHECK dout0_46 Vdout0_46ck78 = 0.9 time = 395
.meas tran vdout0_46ck78 FIND v(dout0_46) AT=395.025n

* CHECK dout0_47 Vdout0_47ck78 = 0 time = 395
.meas tran vdout0_47ck78 FIND v(dout0_47) AT=395.025n

* CHECK dout0_48 Vdout0_48ck78 = 0.9 time = 395
.meas tran vdout0_48ck78 FIND v(dout0_48) AT=395.025n

* CHECK dout0_49 Vdout0_49ck78 = 0.9 time = 395
.meas tran vdout0_49ck78 FIND v(dout0_49) AT=395.025n

* CHECK dout0_50 Vdout0_50ck78 = 0 time = 395
.meas tran vdout0_50ck78 FIND v(dout0_50) AT=395.025n

* CHECK dout0_51 Vdout0_51ck78 = 0.9 time = 395
.meas tran vdout0_51ck78 FIND v(dout0_51) AT=395.025n

* CHECK dout0_52 Vdout0_52ck78 = 0 time = 395
.meas tran vdout0_52ck78 FIND v(dout0_52) AT=395.025n

* CHECK dout0_53 Vdout0_53ck78 = 0.9 time = 395
.meas tran vdout0_53ck78 FIND v(dout0_53) AT=395.025n

* CHECK dout0_54 Vdout0_54ck78 = 0.9 time = 395
.meas tran vdout0_54ck78 FIND v(dout0_54) AT=395.025n

* CHECK dout0_55 Vdout0_55ck78 = 0 time = 395
.meas tran vdout0_55ck78 FIND v(dout0_55) AT=395.025n

* CHECK dout0_56 Vdout0_56ck78 = 0 time = 395
.meas tran vdout0_56ck78 FIND v(dout0_56) AT=395.025n

* CHECK dout0_57 Vdout0_57ck78 = 0.9 time = 395
.meas tran vdout0_57ck78 FIND v(dout0_57) AT=395.025n

* CHECK dout0_58 Vdout0_58ck78 = 0.9 time = 395
.meas tran vdout0_58ck78 FIND v(dout0_58) AT=395.025n

* CHECK dout0_59 Vdout0_59ck78 = 0.9 time = 395
.meas tran vdout0_59ck78 FIND v(dout0_59) AT=395.025n

* CHECK dout0_60 Vdout0_60ck78 = 0.9 time = 395
.meas tran vdout0_60ck78 FIND v(dout0_60) AT=395.025n

* CHECK dout0_61 Vdout0_61ck78 = 0 time = 395
.meas tran vdout0_61ck78 FIND v(dout0_61) AT=395.025n

* CHECK dout0_62 Vdout0_62ck78 = 0 time = 395
.meas tran vdout0_62ck78 FIND v(dout0_62) AT=395.025n

* CHECK dout0_63 Vdout0_63ck78 = 0 time = 395
.meas tran vdout0_63ck78 FIND v(dout0_63) AT=395.025n

* CHECK dout0_0 Vdout0_0ck79 = 0 time = 400
.meas tran vdout0_0ck79 FIND v(dout0_0) AT=400.025n

* CHECK dout0_1 Vdout0_1ck79 = 0 time = 400
.meas tran vdout0_1ck79 FIND v(dout0_1) AT=400.025n

* CHECK dout0_2 Vdout0_2ck79 = 0.9 time = 400
.meas tran vdout0_2ck79 FIND v(dout0_2) AT=400.025n

* CHECK dout0_3 Vdout0_3ck79 = 0.9 time = 400
.meas tran vdout0_3ck79 FIND v(dout0_3) AT=400.025n

* CHECK dout0_4 Vdout0_4ck79 = 0.9 time = 400
.meas tran vdout0_4ck79 FIND v(dout0_4) AT=400.025n

* CHECK dout0_5 Vdout0_5ck79 = 0 time = 400
.meas tran vdout0_5ck79 FIND v(dout0_5) AT=400.025n

* CHECK dout0_6 Vdout0_6ck79 = 0.9 time = 400
.meas tran vdout0_6ck79 FIND v(dout0_6) AT=400.025n

* CHECK dout0_7 Vdout0_7ck79 = 0 time = 400
.meas tran vdout0_7ck79 FIND v(dout0_7) AT=400.025n

* CHECK dout0_8 Vdout0_8ck79 = 0 time = 400
.meas tran vdout0_8ck79 FIND v(dout0_8) AT=400.025n

* CHECK dout0_9 Vdout0_9ck79 = 0.9 time = 400
.meas tran vdout0_9ck79 FIND v(dout0_9) AT=400.025n

* CHECK dout0_10 Vdout0_10ck79 = 0.9 time = 400
.meas tran vdout0_10ck79 FIND v(dout0_10) AT=400.025n

* CHECK dout0_11 Vdout0_11ck79 = 0 time = 400
.meas tran vdout0_11ck79 FIND v(dout0_11) AT=400.025n

* CHECK dout0_12 Vdout0_12ck79 = 0.9 time = 400
.meas tran vdout0_12ck79 FIND v(dout0_12) AT=400.025n

* CHECK dout0_13 Vdout0_13ck79 = 0 time = 400
.meas tran vdout0_13ck79 FIND v(dout0_13) AT=400.025n

* CHECK dout0_14 Vdout0_14ck79 = 0 time = 400
.meas tran vdout0_14ck79 FIND v(dout0_14) AT=400.025n

* CHECK dout0_15 Vdout0_15ck79 = 0.9 time = 400
.meas tran vdout0_15ck79 FIND v(dout0_15) AT=400.025n

* CHECK dout0_16 Vdout0_16ck79 = 0 time = 400
.meas tran vdout0_16ck79 FIND v(dout0_16) AT=400.025n

* CHECK dout0_17 Vdout0_17ck79 = 0.9 time = 400
.meas tran vdout0_17ck79 FIND v(dout0_17) AT=400.025n

* CHECK dout0_18 Vdout0_18ck79 = 0.9 time = 400
.meas tran vdout0_18ck79 FIND v(dout0_18) AT=400.025n

* CHECK dout0_19 Vdout0_19ck79 = 0 time = 400
.meas tran vdout0_19ck79 FIND v(dout0_19) AT=400.025n

* CHECK dout0_20 Vdout0_20ck79 = 0.9 time = 400
.meas tran vdout0_20ck79 FIND v(dout0_20) AT=400.025n

* CHECK dout0_21 Vdout0_21ck79 = 0 time = 400
.meas tran vdout0_21ck79 FIND v(dout0_21) AT=400.025n

* CHECK dout0_22 Vdout0_22ck79 = 0 time = 400
.meas tran vdout0_22ck79 FIND v(dout0_22) AT=400.025n

* CHECK dout0_23 Vdout0_23ck79 = 0 time = 400
.meas tran vdout0_23ck79 FIND v(dout0_23) AT=400.025n

* CHECK dout0_24 Vdout0_24ck79 = 0.9 time = 400
.meas tran vdout0_24ck79 FIND v(dout0_24) AT=400.025n

* CHECK dout0_25 Vdout0_25ck79 = 0 time = 400
.meas tran vdout0_25ck79 FIND v(dout0_25) AT=400.025n

* CHECK dout0_26 Vdout0_26ck79 = 0.9 time = 400
.meas tran vdout0_26ck79 FIND v(dout0_26) AT=400.025n

* CHECK dout0_27 Vdout0_27ck79 = 0 time = 400
.meas tran vdout0_27ck79 FIND v(dout0_27) AT=400.025n

* CHECK dout0_28 Vdout0_28ck79 = 0 time = 400
.meas tran vdout0_28ck79 FIND v(dout0_28) AT=400.025n

* CHECK dout0_29 Vdout0_29ck79 = 0.9 time = 400
.meas tran vdout0_29ck79 FIND v(dout0_29) AT=400.025n

* CHECK dout0_30 Vdout0_30ck79 = 0.9 time = 400
.meas tran vdout0_30ck79 FIND v(dout0_30) AT=400.025n

* CHECK dout0_31 Vdout0_31ck79 = 0.9 time = 400
.meas tran vdout0_31ck79 FIND v(dout0_31) AT=400.025n

* CHECK dout0_32 Vdout0_32ck79 = 0 time = 400
.meas tran vdout0_32ck79 FIND v(dout0_32) AT=400.025n

* CHECK dout0_33 Vdout0_33ck79 = 0 time = 400
.meas tran vdout0_33ck79 FIND v(dout0_33) AT=400.025n

* CHECK dout0_34 Vdout0_34ck79 = 0 time = 400
.meas tran vdout0_34ck79 FIND v(dout0_34) AT=400.025n

* CHECK dout0_35 Vdout0_35ck79 = 0.9 time = 400
.meas tran vdout0_35ck79 FIND v(dout0_35) AT=400.025n

* CHECK dout0_36 Vdout0_36ck79 = 0.9 time = 400
.meas tran vdout0_36ck79 FIND v(dout0_36) AT=400.025n

* CHECK dout0_37 Vdout0_37ck79 = 0.9 time = 400
.meas tran vdout0_37ck79 FIND v(dout0_37) AT=400.025n

* CHECK dout0_38 Vdout0_38ck79 = 0 time = 400
.meas tran vdout0_38ck79 FIND v(dout0_38) AT=400.025n

* CHECK dout0_39 Vdout0_39ck79 = 0 time = 400
.meas tran vdout0_39ck79 FIND v(dout0_39) AT=400.025n

* CHECK dout0_40 Vdout0_40ck79 = 0 time = 400
.meas tran vdout0_40ck79 FIND v(dout0_40) AT=400.025n

* CHECK dout0_41 Vdout0_41ck79 = 0 time = 400
.meas tran vdout0_41ck79 FIND v(dout0_41) AT=400.025n

* CHECK dout0_42 Vdout0_42ck79 = 0.9 time = 400
.meas tran vdout0_42ck79 FIND v(dout0_42) AT=400.025n

* CHECK dout0_43 Vdout0_43ck79 = 0.9 time = 400
.meas tran vdout0_43ck79 FIND v(dout0_43) AT=400.025n

* CHECK dout0_44 Vdout0_44ck79 = 0 time = 400
.meas tran vdout0_44ck79 FIND v(dout0_44) AT=400.025n

* CHECK dout0_45 Vdout0_45ck79 = 0 time = 400
.meas tran vdout0_45ck79 FIND v(dout0_45) AT=400.025n

* CHECK dout0_46 Vdout0_46ck79 = 0.9 time = 400
.meas tran vdout0_46ck79 FIND v(dout0_46) AT=400.025n

* CHECK dout0_47 Vdout0_47ck79 = 0.9 time = 400
.meas tran vdout0_47ck79 FIND v(dout0_47) AT=400.025n

* CHECK dout0_48 Vdout0_48ck79 = 0.9 time = 400
.meas tran vdout0_48ck79 FIND v(dout0_48) AT=400.025n

* CHECK dout0_49 Vdout0_49ck79 = 0.9 time = 400
.meas tran vdout0_49ck79 FIND v(dout0_49) AT=400.025n

* CHECK dout0_50 Vdout0_50ck79 = 0.9 time = 400
.meas tran vdout0_50ck79 FIND v(dout0_50) AT=400.025n

* CHECK dout0_51 Vdout0_51ck79 = 0 time = 400
.meas tran vdout0_51ck79 FIND v(dout0_51) AT=400.025n

* CHECK dout0_52 Vdout0_52ck79 = 0 time = 400
.meas tran vdout0_52ck79 FIND v(dout0_52) AT=400.025n

* CHECK dout0_53 Vdout0_53ck79 = 0 time = 400
.meas tran vdout0_53ck79 FIND v(dout0_53) AT=400.025n

* CHECK dout0_54 Vdout0_54ck79 = 0.9 time = 400
.meas tran vdout0_54ck79 FIND v(dout0_54) AT=400.025n

* CHECK dout0_55 Vdout0_55ck79 = 0 time = 400
.meas tran vdout0_55ck79 FIND v(dout0_55) AT=400.025n

* CHECK dout0_56 Vdout0_56ck79 = 0.9 time = 400
.meas tran vdout0_56ck79 FIND v(dout0_56) AT=400.025n

* CHECK dout0_57 Vdout0_57ck79 = 0.9 time = 400
.meas tran vdout0_57ck79 FIND v(dout0_57) AT=400.025n

* CHECK dout0_58 Vdout0_58ck79 = 0.9 time = 400
.meas tran vdout0_58ck79 FIND v(dout0_58) AT=400.025n

* CHECK dout0_59 Vdout0_59ck79 = 0 time = 400
.meas tran vdout0_59ck79 FIND v(dout0_59) AT=400.025n

* CHECK dout0_60 Vdout0_60ck79 = 0 time = 400
.meas tran vdout0_60ck79 FIND v(dout0_60) AT=400.025n

* CHECK dout0_61 Vdout0_61ck79 = 0 time = 400
.meas tran vdout0_61ck79 FIND v(dout0_61) AT=400.025n

* CHECK dout0_62 Vdout0_62ck79 = 0.9 time = 400
.meas tran vdout0_62ck79 FIND v(dout0_62) AT=400.025n

* CHECK dout0_63 Vdout0_63ck79 = 0.9 time = 400
.meas tran vdout0_63ck79 FIND v(dout0_63) AT=400.025n

* CHECK dout0_0 Vdout0_0ck80 = 0 time = 405
.meas tran vdout0_0ck80 FIND v(dout0_0) AT=405.025n

* CHECK dout0_1 Vdout0_1ck80 = 0.9 time = 405
.meas tran vdout0_1ck80 FIND v(dout0_1) AT=405.025n

* CHECK dout0_2 Vdout0_2ck80 = 0.9 time = 405
.meas tran vdout0_2ck80 FIND v(dout0_2) AT=405.025n

* CHECK dout0_3 Vdout0_3ck80 = 0.9 time = 405
.meas tran vdout0_3ck80 FIND v(dout0_3) AT=405.025n

* CHECK dout0_4 Vdout0_4ck80 = 0 time = 405
.meas tran vdout0_4ck80 FIND v(dout0_4) AT=405.025n

* CHECK dout0_5 Vdout0_5ck80 = 0.9 time = 405
.meas tran vdout0_5ck80 FIND v(dout0_5) AT=405.025n

* CHECK dout0_6 Vdout0_6ck80 = 0 time = 405
.meas tran vdout0_6ck80 FIND v(dout0_6) AT=405.025n

* CHECK dout0_7 Vdout0_7ck80 = 0 time = 405
.meas tran vdout0_7ck80 FIND v(dout0_7) AT=405.025n

* CHECK dout0_8 Vdout0_8ck80 = 0.9 time = 405
.meas tran vdout0_8ck80 FIND v(dout0_8) AT=405.025n

* CHECK dout0_9 Vdout0_9ck80 = 0.9 time = 405
.meas tran vdout0_9ck80 FIND v(dout0_9) AT=405.025n

* CHECK dout0_10 Vdout0_10ck80 = 0.9 time = 405
.meas tran vdout0_10ck80 FIND v(dout0_10) AT=405.025n

* CHECK dout0_11 Vdout0_11ck80 = 0.9 time = 405
.meas tran vdout0_11ck80 FIND v(dout0_11) AT=405.025n

* CHECK dout0_12 Vdout0_12ck80 = 0.9 time = 405
.meas tran vdout0_12ck80 FIND v(dout0_12) AT=405.025n

* CHECK dout0_13 Vdout0_13ck80 = 0.9 time = 405
.meas tran vdout0_13ck80 FIND v(dout0_13) AT=405.025n

* CHECK dout0_14 Vdout0_14ck80 = 0 time = 405
.meas tran vdout0_14ck80 FIND v(dout0_14) AT=405.025n

* CHECK dout0_15 Vdout0_15ck80 = 0 time = 405
.meas tran vdout0_15ck80 FIND v(dout0_15) AT=405.025n

* CHECK dout0_16 Vdout0_16ck80 = 0.9 time = 405
.meas tran vdout0_16ck80 FIND v(dout0_16) AT=405.025n

* CHECK dout0_17 Vdout0_17ck80 = 0.9 time = 405
.meas tran vdout0_17ck80 FIND v(dout0_17) AT=405.025n

* CHECK dout0_18 Vdout0_18ck80 = 0 time = 405
.meas tran vdout0_18ck80 FIND v(dout0_18) AT=405.025n

* CHECK dout0_19 Vdout0_19ck80 = 0 time = 405
.meas tran vdout0_19ck80 FIND v(dout0_19) AT=405.025n

* CHECK dout0_20 Vdout0_20ck80 = 0.9 time = 405
.meas tran vdout0_20ck80 FIND v(dout0_20) AT=405.025n

* CHECK dout0_21 Vdout0_21ck80 = 0 time = 405
.meas tran vdout0_21ck80 FIND v(dout0_21) AT=405.025n

* CHECK dout0_22 Vdout0_22ck80 = 0 time = 405
.meas tran vdout0_22ck80 FIND v(dout0_22) AT=405.025n

* CHECK dout0_23 Vdout0_23ck80 = 0 time = 405
.meas tran vdout0_23ck80 FIND v(dout0_23) AT=405.025n

* CHECK dout0_24 Vdout0_24ck80 = 0 time = 405
.meas tran vdout0_24ck80 FIND v(dout0_24) AT=405.025n

* CHECK dout0_25 Vdout0_25ck80 = 0.9 time = 405
.meas tran vdout0_25ck80 FIND v(dout0_25) AT=405.025n

* CHECK dout0_26 Vdout0_26ck80 = 0 time = 405
.meas tran vdout0_26ck80 FIND v(dout0_26) AT=405.025n

* CHECK dout0_27 Vdout0_27ck80 = 0.9 time = 405
.meas tran vdout0_27ck80 FIND v(dout0_27) AT=405.025n

* CHECK dout0_28 Vdout0_28ck80 = 0 time = 405
.meas tran vdout0_28ck80 FIND v(dout0_28) AT=405.025n

* CHECK dout0_29 Vdout0_29ck80 = 0.9 time = 405
.meas tran vdout0_29ck80 FIND v(dout0_29) AT=405.025n

* CHECK dout0_30 Vdout0_30ck80 = 0.9 time = 405
.meas tran vdout0_30ck80 FIND v(dout0_30) AT=405.025n

* CHECK dout0_31 Vdout0_31ck80 = 0 time = 405
.meas tran vdout0_31ck80 FIND v(dout0_31) AT=405.025n

* CHECK dout0_32 Vdout0_32ck80 = 0.9 time = 405
.meas tran vdout0_32ck80 FIND v(dout0_32) AT=405.025n

* CHECK dout0_33 Vdout0_33ck80 = 0.9 time = 405
.meas tran vdout0_33ck80 FIND v(dout0_33) AT=405.025n

* CHECK dout0_34 Vdout0_34ck80 = 0.9 time = 405
.meas tran vdout0_34ck80 FIND v(dout0_34) AT=405.025n

* CHECK dout0_35 Vdout0_35ck80 = 0 time = 405
.meas tran vdout0_35ck80 FIND v(dout0_35) AT=405.025n

* CHECK dout0_36 Vdout0_36ck80 = 0 time = 405
.meas tran vdout0_36ck80 FIND v(dout0_36) AT=405.025n

* CHECK dout0_37 Vdout0_37ck80 = 0 time = 405
.meas tran vdout0_37ck80 FIND v(dout0_37) AT=405.025n

* CHECK dout0_38 Vdout0_38ck80 = 0.9 time = 405
.meas tran vdout0_38ck80 FIND v(dout0_38) AT=405.025n

* CHECK dout0_39 Vdout0_39ck80 = 0 time = 405
.meas tran vdout0_39ck80 FIND v(dout0_39) AT=405.025n

* CHECK dout0_40 Vdout0_40ck80 = 0.9 time = 405
.meas tran vdout0_40ck80 FIND v(dout0_40) AT=405.025n

* CHECK dout0_41 Vdout0_41ck80 = 0.9 time = 405
.meas tran vdout0_41ck80 FIND v(dout0_41) AT=405.025n

* CHECK dout0_42 Vdout0_42ck80 = 0.9 time = 405
.meas tran vdout0_42ck80 FIND v(dout0_42) AT=405.025n

* CHECK dout0_43 Vdout0_43ck80 = 0 time = 405
.meas tran vdout0_43ck80 FIND v(dout0_43) AT=405.025n

* CHECK dout0_44 Vdout0_44ck80 = 0.9 time = 405
.meas tran vdout0_44ck80 FIND v(dout0_44) AT=405.025n

* CHECK dout0_45 Vdout0_45ck80 = 0 time = 405
.meas tran vdout0_45ck80 FIND v(dout0_45) AT=405.025n

* CHECK dout0_46 Vdout0_46ck80 = 0.9 time = 405
.meas tran vdout0_46ck80 FIND v(dout0_46) AT=405.025n

* CHECK dout0_47 Vdout0_47ck80 = 0 time = 405
.meas tran vdout0_47ck80 FIND v(dout0_47) AT=405.025n

* CHECK dout0_48 Vdout0_48ck80 = 0 time = 405
.meas tran vdout0_48ck80 FIND v(dout0_48) AT=405.025n

* CHECK dout0_49 Vdout0_49ck80 = 0.9 time = 405
.meas tran vdout0_49ck80 FIND v(dout0_49) AT=405.025n

* CHECK dout0_50 Vdout0_50ck80 = 0.9 time = 405
.meas tran vdout0_50ck80 FIND v(dout0_50) AT=405.025n

* CHECK dout0_51 Vdout0_51ck80 = 0 time = 405
.meas tran vdout0_51ck80 FIND v(dout0_51) AT=405.025n

* CHECK dout0_52 Vdout0_52ck80 = 0.9 time = 405
.meas tran vdout0_52ck80 FIND v(dout0_52) AT=405.025n

* CHECK dout0_53 Vdout0_53ck80 = 0.9 time = 405
.meas tran vdout0_53ck80 FIND v(dout0_53) AT=405.025n

* CHECK dout0_54 Vdout0_54ck80 = 0 time = 405
.meas tran vdout0_54ck80 FIND v(dout0_54) AT=405.025n

* CHECK dout0_55 Vdout0_55ck80 = 0 time = 405
.meas tran vdout0_55ck80 FIND v(dout0_55) AT=405.025n

* CHECK dout0_56 Vdout0_56ck80 = 0.9 time = 405
.meas tran vdout0_56ck80 FIND v(dout0_56) AT=405.025n

* CHECK dout0_57 Vdout0_57ck80 = 0.9 time = 405
.meas tran vdout0_57ck80 FIND v(dout0_57) AT=405.025n

* CHECK dout0_58 Vdout0_58ck80 = 0.9 time = 405
.meas tran vdout0_58ck80 FIND v(dout0_58) AT=405.025n

* CHECK dout0_59 Vdout0_59ck80 = 0.9 time = 405
.meas tran vdout0_59ck80 FIND v(dout0_59) AT=405.025n

* CHECK dout0_60 Vdout0_60ck80 = 0 time = 405
.meas tran vdout0_60ck80 FIND v(dout0_60) AT=405.025n

* CHECK dout0_61 Vdout0_61ck80 = 0.9 time = 405
.meas tran vdout0_61ck80 FIND v(dout0_61) AT=405.025n

* CHECK dout0_62 Vdout0_62ck80 = 0.9 time = 405
.meas tran vdout0_62ck80 FIND v(dout0_62) AT=405.025n

* CHECK dout0_63 Vdout0_63ck80 = 0.9 time = 405
.meas tran vdout0_63ck80 FIND v(dout0_63) AT=405.025n

* CHECK dout0_0 Vdout0_0ck82 = 0 time = 415
.meas tran vdout0_0ck82 FIND v(dout0_0) AT=415.025n

* CHECK dout0_1 Vdout0_1ck82 = 0.9 time = 415
.meas tran vdout0_1ck82 FIND v(dout0_1) AT=415.025n

* CHECK dout0_2 Vdout0_2ck82 = 0.9 time = 415
.meas tran vdout0_2ck82 FIND v(dout0_2) AT=415.025n

* CHECK dout0_3 Vdout0_3ck82 = 0.9 time = 415
.meas tran vdout0_3ck82 FIND v(dout0_3) AT=415.025n

* CHECK dout0_4 Vdout0_4ck82 = 0 time = 415
.meas tran vdout0_4ck82 FIND v(dout0_4) AT=415.025n

* CHECK dout0_5 Vdout0_5ck82 = 0 time = 415
.meas tran vdout0_5ck82 FIND v(dout0_5) AT=415.025n

* CHECK dout0_6 Vdout0_6ck82 = 0.9 time = 415
.meas tran vdout0_6ck82 FIND v(dout0_6) AT=415.025n

* CHECK dout0_7 Vdout0_7ck82 = 0.9 time = 415
.meas tran vdout0_7ck82 FIND v(dout0_7) AT=415.025n

* CHECK dout0_8 Vdout0_8ck82 = 0 time = 415
.meas tran vdout0_8ck82 FIND v(dout0_8) AT=415.025n

* CHECK dout0_9 Vdout0_9ck82 = 0 time = 415
.meas tran vdout0_9ck82 FIND v(dout0_9) AT=415.025n

* CHECK dout0_10 Vdout0_10ck82 = 0 time = 415
.meas tran vdout0_10ck82 FIND v(dout0_10) AT=415.025n

* CHECK dout0_11 Vdout0_11ck82 = 0 time = 415
.meas tran vdout0_11ck82 FIND v(dout0_11) AT=415.025n

* CHECK dout0_12 Vdout0_12ck82 = 0 time = 415
.meas tran vdout0_12ck82 FIND v(dout0_12) AT=415.025n

* CHECK dout0_13 Vdout0_13ck82 = 0.9 time = 415
.meas tran vdout0_13ck82 FIND v(dout0_13) AT=415.025n

* CHECK dout0_14 Vdout0_14ck82 = 0 time = 415
.meas tran vdout0_14ck82 FIND v(dout0_14) AT=415.025n

* CHECK dout0_15 Vdout0_15ck82 = 0 time = 415
.meas tran vdout0_15ck82 FIND v(dout0_15) AT=415.025n

* CHECK dout0_16 Vdout0_16ck82 = 0 time = 415
.meas tran vdout0_16ck82 FIND v(dout0_16) AT=415.025n

* CHECK dout0_17 Vdout0_17ck82 = 0.9 time = 415
.meas tran vdout0_17ck82 FIND v(dout0_17) AT=415.025n

* CHECK dout0_18 Vdout0_18ck82 = 0.9 time = 415
.meas tran vdout0_18ck82 FIND v(dout0_18) AT=415.025n

* CHECK dout0_19 Vdout0_19ck82 = 0 time = 415
.meas tran vdout0_19ck82 FIND v(dout0_19) AT=415.025n

* CHECK dout0_20 Vdout0_20ck82 = 0 time = 415
.meas tran vdout0_20ck82 FIND v(dout0_20) AT=415.025n

* CHECK dout0_21 Vdout0_21ck82 = 0.9 time = 415
.meas tran vdout0_21ck82 FIND v(dout0_21) AT=415.025n

* CHECK dout0_22 Vdout0_22ck82 = 0.9 time = 415
.meas tran vdout0_22ck82 FIND v(dout0_22) AT=415.025n

* CHECK dout0_23 Vdout0_23ck82 = 0 time = 415
.meas tran vdout0_23ck82 FIND v(dout0_23) AT=415.025n

* CHECK dout0_24 Vdout0_24ck82 = 0 time = 415
.meas tran vdout0_24ck82 FIND v(dout0_24) AT=415.025n

* CHECK dout0_25 Vdout0_25ck82 = 0 time = 415
.meas tran vdout0_25ck82 FIND v(dout0_25) AT=415.025n

* CHECK dout0_26 Vdout0_26ck82 = 0 time = 415
.meas tran vdout0_26ck82 FIND v(dout0_26) AT=415.025n

* CHECK dout0_27 Vdout0_27ck82 = 0.9 time = 415
.meas tran vdout0_27ck82 FIND v(dout0_27) AT=415.025n

* CHECK dout0_28 Vdout0_28ck82 = 0.9 time = 415
.meas tran vdout0_28ck82 FIND v(dout0_28) AT=415.025n

* CHECK dout0_29 Vdout0_29ck82 = 0.9 time = 415
.meas tran vdout0_29ck82 FIND v(dout0_29) AT=415.025n

* CHECK dout0_30 Vdout0_30ck82 = 0.9 time = 415
.meas tran vdout0_30ck82 FIND v(dout0_30) AT=415.025n

* CHECK dout0_31 Vdout0_31ck82 = 0 time = 415
.meas tran vdout0_31ck82 FIND v(dout0_31) AT=415.025n

* CHECK dout0_32 Vdout0_32ck82 = 0 time = 415
.meas tran vdout0_32ck82 FIND v(dout0_32) AT=415.025n

* CHECK dout0_33 Vdout0_33ck82 = 0.9 time = 415
.meas tran vdout0_33ck82 FIND v(dout0_33) AT=415.025n

* CHECK dout0_34 Vdout0_34ck82 = 0 time = 415
.meas tran vdout0_34ck82 FIND v(dout0_34) AT=415.025n

* CHECK dout0_35 Vdout0_35ck82 = 0.9 time = 415
.meas tran vdout0_35ck82 FIND v(dout0_35) AT=415.025n

* CHECK dout0_36 Vdout0_36ck82 = 0.9 time = 415
.meas tran vdout0_36ck82 FIND v(dout0_36) AT=415.025n

* CHECK dout0_37 Vdout0_37ck82 = 0 time = 415
.meas tran vdout0_37ck82 FIND v(dout0_37) AT=415.025n

* CHECK dout0_38 Vdout0_38ck82 = 0.9 time = 415
.meas tran vdout0_38ck82 FIND v(dout0_38) AT=415.025n

* CHECK dout0_39 Vdout0_39ck82 = 0 time = 415
.meas tran vdout0_39ck82 FIND v(dout0_39) AT=415.025n

* CHECK dout0_40 Vdout0_40ck82 = 0 time = 415
.meas tran vdout0_40ck82 FIND v(dout0_40) AT=415.025n

* CHECK dout0_41 Vdout0_41ck82 = 0 time = 415
.meas tran vdout0_41ck82 FIND v(dout0_41) AT=415.025n

* CHECK dout0_42 Vdout0_42ck82 = 0 time = 415
.meas tran vdout0_42ck82 FIND v(dout0_42) AT=415.025n

* CHECK dout0_43 Vdout0_43ck82 = 0 time = 415
.meas tran vdout0_43ck82 FIND v(dout0_43) AT=415.025n

* CHECK dout0_44 Vdout0_44ck82 = 0.9 time = 415
.meas tran vdout0_44ck82 FIND v(dout0_44) AT=415.025n

* CHECK dout0_45 Vdout0_45ck82 = 0.9 time = 415
.meas tran vdout0_45ck82 FIND v(dout0_45) AT=415.025n

* CHECK dout0_46 Vdout0_46ck82 = 0 time = 415
.meas tran vdout0_46ck82 FIND v(dout0_46) AT=415.025n

* CHECK dout0_47 Vdout0_47ck82 = 0 time = 415
.meas tran vdout0_47ck82 FIND v(dout0_47) AT=415.025n

* CHECK dout0_48 Vdout0_48ck82 = 0.9 time = 415
.meas tran vdout0_48ck82 FIND v(dout0_48) AT=415.025n

* CHECK dout0_49 Vdout0_49ck82 = 0.9 time = 415
.meas tran vdout0_49ck82 FIND v(dout0_49) AT=415.025n

* CHECK dout0_50 Vdout0_50ck82 = 0 time = 415
.meas tran vdout0_50ck82 FIND v(dout0_50) AT=415.025n

* CHECK dout0_51 Vdout0_51ck82 = 0.9 time = 415
.meas tran vdout0_51ck82 FIND v(dout0_51) AT=415.025n

* CHECK dout0_52 Vdout0_52ck82 = 0.9 time = 415
.meas tran vdout0_52ck82 FIND v(dout0_52) AT=415.025n

* CHECK dout0_53 Vdout0_53ck82 = 0.9 time = 415
.meas tran vdout0_53ck82 FIND v(dout0_53) AT=415.025n

* CHECK dout0_54 Vdout0_54ck82 = 0.9 time = 415
.meas tran vdout0_54ck82 FIND v(dout0_54) AT=415.025n

* CHECK dout0_55 Vdout0_55ck82 = 0 time = 415
.meas tran vdout0_55ck82 FIND v(dout0_55) AT=415.025n

* CHECK dout0_56 Vdout0_56ck82 = 0 time = 415
.meas tran vdout0_56ck82 FIND v(dout0_56) AT=415.025n

* CHECK dout0_57 Vdout0_57ck82 = 0.9 time = 415
.meas tran vdout0_57ck82 FIND v(dout0_57) AT=415.025n

* CHECK dout0_58 Vdout0_58ck82 = 0.9 time = 415
.meas tran vdout0_58ck82 FIND v(dout0_58) AT=415.025n

* CHECK dout0_59 Vdout0_59ck82 = 0.9 time = 415
.meas tran vdout0_59ck82 FIND v(dout0_59) AT=415.025n

* CHECK dout0_60 Vdout0_60ck82 = 0.9 time = 415
.meas tran vdout0_60ck82 FIND v(dout0_60) AT=415.025n

* CHECK dout0_61 Vdout0_61ck82 = 0 time = 415
.meas tran vdout0_61ck82 FIND v(dout0_61) AT=415.025n

* CHECK dout0_62 Vdout0_62ck82 = 0.9 time = 415
.meas tran vdout0_62ck82 FIND v(dout0_62) AT=415.025n

* CHECK dout0_63 Vdout0_63ck82 = 0.9 time = 415
.meas tran vdout0_63ck82 FIND v(dout0_63) AT=415.025n

* CHECK dout0_0 Vdout0_0ck83 = 0 time = 420
.meas tran vdout0_0ck83 FIND v(dout0_0) AT=420.025n

* CHECK dout0_1 Vdout0_1ck83 = 0 time = 420
.meas tran vdout0_1ck83 FIND v(dout0_1) AT=420.025n

* CHECK dout0_2 Vdout0_2ck83 = 0.9 time = 420
.meas tran vdout0_2ck83 FIND v(dout0_2) AT=420.025n

* CHECK dout0_3 Vdout0_3ck83 = 0.9 time = 420
.meas tran vdout0_3ck83 FIND v(dout0_3) AT=420.025n

* CHECK dout0_4 Vdout0_4ck83 = 0 time = 420
.meas tran vdout0_4ck83 FIND v(dout0_4) AT=420.025n

* CHECK dout0_5 Vdout0_5ck83 = 0 time = 420
.meas tran vdout0_5ck83 FIND v(dout0_5) AT=420.025n

* CHECK dout0_6 Vdout0_6ck83 = 0.9 time = 420
.meas tran vdout0_6ck83 FIND v(dout0_6) AT=420.025n

* CHECK dout0_7 Vdout0_7ck83 = 0 time = 420
.meas tran vdout0_7ck83 FIND v(dout0_7) AT=420.025n

* CHECK dout0_8 Vdout0_8ck83 = 0 time = 420
.meas tran vdout0_8ck83 FIND v(dout0_8) AT=420.025n

* CHECK dout0_9 Vdout0_9ck83 = 0.9 time = 420
.meas tran vdout0_9ck83 FIND v(dout0_9) AT=420.025n

* CHECK dout0_10 Vdout0_10ck83 = 0 time = 420
.meas tran vdout0_10ck83 FIND v(dout0_10) AT=420.025n

* CHECK dout0_11 Vdout0_11ck83 = 0 time = 420
.meas tran vdout0_11ck83 FIND v(dout0_11) AT=420.025n

* CHECK dout0_12 Vdout0_12ck83 = 0 time = 420
.meas tran vdout0_12ck83 FIND v(dout0_12) AT=420.025n

* CHECK dout0_13 Vdout0_13ck83 = 0.9 time = 420
.meas tran vdout0_13ck83 FIND v(dout0_13) AT=420.025n

* CHECK dout0_14 Vdout0_14ck83 = 0.9 time = 420
.meas tran vdout0_14ck83 FIND v(dout0_14) AT=420.025n

* CHECK dout0_15 Vdout0_15ck83 = 0 time = 420
.meas tran vdout0_15ck83 FIND v(dout0_15) AT=420.025n

* CHECK dout0_16 Vdout0_16ck83 = 0.9 time = 420
.meas tran vdout0_16ck83 FIND v(dout0_16) AT=420.025n

* CHECK dout0_17 Vdout0_17ck83 = 0.9 time = 420
.meas tran vdout0_17ck83 FIND v(dout0_17) AT=420.025n

* CHECK dout0_18 Vdout0_18ck83 = 0 time = 420
.meas tran vdout0_18ck83 FIND v(dout0_18) AT=420.025n

* CHECK dout0_19 Vdout0_19ck83 = 0.9 time = 420
.meas tran vdout0_19ck83 FIND v(dout0_19) AT=420.025n

* CHECK dout0_20 Vdout0_20ck83 = 0 time = 420
.meas tran vdout0_20ck83 FIND v(dout0_20) AT=420.025n

* CHECK dout0_21 Vdout0_21ck83 = 0 time = 420
.meas tran vdout0_21ck83 FIND v(dout0_21) AT=420.025n

* CHECK dout0_22 Vdout0_22ck83 = 0.9 time = 420
.meas tran vdout0_22ck83 FIND v(dout0_22) AT=420.025n

* CHECK dout0_23 Vdout0_23ck83 = 0.9 time = 420
.meas tran vdout0_23ck83 FIND v(dout0_23) AT=420.025n

* CHECK dout0_24 Vdout0_24ck83 = 0.9 time = 420
.meas tran vdout0_24ck83 FIND v(dout0_24) AT=420.025n

* CHECK dout0_25 Vdout0_25ck83 = 0 time = 420
.meas tran vdout0_25ck83 FIND v(dout0_25) AT=420.025n

* CHECK dout0_26 Vdout0_26ck83 = 0.9 time = 420
.meas tran vdout0_26ck83 FIND v(dout0_26) AT=420.025n

* CHECK dout0_27 Vdout0_27ck83 = 0.9 time = 420
.meas tran vdout0_27ck83 FIND v(dout0_27) AT=420.025n

* CHECK dout0_28 Vdout0_28ck83 = 0 time = 420
.meas tran vdout0_28ck83 FIND v(dout0_28) AT=420.025n

* CHECK dout0_29 Vdout0_29ck83 = 0.9 time = 420
.meas tran vdout0_29ck83 FIND v(dout0_29) AT=420.025n

* CHECK dout0_30 Vdout0_30ck83 = 0.9 time = 420
.meas tran vdout0_30ck83 FIND v(dout0_30) AT=420.025n

* CHECK dout0_31 Vdout0_31ck83 = 0 time = 420
.meas tran vdout0_31ck83 FIND v(dout0_31) AT=420.025n

* CHECK dout0_32 Vdout0_32ck83 = 0 time = 420
.meas tran vdout0_32ck83 FIND v(dout0_32) AT=420.025n

* CHECK dout0_33 Vdout0_33ck83 = 0 time = 420
.meas tran vdout0_33ck83 FIND v(dout0_33) AT=420.025n

* CHECK dout0_34 Vdout0_34ck83 = 0 time = 420
.meas tran vdout0_34ck83 FIND v(dout0_34) AT=420.025n

* CHECK dout0_35 Vdout0_35ck83 = 0 time = 420
.meas tran vdout0_35ck83 FIND v(dout0_35) AT=420.025n

* CHECK dout0_36 Vdout0_36ck83 = 0.9 time = 420
.meas tran vdout0_36ck83 FIND v(dout0_36) AT=420.025n

* CHECK dout0_37 Vdout0_37ck83 = 0 time = 420
.meas tran vdout0_37ck83 FIND v(dout0_37) AT=420.025n

* CHECK dout0_38 Vdout0_38ck83 = 0 time = 420
.meas tran vdout0_38ck83 FIND v(dout0_38) AT=420.025n

* CHECK dout0_39 Vdout0_39ck83 = 0 time = 420
.meas tran vdout0_39ck83 FIND v(dout0_39) AT=420.025n

* CHECK dout0_40 Vdout0_40ck83 = 0.9 time = 420
.meas tran vdout0_40ck83 FIND v(dout0_40) AT=420.025n

* CHECK dout0_41 Vdout0_41ck83 = 0.9 time = 420
.meas tran vdout0_41ck83 FIND v(dout0_41) AT=420.025n

* CHECK dout0_42 Vdout0_42ck83 = 0.9 time = 420
.meas tran vdout0_42ck83 FIND v(dout0_42) AT=420.025n

* CHECK dout0_43 Vdout0_43ck83 = 0.9 time = 420
.meas tran vdout0_43ck83 FIND v(dout0_43) AT=420.025n

* CHECK dout0_44 Vdout0_44ck83 = 0 time = 420
.meas tran vdout0_44ck83 FIND v(dout0_44) AT=420.025n

* CHECK dout0_45 Vdout0_45ck83 = 0.9 time = 420
.meas tran vdout0_45ck83 FIND v(dout0_45) AT=420.025n

* CHECK dout0_46 Vdout0_46ck83 = 0 time = 420
.meas tran vdout0_46ck83 FIND v(dout0_46) AT=420.025n

* CHECK dout0_47 Vdout0_47ck83 = 0.9 time = 420
.meas tran vdout0_47ck83 FIND v(dout0_47) AT=420.025n

* CHECK dout0_48 Vdout0_48ck83 = 0.9 time = 420
.meas tran vdout0_48ck83 FIND v(dout0_48) AT=420.025n

* CHECK dout0_49 Vdout0_49ck83 = 0.9 time = 420
.meas tran vdout0_49ck83 FIND v(dout0_49) AT=420.025n

* CHECK dout0_50 Vdout0_50ck83 = 0 time = 420
.meas tran vdout0_50ck83 FIND v(dout0_50) AT=420.025n

* CHECK dout0_51 Vdout0_51ck83 = 0.9 time = 420
.meas tran vdout0_51ck83 FIND v(dout0_51) AT=420.025n

* CHECK dout0_52 Vdout0_52ck83 = 0.9 time = 420
.meas tran vdout0_52ck83 FIND v(dout0_52) AT=420.025n

* CHECK dout0_53 Vdout0_53ck83 = 0.9 time = 420
.meas tran vdout0_53ck83 FIND v(dout0_53) AT=420.025n

* CHECK dout0_54 Vdout0_54ck83 = 0 time = 420
.meas tran vdout0_54ck83 FIND v(dout0_54) AT=420.025n

* CHECK dout0_55 Vdout0_55ck83 = 0.9 time = 420
.meas tran vdout0_55ck83 FIND v(dout0_55) AT=420.025n

* CHECK dout0_56 Vdout0_56ck83 = 0 time = 420
.meas tran vdout0_56ck83 FIND v(dout0_56) AT=420.025n

* CHECK dout0_57 Vdout0_57ck83 = 0.9 time = 420
.meas tran vdout0_57ck83 FIND v(dout0_57) AT=420.025n

* CHECK dout0_58 Vdout0_58ck83 = 0 time = 420
.meas tran vdout0_58ck83 FIND v(dout0_58) AT=420.025n

* CHECK dout0_59 Vdout0_59ck83 = 0.9 time = 420
.meas tran vdout0_59ck83 FIND v(dout0_59) AT=420.025n

* CHECK dout0_60 Vdout0_60ck83 = 0 time = 420
.meas tran vdout0_60ck83 FIND v(dout0_60) AT=420.025n

* CHECK dout0_61 Vdout0_61ck83 = 0 time = 420
.meas tran vdout0_61ck83 FIND v(dout0_61) AT=420.025n

* CHECK dout0_62 Vdout0_62ck83 = 0.9 time = 420
.meas tran vdout0_62ck83 FIND v(dout0_62) AT=420.025n

* CHECK dout0_63 Vdout0_63ck83 = 0.9 time = 420
.meas tran vdout0_63ck83 FIND v(dout0_63) AT=420.025n

* CHECK dout0_0 Vdout0_0ck85 = 0.9 time = 430
.meas tran vdout0_0ck85 FIND v(dout0_0) AT=430.025n

* CHECK dout0_1 Vdout0_1ck85 = 0.9 time = 430
.meas tran vdout0_1ck85 FIND v(dout0_1) AT=430.025n

* CHECK dout0_2 Vdout0_2ck85 = 0 time = 430
.meas tran vdout0_2ck85 FIND v(dout0_2) AT=430.025n

* CHECK dout0_3 Vdout0_3ck85 = 0 time = 430
.meas tran vdout0_3ck85 FIND v(dout0_3) AT=430.025n

* CHECK dout0_4 Vdout0_4ck85 = 0.9 time = 430
.meas tran vdout0_4ck85 FIND v(dout0_4) AT=430.025n

* CHECK dout0_5 Vdout0_5ck85 = 0.9 time = 430
.meas tran vdout0_5ck85 FIND v(dout0_5) AT=430.025n

* CHECK dout0_6 Vdout0_6ck85 = 0 time = 430
.meas tran vdout0_6ck85 FIND v(dout0_6) AT=430.025n

* CHECK dout0_7 Vdout0_7ck85 = 0.9 time = 430
.meas tran vdout0_7ck85 FIND v(dout0_7) AT=430.025n

* CHECK dout0_8 Vdout0_8ck85 = 0.9 time = 430
.meas tran vdout0_8ck85 FIND v(dout0_8) AT=430.025n

* CHECK dout0_9 Vdout0_9ck85 = 0 time = 430
.meas tran vdout0_9ck85 FIND v(dout0_9) AT=430.025n

* CHECK dout0_10 Vdout0_10ck85 = 0 time = 430
.meas tran vdout0_10ck85 FIND v(dout0_10) AT=430.025n

* CHECK dout0_11 Vdout0_11ck85 = 0 time = 430
.meas tran vdout0_11ck85 FIND v(dout0_11) AT=430.025n

* CHECK dout0_12 Vdout0_12ck85 = 0 time = 430
.meas tran vdout0_12ck85 FIND v(dout0_12) AT=430.025n

* CHECK dout0_13 Vdout0_13ck85 = 0 time = 430
.meas tran vdout0_13ck85 FIND v(dout0_13) AT=430.025n

* CHECK dout0_14 Vdout0_14ck85 = 0 time = 430
.meas tran vdout0_14ck85 FIND v(dout0_14) AT=430.025n

* CHECK dout0_15 Vdout0_15ck85 = 0.9 time = 430
.meas tran vdout0_15ck85 FIND v(dout0_15) AT=430.025n

* CHECK dout0_16 Vdout0_16ck85 = 0.9 time = 430
.meas tran vdout0_16ck85 FIND v(dout0_16) AT=430.025n

* CHECK dout0_17 Vdout0_17ck85 = 0.9 time = 430
.meas tran vdout0_17ck85 FIND v(dout0_17) AT=430.025n

* CHECK dout0_18 Vdout0_18ck85 = 0.9 time = 430
.meas tran vdout0_18ck85 FIND v(dout0_18) AT=430.025n

* CHECK dout0_19 Vdout0_19ck85 = 0 time = 430
.meas tran vdout0_19ck85 FIND v(dout0_19) AT=430.025n

* CHECK dout0_20 Vdout0_20ck85 = 0.9 time = 430
.meas tran vdout0_20ck85 FIND v(dout0_20) AT=430.025n

* CHECK dout0_21 Vdout0_21ck85 = 0.9 time = 430
.meas tran vdout0_21ck85 FIND v(dout0_21) AT=430.025n

* CHECK dout0_22 Vdout0_22ck85 = 0.9 time = 430
.meas tran vdout0_22ck85 FIND v(dout0_22) AT=430.025n

* CHECK dout0_23 Vdout0_23ck85 = 0.9 time = 430
.meas tran vdout0_23ck85 FIND v(dout0_23) AT=430.025n

* CHECK dout0_24 Vdout0_24ck85 = 0 time = 430
.meas tran vdout0_24ck85 FIND v(dout0_24) AT=430.025n

* CHECK dout0_25 Vdout0_25ck85 = 0 time = 430
.meas tran vdout0_25ck85 FIND v(dout0_25) AT=430.025n

* CHECK dout0_26 Vdout0_26ck85 = 0 time = 430
.meas tran vdout0_26ck85 FIND v(dout0_26) AT=430.025n

* CHECK dout0_27 Vdout0_27ck85 = 0 time = 430
.meas tran vdout0_27ck85 FIND v(dout0_27) AT=430.025n

* CHECK dout0_28 Vdout0_28ck85 = 0 time = 430
.meas tran vdout0_28ck85 FIND v(dout0_28) AT=430.025n

* CHECK dout0_29 Vdout0_29ck85 = 0 time = 430
.meas tran vdout0_29ck85 FIND v(dout0_29) AT=430.025n

* CHECK dout0_30 Vdout0_30ck85 = 0.9 time = 430
.meas tran vdout0_30ck85 FIND v(dout0_30) AT=430.025n

* CHECK dout0_31 Vdout0_31ck85 = 0 time = 430
.meas tran vdout0_31ck85 FIND v(dout0_31) AT=430.025n

* CHECK dout0_32 Vdout0_32ck85 = 0 time = 430
.meas tran vdout0_32ck85 FIND v(dout0_32) AT=430.025n

* CHECK dout0_33 Vdout0_33ck85 = 0.9 time = 430
.meas tran vdout0_33ck85 FIND v(dout0_33) AT=430.025n

* CHECK dout0_34 Vdout0_34ck85 = 0.9 time = 430
.meas tran vdout0_34ck85 FIND v(dout0_34) AT=430.025n

* CHECK dout0_35 Vdout0_35ck85 = 0 time = 430
.meas tran vdout0_35ck85 FIND v(dout0_35) AT=430.025n

* CHECK dout0_36 Vdout0_36ck85 = 0 time = 430
.meas tran vdout0_36ck85 FIND v(dout0_36) AT=430.025n

* CHECK dout0_37 Vdout0_37ck85 = 0 time = 430
.meas tran vdout0_37ck85 FIND v(dout0_37) AT=430.025n

* CHECK dout0_38 Vdout0_38ck85 = 0.9 time = 430
.meas tran vdout0_38ck85 FIND v(dout0_38) AT=430.025n

* CHECK dout0_39 Vdout0_39ck85 = 0 time = 430
.meas tran vdout0_39ck85 FIND v(dout0_39) AT=430.025n

* CHECK dout0_40 Vdout0_40ck85 = 0 time = 430
.meas tran vdout0_40ck85 FIND v(dout0_40) AT=430.025n

* CHECK dout0_41 Vdout0_41ck85 = 0 time = 430
.meas tran vdout0_41ck85 FIND v(dout0_41) AT=430.025n

* CHECK dout0_42 Vdout0_42ck85 = 0.9 time = 430
.meas tran vdout0_42ck85 FIND v(dout0_42) AT=430.025n

* CHECK dout0_43 Vdout0_43ck85 = 0.9 time = 430
.meas tran vdout0_43ck85 FIND v(dout0_43) AT=430.025n

* CHECK dout0_44 Vdout0_44ck85 = 0.9 time = 430
.meas tran vdout0_44ck85 FIND v(dout0_44) AT=430.025n

* CHECK dout0_45 Vdout0_45ck85 = 0 time = 430
.meas tran vdout0_45ck85 FIND v(dout0_45) AT=430.025n

* CHECK dout0_46 Vdout0_46ck85 = 0 time = 430
.meas tran vdout0_46ck85 FIND v(dout0_46) AT=430.025n

* CHECK dout0_47 Vdout0_47ck85 = 0 time = 430
.meas tran vdout0_47ck85 FIND v(dout0_47) AT=430.025n

* CHECK dout0_48 Vdout0_48ck85 = 0.9 time = 430
.meas tran vdout0_48ck85 FIND v(dout0_48) AT=430.025n

* CHECK dout0_49 Vdout0_49ck85 = 0 time = 430
.meas tran vdout0_49ck85 FIND v(dout0_49) AT=430.025n

* CHECK dout0_50 Vdout0_50ck85 = 0 time = 430
.meas tran vdout0_50ck85 FIND v(dout0_50) AT=430.025n

* CHECK dout0_51 Vdout0_51ck85 = 0 time = 430
.meas tran vdout0_51ck85 FIND v(dout0_51) AT=430.025n

* CHECK dout0_52 Vdout0_52ck85 = 0 time = 430
.meas tran vdout0_52ck85 FIND v(dout0_52) AT=430.025n

* CHECK dout0_53 Vdout0_53ck85 = 0 time = 430
.meas tran vdout0_53ck85 FIND v(dout0_53) AT=430.025n

* CHECK dout0_54 Vdout0_54ck85 = 0 time = 430
.meas tran vdout0_54ck85 FIND v(dout0_54) AT=430.025n

* CHECK dout0_55 Vdout0_55ck85 = 0.9 time = 430
.meas tran vdout0_55ck85 FIND v(dout0_55) AT=430.025n

* CHECK dout0_56 Vdout0_56ck85 = 0 time = 430
.meas tran vdout0_56ck85 FIND v(dout0_56) AT=430.025n

* CHECK dout0_57 Vdout0_57ck85 = 0.9 time = 430
.meas tran vdout0_57ck85 FIND v(dout0_57) AT=430.025n

* CHECK dout0_58 Vdout0_58ck85 = 0 time = 430
.meas tran vdout0_58ck85 FIND v(dout0_58) AT=430.025n

* CHECK dout0_59 Vdout0_59ck85 = 0.9 time = 430
.meas tran vdout0_59ck85 FIND v(dout0_59) AT=430.025n

* CHECK dout0_60 Vdout0_60ck85 = 0 time = 430
.meas tran vdout0_60ck85 FIND v(dout0_60) AT=430.025n

* CHECK dout0_61 Vdout0_61ck85 = 0.9 time = 430
.meas tran vdout0_61ck85 FIND v(dout0_61) AT=430.025n

* CHECK dout0_62 Vdout0_62ck85 = 0.9 time = 430
.meas tran vdout0_62ck85 FIND v(dout0_62) AT=430.025n

* CHECK dout0_63 Vdout0_63ck85 = 0 time = 430
.meas tran vdout0_63ck85 FIND v(dout0_63) AT=430.025n

* CHECK dout0_0 Vdout0_0ck86 = 0.9 time = 435
.meas tran vdout0_0ck86 FIND v(dout0_0) AT=435.025n

* CHECK dout0_1 Vdout0_1ck86 = 0.9 time = 435
.meas tran vdout0_1ck86 FIND v(dout0_1) AT=435.025n

* CHECK dout0_2 Vdout0_2ck86 = 0 time = 435
.meas tran vdout0_2ck86 FIND v(dout0_2) AT=435.025n

* CHECK dout0_3 Vdout0_3ck86 = 0 time = 435
.meas tran vdout0_3ck86 FIND v(dout0_3) AT=435.025n

* CHECK dout0_4 Vdout0_4ck86 = 0.9 time = 435
.meas tran vdout0_4ck86 FIND v(dout0_4) AT=435.025n

* CHECK dout0_5 Vdout0_5ck86 = 0.9 time = 435
.meas tran vdout0_5ck86 FIND v(dout0_5) AT=435.025n

* CHECK dout0_6 Vdout0_6ck86 = 0 time = 435
.meas tran vdout0_6ck86 FIND v(dout0_6) AT=435.025n

* CHECK dout0_7 Vdout0_7ck86 = 0.9 time = 435
.meas tran vdout0_7ck86 FIND v(dout0_7) AT=435.025n

* CHECK dout0_8 Vdout0_8ck86 = 0.9 time = 435
.meas tran vdout0_8ck86 FIND v(dout0_8) AT=435.025n

* CHECK dout0_9 Vdout0_9ck86 = 0 time = 435
.meas tran vdout0_9ck86 FIND v(dout0_9) AT=435.025n

* CHECK dout0_10 Vdout0_10ck86 = 0 time = 435
.meas tran vdout0_10ck86 FIND v(dout0_10) AT=435.025n

* CHECK dout0_11 Vdout0_11ck86 = 0 time = 435
.meas tran vdout0_11ck86 FIND v(dout0_11) AT=435.025n

* CHECK dout0_12 Vdout0_12ck86 = 0 time = 435
.meas tran vdout0_12ck86 FIND v(dout0_12) AT=435.025n

* CHECK dout0_13 Vdout0_13ck86 = 0 time = 435
.meas tran vdout0_13ck86 FIND v(dout0_13) AT=435.025n

* CHECK dout0_14 Vdout0_14ck86 = 0 time = 435
.meas tran vdout0_14ck86 FIND v(dout0_14) AT=435.025n

* CHECK dout0_15 Vdout0_15ck86 = 0.9 time = 435
.meas tran vdout0_15ck86 FIND v(dout0_15) AT=435.025n

* CHECK dout0_16 Vdout0_16ck86 = 0.9 time = 435
.meas tran vdout0_16ck86 FIND v(dout0_16) AT=435.025n

* CHECK dout0_17 Vdout0_17ck86 = 0.9 time = 435
.meas tran vdout0_17ck86 FIND v(dout0_17) AT=435.025n

* CHECK dout0_18 Vdout0_18ck86 = 0.9 time = 435
.meas tran vdout0_18ck86 FIND v(dout0_18) AT=435.025n

* CHECK dout0_19 Vdout0_19ck86 = 0 time = 435
.meas tran vdout0_19ck86 FIND v(dout0_19) AT=435.025n

* CHECK dout0_20 Vdout0_20ck86 = 0.9 time = 435
.meas tran vdout0_20ck86 FIND v(dout0_20) AT=435.025n

* CHECK dout0_21 Vdout0_21ck86 = 0.9 time = 435
.meas tran vdout0_21ck86 FIND v(dout0_21) AT=435.025n

* CHECK dout0_22 Vdout0_22ck86 = 0.9 time = 435
.meas tran vdout0_22ck86 FIND v(dout0_22) AT=435.025n

* CHECK dout0_23 Vdout0_23ck86 = 0.9 time = 435
.meas tran vdout0_23ck86 FIND v(dout0_23) AT=435.025n

* CHECK dout0_24 Vdout0_24ck86 = 0 time = 435
.meas tran vdout0_24ck86 FIND v(dout0_24) AT=435.025n

* CHECK dout0_25 Vdout0_25ck86 = 0 time = 435
.meas tran vdout0_25ck86 FIND v(dout0_25) AT=435.025n

* CHECK dout0_26 Vdout0_26ck86 = 0 time = 435
.meas tran vdout0_26ck86 FIND v(dout0_26) AT=435.025n

* CHECK dout0_27 Vdout0_27ck86 = 0 time = 435
.meas tran vdout0_27ck86 FIND v(dout0_27) AT=435.025n

* CHECK dout0_28 Vdout0_28ck86 = 0 time = 435
.meas tran vdout0_28ck86 FIND v(dout0_28) AT=435.025n

* CHECK dout0_29 Vdout0_29ck86 = 0 time = 435
.meas tran vdout0_29ck86 FIND v(dout0_29) AT=435.025n

* CHECK dout0_30 Vdout0_30ck86 = 0.9 time = 435
.meas tran vdout0_30ck86 FIND v(dout0_30) AT=435.025n

* CHECK dout0_31 Vdout0_31ck86 = 0 time = 435
.meas tran vdout0_31ck86 FIND v(dout0_31) AT=435.025n

* CHECK dout0_32 Vdout0_32ck86 = 0 time = 435
.meas tran vdout0_32ck86 FIND v(dout0_32) AT=435.025n

* CHECK dout0_33 Vdout0_33ck86 = 0.9 time = 435
.meas tran vdout0_33ck86 FIND v(dout0_33) AT=435.025n

* CHECK dout0_34 Vdout0_34ck86 = 0.9 time = 435
.meas tran vdout0_34ck86 FIND v(dout0_34) AT=435.025n

* CHECK dout0_35 Vdout0_35ck86 = 0 time = 435
.meas tran vdout0_35ck86 FIND v(dout0_35) AT=435.025n

* CHECK dout0_36 Vdout0_36ck86 = 0 time = 435
.meas tran vdout0_36ck86 FIND v(dout0_36) AT=435.025n

* CHECK dout0_37 Vdout0_37ck86 = 0 time = 435
.meas tran vdout0_37ck86 FIND v(dout0_37) AT=435.025n

* CHECK dout0_38 Vdout0_38ck86 = 0.9 time = 435
.meas tran vdout0_38ck86 FIND v(dout0_38) AT=435.025n

* CHECK dout0_39 Vdout0_39ck86 = 0 time = 435
.meas tran vdout0_39ck86 FIND v(dout0_39) AT=435.025n

* CHECK dout0_40 Vdout0_40ck86 = 0 time = 435
.meas tran vdout0_40ck86 FIND v(dout0_40) AT=435.025n

* CHECK dout0_41 Vdout0_41ck86 = 0 time = 435
.meas tran vdout0_41ck86 FIND v(dout0_41) AT=435.025n

* CHECK dout0_42 Vdout0_42ck86 = 0.9 time = 435
.meas tran vdout0_42ck86 FIND v(dout0_42) AT=435.025n

* CHECK dout0_43 Vdout0_43ck86 = 0.9 time = 435
.meas tran vdout0_43ck86 FIND v(dout0_43) AT=435.025n

* CHECK dout0_44 Vdout0_44ck86 = 0.9 time = 435
.meas tran vdout0_44ck86 FIND v(dout0_44) AT=435.025n

* CHECK dout0_45 Vdout0_45ck86 = 0 time = 435
.meas tran vdout0_45ck86 FIND v(dout0_45) AT=435.025n

* CHECK dout0_46 Vdout0_46ck86 = 0 time = 435
.meas tran vdout0_46ck86 FIND v(dout0_46) AT=435.025n

* CHECK dout0_47 Vdout0_47ck86 = 0 time = 435
.meas tran vdout0_47ck86 FIND v(dout0_47) AT=435.025n

* CHECK dout0_48 Vdout0_48ck86 = 0.9 time = 435
.meas tran vdout0_48ck86 FIND v(dout0_48) AT=435.025n

* CHECK dout0_49 Vdout0_49ck86 = 0 time = 435
.meas tran vdout0_49ck86 FIND v(dout0_49) AT=435.025n

* CHECK dout0_50 Vdout0_50ck86 = 0 time = 435
.meas tran vdout0_50ck86 FIND v(dout0_50) AT=435.025n

* CHECK dout0_51 Vdout0_51ck86 = 0 time = 435
.meas tran vdout0_51ck86 FIND v(dout0_51) AT=435.025n

* CHECK dout0_52 Vdout0_52ck86 = 0 time = 435
.meas tran vdout0_52ck86 FIND v(dout0_52) AT=435.025n

* CHECK dout0_53 Vdout0_53ck86 = 0 time = 435
.meas tran vdout0_53ck86 FIND v(dout0_53) AT=435.025n

* CHECK dout0_54 Vdout0_54ck86 = 0 time = 435
.meas tran vdout0_54ck86 FIND v(dout0_54) AT=435.025n

* CHECK dout0_55 Vdout0_55ck86 = 0.9 time = 435
.meas tran vdout0_55ck86 FIND v(dout0_55) AT=435.025n

* CHECK dout0_56 Vdout0_56ck86 = 0 time = 435
.meas tran vdout0_56ck86 FIND v(dout0_56) AT=435.025n

* CHECK dout0_57 Vdout0_57ck86 = 0.9 time = 435
.meas tran vdout0_57ck86 FIND v(dout0_57) AT=435.025n

* CHECK dout0_58 Vdout0_58ck86 = 0 time = 435
.meas tran vdout0_58ck86 FIND v(dout0_58) AT=435.025n

* CHECK dout0_59 Vdout0_59ck86 = 0.9 time = 435
.meas tran vdout0_59ck86 FIND v(dout0_59) AT=435.025n

* CHECK dout0_60 Vdout0_60ck86 = 0 time = 435
.meas tran vdout0_60ck86 FIND v(dout0_60) AT=435.025n

* CHECK dout0_61 Vdout0_61ck86 = 0.9 time = 435
.meas tran vdout0_61ck86 FIND v(dout0_61) AT=435.025n

* CHECK dout0_62 Vdout0_62ck86 = 0.9 time = 435
.meas tran vdout0_62ck86 FIND v(dout0_62) AT=435.025n

* CHECK dout0_63 Vdout0_63ck86 = 0 time = 435
.meas tran vdout0_63ck86 FIND v(dout0_63) AT=435.025n

* CHECK dout0_0 Vdout0_0ck87 = 0 time = 440
.meas tran vdout0_0ck87 FIND v(dout0_0) AT=440.025n

* CHECK dout0_1 Vdout0_1ck87 = 0.9 time = 440
.meas tran vdout0_1ck87 FIND v(dout0_1) AT=440.025n

* CHECK dout0_2 Vdout0_2ck87 = 0 time = 440
.meas tran vdout0_2ck87 FIND v(dout0_2) AT=440.025n

* CHECK dout0_3 Vdout0_3ck87 = 0.9 time = 440
.meas tran vdout0_3ck87 FIND v(dout0_3) AT=440.025n

* CHECK dout0_4 Vdout0_4ck87 = 0.9 time = 440
.meas tran vdout0_4ck87 FIND v(dout0_4) AT=440.025n

* CHECK dout0_5 Vdout0_5ck87 = 0.9 time = 440
.meas tran vdout0_5ck87 FIND v(dout0_5) AT=440.025n

* CHECK dout0_6 Vdout0_6ck87 = 0.9 time = 440
.meas tran vdout0_6ck87 FIND v(dout0_6) AT=440.025n

* CHECK dout0_7 Vdout0_7ck87 = 0 time = 440
.meas tran vdout0_7ck87 FIND v(dout0_7) AT=440.025n

* CHECK dout0_8 Vdout0_8ck87 = 0 time = 440
.meas tran vdout0_8ck87 FIND v(dout0_8) AT=440.025n

* CHECK dout0_9 Vdout0_9ck87 = 0 time = 440
.meas tran vdout0_9ck87 FIND v(dout0_9) AT=440.025n

* CHECK dout0_10 Vdout0_10ck87 = 0 time = 440
.meas tran vdout0_10ck87 FIND v(dout0_10) AT=440.025n

* CHECK dout0_11 Vdout0_11ck87 = 0 time = 440
.meas tran vdout0_11ck87 FIND v(dout0_11) AT=440.025n

* CHECK dout0_12 Vdout0_12ck87 = 0 time = 440
.meas tran vdout0_12ck87 FIND v(dout0_12) AT=440.025n

* CHECK dout0_13 Vdout0_13ck87 = 0 time = 440
.meas tran vdout0_13ck87 FIND v(dout0_13) AT=440.025n

* CHECK dout0_14 Vdout0_14ck87 = 0 time = 440
.meas tran vdout0_14ck87 FIND v(dout0_14) AT=440.025n

* CHECK dout0_15 Vdout0_15ck87 = 0.9 time = 440
.meas tran vdout0_15ck87 FIND v(dout0_15) AT=440.025n

* CHECK dout0_16 Vdout0_16ck87 = 0.9 time = 440
.meas tran vdout0_16ck87 FIND v(dout0_16) AT=440.025n

* CHECK dout0_17 Vdout0_17ck87 = 0 time = 440
.meas tran vdout0_17ck87 FIND v(dout0_17) AT=440.025n

* CHECK dout0_18 Vdout0_18ck87 = 0.9 time = 440
.meas tran vdout0_18ck87 FIND v(dout0_18) AT=440.025n

* CHECK dout0_19 Vdout0_19ck87 = 0 time = 440
.meas tran vdout0_19ck87 FIND v(dout0_19) AT=440.025n

* CHECK dout0_20 Vdout0_20ck87 = 0.9 time = 440
.meas tran vdout0_20ck87 FIND v(dout0_20) AT=440.025n

* CHECK dout0_21 Vdout0_21ck87 = 0.9 time = 440
.meas tran vdout0_21ck87 FIND v(dout0_21) AT=440.025n

* CHECK dout0_22 Vdout0_22ck87 = 0 time = 440
.meas tran vdout0_22ck87 FIND v(dout0_22) AT=440.025n

* CHECK dout0_23 Vdout0_23ck87 = 0 time = 440
.meas tran vdout0_23ck87 FIND v(dout0_23) AT=440.025n

* CHECK dout0_24 Vdout0_24ck87 = 0.9 time = 440
.meas tran vdout0_24ck87 FIND v(dout0_24) AT=440.025n

* CHECK dout0_25 Vdout0_25ck87 = 0.9 time = 440
.meas tran vdout0_25ck87 FIND v(dout0_25) AT=440.025n

* CHECK dout0_26 Vdout0_26ck87 = 0 time = 440
.meas tran vdout0_26ck87 FIND v(dout0_26) AT=440.025n

* CHECK dout0_27 Vdout0_27ck87 = 0 time = 440
.meas tran vdout0_27ck87 FIND v(dout0_27) AT=440.025n

* CHECK dout0_28 Vdout0_28ck87 = 0 time = 440
.meas tran vdout0_28ck87 FIND v(dout0_28) AT=440.025n

* CHECK dout0_29 Vdout0_29ck87 = 0.9 time = 440
.meas tran vdout0_29ck87 FIND v(dout0_29) AT=440.025n

* CHECK dout0_30 Vdout0_30ck87 = 0 time = 440
.meas tran vdout0_30ck87 FIND v(dout0_30) AT=440.025n

* CHECK dout0_31 Vdout0_31ck87 = 0 time = 440
.meas tran vdout0_31ck87 FIND v(dout0_31) AT=440.025n

* CHECK dout0_32 Vdout0_32ck87 = 0 time = 440
.meas tran vdout0_32ck87 FIND v(dout0_32) AT=440.025n

* CHECK dout0_33 Vdout0_33ck87 = 0 time = 440
.meas tran vdout0_33ck87 FIND v(dout0_33) AT=440.025n

* CHECK dout0_34 Vdout0_34ck87 = 0 time = 440
.meas tran vdout0_34ck87 FIND v(dout0_34) AT=440.025n

* CHECK dout0_35 Vdout0_35ck87 = 0 time = 440
.meas tran vdout0_35ck87 FIND v(dout0_35) AT=440.025n

* CHECK dout0_36 Vdout0_36ck87 = 0 time = 440
.meas tran vdout0_36ck87 FIND v(dout0_36) AT=440.025n

* CHECK dout0_37 Vdout0_37ck87 = 0.9 time = 440
.meas tran vdout0_37ck87 FIND v(dout0_37) AT=440.025n

* CHECK dout0_38 Vdout0_38ck87 = 0 time = 440
.meas tran vdout0_38ck87 FIND v(dout0_38) AT=440.025n

* CHECK dout0_39 Vdout0_39ck87 = 0 time = 440
.meas tran vdout0_39ck87 FIND v(dout0_39) AT=440.025n

* CHECK dout0_40 Vdout0_40ck87 = 0 time = 440
.meas tran vdout0_40ck87 FIND v(dout0_40) AT=440.025n

* CHECK dout0_41 Vdout0_41ck87 = 0.9 time = 440
.meas tran vdout0_41ck87 FIND v(dout0_41) AT=440.025n

* CHECK dout0_42 Vdout0_42ck87 = 0 time = 440
.meas tran vdout0_42ck87 FIND v(dout0_42) AT=440.025n

* CHECK dout0_43 Vdout0_43ck87 = 0.9 time = 440
.meas tran vdout0_43ck87 FIND v(dout0_43) AT=440.025n

* CHECK dout0_44 Vdout0_44ck87 = 0 time = 440
.meas tran vdout0_44ck87 FIND v(dout0_44) AT=440.025n

* CHECK dout0_45 Vdout0_45ck87 = 0.9 time = 440
.meas tran vdout0_45ck87 FIND v(dout0_45) AT=440.025n

* CHECK dout0_46 Vdout0_46ck87 = 0 time = 440
.meas tran vdout0_46ck87 FIND v(dout0_46) AT=440.025n

* CHECK dout0_47 Vdout0_47ck87 = 0.9 time = 440
.meas tran vdout0_47ck87 FIND v(dout0_47) AT=440.025n

* CHECK dout0_48 Vdout0_48ck87 = 0.9 time = 440
.meas tran vdout0_48ck87 FIND v(dout0_48) AT=440.025n

* CHECK dout0_49 Vdout0_49ck87 = 0 time = 440
.meas tran vdout0_49ck87 FIND v(dout0_49) AT=440.025n

* CHECK dout0_50 Vdout0_50ck87 = 0 time = 440
.meas tran vdout0_50ck87 FIND v(dout0_50) AT=440.025n

* CHECK dout0_51 Vdout0_51ck87 = 0.9 time = 440
.meas tran vdout0_51ck87 FIND v(dout0_51) AT=440.025n

* CHECK dout0_52 Vdout0_52ck87 = 0 time = 440
.meas tran vdout0_52ck87 FIND v(dout0_52) AT=440.025n

* CHECK dout0_53 Vdout0_53ck87 = 0 time = 440
.meas tran vdout0_53ck87 FIND v(dout0_53) AT=440.025n

* CHECK dout0_54 Vdout0_54ck87 = 0.9 time = 440
.meas tran vdout0_54ck87 FIND v(dout0_54) AT=440.025n

* CHECK dout0_55 Vdout0_55ck87 = 0.9 time = 440
.meas tran vdout0_55ck87 FIND v(dout0_55) AT=440.025n

* CHECK dout0_56 Vdout0_56ck87 = 0.9 time = 440
.meas tran vdout0_56ck87 FIND v(dout0_56) AT=440.025n

* CHECK dout0_57 Vdout0_57ck87 = 0.9 time = 440
.meas tran vdout0_57ck87 FIND v(dout0_57) AT=440.025n

* CHECK dout0_58 Vdout0_58ck87 = 0 time = 440
.meas tran vdout0_58ck87 FIND v(dout0_58) AT=440.025n

* CHECK dout0_59 Vdout0_59ck87 = 0.9 time = 440
.meas tran vdout0_59ck87 FIND v(dout0_59) AT=440.025n

* CHECK dout0_60 Vdout0_60ck87 = 0 time = 440
.meas tran vdout0_60ck87 FIND v(dout0_60) AT=440.025n

* CHECK dout0_61 Vdout0_61ck87 = 0.9 time = 440
.meas tran vdout0_61ck87 FIND v(dout0_61) AT=440.025n

* CHECK dout0_62 Vdout0_62ck87 = 0.9 time = 440
.meas tran vdout0_62ck87 FIND v(dout0_62) AT=440.025n

* CHECK dout0_63 Vdout0_63ck87 = 0.9 time = 440
.meas tran vdout0_63ck87 FIND v(dout0_63) AT=440.025n

* CHECK dout0_0 Vdout0_0ck88 = 0 time = 445
.meas tran vdout0_0ck88 FIND v(dout0_0) AT=445.025n

* CHECK dout0_1 Vdout0_1ck88 = 0.9 time = 445
.meas tran vdout0_1ck88 FIND v(dout0_1) AT=445.025n

* CHECK dout0_2 Vdout0_2ck88 = 0 time = 445
.meas tran vdout0_2ck88 FIND v(dout0_2) AT=445.025n

* CHECK dout0_3 Vdout0_3ck88 = 0.9 time = 445
.meas tran vdout0_3ck88 FIND v(dout0_3) AT=445.025n

* CHECK dout0_4 Vdout0_4ck88 = 0 time = 445
.meas tran vdout0_4ck88 FIND v(dout0_4) AT=445.025n

* CHECK dout0_5 Vdout0_5ck88 = 0 time = 445
.meas tran vdout0_5ck88 FIND v(dout0_5) AT=445.025n

* CHECK dout0_6 Vdout0_6ck88 = 0.9 time = 445
.meas tran vdout0_6ck88 FIND v(dout0_6) AT=445.025n

* CHECK dout0_7 Vdout0_7ck88 = 0 time = 445
.meas tran vdout0_7ck88 FIND v(dout0_7) AT=445.025n

* CHECK dout0_8 Vdout0_8ck88 = 0.9 time = 445
.meas tran vdout0_8ck88 FIND v(dout0_8) AT=445.025n

* CHECK dout0_9 Vdout0_9ck88 = 0.9 time = 445
.meas tran vdout0_9ck88 FIND v(dout0_9) AT=445.025n

* CHECK dout0_10 Vdout0_10ck88 = 0 time = 445
.meas tran vdout0_10ck88 FIND v(dout0_10) AT=445.025n

* CHECK dout0_11 Vdout0_11ck88 = 0.9 time = 445
.meas tran vdout0_11ck88 FIND v(dout0_11) AT=445.025n

* CHECK dout0_12 Vdout0_12ck88 = 0.9 time = 445
.meas tran vdout0_12ck88 FIND v(dout0_12) AT=445.025n

* CHECK dout0_13 Vdout0_13ck88 = 0 time = 445
.meas tran vdout0_13ck88 FIND v(dout0_13) AT=445.025n

* CHECK dout0_14 Vdout0_14ck88 = 0 time = 445
.meas tran vdout0_14ck88 FIND v(dout0_14) AT=445.025n

* CHECK dout0_15 Vdout0_15ck88 = 0 time = 445
.meas tran vdout0_15ck88 FIND v(dout0_15) AT=445.025n

* CHECK dout0_16 Vdout0_16ck88 = 0.9 time = 445
.meas tran vdout0_16ck88 FIND v(dout0_16) AT=445.025n

* CHECK dout0_17 Vdout0_17ck88 = 0.9 time = 445
.meas tran vdout0_17ck88 FIND v(dout0_17) AT=445.025n

* CHECK dout0_18 Vdout0_18ck88 = 0 time = 445
.meas tran vdout0_18ck88 FIND v(dout0_18) AT=445.025n

* CHECK dout0_19 Vdout0_19ck88 = 0 time = 445
.meas tran vdout0_19ck88 FIND v(dout0_19) AT=445.025n

* CHECK dout0_20 Vdout0_20ck88 = 0.9 time = 445
.meas tran vdout0_20ck88 FIND v(dout0_20) AT=445.025n

* CHECK dout0_21 Vdout0_21ck88 = 0.9 time = 445
.meas tran vdout0_21ck88 FIND v(dout0_21) AT=445.025n

* CHECK dout0_22 Vdout0_22ck88 = 0.9 time = 445
.meas tran vdout0_22ck88 FIND v(dout0_22) AT=445.025n

* CHECK dout0_23 Vdout0_23ck88 = 0.9 time = 445
.meas tran vdout0_23ck88 FIND v(dout0_23) AT=445.025n

* CHECK dout0_24 Vdout0_24ck88 = 0 time = 445
.meas tran vdout0_24ck88 FIND v(dout0_24) AT=445.025n

* CHECK dout0_25 Vdout0_25ck88 = 0.9 time = 445
.meas tran vdout0_25ck88 FIND v(dout0_25) AT=445.025n

* CHECK dout0_26 Vdout0_26ck88 = 0.9 time = 445
.meas tran vdout0_26ck88 FIND v(dout0_26) AT=445.025n

* CHECK dout0_27 Vdout0_27ck88 = 0.9 time = 445
.meas tran vdout0_27ck88 FIND v(dout0_27) AT=445.025n

* CHECK dout0_28 Vdout0_28ck88 = 0 time = 445
.meas tran vdout0_28ck88 FIND v(dout0_28) AT=445.025n

* CHECK dout0_29 Vdout0_29ck88 = 0 time = 445
.meas tran vdout0_29ck88 FIND v(dout0_29) AT=445.025n

* CHECK dout0_30 Vdout0_30ck88 = 0 time = 445
.meas tran vdout0_30ck88 FIND v(dout0_30) AT=445.025n

* CHECK dout0_31 Vdout0_31ck88 = 0.9 time = 445
.meas tran vdout0_31ck88 FIND v(dout0_31) AT=445.025n

* CHECK dout0_32 Vdout0_32ck88 = 0.9 time = 445
.meas tran vdout0_32ck88 FIND v(dout0_32) AT=445.025n

* CHECK dout0_33 Vdout0_33ck88 = 0 time = 445
.meas tran vdout0_33ck88 FIND v(dout0_33) AT=445.025n

* CHECK dout0_34 Vdout0_34ck88 = 0.9 time = 445
.meas tran vdout0_34ck88 FIND v(dout0_34) AT=445.025n

* CHECK dout0_35 Vdout0_35ck88 = 0 time = 445
.meas tran vdout0_35ck88 FIND v(dout0_35) AT=445.025n

* CHECK dout0_36 Vdout0_36ck88 = 0 time = 445
.meas tran vdout0_36ck88 FIND v(dout0_36) AT=445.025n

* CHECK dout0_37 Vdout0_37ck88 = 0.9 time = 445
.meas tran vdout0_37ck88 FIND v(dout0_37) AT=445.025n

* CHECK dout0_38 Vdout0_38ck88 = 0.9 time = 445
.meas tran vdout0_38ck88 FIND v(dout0_38) AT=445.025n

* CHECK dout0_39 Vdout0_39ck88 = 0.9 time = 445
.meas tran vdout0_39ck88 FIND v(dout0_39) AT=445.025n

* CHECK dout0_40 Vdout0_40ck88 = 0 time = 445
.meas tran vdout0_40ck88 FIND v(dout0_40) AT=445.025n

* CHECK dout0_41 Vdout0_41ck88 = 0.9 time = 445
.meas tran vdout0_41ck88 FIND v(dout0_41) AT=445.025n

* CHECK dout0_42 Vdout0_42ck88 = 0 time = 445
.meas tran vdout0_42ck88 FIND v(dout0_42) AT=445.025n

* CHECK dout0_43 Vdout0_43ck88 = 0.9 time = 445
.meas tran vdout0_43ck88 FIND v(dout0_43) AT=445.025n

* CHECK dout0_44 Vdout0_44ck88 = 0.9 time = 445
.meas tran vdout0_44ck88 FIND v(dout0_44) AT=445.025n

* CHECK dout0_45 Vdout0_45ck88 = 0.9 time = 445
.meas tran vdout0_45ck88 FIND v(dout0_45) AT=445.025n

* CHECK dout0_46 Vdout0_46ck88 = 0.9 time = 445
.meas tran vdout0_46ck88 FIND v(dout0_46) AT=445.025n

* CHECK dout0_47 Vdout0_47ck88 = 0 time = 445
.meas tran vdout0_47ck88 FIND v(dout0_47) AT=445.025n

* CHECK dout0_48 Vdout0_48ck88 = 0.9 time = 445
.meas tran vdout0_48ck88 FIND v(dout0_48) AT=445.025n

* CHECK dout0_49 Vdout0_49ck88 = 0.9 time = 445
.meas tran vdout0_49ck88 FIND v(dout0_49) AT=445.025n

* CHECK dout0_50 Vdout0_50ck88 = 0 time = 445
.meas tran vdout0_50ck88 FIND v(dout0_50) AT=445.025n

* CHECK dout0_51 Vdout0_51ck88 = 0.9 time = 445
.meas tran vdout0_51ck88 FIND v(dout0_51) AT=445.025n

* CHECK dout0_52 Vdout0_52ck88 = 0 time = 445
.meas tran vdout0_52ck88 FIND v(dout0_52) AT=445.025n

* CHECK dout0_53 Vdout0_53ck88 = 0.9 time = 445
.meas tran vdout0_53ck88 FIND v(dout0_53) AT=445.025n

* CHECK dout0_54 Vdout0_54ck88 = 0.9 time = 445
.meas tran vdout0_54ck88 FIND v(dout0_54) AT=445.025n

* CHECK dout0_55 Vdout0_55ck88 = 0 time = 445
.meas tran vdout0_55ck88 FIND v(dout0_55) AT=445.025n

* CHECK dout0_56 Vdout0_56ck88 = 0 time = 445
.meas tran vdout0_56ck88 FIND v(dout0_56) AT=445.025n

* CHECK dout0_57 Vdout0_57ck88 = 0.9 time = 445
.meas tran vdout0_57ck88 FIND v(dout0_57) AT=445.025n

* CHECK dout0_58 Vdout0_58ck88 = 0.9 time = 445
.meas tran vdout0_58ck88 FIND v(dout0_58) AT=445.025n

* CHECK dout0_59 Vdout0_59ck88 = 0.9 time = 445
.meas tran vdout0_59ck88 FIND v(dout0_59) AT=445.025n

* CHECK dout0_60 Vdout0_60ck88 = 0.9 time = 445
.meas tran vdout0_60ck88 FIND v(dout0_60) AT=445.025n

* CHECK dout0_61 Vdout0_61ck88 = 0 time = 445
.meas tran vdout0_61ck88 FIND v(dout0_61) AT=445.025n

* CHECK dout0_62 Vdout0_62ck88 = 0 time = 445
.meas tran vdout0_62ck88 FIND v(dout0_62) AT=445.025n

* CHECK dout0_63 Vdout0_63ck88 = 0 time = 445
.meas tran vdout0_63ck88 FIND v(dout0_63) AT=445.025n

* CHECK dout0_0 Vdout0_0ck89 = 0 time = 450
.meas tran vdout0_0ck89 FIND v(dout0_0) AT=450.025n

* CHECK dout0_1 Vdout0_1ck89 = 0 time = 450
.meas tran vdout0_1ck89 FIND v(dout0_1) AT=450.025n

* CHECK dout0_2 Vdout0_2ck89 = 0.9 time = 450
.meas tran vdout0_2ck89 FIND v(dout0_2) AT=450.025n

* CHECK dout0_3 Vdout0_3ck89 = 0.9 time = 450
.meas tran vdout0_3ck89 FIND v(dout0_3) AT=450.025n

* CHECK dout0_4 Vdout0_4ck89 = 0.9 time = 450
.meas tran vdout0_4ck89 FIND v(dout0_4) AT=450.025n

* CHECK dout0_5 Vdout0_5ck89 = 0 time = 450
.meas tran vdout0_5ck89 FIND v(dout0_5) AT=450.025n

* CHECK dout0_6 Vdout0_6ck89 = 0.9 time = 450
.meas tran vdout0_6ck89 FIND v(dout0_6) AT=450.025n

* CHECK dout0_7 Vdout0_7ck89 = 0 time = 450
.meas tran vdout0_7ck89 FIND v(dout0_7) AT=450.025n

* CHECK dout0_8 Vdout0_8ck89 = 0 time = 450
.meas tran vdout0_8ck89 FIND v(dout0_8) AT=450.025n

* CHECK dout0_9 Vdout0_9ck89 = 0.9 time = 450
.meas tran vdout0_9ck89 FIND v(dout0_9) AT=450.025n

* CHECK dout0_10 Vdout0_10ck89 = 0.9 time = 450
.meas tran vdout0_10ck89 FIND v(dout0_10) AT=450.025n

* CHECK dout0_11 Vdout0_11ck89 = 0 time = 450
.meas tran vdout0_11ck89 FIND v(dout0_11) AT=450.025n

* CHECK dout0_12 Vdout0_12ck89 = 0.9 time = 450
.meas tran vdout0_12ck89 FIND v(dout0_12) AT=450.025n

* CHECK dout0_13 Vdout0_13ck89 = 0 time = 450
.meas tran vdout0_13ck89 FIND v(dout0_13) AT=450.025n

* CHECK dout0_14 Vdout0_14ck89 = 0 time = 450
.meas tran vdout0_14ck89 FIND v(dout0_14) AT=450.025n

* CHECK dout0_15 Vdout0_15ck89 = 0.9 time = 450
.meas tran vdout0_15ck89 FIND v(dout0_15) AT=450.025n

* CHECK dout0_16 Vdout0_16ck89 = 0 time = 450
.meas tran vdout0_16ck89 FIND v(dout0_16) AT=450.025n

* CHECK dout0_17 Vdout0_17ck89 = 0.9 time = 450
.meas tran vdout0_17ck89 FIND v(dout0_17) AT=450.025n

* CHECK dout0_18 Vdout0_18ck89 = 0.9 time = 450
.meas tran vdout0_18ck89 FIND v(dout0_18) AT=450.025n

* CHECK dout0_19 Vdout0_19ck89 = 0 time = 450
.meas tran vdout0_19ck89 FIND v(dout0_19) AT=450.025n

* CHECK dout0_20 Vdout0_20ck89 = 0.9 time = 450
.meas tran vdout0_20ck89 FIND v(dout0_20) AT=450.025n

* CHECK dout0_21 Vdout0_21ck89 = 0 time = 450
.meas tran vdout0_21ck89 FIND v(dout0_21) AT=450.025n

* CHECK dout0_22 Vdout0_22ck89 = 0 time = 450
.meas tran vdout0_22ck89 FIND v(dout0_22) AT=450.025n

* CHECK dout0_23 Vdout0_23ck89 = 0 time = 450
.meas tran vdout0_23ck89 FIND v(dout0_23) AT=450.025n

* CHECK dout0_24 Vdout0_24ck89 = 0.9 time = 450
.meas tran vdout0_24ck89 FIND v(dout0_24) AT=450.025n

* CHECK dout0_25 Vdout0_25ck89 = 0 time = 450
.meas tran vdout0_25ck89 FIND v(dout0_25) AT=450.025n

* CHECK dout0_26 Vdout0_26ck89 = 0.9 time = 450
.meas tran vdout0_26ck89 FIND v(dout0_26) AT=450.025n

* CHECK dout0_27 Vdout0_27ck89 = 0 time = 450
.meas tran vdout0_27ck89 FIND v(dout0_27) AT=450.025n

* CHECK dout0_28 Vdout0_28ck89 = 0 time = 450
.meas tran vdout0_28ck89 FIND v(dout0_28) AT=450.025n

* CHECK dout0_29 Vdout0_29ck89 = 0.9 time = 450
.meas tran vdout0_29ck89 FIND v(dout0_29) AT=450.025n

* CHECK dout0_30 Vdout0_30ck89 = 0.9 time = 450
.meas tran vdout0_30ck89 FIND v(dout0_30) AT=450.025n

* CHECK dout0_31 Vdout0_31ck89 = 0.9 time = 450
.meas tran vdout0_31ck89 FIND v(dout0_31) AT=450.025n

* CHECK dout0_32 Vdout0_32ck89 = 0 time = 450
.meas tran vdout0_32ck89 FIND v(dout0_32) AT=450.025n

* CHECK dout0_33 Vdout0_33ck89 = 0 time = 450
.meas tran vdout0_33ck89 FIND v(dout0_33) AT=450.025n

* CHECK dout0_34 Vdout0_34ck89 = 0 time = 450
.meas tran vdout0_34ck89 FIND v(dout0_34) AT=450.025n

* CHECK dout0_35 Vdout0_35ck89 = 0.9 time = 450
.meas tran vdout0_35ck89 FIND v(dout0_35) AT=450.025n

* CHECK dout0_36 Vdout0_36ck89 = 0.9 time = 450
.meas tran vdout0_36ck89 FIND v(dout0_36) AT=450.025n

* CHECK dout0_37 Vdout0_37ck89 = 0.9 time = 450
.meas tran vdout0_37ck89 FIND v(dout0_37) AT=450.025n

* CHECK dout0_38 Vdout0_38ck89 = 0 time = 450
.meas tran vdout0_38ck89 FIND v(dout0_38) AT=450.025n

* CHECK dout0_39 Vdout0_39ck89 = 0 time = 450
.meas tran vdout0_39ck89 FIND v(dout0_39) AT=450.025n

* CHECK dout0_40 Vdout0_40ck89 = 0 time = 450
.meas tran vdout0_40ck89 FIND v(dout0_40) AT=450.025n

* CHECK dout0_41 Vdout0_41ck89 = 0 time = 450
.meas tran vdout0_41ck89 FIND v(dout0_41) AT=450.025n

* CHECK dout0_42 Vdout0_42ck89 = 0.9 time = 450
.meas tran vdout0_42ck89 FIND v(dout0_42) AT=450.025n

* CHECK dout0_43 Vdout0_43ck89 = 0.9 time = 450
.meas tran vdout0_43ck89 FIND v(dout0_43) AT=450.025n

* CHECK dout0_44 Vdout0_44ck89 = 0 time = 450
.meas tran vdout0_44ck89 FIND v(dout0_44) AT=450.025n

* CHECK dout0_45 Vdout0_45ck89 = 0 time = 450
.meas tran vdout0_45ck89 FIND v(dout0_45) AT=450.025n

* CHECK dout0_46 Vdout0_46ck89 = 0.9 time = 450
.meas tran vdout0_46ck89 FIND v(dout0_46) AT=450.025n

* CHECK dout0_47 Vdout0_47ck89 = 0.9 time = 450
.meas tran vdout0_47ck89 FIND v(dout0_47) AT=450.025n

* CHECK dout0_48 Vdout0_48ck89 = 0.9 time = 450
.meas tran vdout0_48ck89 FIND v(dout0_48) AT=450.025n

* CHECK dout0_49 Vdout0_49ck89 = 0.9 time = 450
.meas tran vdout0_49ck89 FIND v(dout0_49) AT=450.025n

* CHECK dout0_50 Vdout0_50ck89 = 0.9 time = 450
.meas tran vdout0_50ck89 FIND v(dout0_50) AT=450.025n

* CHECK dout0_51 Vdout0_51ck89 = 0 time = 450
.meas tran vdout0_51ck89 FIND v(dout0_51) AT=450.025n

* CHECK dout0_52 Vdout0_52ck89 = 0 time = 450
.meas tran vdout0_52ck89 FIND v(dout0_52) AT=450.025n

* CHECK dout0_53 Vdout0_53ck89 = 0 time = 450
.meas tran vdout0_53ck89 FIND v(dout0_53) AT=450.025n

* CHECK dout0_54 Vdout0_54ck89 = 0.9 time = 450
.meas tran vdout0_54ck89 FIND v(dout0_54) AT=450.025n

* CHECK dout0_55 Vdout0_55ck89 = 0 time = 450
.meas tran vdout0_55ck89 FIND v(dout0_55) AT=450.025n

* CHECK dout0_56 Vdout0_56ck89 = 0.9 time = 450
.meas tran vdout0_56ck89 FIND v(dout0_56) AT=450.025n

* CHECK dout0_57 Vdout0_57ck89 = 0.9 time = 450
.meas tran vdout0_57ck89 FIND v(dout0_57) AT=450.025n

* CHECK dout0_58 Vdout0_58ck89 = 0.9 time = 450
.meas tran vdout0_58ck89 FIND v(dout0_58) AT=450.025n

* CHECK dout0_59 Vdout0_59ck89 = 0 time = 450
.meas tran vdout0_59ck89 FIND v(dout0_59) AT=450.025n

* CHECK dout0_60 Vdout0_60ck89 = 0 time = 450
.meas tran vdout0_60ck89 FIND v(dout0_60) AT=450.025n

* CHECK dout0_61 Vdout0_61ck89 = 0 time = 450
.meas tran vdout0_61ck89 FIND v(dout0_61) AT=450.025n

* CHECK dout0_62 Vdout0_62ck89 = 0.9 time = 450
.meas tran vdout0_62ck89 FIND v(dout0_62) AT=450.025n

* CHECK dout0_63 Vdout0_63ck89 = 0.9 time = 450
.meas tran vdout0_63ck89 FIND v(dout0_63) AT=450.025n

* CHECK dout0_0 Vdout0_0ck90 = 0.9 time = 455
.meas tran vdout0_0ck90 FIND v(dout0_0) AT=455.025n

* CHECK dout0_1 Vdout0_1ck90 = 0.9 time = 455
.meas tran vdout0_1ck90 FIND v(dout0_1) AT=455.025n

* CHECK dout0_2 Vdout0_2ck90 = 0 time = 455
.meas tran vdout0_2ck90 FIND v(dout0_2) AT=455.025n

* CHECK dout0_3 Vdout0_3ck90 = 0 time = 455
.meas tran vdout0_3ck90 FIND v(dout0_3) AT=455.025n

* CHECK dout0_4 Vdout0_4ck90 = 0.9 time = 455
.meas tran vdout0_4ck90 FIND v(dout0_4) AT=455.025n

* CHECK dout0_5 Vdout0_5ck90 = 0.9 time = 455
.meas tran vdout0_5ck90 FIND v(dout0_5) AT=455.025n

* CHECK dout0_6 Vdout0_6ck90 = 0 time = 455
.meas tran vdout0_6ck90 FIND v(dout0_6) AT=455.025n

* CHECK dout0_7 Vdout0_7ck90 = 0.9 time = 455
.meas tran vdout0_7ck90 FIND v(dout0_7) AT=455.025n

* CHECK dout0_8 Vdout0_8ck90 = 0.9 time = 455
.meas tran vdout0_8ck90 FIND v(dout0_8) AT=455.025n

* CHECK dout0_9 Vdout0_9ck90 = 0 time = 455
.meas tran vdout0_9ck90 FIND v(dout0_9) AT=455.025n

* CHECK dout0_10 Vdout0_10ck90 = 0 time = 455
.meas tran vdout0_10ck90 FIND v(dout0_10) AT=455.025n

* CHECK dout0_11 Vdout0_11ck90 = 0 time = 455
.meas tran vdout0_11ck90 FIND v(dout0_11) AT=455.025n

* CHECK dout0_12 Vdout0_12ck90 = 0 time = 455
.meas tran vdout0_12ck90 FIND v(dout0_12) AT=455.025n

* CHECK dout0_13 Vdout0_13ck90 = 0 time = 455
.meas tran vdout0_13ck90 FIND v(dout0_13) AT=455.025n

* CHECK dout0_14 Vdout0_14ck90 = 0 time = 455
.meas tran vdout0_14ck90 FIND v(dout0_14) AT=455.025n

* CHECK dout0_15 Vdout0_15ck90 = 0.9 time = 455
.meas tran vdout0_15ck90 FIND v(dout0_15) AT=455.025n

* CHECK dout0_16 Vdout0_16ck90 = 0.9 time = 455
.meas tran vdout0_16ck90 FIND v(dout0_16) AT=455.025n

* CHECK dout0_17 Vdout0_17ck90 = 0.9 time = 455
.meas tran vdout0_17ck90 FIND v(dout0_17) AT=455.025n

* CHECK dout0_18 Vdout0_18ck90 = 0.9 time = 455
.meas tran vdout0_18ck90 FIND v(dout0_18) AT=455.025n

* CHECK dout0_19 Vdout0_19ck90 = 0 time = 455
.meas tran vdout0_19ck90 FIND v(dout0_19) AT=455.025n

* CHECK dout0_20 Vdout0_20ck90 = 0.9 time = 455
.meas tran vdout0_20ck90 FIND v(dout0_20) AT=455.025n

* CHECK dout0_21 Vdout0_21ck90 = 0.9 time = 455
.meas tran vdout0_21ck90 FIND v(dout0_21) AT=455.025n

* CHECK dout0_22 Vdout0_22ck90 = 0.9 time = 455
.meas tran vdout0_22ck90 FIND v(dout0_22) AT=455.025n

* CHECK dout0_23 Vdout0_23ck90 = 0.9 time = 455
.meas tran vdout0_23ck90 FIND v(dout0_23) AT=455.025n

* CHECK dout0_24 Vdout0_24ck90 = 0 time = 455
.meas tran vdout0_24ck90 FIND v(dout0_24) AT=455.025n

* CHECK dout0_25 Vdout0_25ck90 = 0 time = 455
.meas tran vdout0_25ck90 FIND v(dout0_25) AT=455.025n

* CHECK dout0_26 Vdout0_26ck90 = 0 time = 455
.meas tran vdout0_26ck90 FIND v(dout0_26) AT=455.025n

* CHECK dout0_27 Vdout0_27ck90 = 0 time = 455
.meas tran vdout0_27ck90 FIND v(dout0_27) AT=455.025n

* CHECK dout0_28 Vdout0_28ck90 = 0 time = 455
.meas tran vdout0_28ck90 FIND v(dout0_28) AT=455.025n

* CHECK dout0_29 Vdout0_29ck90 = 0 time = 455
.meas tran vdout0_29ck90 FIND v(dout0_29) AT=455.025n

* CHECK dout0_30 Vdout0_30ck90 = 0.9 time = 455
.meas tran vdout0_30ck90 FIND v(dout0_30) AT=455.025n

* CHECK dout0_31 Vdout0_31ck90 = 0 time = 455
.meas tran vdout0_31ck90 FIND v(dout0_31) AT=455.025n

* CHECK dout0_32 Vdout0_32ck90 = 0 time = 455
.meas tran vdout0_32ck90 FIND v(dout0_32) AT=455.025n

* CHECK dout0_33 Vdout0_33ck90 = 0.9 time = 455
.meas tran vdout0_33ck90 FIND v(dout0_33) AT=455.025n

* CHECK dout0_34 Vdout0_34ck90 = 0.9 time = 455
.meas tran vdout0_34ck90 FIND v(dout0_34) AT=455.025n

* CHECK dout0_35 Vdout0_35ck90 = 0 time = 455
.meas tran vdout0_35ck90 FIND v(dout0_35) AT=455.025n

* CHECK dout0_36 Vdout0_36ck90 = 0 time = 455
.meas tran vdout0_36ck90 FIND v(dout0_36) AT=455.025n

* CHECK dout0_37 Vdout0_37ck90 = 0 time = 455
.meas tran vdout0_37ck90 FIND v(dout0_37) AT=455.025n

* CHECK dout0_38 Vdout0_38ck90 = 0.9 time = 455
.meas tran vdout0_38ck90 FIND v(dout0_38) AT=455.025n

* CHECK dout0_39 Vdout0_39ck90 = 0 time = 455
.meas tran vdout0_39ck90 FIND v(dout0_39) AT=455.025n

* CHECK dout0_40 Vdout0_40ck90 = 0 time = 455
.meas tran vdout0_40ck90 FIND v(dout0_40) AT=455.025n

* CHECK dout0_41 Vdout0_41ck90 = 0 time = 455
.meas tran vdout0_41ck90 FIND v(dout0_41) AT=455.025n

* CHECK dout0_42 Vdout0_42ck90 = 0.9 time = 455
.meas tran vdout0_42ck90 FIND v(dout0_42) AT=455.025n

* CHECK dout0_43 Vdout0_43ck90 = 0.9 time = 455
.meas tran vdout0_43ck90 FIND v(dout0_43) AT=455.025n

* CHECK dout0_44 Vdout0_44ck90 = 0.9 time = 455
.meas tran vdout0_44ck90 FIND v(dout0_44) AT=455.025n

* CHECK dout0_45 Vdout0_45ck90 = 0 time = 455
.meas tran vdout0_45ck90 FIND v(dout0_45) AT=455.025n

* CHECK dout0_46 Vdout0_46ck90 = 0 time = 455
.meas tran vdout0_46ck90 FIND v(dout0_46) AT=455.025n

* CHECK dout0_47 Vdout0_47ck90 = 0 time = 455
.meas tran vdout0_47ck90 FIND v(dout0_47) AT=455.025n

* CHECK dout0_48 Vdout0_48ck90 = 0.9 time = 455
.meas tran vdout0_48ck90 FIND v(dout0_48) AT=455.025n

* CHECK dout0_49 Vdout0_49ck90 = 0 time = 455
.meas tran vdout0_49ck90 FIND v(dout0_49) AT=455.025n

* CHECK dout0_50 Vdout0_50ck90 = 0 time = 455
.meas tran vdout0_50ck90 FIND v(dout0_50) AT=455.025n

* CHECK dout0_51 Vdout0_51ck90 = 0 time = 455
.meas tran vdout0_51ck90 FIND v(dout0_51) AT=455.025n

* CHECK dout0_52 Vdout0_52ck90 = 0 time = 455
.meas tran vdout0_52ck90 FIND v(dout0_52) AT=455.025n

* CHECK dout0_53 Vdout0_53ck90 = 0 time = 455
.meas tran vdout0_53ck90 FIND v(dout0_53) AT=455.025n

* CHECK dout0_54 Vdout0_54ck90 = 0 time = 455
.meas tran vdout0_54ck90 FIND v(dout0_54) AT=455.025n

* CHECK dout0_55 Vdout0_55ck90 = 0.9 time = 455
.meas tran vdout0_55ck90 FIND v(dout0_55) AT=455.025n

* CHECK dout0_56 Vdout0_56ck90 = 0 time = 455
.meas tran vdout0_56ck90 FIND v(dout0_56) AT=455.025n

* CHECK dout0_57 Vdout0_57ck90 = 0.9 time = 455
.meas tran vdout0_57ck90 FIND v(dout0_57) AT=455.025n

* CHECK dout0_58 Vdout0_58ck90 = 0 time = 455
.meas tran vdout0_58ck90 FIND v(dout0_58) AT=455.025n

* CHECK dout0_59 Vdout0_59ck90 = 0.9 time = 455
.meas tran vdout0_59ck90 FIND v(dout0_59) AT=455.025n

* CHECK dout0_60 Vdout0_60ck90 = 0 time = 455
.meas tran vdout0_60ck90 FIND v(dout0_60) AT=455.025n

* CHECK dout0_61 Vdout0_61ck90 = 0.9 time = 455
.meas tran vdout0_61ck90 FIND v(dout0_61) AT=455.025n

* CHECK dout0_62 Vdout0_62ck90 = 0.9 time = 455
.meas tran vdout0_62ck90 FIND v(dout0_62) AT=455.025n

* CHECK dout0_63 Vdout0_63ck90 = 0 time = 455
.meas tran vdout0_63ck90 FIND v(dout0_63) AT=455.025n

* CHECK dout0_0 Vdout0_0ck92 = 0 time = 465
.meas tran vdout0_0ck92 FIND v(dout0_0) AT=465.025n

* CHECK dout0_1 Vdout0_1ck92 = 0.9 time = 465
.meas tran vdout0_1ck92 FIND v(dout0_1) AT=465.025n

* CHECK dout0_2 Vdout0_2ck92 = 0 time = 465
.meas tran vdout0_2ck92 FIND v(dout0_2) AT=465.025n

* CHECK dout0_3 Vdout0_3ck92 = 0.9 time = 465
.meas tran vdout0_3ck92 FIND v(dout0_3) AT=465.025n

* CHECK dout0_4 Vdout0_4ck92 = 0 time = 465
.meas tran vdout0_4ck92 FIND v(dout0_4) AT=465.025n

* CHECK dout0_5 Vdout0_5ck92 = 0 time = 465
.meas tran vdout0_5ck92 FIND v(dout0_5) AT=465.025n

* CHECK dout0_6 Vdout0_6ck92 = 0 time = 465
.meas tran vdout0_6ck92 FIND v(dout0_6) AT=465.025n

* CHECK dout0_7 Vdout0_7ck92 = 0.9 time = 465
.meas tran vdout0_7ck92 FIND v(dout0_7) AT=465.025n

* CHECK dout0_8 Vdout0_8ck92 = 0.9 time = 465
.meas tran vdout0_8ck92 FIND v(dout0_8) AT=465.025n

* CHECK dout0_9 Vdout0_9ck92 = 0 time = 465
.meas tran vdout0_9ck92 FIND v(dout0_9) AT=465.025n

* CHECK dout0_10 Vdout0_10ck92 = 0 time = 465
.meas tran vdout0_10ck92 FIND v(dout0_10) AT=465.025n

* CHECK dout0_11 Vdout0_11ck92 = 0.9 time = 465
.meas tran vdout0_11ck92 FIND v(dout0_11) AT=465.025n

* CHECK dout0_12 Vdout0_12ck92 = 0.9 time = 465
.meas tran vdout0_12ck92 FIND v(dout0_12) AT=465.025n

* CHECK dout0_13 Vdout0_13ck92 = 0 time = 465
.meas tran vdout0_13ck92 FIND v(dout0_13) AT=465.025n

* CHECK dout0_14 Vdout0_14ck92 = 0 time = 465
.meas tran vdout0_14ck92 FIND v(dout0_14) AT=465.025n

* CHECK dout0_15 Vdout0_15ck92 = 0.9 time = 465
.meas tran vdout0_15ck92 FIND v(dout0_15) AT=465.025n

* CHECK dout0_16 Vdout0_16ck92 = 0.9 time = 465
.meas tran vdout0_16ck92 FIND v(dout0_16) AT=465.025n

* CHECK dout0_17 Vdout0_17ck92 = 0.9 time = 465
.meas tran vdout0_17ck92 FIND v(dout0_17) AT=465.025n

* CHECK dout0_18 Vdout0_18ck92 = 0.9 time = 465
.meas tran vdout0_18ck92 FIND v(dout0_18) AT=465.025n

* CHECK dout0_19 Vdout0_19ck92 = 0.9 time = 465
.meas tran vdout0_19ck92 FIND v(dout0_19) AT=465.025n

* CHECK dout0_20 Vdout0_20ck92 = 0.9 time = 465
.meas tran vdout0_20ck92 FIND v(dout0_20) AT=465.025n

* CHECK dout0_21 Vdout0_21ck92 = 0.9 time = 465
.meas tran vdout0_21ck92 FIND v(dout0_21) AT=465.025n

* CHECK dout0_22 Vdout0_22ck92 = 0 time = 465
.meas tran vdout0_22ck92 FIND v(dout0_22) AT=465.025n

* CHECK dout0_23 Vdout0_23ck92 = 0.9 time = 465
.meas tran vdout0_23ck92 FIND v(dout0_23) AT=465.025n

* CHECK dout0_24 Vdout0_24ck92 = 0.9 time = 465
.meas tran vdout0_24ck92 FIND v(dout0_24) AT=465.025n

* CHECK dout0_25 Vdout0_25ck92 = 0.9 time = 465
.meas tran vdout0_25ck92 FIND v(dout0_25) AT=465.025n

* CHECK dout0_26 Vdout0_26ck92 = 0.9 time = 465
.meas tran vdout0_26ck92 FIND v(dout0_26) AT=465.025n

* CHECK dout0_27 Vdout0_27ck92 = 0.9 time = 465
.meas tran vdout0_27ck92 FIND v(dout0_27) AT=465.025n

* CHECK dout0_28 Vdout0_28ck92 = 0 time = 465
.meas tran vdout0_28ck92 FIND v(dout0_28) AT=465.025n

* CHECK dout0_29 Vdout0_29ck92 = 0.9 time = 465
.meas tran vdout0_29ck92 FIND v(dout0_29) AT=465.025n

* CHECK dout0_30 Vdout0_30ck92 = 0.9 time = 465
.meas tran vdout0_30ck92 FIND v(dout0_30) AT=465.025n

* CHECK dout0_31 Vdout0_31ck92 = 0.9 time = 465
.meas tran vdout0_31ck92 FIND v(dout0_31) AT=465.025n

* CHECK dout0_32 Vdout0_32ck92 = 0.9 time = 465
.meas tran vdout0_32ck92 FIND v(dout0_32) AT=465.025n

* CHECK dout0_33 Vdout0_33ck92 = 0 time = 465
.meas tran vdout0_33ck92 FIND v(dout0_33) AT=465.025n

* CHECK dout0_34 Vdout0_34ck92 = 0 time = 465
.meas tran vdout0_34ck92 FIND v(dout0_34) AT=465.025n

* CHECK dout0_35 Vdout0_35ck92 = 0.9 time = 465
.meas tran vdout0_35ck92 FIND v(dout0_35) AT=465.025n

* CHECK dout0_36 Vdout0_36ck92 = 0 time = 465
.meas tran vdout0_36ck92 FIND v(dout0_36) AT=465.025n

* CHECK dout0_37 Vdout0_37ck92 = 0 time = 465
.meas tran vdout0_37ck92 FIND v(dout0_37) AT=465.025n

* CHECK dout0_38 Vdout0_38ck92 = 0 time = 465
.meas tran vdout0_38ck92 FIND v(dout0_38) AT=465.025n

* CHECK dout0_39 Vdout0_39ck92 = 0 time = 465
.meas tran vdout0_39ck92 FIND v(dout0_39) AT=465.025n

* CHECK dout0_40 Vdout0_40ck92 = 0 time = 465
.meas tran vdout0_40ck92 FIND v(dout0_40) AT=465.025n

* CHECK dout0_41 Vdout0_41ck92 = 0.9 time = 465
.meas tran vdout0_41ck92 FIND v(dout0_41) AT=465.025n

* CHECK dout0_42 Vdout0_42ck92 = 0 time = 465
.meas tran vdout0_42ck92 FIND v(dout0_42) AT=465.025n

* CHECK dout0_43 Vdout0_43ck92 = 0 time = 465
.meas tran vdout0_43ck92 FIND v(dout0_43) AT=465.025n

* CHECK dout0_44 Vdout0_44ck92 = 0 time = 465
.meas tran vdout0_44ck92 FIND v(dout0_44) AT=465.025n

* CHECK dout0_45 Vdout0_45ck92 = 0 time = 465
.meas tran vdout0_45ck92 FIND v(dout0_45) AT=465.025n

* CHECK dout0_46 Vdout0_46ck92 = 0.9 time = 465
.meas tran vdout0_46ck92 FIND v(dout0_46) AT=465.025n

* CHECK dout0_47 Vdout0_47ck92 = 0 time = 465
.meas tran vdout0_47ck92 FIND v(dout0_47) AT=465.025n

* CHECK dout0_48 Vdout0_48ck92 = 0 time = 465
.meas tran vdout0_48ck92 FIND v(dout0_48) AT=465.025n

* CHECK dout0_49 Vdout0_49ck92 = 0.9 time = 465
.meas tran vdout0_49ck92 FIND v(dout0_49) AT=465.025n

* CHECK dout0_50 Vdout0_50ck92 = 0 time = 465
.meas tran vdout0_50ck92 FIND v(dout0_50) AT=465.025n

* CHECK dout0_51 Vdout0_51ck92 = 0.9 time = 465
.meas tran vdout0_51ck92 FIND v(dout0_51) AT=465.025n

* CHECK dout0_52 Vdout0_52ck92 = 0 time = 465
.meas tran vdout0_52ck92 FIND v(dout0_52) AT=465.025n

* CHECK dout0_53 Vdout0_53ck92 = 0.9 time = 465
.meas tran vdout0_53ck92 FIND v(dout0_53) AT=465.025n

* CHECK dout0_54 Vdout0_54ck92 = 0.9 time = 465
.meas tran vdout0_54ck92 FIND v(dout0_54) AT=465.025n

* CHECK dout0_55 Vdout0_55ck92 = 0.9 time = 465
.meas tran vdout0_55ck92 FIND v(dout0_55) AT=465.025n

* CHECK dout0_56 Vdout0_56ck92 = 0 time = 465
.meas tran vdout0_56ck92 FIND v(dout0_56) AT=465.025n

* CHECK dout0_57 Vdout0_57ck92 = 0 time = 465
.meas tran vdout0_57ck92 FIND v(dout0_57) AT=465.025n

* CHECK dout0_58 Vdout0_58ck92 = 0 time = 465
.meas tran vdout0_58ck92 FIND v(dout0_58) AT=465.025n

* CHECK dout0_59 Vdout0_59ck92 = 0 time = 465
.meas tran vdout0_59ck92 FIND v(dout0_59) AT=465.025n

* CHECK dout0_60 Vdout0_60ck92 = 0 time = 465
.meas tran vdout0_60ck92 FIND v(dout0_60) AT=465.025n

* CHECK dout0_61 Vdout0_61ck92 = 0.9 time = 465
.meas tran vdout0_61ck92 FIND v(dout0_61) AT=465.025n

* CHECK dout0_62 Vdout0_62ck92 = 0.9 time = 465
.meas tran vdout0_62ck92 FIND v(dout0_62) AT=465.025n

* CHECK dout0_63 Vdout0_63ck92 = 0 time = 465
.meas tran vdout0_63ck92 FIND v(dout0_63) AT=465.025n

* CHECK dout0_0 Vdout0_0ck93 = 0 time = 470
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=470.025n

* CHECK dout0_1 Vdout0_1ck93 = 0.9 time = 470
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=470.025n

* CHECK dout0_2 Vdout0_2ck93 = 0 time = 470
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=470.025n

* CHECK dout0_3 Vdout0_3ck93 = 0.9 time = 470
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=470.025n

* CHECK dout0_4 Vdout0_4ck93 = 0 time = 470
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=470.025n

* CHECK dout0_5 Vdout0_5ck93 = 0 time = 470
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=470.025n

* CHECK dout0_6 Vdout0_6ck93 = 0 time = 470
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=470.025n

* CHECK dout0_7 Vdout0_7ck93 = 0.9 time = 470
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=470.025n

* CHECK dout0_8 Vdout0_8ck93 = 0.9 time = 470
.meas tran vdout0_8ck93 FIND v(dout0_8) AT=470.025n

* CHECK dout0_9 Vdout0_9ck93 = 0 time = 470
.meas tran vdout0_9ck93 FIND v(dout0_9) AT=470.025n

* CHECK dout0_10 Vdout0_10ck93 = 0 time = 470
.meas tran vdout0_10ck93 FIND v(dout0_10) AT=470.025n

* CHECK dout0_11 Vdout0_11ck93 = 0.9 time = 470
.meas tran vdout0_11ck93 FIND v(dout0_11) AT=470.025n

* CHECK dout0_12 Vdout0_12ck93 = 0.9 time = 470
.meas tran vdout0_12ck93 FIND v(dout0_12) AT=470.025n

* CHECK dout0_13 Vdout0_13ck93 = 0 time = 470
.meas tran vdout0_13ck93 FIND v(dout0_13) AT=470.025n

* CHECK dout0_14 Vdout0_14ck93 = 0 time = 470
.meas tran vdout0_14ck93 FIND v(dout0_14) AT=470.025n

* CHECK dout0_15 Vdout0_15ck93 = 0.9 time = 470
.meas tran vdout0_15ck93 FIND v(dout0_15) AT=470.025n

* CHECK dout0_16 Vdout0_16ck93 = 0.9 time = 470
.meas tran vdout0_16ck93 FIND v(dout0_16) AT=470.025n

* CHECK dout0_17 Vdout0_17ck93 = 0.9 time = 470
.meas tran vdout0_17ck93 FIND v(dout0_17) AT=470.025n

* CHECK dout0_18 Vdout0_18ck93 = 0.9 time = 470
.meas tran vdout0_18ck93 FIND v(dout0_18) AT=470.025n

* CHECK dout0_19 Vdout0_19ck93 = 0.9 time = 470
.meas tran vdout0_19ck93 FIND v(dout0_19) AT=470.025n

* CHECK dout0_20 Vdout0_20ck93 = 0.9 time = 470
.meas tran vdout0_20ck93 FIND v(dout0_20) AT=470.025n

* CHECK dout0_21 Vdout0_21ck93 = 0.9 time = 470
.meas tran vdout0_21ck93 FIND v(dout0_21) AT=470.025n

* CHECK dout0_22 Vdout0_22ck93 = 0 time = 470
.meas tran vdout0_22ck93 FIND v(dout0_22) AT=470.025n

* CHECK dout0_23 Vdout0_23ck93 = 0.9 time = 470
.meas tran vdout0_23ck93 FIND v(dout0_23) AT=470.025n

* CHECK dout0_24 Vdout0_24ck93 = 0.9 time = 470
.meas tran vdout0_24ck93 FIND v(dout0_24) AT=470.025n

* CHECK dout0_25 Vdout0_25ck93 = 0.9 time = 470
.meas tran vdout0_25ck93 FIND v(dout0_25) AT=470.025n

* CHECK dout0_26 Vdout0_26ck93 = 0.9 time = 470
.meas tran vdout0_26ck93 FIND v(dout0_26) AT=470.025n

* CHECK dout0_27 Vdout0_27ck93 = 0.9 time = 470
.meas tran vdout0_27ck93 FIND v(dout0_27) AT=470.025n

* CHECK dout0_28 Vdout0_28ck93 = 0 time = 470
.meas tran vdout0_28ck93 FIND v(dout0_28) AT=470.025n

* CHECK dout0_29 Vdout0_29ck93 = 0.9 time = 470
.meas tran vdout0_29ck93 FIND v(dout0_29) AT=470.025n

* CHECK dout0_30 Vdout0_30ck93 = 0.9 time = 470
.meas tran vdout0_30ck93 FIND v(dout0_30) AT=470.025n

* CHECK dout0_31 Vdout0_31ck93 = 0.9 time = 470
.meas tran vdout0_31ck93 FIND v(dout0_31) AT=470.025n

* CHECK dout0_32 Vdout0_32ck93 = 0.9 time = 470
.meas tran vdout0_32ck93 FIND v(dout0_32) AT=470.025n

* CHECK dout0_33 Vdout0_33ck93 = 0 time = 470
.meas tran vdout0_33ck93 FIND v(dout0_33) AT=470.025n

* CHECK dout0_34 Vdout0_34ck93 = 0 time = 470
.meas tran vdout0_34ck93 FIND v(dout0_34) AT=470.025n

* CHECK dout0_35 Vdout0_35ck93 = 0.9 time = 470
.meas tran vdout0_35ck93 FIND v(dout0_35) AT=470.025n

* CHECK dout0_36 Vdout0_36ck93 = 0 time = 470
.meas tran vdout0_36ck93 FIND v(dout0_36) AT=470.025n

* CHECK dout0_37 Vdout0_37ck93 = 0 time = 470
.meas tran vdout0_37ck93 FIND v(dout0_37) AT=470.025n

* CHECK dout0_38 Vdout0_38ck93 = 0 time = 470
.meas tran vdout0_38ck93 FIND v(dout0_38) AT=470.025n

* CHECK dout0_39 Vdout0_39ck93 = 0 time = 470
.meas tran vdout0_39ck93 FIND v(dout0_39) AT=470.025n

* CHECK dout0_40 Vdout0_40ck93 = 0 time = 470
.meas tran vdout0_40ck93 FIND v(dout0_40) AT=470.025n

* CHECK dout0_41 Vdout0_41ck93 = 0.9 time = 470
.meas tran vdout0_41ck93 FIND v(dout0_41) AT=470.025n

* CHECK dout0_42 Vdout0_42ck93 = 0 time = 470
.meas tran vdout0_42ck93 FIND v(dout0_42) AT=470.025n

* CHECK dout0_43 Vdout0_43ck93 = 0 time = 470
.meas tran vdout0_43ck93 FIND v(dout0_43) AT=470.025n

* CHECK dout0_44 Vdout0_44ck93 = 0 time = 470
.meas tran vdout0_44ck93 FIND v(dout0_44) AT=470.025n

* CHECK dout0_45 Vdout0_45ck93 = 0 time = 470
.meas tran vdout0_45ck93 FIND v(dout0_45) AT=470.025n

* CHECK dout0_46 Vdout0_46ck93 = 0.9 time = 470
.meas tran vdout0_46ck93 FIND v(dout0_46) AT=470.025n

* CHECK dout0_47 Vdout0_47ck93 = 0 time = 470
.meas tran vdout0_47ck93 FIND v(dout0_47) AT=470.025n

* CHECK dout0_48 Vdout0_48ck93 = 0 time = 470
.meas tran vdout0_48ck93 FIND v(dout0_48) AT=470.025n

* CHECK dout0_49 Vdout0_49ck93 = 0.9 time = 470
.meas tran vdout0_49ck93 FIND v(dout0_49) AT=470.025n

* CHECK dout0_50 Vdout0_50ck93 = 0 time = 470
.meas tran vdout0_50ck93 FIND v(dout0_50) AT=470.025n

* CHECK dout0_51 Vdout0_51ck93 = 0.9 time = 470
.meas tran vdout0_51ck93 FIND v(dout0_51) AT=470.025n

* CHECK dout0_52 Vdout0_52ck93 = 0 time = 470
.meas tran vdout0_52ck93 FIND v(dout0_52) AT=470.025n

* CHECK dout0_53 Vdout0_53ck93 = 0.9 time = 470
.meas tran vdout0_53ck93 FIND v(dout0_53) AT=470.025n

* CHECK dout0_54 Vdout0_54ck93 = 0.9 time = 470
.meas tran vdout0_54ck93 FIND v(dout0_54) AT=470.025n

* CHECK dout0_55 Vdout0_55ck93 = 0.9 time = 470
.meas tran vdout0_55ck93 FIND v(dout0_55) AT=470.025n

* CHECK dout0_56 Vdout0_56ck93 = 0 time = 470
.meas tran vdout0_56ck93 FIND v(dout0_56) AT=470.025n

* CHECK dout0_57 Vdout0_57ck93 = 0 time = 470
.meas tran vdout0_57ck93 FIND v(dout0_57) AT=470.025n

* CHECK dout0_58 Vdout0_58ck93 = 0 time = 470
.meas tran vdout0_58ck93 FIND v(dout0_58) AT=470.025n

* CHECK dout0_59 Vdout0_59ck93 = 0 time = 470
.meas tran vdout0_59ck93 FIND v(dout0_59) AT=470.025n

* CHECK dout0_60 Vdout0_60ck93 = 0 time = 470
.meas tran vdout0_60ck93 FIND v(dout0_60) AT=470.025n

* CHECK dout0_61 Vdout0_61ck93 = 0.9 time = 470
.meas tran vdout0_61ck93 FIND v(dout0_61) AT=470.025n

* CHECK dout0_62 Vdout0_62ck93 = 0.9 time = 470
.meas tran vdout0_62ck93 FIND v(dout0_62) AT=470.025n

* CHECK dout0_63 Vdout0_63ck93 = 0 time = 470
.meas tran vdout0_63ck93 FIND v(dout0_63) AT=470.025n

* CHECK dout0_0 Vdout0_0ck97 = 0 time = 490
.meas tran vdout0_0ck97 FIND v(dout0_0) AT=490.025n

* CHECK dout0_1 Vdout0_1ck97 = 0 time = 490
.meas tran vdout0_1ck97 FIND v(dout0_1) AT=490.025n

* CHECK dout0_2 Vdout0_2ck97 = 0.9 time = 490
.meas tran vdout0_2ck97 FIND v(dout0_2) AT=490.025n

* CHECK dout0_3 Vdout0_3ck97 = 0.9 time = 490
.meas tran vdout0_3ck97 FIND v(dout0_3) AT=490.025n

* CHECK dout0_4 Vdout0_4ck97 = 0 time = 490
.meas tran vdout0_4ck97 FIND v(dout0_4) AT=490.025n

* CHECK dout0_5 Vdout0_5ck97 = 0 time = 490
.meas tran vdout0_5ck97 FIND v(dout0_5) AT=490.025n

* CHECK dout0_6 Vdout0_6ck97 = 0.9 time = 490
.meas tran vdout0_6ck97 FIND v(dout0_6) AT=490.025n

* CHECK dout0_7 Vdout0_7ck97 = 0 time = 490
.meas tran vdout0_7ck97 FIND v(dout0_7) AT=490.025n

* CHECK dout0_8 Vdout0_8ck97 = 0 time = 490
.meas tran vdout0_8ck97 FIND v(dout0_8) AT=490.025n

* CHECK dout0_9 Vdout0_9ck97 = 0.9 time = 490
.meas tran vdout0_9ck97 FIND v(dout0_9) AT=490.025n

* CHECK dout0_10 Vdout0_10ck97 = 0 time = 490
.meas tran vdout0_10ck97 FIND v(dout0_10) AT=490.025n

* CHECK dout0_11 Vdout0_11ck97 = 0 time = 490
.meas tran vdout0_11ck97 FIND v(dout0_11) AT=490.025n

* CHECK dout0_12 Vdout0_12ck97 = 0 time = 490
.meas tran vdout0_12ck97 FIND v(dout0_12) AT=490.025n

* CHECK dout0_13 Vdout0_13ck97 = 0.9 time = 490
.meas tran vdout0_13ck97 FIND v(dout0_13) AT=490.025n

* CHECK dout0_14 Vdout0_14ck97 = 0.9 time = 490
.meas tran vdout0_14ck97 FIND v(dout0_14) AT=490.025n

* CHECK dout0_15 Vdout0_15ck97 = 0 time = 490
.meas tran vdout0_15ck97 FIND v(dout0_15) AT=490.025n

* CHECK dout0_16 Vdout0_16ck97 = 0.9 time = 490
.meas tran vdout0_16ck97 FIND v(dout0_16) AT=490.025n

* CHECK dout0_17 Vdout0_17ck97 = 0.9 time = 490
.meas tran vdout0_17ck97 FIND v(dout0_17) AT=490.025n

* CHECK dout0_18 Vdout0_18ck97 = 0 time = 490
.meas tran vdout0_18ck97 FIND v(dout0_18) AT=490.025n

* CHECK dout0_19 Vdout0_19ck97 = 0.9 time = 490
.meas tran vdout0_19ck97 FIND v(dout0_19) AT=490.025n

* CHECK dout0_20 Vdout0_20ck97 = 0 time = 490
.meas tran vdout0_20ck97 FIND v(dout0_20) AT=490.025n

* CHECK dout0_21 Vdout0_21ck97 = 0 time = 490
.meas tran vdout0_21ck97 FIND v(dout0_21) AT=490.025n

* CHECK dout0_22 Vdout0_22ck97 = 0.9 time = 490
.meas tran vdout0_22ck97 FIND v(dout0_22) AT=490.025n

* CHECK dout0_23 Vdout0_23ck97 = 0.9 time = 490
.meas tran vdout0_23ck97 FIND v(dout0_23) AT=490.025n

* CHECK dout0_24 Vdout0_24ck97 = 0.9 time = 490
.meas tran vdout0_24ck97 FIND v(dout0_24) AT=490.025n

* CHECK dout0_25 Vdout0_25ck97 = 0 time = 490
.meas tran vdout0_25ck97 FIND v(dout0_25) AT=490.025n

* CHECK dout0_26 Vdout0_26ck97 = 0.9 time = 490
.meas tran vdout0_26ck97 FIND v(dout0_26) AT=490.025n

* CHECK dout0_27 Vdout0_27ck97 = 0.9 time = 490
.meas tran vdout0_27ck97 FIND v(dout0_27) AT=490.025n

* CHECK dout0_28 Vdout0_28ck97 = 0 time = 490
.meas tran vdout0_28ck97 FIND v(dout0_28) AT=490.025n

* CHECK dout0_29 Vdout0_29ck97 = 0.9 time = 490
.meas tran vdout0_29ck97 FIND v(dout0_29) AT=490.025n

* CHECK dout0_30 Vdout0_30ck97 = 0.9 time = 490
.meas tran vdout0_30ck97 FIND v(dout0_30) AT=490.025n

* CHECK dout0_31 Vdout0_31ck97 = 0 time = 490
.meas tran vdout0_31ck97 FIND v(dout0_31) AT=490.025n

* CHECK dout0_32 Vdout0_32ck97 = 0 time = 490
.meas tran vdout0_32ck97 FIND v(dout0_32) AT=490.025n

* CHECK dout0_33 Vdout0_33ck97 = 0 time = 490
.meas tran vdout0_33ck97 FIND v(dout0_33) AT=490.025n

* CHECK dout0_34 Vdout0_34ck97 = 0 time = 490
.meas tran vdout0_34ck97 FIND v(dout0_34) AT=490.025n

* CHECK dout0_35 Vdout0_35ck97 = 0 time = 490
.meas tran vdout0_35ck97 FIND v(dout0_35) AT=490.025n

* CHECK dout0_36 Vdout0_36ck97 = 0.9 time = 490
.meas tran vdout0_36ck97 FIND v(dout0_36) AT=490.025n

* CHECK dout0_37 Vdout0_37ck97 = 0 time = 490
.meas tran vdout0_37ck97 FIND v(dout0_37) AT=490.025n

* CHECK dout0_38 Vdout0_38ck97 = 0 time = 490
.meas tran vdout0_38ck97 FIND v(dout0_38) AT=490.025n

* CHECK dout0_39 Vdout0_39ck97 = 0 time = 490
.meas tran vdout0_39ck97 FIND v(dout0_39) AT=490.025n

* CHECK dout0_40 Vdout0_40ck97 = 0.9 time = 490
.meas tran vdout0_40ck97 FIND v(dout0_40) AT=490.025n

* CHECK dout0_41 Vdout0_41ck97 = 0.9 time = 490
.meas tran vdout0_41ck97 FIND v(dout0_41) AT=490.025n

* CHECK dout0_42 Vdout0_42ck97 = 0.9 time = 490
.meas tran vdout0_42ck97 FIND v(dout0_42) AT=490.025n

* CHECK dout0_43 Vdout0_43ck97 = 0.9 time = 490
.meas tran vdout0_43ck97 FIND v(dout0_43) AT=490.025n

* CHECK dout0_44 Vdout0_44ck97 = 0 time = 490
.meas tran vdout0_44ck97 FIND v(dout0_44) AT=490.025n

* CHECK dout0_45 Vdout0_45ck97 = 0.9 time = 490
.meas tran vdout0_45ck97 FIND v(dout0_45) AT=490.025n

* CHECK dout0_46 Vdout0_46ck97 = 0 time = 490
.meas tran vdout0_46ck97 FIND v(dout0_46) AT=490.025n

* CHECK dout0_47 Vdout0_47ck97 = 0.9 time = 490
.meas tran vdout0_47ck97 FIND v(dout0_47) AT=490.025n

* CHECK dout0_48 Vdout0_48ck97 = 0.9 time = 490
.meas tran vdout0_48ck97 FIND v(dout0_48) AT=490.025n

* CHECK dout0_49 Vdout0_49ck97 = 0.9 time = 490
.meas tran vdout0_49ck97 FIND v(dout0_49) AT=490.025n

* CHECK dout0_50 Vdout0_50ck97 = 0 time = 490
.meas tran vdout0_50ck97 FIND v(dout0_50) AT=490.025n

* CHECK dout0_51 Vdout0_51ck97 = 0.9 time = 490
.meas tran vdout0_51ck97 FIND v(dout0_51) AT=490.025n

* CHECK dout0_52 Vdout0_52ck97 = 0.9 time = 490
.meas tran vdout0_52ck97 FIND v(dout0_52) AT=490.025n

* CHECK dout0_53 Vdout0_53ck97 = 0.9 time = 490
.meas tran vdout0_53ck97 FIND v(dout0_53) AT=490.025n

* CHECK dout0_54 Vdout0_54ck97 = 0 time = 490
.meas tran vdout0_54ck97 FIND v(dout0_54) AT=490.025n

* CHECK dout0_55 Vdout0_55ck97 = 0.9 time = 490
.meas tran vdout0_55ck97 FIND v(dout0_55) AT=490.025n

* CHECK dout0_56 Vdout0_56ck97 = 0 time = 490
.meas tran vdout0_56ck97 FIND v(dout0_56) AT=490.025n

* CHECK dout0_57 Vdout0_57ck97 = 0.9 time = 490
.meas tran vdout0_57ck97 FIND v(dout0_57) AT=490.025n

* CHECK dout0_58 Vdout0_58ck97 = 0 time = 490
.meas tran vdout0_58ck97 FIND v(dout0_58) AT=490.025n

* CHECK dout0_59 Vdout0_59ck97 = 0.9 time = 490
.meas tran vdout0_59ck97 FIND v(dout0_59) AT=490.025n

* CHECK dout0_60 Vdout0_60ck97 = 0 time = 490
.meas tran vdout0_60ck97 FIND v(dout0_60) AT=490.025n

* CHECK dout0_61 Vdout0_61ck97 = 0 time = 490
.meas tran vdout0_61ck97 FIND v(dout0_61) AT=490.025n

* CHECK dout0_62 Vdout0_62ck97 = 0.9 time = 490
.meas tran vdout0_62ck97 FIND v(dout0_62) AT=490.025n

* CHECK dout0_63 Vdout0_63ck97 = 0.9 time = 490
.meas tran vdout0_63ck97 FIND v(dout0_63) AT=490.025n

* CHECK dout0_0 Vdout0_0ck99 = 0.9 time = 500
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=500.025n

* CHECK dout0_1 Vdout0_1ck99 = 0.9 time = 500
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=500.025n

* CHECK dout0_2 Vdout0_2ck99 = 0 time = 500
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=500.025n

* CHECK dout0_3 Vdout0_3ck99 = 0 time = 500
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=500.025n

* CHECK dout0_4 Vdout0_4ck99 = 0.9 time = 500
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=500.025n

* CHECK dout0_5 Vdout0_5ck99 = 0.9 time = 500
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=500.025n

* CHECK dout0_6 Vdout0_6ck99 = 0 time = 500
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=500.025n

* CHECK dout0_7 Vdout0_7ck99 = 0.9 time = 500
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=500.025n

* CHECK dout0_8 Vdout0_8ck99 = 0.9 time = 500
.meas tran vdout0_8ck99 FIND v(dout0_8) AT=500.025n

* CHECK dout0_9 Vdout0_9ck99 = 0 time = 500
.meas tran vdout0_9ck99 FIND v(dout0_9) AT=500.025n

* CHECK dout0_10 Vdout0_10ck99 = 0 time = 500
.meas tran vdout0_10ck99 FIND v(dout0_10) AT=500.025n

* CHECK dout0_11 Vdout0_11ck99 = 0 time = 500
.meas tran vdout0_11ck99 FIND v(dout0_11) AT=500.025n

* CHECK dout0_12 Vdout0_12ck99 = 0 time = 500
.meas tran vdout0_12ck99 FIND v(dout0_12) AT=500.025n

* CHECK dout0_13 Vdout0_13ck99 = 0 time = 500
.meas tran vdout0_13ck99 FIND v(dout0_13) AT=500.025n

* CHECK dout0_14 Vdout0_14ck99 = 0 time = 500
.meas tran vdout0_14ck99 FIND v(dout0_14) AT=500.025n

* CHECK dout0_15 Vdout0_15ck99 = 0.9 time = 500
.meas tran vdout0_15ck99 FIND v(dout0_15) AT=500.025n

* CHECK dout0_16 Vdout0_16ck99 = 0.9 time = 500
.meas tran vdout0_16ck99 FIND v(dout0_16) AT=500.025n

* CHECK dout0_17 Vdout0_17ck99 = 0.9 time = 500
.meas tran vdout0_17ck99 FIND v(dout0_17) AT=500.025n

* CHECK dout0_18 Vdout0_18ck99 = 0.9 time = 500
.meas tran vdout0_18ck99 FIND v(dout0_18) AT=500.025n

* CHECK dout0_19 Vdout0_19ck99 = 0 time = 500
.meas tran vdout0_19ck99 FIND v(dout0_19) AT=500.025n

* CHECK dout0_20 Vdout0_20ck99 = 0.9 time = 500
.meas tran vdout0_20ck99 FIND v(dout0_20) AT=500.025n

* CHECK dout0_21 Vdout0_21ck99 = 0.9 time = 500
.meas tran vdout0_21ck99 FIND v(dout0_21) AT=500.025n

* CHECK dout0_22 Vdout0_22ck99 = 0.9 time = 500
.meas tran vdout0_22ck99 FIND v(dout0_22) AT=500.025n

* CHECK dout0_23 Vdout0_23ck99 = 0.9 time = 500
.meas tran vdout0_23ck99 FIND v(dout0_23) AT=500.025n

* CHECK dout0_24 Vdout0_24ck99 = 0 time = 500
.meas tran vdout0_24ck99 FIND v(dout0_24) AT=500.025n

* CHECK dout0_25 Vdout0_25ck99 = 0 time = 500
.meas tran vdout0_25ck99 FIND v(dout0_25) AT=500.025n

* CHECK dout0_26 Vdout0_26ck99 = 0 time = 500
.meas tran vdout0_26ck99 FIND v(dout0_26) AT=500.025n

* CHECK dout0_27 Vdout0_27ck99 = 0 time = 500
.meas tran vdout0_27ck99 FIND v(dout0_27) AT=500.025n

* CHECK dout0_28 Vdout0_28ck99 = 0 time = 500
.meas tran vdout0_28ck99 FIND v(dout0_28) AT=500.025n

* CHECK dout0_29 Vdout0_29ck99 = 0 time = 500
.meas tran vdout0_29ck99 FIND v(dout0_29) AT=500.025n

* CHECK dout0_30 Vdout0_30ck99 = 0.9 time = 500
.meas tran vdout0_30ck99 FIND v(dout0_30) AT=500.025n

* CHECK dout0_31 Vdout0_31ck99 = 0 time = 500
.meas tran vdout0_31ck99 FIND v(dout0_31) AT=500.025n

* CHECK dout0_32 Vdout0_32ck99 = 0 time = 500
.meas tran vdout0_32ck99 FIND v(dout0_32) AT=500.025n

* CHECK dout0_33 Vdout0_33ck99 = 0.9 time = 500
.meas tran vdout0_33ck99 FIND v(dout0_33) AT=500.025n

* CHECK dout0_34 Vdout0_34ck99 = 0.9 time = 500
.meas tran vdout0_34ck99 FIND v(dout0_34) AT=500.025n

* CHECK dout0_35 Vdout0_35ck99 = 0 time = 500
.meas tran vdout0_35ck99 FIND v(dout0_35) AT=500.025n

* CHECK dout0_36 Vdout0_36ck99 = 0 time = 500
.meas tran vdout0_36ck99 FIND v(dout0_36) AT=500.025n

* CHECK dout0_37 Vdout0_37ck99 = 0 time = 500
.meas tran vdout0_37ck99 FIND v(dout0_37) AT=500.025n

* CHECK dout0_38 Vdout0_38ck99 = 0.9 time = 500
.meas tran vdout0_38ck99 FIND v(dout0_38) AT=500.025n

* CHECK dout0_39 Vdout0_39ck99 = 0 time = 500
.meas tran vdout0_39ck99 FIND v(dout0_39) AT=500.025n

* CHECK dout0_40 Vdout0_40ck99 = 0 time = 500
.meas tran vdout0_40ck99 FIND v(dout0_40) AT=500.025n

* CHECK dout0_41 Vdout0_41ck99 = 0 time = 500
.meas tran vdout0_41ck99 FIND v(dout0_41) AT=500.025n

* CHECK dout0_42 Vdout0_42ck99 = 0.9 time = 500
.meas tran vdout0_42ck99 FIND v(dout0_42) AT=500.025n

* CHECK dout0_43 Vdout0_43ck99 = 0.9 time = 500
.meas tran vdout0_43ck99 FIND v(dout0_43) AT=500.025n

* CHECK dout0_44 Vdout0_44ck99 = 0.9 time = 500
.meas tran vdout0_44ck99 FIND v(dout0_44) AT=500.025n

* CHECK dout0_45 Vdout0_45ck99 = 0 time = 500
.meas tran vdout0_45ck99 FIND v(dout0_45) AT=500.025n

* CHECK dout0_46 Vdout0_46ck99 = 0 time = 500
.meas tran vdout0_46ck99 FIND v(dout0_46) AT=500.025n

* CHECK dout0_47 Vdout0_47ck99 = 0 time = 500
.meas tran vdout0_47ck99 FIND v(dout0_47) AT=500.025n

* CHECK dout0_48 Vdout0_48ck99 = 0.9 time = 500
.meas tran vdout0_48ck99 FIND v(dout0_48) AT=500.025n

* CHECK dout0_49 Vdout0_49ck99 = 0 time = 500
.meas tran vdout0_49ck99 FIND v(dout0_49) AT=500.025n

* CHECK dout0_50 Vdout0_50ck99 = 0 time = 500
.meas tran vdout0_50ck99 FIND v(dout0_50) AT=500.025n

* CHECK dout0_51 Vdout0_51ck99 = 0 time = 500
.meas tran vdout0_51ck99 FIND v(dout0_51) AT=500.025n

* CHECK dout0_52 Vdout0_52ck99 = 0 time = 500
.meas tran vdout0_52ck99 FIND v(dout0_52) AT=500.025n

* CHECK dout0_53 Vdout0_53ck99 = 0 time = 500
.meas tran vdout0_53ck99 FIND v(dout0_53) AT=500.025n

* CHECK dout0_54 Vdout0_54ck99 = 0 time = 500
.meas tran vdout0_54ck99 FIND v(dout0_54) AT=500.025n

* CHECK dout0_55 Vdout0_55ck99 = 0.9 time = 500
.meas tran vdout0_55ck99 FIND v(dout0_55) AT=500.025n

* CHECK dout0_56 Vdout0_56ck99 = 0 time = 500
.meas tran vdout0_56ck99 FIND v(dout0_56) AT=500.025n

* CHECK dout0_57 Vdout0_57ck99 = 0.9 time = 500
.meas tran vdout0_57ck99 FIND v(dout0_57) AT=500.025n

* CHECK dout0_58 Vdout0_58ck99 = 0 time = 500
.meas tran vdout0_58ck99 FIND v(dout0_58) AT=500.025n

* CHECK dout0_59 Vdout0_59ck99 = 0.9 time = 500
.meas tran vdout0_59ck99 FIND v(dout0_59) AT=500.025n

* CHECK dout0_60 Vdout0_60ck99 = 0 time = 500
.meas tran vdout0_60ck99 FIND v(dout0_60) AT=500.025n

* CHECK dout0_61 Vdout0_61ck99 = 0.9 time = 500
.meas tran vdout0_61ck99 FIND v(dout0_61) AT=500.025n

* CHECK dout0_62 Vdout0_62ck99 = 0.9 time = 500
.meas tran vdout0_62ck99 FIND v(dout0_62) AT=500.025n

* CHECK dout0_63 Vdout0_63ck99 = 0 time = 500
.meas tran vdout0_63ck99 FIND v(dout0_63) AT=500.025n

* CHECK dout0_0 Vdout0_0ck100 = 0 time = 505
.meas tran vdout0_0ck100 FIND v(dout0_0) AT=505.025n

* CHECK dout0_1 Vdout0_1ck100 = 0 time = 505
.meas tran vdout0_1ck100 FIND v(dout0_1) AT=505.025n

* CHECK dout0_2 Vdout0_2ck100 = 0 time = 505
.meas tran vdout0_2ck100 FIND v(dout0_2) AT=505.025n

* CHECK dout0_3 Vdout0_3ck100 = 0 time = 505
.meas tran vdout0_3ck100 FIND v(dout0_3) AT=505.025n

* CHECK dout0_4 Vdout0_4ck100 = 0.9 time = 505
.meas tran vdout0_4ck100 FIND v(dout0_4) AT=505.025n

* CHECK dout0_5 Vdout0_5ck100 = 0.9 time = 505
.meas tran vdout0_5ck100 FIND v(dout0_5) AT=505.025n

* CHECK dout0_6 Vdout0_6ck100 = 0 time = 505
.meas tran vdout0_6ck100 FIND v(dout0_6) AT=505.025n

* CHECK dout0_7 Vdout0_7ck100 = 0.9 time = 505
.meas tran vdout0_7ck100 FIND v(dout0_7) AT=505.025n

* CHECK dout0_8 Vdout0_8ck100 = 0 time = 505
.meas tran vdout0_8ck100 FIND v(dout0_8) AT=505.025n

* CHECK dout0_9 Vdout0_9ck100 = 0 time = 505
.meas tran vdout0_9ck100 FIND v(dout0_9) AT=505.025n

* CHECK dout0_10 Vdout0_10ck100 = 0 time = 505
.meas tran vdout0_10ck100 FIND v(dout0_10) AT=505.025n

* CHECK dout0_11 Vdout0_11ck100 = 0.9 time = 505
.meas tran vdout0_11ck100 FIND v(dout0_11) AT=505.025n

* CHECK dout0_12 Vdout0_12ck100 = 0.9 time = 505
.meas tran vdout0_12ck100 FIND v(dout0_12) AT=505.025n

* CHECK dout0_13 Vdout0_13ck100 = 0.9 time = 505
.meas tran vdout0_13ck100 FIND v(dout0_13) AT=505.025n

* CHECK dout0_14 Vdout0_14ck100 = 0.9 time = 505
.meas tran vdout0_14ck100 FIND v(dout0_14) AT=505.025n

* CHECK dout0_15 Vdout0_15ck100 = 0.9 time = 505
.meas tran vdout0_15ck100 FIND v(dout0_15) AT=505.025n

* CHECK dout0_16 Vdout0_16ck100 = 0.9 time = 505
.meas tran vdout0_16ck100 FIND v(dout0_16) AT=505.025n

* CHECK dout0_17 Vdout0_17ck100 = 0 time = 505
.meas tran vdout0_17ck100 FIND v(dout0_17) AT=505.025n

* CHECK dout0_18 Vdout0_18ck100 = 0 time = 505
.meas tran vdout0_18ck100 FIND v(dout0_18) AT=505.025n

* CHECK dout0_19 Vdout0_19ck100 = 0.9 time = 505
.meas tran vdout0_19ck100 FIND v(dout0_19) AT=505.025n

* CHECK dout0_20 Vdout0_20ck100 = 0 time = 505
.meas tran vdout0_20ck100 FIND v(dout0_20) AT=505.025n

* CHECK dout0_21 Vdout0_21ck100 = 0.9 time = 505
.meas tran vdout0_21ck100 FIND v(dout0_21) AT=505.025n

* CHECK dout0_22 Vdout0_22ck100 = 0.9 time = 505
.meas tran vdout0_22ck100 FIND v(dout0_22) AT=505.025n

* CHECK dout0_23 Vdout0_23ck100 = 0 time = 505
.meas tran vdout0_23ck100 FIND v(dout0_23) AT=505.025n

* CHECK dout0_24 Vdout0_24ck100 = 0 time = 505
.meas tran vdout0_24ck100 FIND v(dout0_24) AT=505.025n

* CHECK dout0_25 Vdout0_25ck100 = 0.9 time = 505
.meas tran vdout0_25ck100 FIND v(dout0_25) AT=505.025n

* CHECK dout0_26 Vdout0_26ck100 = 0.9 time = 505
.meas tran vdout0_26ck100 FIND v(dout0_26) AT=505.025n

* CHECK dout0_27 Vdout0_27ck100 = 0.9 time = 505
.meas tran vdout0_27ck100 FIND v(dout0_27) AT=505.025n

* CHECK dout0_28 Vdout0_28ck100 = 0.9 time = 505
.meas tran vdout0_28ck100 FIND v(dout0_28) AT=505.025n

* CHECK dout0_29 Vdout0_29ck100 = 0.9 time = 505
.meas tran vdout0_29ck100 FIND v(dout0_29) AT=505.025n

* CHECK dout0_30 Vdout0_30ck100 = 0 time = 505
.meas tran vdout0_30ck100 FIND v(dout0_30) AT=505.025n

* CHECK dout0_31 Vdout0_31ck100 = 0 time = 505
.meas tran vdout0_31ck100 FIND v(dout0_31) AT=505.025n

* CHECK dout0_32 Vdout0_32ck100 = 0.9 time = 505
.meas tran vdout0_32ck100 FIND v(dout0_32) AT=505.025n

* CHECK dout0_33 Vdout0_33ck100 = 0.9 time = 505
.meas tran vdout0_33ck100 FIND v(dout0_33) AT=505.025n

* CHECK dout0_34 Vdout0_34ck100 = 0.9 time = 505
.meas tran vdout0_34ck100 FIND v(dout0_34) AT=505.025n

* CHECK dout0_35 Vdout0_35ck100 = 0.9 time = 505
.meas tran vdout0_35ck100 FIND v(dout0_35) AT=505.025n

* CHECK dout0_36 Vdout0_36ck100 = 0.9 time = 505
.meas tran vdout0_36ck100 FIND v(dout0_36) AT=505.025n

* CHECK dout0_37 Vdout0_37ck100 = 0.9 time = 505
.meas tran vdout0_37ck100 FIND v(dout0_37) AT=505.025n

* CHECK dout0_38 Vdout0_38ck100 = 0.9 time = 505
.meas tran vdout0_38ck100 FIND v(dout0_38) AT=505.025n

* CHECK dout0_39 Vdout0_39ck100 = 0 time = 505
.meas tran vdout0_39ck100 FIND v(dout0_39) AT=505.025n

* CHECK dout0_40 Vdout0_40ck100 = 0 time = 505
.meas tran vdout0_40ck100 FIND v(dout0_40) AT=505.025n

* CHECK dout0_41 Vdout0_41ck100 = 0 time = 505
.meas tran vdout0_41ck100 FIND v(dout0_41) AT=505.025n

* CHECK dout0_42 Vdout0_42ck100 = 0.9 time = 505
.meas tran vdout0_42ck100 FIND v(dout0_42) AT=505.025n

* CHECK dout0_43 Vdout0_43ck100 = 0 time = 505
.meas tran vdout0_43ck100 FIND v(dout0_43) AT=505.025n

* CHECK dout0_44 Vdout0_44ck100 = 0.9 time = 505
.meas tran vdout0_44ck100 FIND v(dout0_44) AT=505.025n

* CHECK dout0_45 Vdout0_45ck100 = 0.9 time = 505
.meas tran vdout0_45ck100 FIND v(dout0_45) AT=505.025n

* CHECK dout0_46 Vdout0_46ck100 = 0.9 time = 505
.meas tran vdout0_46ck100 FIND v(dout0_46) AT=505.025n

* CHECK dout0_47 Vdout0_47ck100 = 0 time = 505
.meas tran vdout0_47ck100 FIND v(dout0_47) AT=505.025n

* CHECK dout0_48 Vdout0_48ck100 = 0 time = 505
.meas tran vdout0_48ck100 FIND v(dout0_48) AT=505.025n

* CHECK dout0_49 Vdout0_49ck100 = 0 time = 505
.meas tran vdout0_49ck100 FIND v(dout0_49) AT=505.025n

* CHECK dout0_50 Vdout0_50ck100 = 0 time = 505
.meas tran vdout0_50ck100 FIND v(dout0_50) AT=505.025n

* CHECK dout0_51 Vdout0_51ck100 = 0.9 time = 505
.meas tran vdout0_51ck100 FIND v(dout0_51) AT=505.025n

* CHECK dout0_52 Vdout0_52ck100 = 0 time = 505
.meas tran vdout0_52ck100 FIND v(dout0_52) AT=505.025n

* CHECK dout0_53 Vdout0_53ck100 = 0.9 time = 505
.meas tran vdout0_53ck100 FIND v(dout0_53) AT=505.025n

* CHECK dout0_54 Vdout0_54ck100 = 0 time = 505
.meas tran vdout0_54ck100 FIND v(dout0_54) AT=505.025n

* CHECK dout0_55 Vdout0_55ck100 = 0.9 time = 505
.meas tran vdout0_55ck100 FIND v(dout0_55) AT=505.025n

* CHECK dout0_56 Vdout0_56ck100 = 0.9 time = 505
.meas tran vdout0_56ck100 FIND v(dout0_56) AT=505.025n

* CHECK dout0_57 Vdout0_57ck100 = 0 time = 505
.meas tran vdout0_57ck100 FIND v(dout0_57) AT=505.025n

* CHECK dout0_58 Vdout0_58ck100 = 0.9 time = 505
.meas tran vdout0_58ck100 FIND v(dout0_58) AT=505.025n

* CHECK dout0_59 Vdout0_59ck100 = 0 time = 505
.meas tran vdout0_59ck100 FIND v(dout0_59) AT=505.025n

* CHECK dout0_60 Vdout0_60ck100 = 0 time = 505
.meas tran vdout0_60ck100 FIND v(dout0_60) AT=505.025n

* CHECK dout0_61 Vdout0_61ck100 = 0.9 time = 505
.meas tran vdout0_61ck100 FIND v(dout0_61) AT=505.025n

* CHECK dout0_62 Vdout0_62ck100 = 0 time = 505
.meas tran vdout0_62ck100 FIND v(dout0_62) AT=505.025n

* CHECK dout0_63 Vdout0_63ck100 = 0 time = 505
.meas tran vdout0_63ck100 FIND v(dout0_63) AT=505.025n

* CHECK dout0_0 Vdout0_0ck101 = 0 time = 510
.meas tran vdout0_0ck101 FIND v(dout0_0) AT=510.025n

* CHECK dout0_1 Vdout0_1ck101 = 0.9 time = 510
.meas tran vdout0_1ck101 FIND v(dout0_1) AT=510.025n

* CHECK dout0_2 Vdout0_2ck101 = 0 time = 510
.meas tran vdout0_2ck101 FIND v(dout0_2) AT=510.025n

* CHECK dout0_3 Vdout0_3ck101 = 0.9 time = 510
.meas tran vdout0_3ck101 FIND v(dout0_3) AT=510.025n

* CHECK dout0_4 Vdout0_4ck101 = 0 time = 510
.meas tran vdout0_4ck101 FIND v(dout0_4) AT=510.025n

* CHECK dout0_5 Vdout0_5ck101 = 0 time = 510
.meas tran vdout0_5ck101 FIND v(dout0_5) AT=510.025n

* CHECK dout0_6 Vdout0_6ck101 = 0 time = 510
.meas tran vdout0_6ck101 FIND v(dout0_6) AT=510.025n

* CHECK dout0_7 Vdout0_7ck101 = 0.9 time = 510
.meas tran vdout0_7ck101 FIND v(dout0_7) AT=510.025n

* CHECK dout0_8 Vdout0_8ck101 = 0.9 time = 510
.meas tran vdout0_8ck101 FIND v(dout0_8) AT=510.025n

* CHECK dout0_9 Vdout0_9ck101 = 0 time = 510
.meas tran vdout0_9ck101 FIND v(dout0_9) AT=510.025n

* CHECK dout0_10 Vdout0_10ck101 = 0.9 time = 510
.meas tran vdout0_10ck101 FIND v(dout0_10) AT=510.025n

* CHECK dout0_11 Vdout0_11ck101 = 0.9 time = 510
.meas tran vdout0_11ck101 FIND v(dout0_11) AT=510.025n

* CHECK dout0_12 Vdout0_12ck101 = 0 time = 510
.meas tran vdout0_12ck101 FIND v(dout0_12) AT=510.025n

* CHECK dout0_13 Vdout0_13ck101 = 0.9 time = 510
.meas tran vdout0_13ck101 FIND v(dout0_13) AT=510.025n

* CHECK dout0_14 Vdout0_14ck101 = 0.9 time = 510
.meas tran vdout0_14ck101 FIND v(dout0_14) AT=510.025n

* CHECK dout0_15 Vdout0_15ck101 = 0.9 time = 510
.meas tran vdout0_15ck101 FIND v(dout0_15) AT=510.025n

* CHECK dout0_16 Vdout0_16ck101 = 0 time = 510
.meas tran vdout0_16ck101 FIND v(dout0_16) AT=510.025n

* CHECK dout0_17 Vdout0_17ck101 = 0.9 time = 510
.meas tran vdout0_17ck101 FIND v(dout0_17) AT=510.025n

* CHECK dout0_18 Vdout0_18ck101 = 0 time = 510
.meas tran vdout0_18ck101 FIND v(dout0_18) AT=510.025n

* CHECK dout0_19 Vdout0_19ck101 = 0 time = 510
.meas tran vdout0_19ck101 FIND v(dout0_19) AT=510.025n

* CHECK dout0_20 Vdout0_20ck101 = 0 time = 510
.meas tran vdout0_20ck101 FIND v(dout0_20) AT=510.025n

* CHECK dout0_21 Vdout0_21ck101 = 0.9 time = 510
.meas tran vdout0_21ck101 FIND v(dout0_21) AT=510.025n

* CHECK dout0_22 Vdout0_22ck101 = 0.9 time = 510
.meas tran vdout0_22ck101 FIND v(dout0_22) AT=510.025n

* CHECK dout0_23 Vdout0_23ck101 = 0.9 time = 510
.meas tran vdout0_23ck101 FIND v(dout0_23) AT=510.025n

* CHECK dout0_24 Vdout0_24ck101 = 0 time = 510
.meas tran vdout0_24ck101 FIND v(dout0_24) AT=510.025n

* CHECK dout0_25 Vdout0_25ck101 = 0 time = 510
.meas tran vdout0_25ck101 FIND v(dout0_25) AT=510.025n

* CHECK dout0_26 Vdout0_26ck101 = 0 time = 510
.meas tran vdout0_26ck101 FIND v(dout0_26) AT=510.025n

* CHECK dout0_27 Vdout0_27ck101 = 0.9 time = 510
.meas tran vdout0_27ck101 FIND v(dout0_27) AT=510.025n

* CHECK dout0_28 Vdout0_28ck101 = 0.9 time = 510
.meas tran vdout0_28ck101 FIND v(dout0_28) AT=510.025n

* CHECK dout0_29 Vdout0_29ck101 = 0 time = 510
.meas tran vdout0_29ck101 FIND v(dout0_29) AT=510.025n

* CHECK dout0_30 Vdout0_30ck101 = 0.9 time = 510
.meas tran vdout0_30ck101 FIND v(dout0_30) AT=510.025n

* CHECK dout0_31 Vdout0_31ck101 = 0 time = 510
.meas tran vdout0_31ck101 FIND v(dout0_31) AT=510.025n

* CHECK dout0_32 Vdout0_32ck101 = 0 time = 510
.meas tran vdout0_32ck101 FIND v(dout0_32) AT=510.025n

* CHECK dout0_33 Vdout0_33ck101 = 0.9 time = 510
.meas tran vdout0_33ck101 FIND v(dout0_33) AT=510.025n

* CHECK dout0_34 Vdout0_34ck101 = 0.9 time = 510
.meas tran vdout0_34ck101 FIND v(dout0_34) AT=510.025n

* CHECK dout0_35 Vdout0_35ck101 = 0 time = 510
.meas tran vdout0_35ck101 FIND v(dout0_35) AT=510.025n

* CHECK dout0_36 Vdout0_36ck101 = 0 time = 510
.meas tran vdout0_36ck101 FIND v(dout0_36) AT=510.025n

* CHECK dout0_37 Vdout0_37ck101 = 0.9 time = 510
.meas tran vdout0_37ck101 FIND v(dout0_37) AT=510.025n

* CHECK dout0_38 Vdout0_38ck101 = 0.9 time = 510
.meas tran vdout0_38ck101 FIND v(dout0_38) AT=510.025n

* CHECK dout0_39 Vdout0_39ck101 = 0.9 time = 510
.meas tran vdout0_39ck101 FIND v(dout0_39) AT=510.025n

* CHECK dout0_40 Vdout0_40ck101 = 0 time = 510
.meas tran vdout0_40ck101 FIND v(dout0_40) AT=510.025n

* CHECK dout0_41 Vdout0_41ck101 = 0 time = 510
.meas tran vdout0_41ck101 FIND v(dout0_41) AT=510.025n

* CHECK dout0_42 Vdout0_42ck101 = 0.9 time = 510
.meas tran vdout0_42ck101 FIND v(dout0_42) AT=510.025n

* CHECK dout0_43 Vdout0_43ck101 = 0 time = 510
.meas tran vdout0_43ck101 FIND v(dout0_43) AT=510.025n

* CHECK dout0_44 Vdout0_44ck101 = 0 time = 510
.meas tran vdout0_44ck101 FIND v(dout0_44) AT=510.025n

* CHECK dout0_45 Vdout0_45ck101 = 0.9 time = 510
.meas tran vdout0_45ck101 FIND v(dout0_45) AT=510.025n

* CHECK dout0_46 Vdout0_46ck101 = 0.9 time = 510
.meas tran vdout0_46ck101 FIND v(dout0_46) AT=510.025n

* CHECK dout0_47 Vdout0_47ck101 = 0.9 time = 510
.meas tran vdout0_47ck101 FIND v(dout0_47) AT=510.025n

* CHECK dout0_48 Vdout0_48ck101 = 0 time = 510
.meas tran vdout0_48ck101 FIND v(dout0_48) AT=510.025n

* CHECK dout0_49 Vdout0_49ck101 = 0.9 time = 510
.meas tran vdout0_49ck101 FIND v(dout0_49) AT=510.025n

* CHECK dout0_50 Vdout0_50ck101 = 0 time = 510
.meas tran vdout0_50ck101 FIND v(dout0_50) AT=510.025n

* CHECK dout0_51 Vdout0_51ck101 = 0 time = 510
.meas tran vdout0_51ck101 FIND v(dout0_51) AT=510.025n

* CHECK dout0_52 Vdout0_52ck101 = 0.9 time = 510
.meas tran vdout0_52ck101 FIND v(dout0_52) AT=510.025n

* CHECK dout0_53 Vdout0_53ck101 = 0 time = 510
.meas tran vdout0_53ck101 FIND v(dout0_53) AT=510.025n

* CHECK dout0_54 Vdout0_54ck101 = 0.9 time = 510
.meas tran vdout0_54ck101 FIND v(dout0_54) AT=510.025n

* CHECK dout0_55 Vdout0_55ck101 = 0 time = 510
.meas tran vdout0_55ck101 FIND v(dout0_55) AT=510.025n

* CHECK dout0_56 Vdout0_56ck101 = 0 time = 510
.meas tran vdout0_56ck101 FIND v(dout0_56) AT=510.025n

* CHECK dout0_57 Vdout0_57ck101 = 0 time = 510
.meas tran vdout0_57ck101 FIND v(dout0_57) AT=510.025n

* CHECK dout0_58 Vdout0_58ck101 = 0.9 time = 510
.meas tran vdout0_58ck101 FIND v(dout0_58) AT=510.025n

* CHECK dout0_59 Vdout0_59ck101 = 0 time = 510
.meas tran vdout0_59ck101 FIND v(dout0_59) AT=510.025n

* CHECK dout0_60 Vdout0_60ck101 = 0.9 time = 510
.meas tran vdout0_60ck101 FIND v(dout0_60) AT=510.025n

* CHECK dout0_61 Vdout0_61ck101 = 0.9 time = 510
.meas tran vdout0_61ck101 FIND v(dout0_61) AT=510.025n

* CHECK dout0_62 Vdout0_62ck101 = 0 time = 510
.meas tran vdout0_62ck101 FIND v(dout0_62) AT=510.025n

* CHECK dout0_63 Vdout0_63ck101 = 0 time = 510
.meas tran vdout0_63ck101 FIND v(dout0_63) AT=510.025n

* CHECK dout0_0 Vdout0_0ck102 = 0 time = 515
.meas tran vdout0_0ck102 FIND v(dout0_0) AT=515.025n

* CHECK dout0_1 Vdout0_1ck102 = 0 time = 515
.meas tran vdout0_1ck102 FIND v(dout0_1) AT=515.025n

* CHECK dout0_2 Vdout0_2ck102 = 0 time = 515
.meas tran vdout0_2ck102 FIND v(dout0_2) AT=515.025n

* CHECK dout0_3 Vdout0_3ck102 = 0 time = 515
.meas tran vdout0_3ck102 FIND v(dout0_3) AT=515.025n

* CHECK dout0_4 Vdout0_4ck102 = 0.9 time = 515
.meas tran vdout0_4ck102 FIND v(dout0_4) AT=515.025n

* CHECK dout0_5 Vdout0_5ck102 = 0.9 time = 515
.meas tran vdout0_5ck102 FIND v(dout0_5) AT=515.025n

* CHECK dout0_6 Vdout0_6ck102 = 0 time = 515
.meas tran vdout0_6ck102 FIND v(dout0_6) AT=515.025n

* CHECK dout0_7 Vdout0_7ck102 = 0.9 time = 515
.meas tran vdout0_7ck102 FIND v(dout0_7) AT=515.025n

* CHECK dout0_8 Vdout0_8ck102 = 0 time = 515
.meas tran vdout0_8ck102 FIND v(dout0_8) AT=515.025n

* CHECK dout0_9 Vdout0_9ck102 = 0 time = 515
.meas tran vdout0_9ck102 FIND v(dout0_9) AT=515.025n

* CHECK dout0_10 Vdout0_10ck102 = 0 time = 515
.meas tran vdout0_10ck102 FIND v(dout0_10) AT=515.025n

* CHECK dout0_11 Vdout0_11ck102 = 0.9 time = 515
.meas tran vdout0_11ck102 FIND v(dout0_11) AT=515.025n

* CHECK dout0_12 Vdout0_12ck102 = 0.9 time = 515
.meas tran vdout0_12ck102 FIND v(dout0_12) AT=515.025n

* CHECK dout0_13 Vdout0_13ck102 = 0.9 time = 515
.meas tran vdout0_13ck102 FIND v(dout0_13) AT=515.025n

* CHECK dout0_14 Vdout0_14ck102 = 0.9 time = 515
.meas tran vdout0_14ck102 FIND v(dout0_14) AT=515.025n

* CHECK dout0_15 Vdout0_15ck102 = 0.9 time = 515
.meas tran vdout0_15ck102 FIND v(dout0_15) AT=515.025n

* CHECK dout0_16 Vdout0_16ck102 = 0.9 time = 515
.meas tran vdout0_16ck102 FIND v(dout0_16) AT=515.025n

* CHECK dout0_17 Vdout0_17ck102 = 0 time = 515
.meas tran vdout0_17ck102 FIND v(dout0_17) AT=515.025n

* CHECK dout0_18 Vdout0_18ck102 = 0 time = 515
.meas tran vdout0_18ck102 FIND v(dout0_18) AT=515.025n

* CHECK dout0_19 Vdout0_19ck102 = 0.9 time = 515
.meas tran vdout0_19ck102 FIND v(dout0_19) AT=515.025n

* CHECK dout0_20 Vdout0_20ck102 = 0 time = 515
.meas tran vdout0_20ck102 FIND v(dout0_20) AT=515.025n

* CHECK dout0_21 Vdout0_21ck102 = 0.9 time = 515
.meas tran vdout0_21ck102 FIND v(dout0_21) AT=515.025n

* CHECK dout0_22 Vdout0_22ck102 = 0.9 time = 515
.meas tran vdout0_22ck102 FIND v(dout0_22) AT=515.025n

* CHECK dout0_23 Vdout0_23ck102 = 0 time = 515
.meas tran vdout0_23ck102 FIND v(dout0_23) AT=515.025n

* CHECK dout0_24 Vdout0_24ck102 = 0 time = 515
.meas tran vdout0_24ck102 FIND v(dout0_24) AT=515.025n

* CHECK dout0_25 Vdout0_25ck102 = 0.9 time = 515
.meas tran vdout0_25ck102 FIND v(dout0_25) AT=515.025n

* CHECK dout0_26 Vdout0_26ck102 = 0.9 time = 515
.meas tran vdout0_26ck102 FIND v(dout0_26) AT=515.025n

* CHECK dout0_27 Vdout0_27ck102 = 0.9 time = 515
.meas tran vdout0_27ck102 FIND v(dout0_27) AT=515.025n

* CHECK dout0_28 Vdout0_28ck102 = 0.9 time = 515
.meas tran vdout0_28ck102 FIND v(dout0_28) AT=515.025n

* CHECK dout0_29 Vdout0_29ck102 = 0.9 time = 515
.meas tran vdout0_29ck102 FIND v(dout0_29) AT=515.025n

* CHECK dout0_30 Vdout0_30ck102 = 0 time = 515
.meas tran vdout0_30ck102 FIND v(dout0_30) AT=515.025n

* CHECK dout0_31 Vdout0_31ck102 = 0 time = 515
.meas tran vdout0_31ck102 FIND v(dout0_31) AT=515.025n

* CHECK dout0_32 Vdout0_32ck102 = 0.9 time = 515
.meas tran vdout0_32ck102 FIND v(dout0_32) AT=515.025n

* CHECK dout0_33 Vdout0_33ck102 = 0.9 time = 515
.meas tran vdout0_33ck102 FIND v(dout0_33) AT=515.025n

* CHECK dout0_34 Vdout0_34ck102 = 0.9 time = 515
.meas tran vdout0_34ck102 FIND v(dout0_34) AT=515.025n

* CHECK dout0_35 Vdout0_35ck102 = 0.9 time = 515
.meas tran vdout0_35ck102 FIND v(dout0_35) AT=515.025n

* CHECK dout0_36 Vdout0_36ck102 = 0.9 time = 515
.meas tran vdout0_36ck102 FIND v(dout0_36) AT=515.025n

* CHECK dout0_37 Vdout0_37ck102 = 0.9 time = 515
.meas tran vdout0_37ck102 FIND v(dout0_37) AT=515.025n

* CHECK dout0_38 Vdout0_38ck102 = 0.9 time = 515
.meas tran vdout0_38ck102 FIND v(dout0_38) AT=515.025n

* CHECK dout0_39 Vdout0_39ck102 = 0 time = 515
.meas tran vdout0_39ck102 FIND v(dout0_39) AT=515.025n

* CHECK dout0_40 Vdout0_40ck102 = 0 time = 515
.meas tran vdout0_40ck102 FIND v(dout0_40) AT=515.025n

* CHECK dout0_41 Vdout0_41ck102 = 0 time = 515
.meas tran vdout0_41ck102 FIND v(dout0_41) AT=515.025n

* CHECK dout0_42 Vdout0_42ck102 = 0.9 time = 515
.meas tran vdout0_42ck102 FIND v(dout0_42) AT=515.025n

* CHECK dout0_43 Vdout0_43ck102 = 0 time = 515
.meas tran vdout0_43ck102 FIND v(dout0_43) AT=515.025n

* CHECK dout0_44 Vdout0_44ck102 = 0.9 time = 515
.meas tran vdout0_44ck102 FIND v(dout0_44) AT=515.025n

* CHECK dout0_45 Vdout0_45ck102 = 0.9 time = 515
.meas tran vdout0_45ck102 FIND v(dout0_45) AT=515.025n

* CHECK dout0_46 Vdout0_46ck102 = 0.9 time = 515
.meas tran vdout0_46ck102 FIND v(dout0_46) AT=515.025n

* CHECK dout0_47 Vdout0_47ck102 = 0 time = 515
.meas tran vdout0_47ck102 FIND v(dout0_47) AT=515.025n

* CHECK dout0_48 Vdout0_48ck102 = 0 time = 515
.meas tran vdout0_48ck102 FIND v(dout0_48) AT=515.025n

* CHECK dout0_49 Vdout0_49ck102 = 0 time = 515
.meas tran vdout0_49ck102 FIND v(dout0_49) AT=515.025n

* CHECK dout0_50 Vdout0_50ck102 = 0 time = 515
.meas tran vdout0_50ck102 FIND v(dout0_50) AT=515.025n

* CHECK dout0_51 Vdout0_51ck102 = 0.9 time = 515
.meas tran vdout0_51ck102 FIND v(dout0_51) AT=515.025n

* CHECK dout0_52 Vdout0_52ck102 = 0 time = 515
.meas tran vdout0_52ck102 FIND v(dout0_52) AT=515.025n

* CHECK dout0_53 Vdout0_53ck102 = 0.9 time = 515
.meas tran vdout0_53ck102 FIND v(dout0_53) AT=515.025n

* CHECK dout0_54 Vdout0_54ck102 = 0 time = 515
.meas tran vdout0_54ck102 FIND v(dout0_54) AT=515.025n

* CHECK dout0_55 Vdout0_55ck102 = 0.9 time = 515
.meas tran vdout0_55ck102 FIND v(dout0_55) AT=515.025n

* CHECK dout0_56 Vdout0_56ck102 = 0.9 time = 515
.meas tran vdout0_56ck102 FIND v(dout0_56) AT=515.025n

* CHECK dout0_57 Vdout0_57ck102 = 0 time = 515
.meas tran vdout0_57ck102 FIND v(dout0_57) AT=515.025n

* CHECK dout0_58 Vdout0_58ck102 = 0.9 time = 515
.meas tran vdout0_58ck102 FIND v(dout0_58) AT=515.025n

* CHECK dout0_59 Vdout0_59ck102 = 0 time = 515
.meas tran vdout0_59ck102 FIND v(dout0_59) AT=515.025n

* CHECK dout0_60 Vdout0_60ck102 = 0 time = 515
.meas tran vdout0_60ck102 FIND v(dout0_60) AT=515.025n

* CHECK dout0_61 Vdout0_61ck102 = 0.9 time = 515
.meas tran vdout0_61ck102 FIND v(dout0_61) AT=515.025n

* CHECK dout0_62 Vdout0_62ck102 = 0 time = 515
.meas tran vdout0_62ck102 FIND v(dout0_62) AT=515.025n

* CHECK dout0_63 Vdout0_63ck102 = 0 time = 515
.meas tran vdout0_63ck102 FIND v(dout0_63) AT=515.025n

* CHECK dout0_0 Vdout0_0ck106 = 0 time = 535
.meas tran vdout0_0ck106 FIND v(dout0_0) AT=535.025n

* CHECK dout0_1 Vdout0_1ck106 = 0 time = 535
.meas tran vdout0_1ck106 FIND v(dout0_1) AT=535.025n

* CHECK dout0_2 Vdout0_2ck106 = 0.9 time = 535
.meas tran vdout0_2ck106 FIND v(dout0_2) AT=535.025n

* CHECK dout0_3 Vdout0_3ck106 = 0.9 time = 535
.meas tran vdout0_3ck106 FIND v(dout0_3) AT=535.025n

* CHECK dout0_4 Vdout0_4ck106 = 0.9 time = 535
.meas tran vdout0_4ck106 FIND v(dout0_4) AT=535.025n

* CHECK dout0_5 Vdout0_5ck106 = 0 time = 535
.meas tran vdout0_5ck106 FIND v(dout0_5) AT=535.025n

* CHECK dout0_6 Vdout0_6ck106 = 0.9 time = 535
.meas tran vdout0_6ck106 FIND v(dout0_6) AT=535.025n

* CHECK dout0_7 Vdout0_7ck106 = 0 time = 535
.meas tran vdout0_7ck106 FIND v(dout0_7) AT=535.025n

* CHECK dout0_8 Vdout0_8ck106 = 0 time = 535
.meas tran vdout0_8ck106 FIND v(dout0_8) AT=535.025n

* CHECK dout0_9 Vdout0_9ck106 = 0.9 time = 535
.meas tran vdout0_9ck106 FIND v(dout0_9) AT=535.025n

* CHECK dout0_10 Vdout0_10ck106 = 0.9 time = 535
.meas tran vdout0_10ck106 FIND v(dout0_10) AT=535.025n

* CHECK dout0_11 Vdout0_11ck106 = 0 time = 535
.meas tran vdout0_11ck106 FIND v(dout0_11) AT=535.025n

* CHECK dout0_12 Vdout0_12ck106 = 0.9 time = 535
.meas tran vdout0_12ck106 FIND v(dout0_12) AT=535.025n

* CHECK dout0_13 Vdout0_13ck106 = 0 time = 535
.meas tran vdout0_13ck106 FIND v(dout0_13) AT=535.025n

* CHECK dout0_14 Vdout0_14ck106 = 0 time = 535
.meas tran vdout0_14ck106 FIND v(dout0_14) AT=535.025n

* CHECK dout0_15 Vdout0_15ck106 = 0.9 time = 535
.meas tran vdout0_15ck106 FIND v(dout0_15) AT=535.025n

* CHECK dout0_16 Vdout0_16ck106 = 0 time = 535
.meas tran vdout0_16ck106 FIND v(dout0_16) AT=535.025n

* CHECK dout0_17 Vdout0_17ck106 = 0.9 time = 535
.meas tran vdout0_17ck106 FIND v(dout0_17) AT=535.025n

* CHECK dout0_18 Vdout0_18ck106 = 0.9 time = 535
.meas tran vdout0_18ck106 FIND v(dout0_18) AT=535.025n

* CHECK dout0_19 Vdout0_19ck106 = 0 time = 535
.meas tran vdout0_19ck106 FIND v(dout0_19) AT=535.025n

* CHECK dout0_20 Vdout0_20ck106 = 0.9 time = 535
.meas tran vdout0_20ck106 FIND v(dout0_20) AT=535.025n

* CHECK dout0_21 Vdout0_21ck106 = 0 time = 535
.meas tran vdout0_21ck106 FIND v(dout0_21) AT=535.025n

* CHECK dout0_22 Vdout0_22ck106 = 0 time = 535
.meas tran vdout0_22ck106 FIND v(dout0_22) AT=535.025n

* CHECK dout0_23 Vdout0_23ck106 = 0 time = 535
.meas tran vdout0_23ck106 FIND v(dout0_23) AT=535.025n

* CHECK dout0_24 Vdout0_24ck106 = 0.9 time = 535
.meas tran vdout0_24ck106 FIND v(dout0_24) AT=535.025n

* CHECK dout0_25 Vdout0_25ck106 = 0 time = 535
.meas tran vdout0_25ck106 FIND v(dout0_25) AT=535.025n

* CHECK dout0_26 Vdout0_26ck106 = 0.9 time = 535
.meas tran vdout0_26ck106 FIND v(dout0_26) AT=535.025n

* CHECK dout0_27 Vdout0_27ck106 = 0 time = 535
.meas tran vdout0_27ck106 FIND v(dout0_27) AT=535.025n

* CHECK dout0_28 Vdout0_28ck106 = 0 time = 535
.meas tran vdout0_28ck106 FIND v(dout0_28) AT=535.025n

* CHECK dout0_29 Vdout0_29ck106 = 0.9 time = 535
.meas tran vdout0_29ck106 FIND v(dout0_29) AT=535.025n

* CHECK dout0_30 Vdout0_30ck106 = 0.9 time = 535
.meas tran vdout0_30ck106 FIND v(dout0_30) AT=535.025n

* CHECK dout0_31 Vdout0_31ck106 = 0.9 time = 535
.meas tran vdout0_31ck106 FIND v(dout0_31) AT=535.025n

* CHECK dout0_32 Vdout0_32ck106 = 0 time = 535
.meas tran vdout0_32ck106 FIND v(dout0_32) AT=535.025n

* CHECK dout0_33 Vdout0_33ck106 = 0 time = 535
.meas tran vdout0_33ck106 FIND v(dout0_33) AT=535.025n

* CHECK dout0_34 Vdout0_34ck106 = 0 time = 535
.meas tran vdout0_34ck106 FIND v(dout0_34) AT=535.025n

* CHECK dout0_35 Vdout0_35ck106 = 0.9 time = 535
.meas tran vdout0_35ck106 FIND v(dout0_35) AT=535.025n

* CHECK dout0_36 Vdout0_36ck106 = 0.9 time = 535
.meas tran vdout0_36ck106 FIND v(dout0_36) AT=535.025n

* CHECK dout0_37 Vdout0_37ck106 = 0.9 time = 535
.meas tran vdout0_37ck106 FIND v(dout0_37) AT=535.025n

* CHECK dout0_38 Vdout0_38ck106 = 0 time = 535
.meas tran vdout0_38ck106 FIND v(dout0_38) AT=535.025n

* CHECK dout0_39 Vdout0_39ck106 = 0 time = 535
.meas tran vdout0_39ck106 FIND v(dout0_39) AT=535.025n

* CHECK dout0_40 Vdout0_40ck106 = 0 time = 535
.meas tran vdout0_40ck106 FIND v(dout0_40) AT=535.025n

* CHECK dout0_41 Vdout0_41ck106 = 0 time = 535
.meas tran vdout0_41ck106 FIND v(dout0_41) AT=535.025n

* CHECK dout0_42 Vdout0_42ck106 = 0.9 time = 535
.meas tran vdout0_42ck106 FIND v(dout0_42) AT=535.025n

* CHECK dout0_43 Vdout0_43ck106 = 0.9 time = 535
.meas tran vdout0_43ck106 FIND v(dout0_43) AT=535.025n

* CHECK dout0_44 Vdout0_44ck106 = 0 time = 535
.meas tran vdout0_44ck106 FIND v(dout0_44) AT=535.025n

* CHECK dout0_45 Vdout0_45ck106 = 0 time = 535
.meas tran vdout0_45ck106 FIND v(dout0_45) AT=535.025n

* CHECK dout0_46 Vdout0_46ck106 = 0.9 time = 535
.meas tran vdout0_46ck106 FIND v(dout0_46) AT=535.025n

* CHECK dout0_47 Vdout0_47ck106 = 0.9 time = 535
.meas tran vdout0_47ck106 FIND v(dout0_47) AT=535.025n

* CHECK dout0_48 Vdout0_48ck106 = 0.9 time = 535
.meas tran vdout0_48ck106 FIND v(dout0_48) AT=535.025n

* CHECK dout0_49 Vdout0_49ck106 = 0.9 time = 535
.meas tran vdout0_49ck106 FIND v(dout0_49) AT=535.025n

* CHECK dout0_50 Vdout0_50ck106 = 0.9 time = 535
.meas tran vdout0_50ck106 FIND v(dout0_50) AT=535.025n

* CHECK dout0_51 Vdout0_51ck106 = 0 time = 535
.meas tran vdout0_51ck106 FIND v(dout0_51) AT=535.025n

* CHECK dout0_52 Vdout0_52ck106 = 0 time = 535
.meas tran vdout0_52ck106 FIND v(dout0_52) AT=535.025n

* CHECK dout0_53 Vdout0_53ck106 = 0 time = 535
.meas tran vdout0_53ck106 FIND v(dout0_53) AT=535.025n

* CHECK dout0_54 Vdout0_54ck106 = 0.9 time = 535
.meas tran vdout0_54ck106 FIND v(dout0_54) AT=535.025n

* CHECK dout0_55 Vdout0_55ck106 = 0 time = 535
.meas tran vdout0_55ck106 FIND v(dout0_55) AT=535.025n

* CHECK dout0_56 Vdout0_56ck106 = 0.9 time = 535
.meas tran vdout0_56ck106 FIND v(dout0_56) AT=535.025n

* CHECK dout0_57 Vdout0_57ck106 = 0.9 time = 535
.meas tran vdout0_57ck106 FIND v(dout0_57) AT=535.025n

* CHECK dout0_58 Vdout0_58ck106 = 0.9 time = 535
.meas tran vdout0_58ck106 FIND v(dout0_58) AT=535.025n

* CHECK dout0_59 Vdout0_59ck106 = 0 time = 535
.meas tran vdout0_59ck106 FIND v(dout0_59) AT=535.025n

* CHECK dout0_60 Vdout0_60ck106 = 0 time = 535
.meas tran vdout0_60ck106 FIND v(dout0_60) AT=535.025n

* CHECK dout0_61 Vdout0_61ck106 = 0 time = 535
.meas tran vdout0_61ck106 FIND v(dout0_61) AT=535.025n

* CHECK dout0_62 Vdout0_62ck106 = 0.9 time = 535
.meas tran vdout0_62ck106 FIND v(dout0_62) AT=535.025n

* CHECK dout0_63 Vdout0_63ck106 = 0.9 time = 535
.meas tran vdout0_63ck106 FIND v(dout0_63) AT=535.025n

* CHECK dout0_0 Vdout0_0ck108 = 0 time = 545
.meas tran vdout0_0ck108 FIND v(dout0_0) AT=545.025n

* CHECK dout0_1 Vdout0_1ck108 = 0 time = 545
.meas tran vdout0_1ck108 FIND v(dout0_1) AT=545.025n

* CHECK dout0_2 Vdout0_2ck108 = 0 time = 545
.meas tran vdout0_2ck108 FIND v(dout0_2) AT=545.025n

* CHECK dout0_3 Vdout0_3ck108 = 0 time = 545
.meas tran vdout0_3ck108 FIND v(dout0_3) AT=545.025n

* CHECK dout0_4 Vdout0_4ck108 = 0.9 time = 545
.meas tran vdout0_4ck108 FIND v(dout0_4) AT=545.025n

* CHECK dout0_5 Vdout0_5ck108 = 0.9 time = 545
.meas tran vdout0_5ck108 FIND v(dout0_5) AT=545.025n

* CHECK dout0_6 Vdout0_6ck108 = 0 time = 545
.meas tran vdout0_6ck108 FIND v(dout0_6) AT=545.025n

* CHECK dout0_7 Vdout0_7ck108 = 0.9 time = 545
.meas tran vdout0_7ck108 FIND v(dout0_7) AT=545.025n

* CHECK dout0_8 Vdout0_8ck108 = 0 time = 545
.meas tran vdout0_8ck108 FIND v(dout0_8) AT=545.025n

* CHECK dout0_9 Vdout0_9ck108 = 0 time = 545
.meas tran vdout0_9ck108 FIND v(dout0_9) AT=545.025n

* CHECK dout0_10 Vdout0_10ck108 = 0 time = 545
.meas tran vdout0_10ck108 FIND v(dout0_10) AT=545.025n

* CHECK dout0_11 Vdout0_11ck108 = 0.9 time = 545
.meas tran vdout0_11ck108 FIND v(dout0_11) AT=545.025n

* CHECK dout0_12 Vdout0_12ck108 = 0.9 time = 545
.meas tran vdout0_12ck108 FIND v(dout0_12) AT=545.025n

* CHECK dout0_13 Vdout0_13ck108 = 0.9 time = 545
.meas tran vdout0_13ck108 FIND v(dout0_13) AT=545.025n

* CHECK dout0_14 Vdout0_14ck108 = 0.9 time = 545
.meas tran vdout0_14ck108 FIND v(dout0_14) AT=545.025n

* CHECK dout0_15 Vdout0_15ck108 = 0.9 time = 545
.meas tran vdout0_15ck108 FIND v(dout0_15) AT=545.025n

* CHECK dout0_16 Vdout0_16ck108 = 0.9 time = 545
.meas tran vdout0_16ck108 FIND v(dout0_16) AT=545.025n

* CHECK dout0_17 Vdout0_17ck108 = 0 time = 545
.meas tran vdout0_17ck108 FIND v(dout0_17) AT=545.025n

* CHECK dout0_18 Vdout0_18ck108 = 0 time = 545
.meas tran vdout0_18ck108 FIND v(dout0_18) AT=545.025n

* CHECK dout0_19 Vdout0_19ck108 = 0.9 time = 545
.meas tran vdout0_19ck108 FIND v(dout0_19) AT=545.025n

* CHECK dout0_20 Vdout0_20ck108 = 0 time = 545
.meas tran vdout0_20ck108 FIND v(dout0_20) AT=545.025n

* CHECK dout0_21 Vdout0_21ck108 = 0.9 time = 545
.meas tran vdout0_21ck108 FIND v(dout0_21) AT=545.025n

* CHECK dout0_22 Vdout0_22ck108 = 0.9 time = 545
.meas tran vdout0_22ck108 FIND v(dout0_22) AT=545.025n

* CHECK dout0_23 Vdout0_23ck108 = 0 time = 545
.meas tran vdout0_23ck108 FIND v(dout0_23) AT=545.025n

* CHECK dout0_24 Vdout0_24ck108 = 0 time = 545
.meas tran vdout0_24ck108 FIND v(dout0_24) AT=545.025n

* CHECK dout0_25 Vdout0_25ck108 = 0.9 time = 545
.meas tran vdout0_25ck108 FIND v(dout0_25) AT=545.025n

* CHECK dout0_26 Vdout0_26ck108 = 0.9 time = 545
.meas tran vdout0_26ck108 FIND v(dout0_26) AT=545.025n

* CHECK dout0_27 Vdout0_27ck108 = 0.9 time = 545
.meas tran vdout0_27ck108 FIND v(dout0_27) AT=545.025n

* CHECK dout0_28 Vdout0_28ck108 = 0.9 time = 545
.meas tran vdout0_28ck108 FIND v(dout0_28) AT=545.025n

* CHECK dout0_29 Vdout0_29ck108 = 0.9 time = 545
.meas tran vdout0_29ck108 FIND v(dout0_29) AT=545.025n

* CHECK dout0_30 Vdout0_30ck108 = 0 time = 545
.meas tran vdout0_30ck108 FIND v(dout0_30) AT=545.025n

* CHECK dout0_31 Vdout0_31ck108 = 0 time = 545
.meas tran vdout0_31ck108 FIND v(dout0_31) AT=545.025n

* CHECK dout0_32 Vdout0_32ck108 = 0.9 time = 545
.meas tran vdout0_32ck108 FIND v(dout0_32) AT=545.025n

* CHECK dout0_33 Vdout0_33ck108 = 0.9 time = 545
.meas tran vdout0_33ck108 FIND v(dout0_33) AT=545.025n

* CHECK dout0_34 Vdout0_34ck108 = 0.9 time = 545
.meas tran vdout0_34ck108 FIND v(dout0_34) AT=545.025n

* CHECK dout0_35 Vdout0_35ck108 = 0.9 time = 545
.meas tran vdout0_35ck108 FIND v(dout0_35) AT=545.025n

* CHECK dout0_36 Vdout0_36ck108 = 0.9 time = 545
.meas tran vdout0_36ck108 FIND v(dout0_36) AT=545.025n

* CHECK dout0_37 Vdout0_37ck108 = 0.9 time = 545
.meas tran vdout0_37ck108 FIND v(dout0_37) AT=545.025n

* CHECK dout0_38 Vdout0_38ck108 = 0.9 time = 545
.meas tran vdout0_38ck108 FIND v(dout0_38) AT=545.025n

* CHECK dout0_39 Vdout0_39ck108 = 0 time = 545
.meas tran vdout0_39ck108 FIND v(dout0_39) AT=545.025n

* CHECK dout0_40 Vdout0_40ck108 = 0 time = 545
.meas tran vdout0_40ck108 FIND v(dout0_40) AT=545.025n

* CHECK dout0_41 Vdout0_41ck108 = 0 time = 545
.meas tran vdout0_41ck108 FIND v(dout0_41) AT=545.025n

* CHECK dout0_42 Vdout0_42ck108 = 0.9 time = 545
.meas tran vdout0_42ck108 FIND v(dout0_42) AT=545.025n

* CHECK dout0_43 Vdout0_43ck108 = 0 time = 545
.meas tran vdout0_43ck108 FIND v(dout0_43) AT=545.025n

* CHECK dout0_44 Vdout0_44ck108 = 0.9 time = 545
.meas tran vdout0_44ck108 FIND v(dout0_44) AT=545.025n

* CHECK dout0_45 Vdout0_45ck108 = 0.9 time = 545
.meas tran vdout0_45ck108 FIND v(dout0_45) AT=545.025n

* CHECK dout0_46 Vdout0_46ck108 = 0.9 time = 545
.meas tran vdout0_46ck108 FIND v(dout0_46) AT=545.025n

* CHECK dout0_47 Vdout0_47ck108 = 0 time = 545
.meas tran vdout0_47ck108 FIND v(dout0_47) AT=545.025n

* CHECK dout0_48 Vdout0_48ck108 = 0 time = 545
.meas tran vdout0_48ck108 FIND v(dout0_48) AT=545.025n

* CHECK dout0_49 Vdout0_49ck108 = 0 time = 545
.meas tran vdout0_49ck108 FIND v(dout0_49) AT=545.025n

* CHECK dout0_50 Vdout0_50ck108 = 0 time = 545
.meas tran vdout0_50ck108 FIND v(dout0_50) AT=545.025n

* CHECK dout0_51 Vdout0_51ck108 = 0.9 time = 545
.meas tran vdout0_51ck108 FIND v(dout0_51) AT=545.025n

* CHECK dout0_52 Vdout0_52ck108 = 0 time = 545
.meas tran vdout0_52ck108 FIND v(dout0_52) AT=545.025n

* CHECK dout0_53 Vdout0_53ck108 = 0.9 time = 545
.meas tran vdout0_53ck108 FIND v(dout0_53) AT=545.025n

* CHECK dout0_54 Vdout0_54ck108 = 0 time = 545
.meas tran vdout0_54ck108 FIND v(dout0_54) AT=545.025n

* CHECK dout0_55 Vdout0_55ck108 = 0.9 time = 545
.meas tran vdout0_55ck108 FIND v(dout0_55) AT=545.025n

* CHECK dout0_56 Vdout0_56ck108 = 0.9 time = 545
.meas tran vdout0_56ck108 FIND v(dout0_56) AT=545.025n

* CHECK dout0_57 Vdout0_57ck108 = 0 time = 545
.meas tran vdout0_57ck108 FIND v(dout0_57) AT=545.025n

* CHECK dout0_58 Vdout0_58ck108 = 0.9 time = 545
.meas tran vdout0_58ck108 FIND v(dout0_58) AT=545.025n

* CHECK dout0_59 Vdout0_59ck108 = 0 time = 545
.meas tran vdout0_59ck108 FIND v(dout0_59) AT=545.025n

* CHECK dout0_60 Vdout0_60ck108 = 0 time = 545
.meas tran vdout0_60ck108 FIND v(dout0_60) AT=545.025n

* CHECK dout0_61 Vdout0_61ck108 = 0.9 time = 545
.meas tran vdout0_61ck108 FIND v(dout0_61) AT=545.025n

* CHECK dout0_62 Vdout0_62ck108 = 0 time = 545
.meas tran vdout0_62ck108 FIND v(dout0_62) AT=545.025n

* CHECK dout0_63 Vdout0_63ck108 = 0 time = 545
.meas tran vdout0_63ck108 FIND v(dout0_63) AT=545.025n

* CHECK dout0_0 Vdout0_0ck110 = 0 time = 555
.meas tran vdout0_0ck110 FIND v(dout0_0) AT=555.025n

* CHECK dout0_1 Vdout0_1ck110 = 0.9 time = 555
.meas tran vdout0_1ck110 FIND v(dout0_1) AT=555.025n

* CHECK dout0_2 Vdout0_2ck110 = 0 time = 555
.meas tran vdout0_2ck110 FIND v(dout0_2) AT=555.025n

* CHECK dout0_3 Vdout0_3ck110 = 0.9 time = 555
.meas tran vdout0_3ck110 FIND v(dout0_3) AT=555.025n

* CHECK dout0_4 Vdout0_4ck110 = 0 time = 555
.meas tran vdout0_4ck110 FIND v(dout0_4) AT=555.025n

* CHECK dout0_5 Vdout0_5ck110 = 0 time = 555
.meas tran vdout0_5ck110 FIND v(dout0_5) AT=555.025n

* CHECK dout0_6 Vdout0_6ck110 = 0.9 time = 555
.meas tran vdout0_6ck110 FIND v(dout0_6) AT=555.025n

* CHECK dout0_7 Vdout0_7ck110 = 0 time = 555
.meas tran vdout0_7ck110 FIND v(dout0_7) AT=555.025n

* CHECK dout0_8 Vdout0_8ck110 = 0.9 time = 555
.meas tran vdout0_8ck110 FIND v(dout0_8) AT=555.025n

* CHECK dout0_9 Vdout0_9ck110 = 0.9 time = 555
.meas tran vdout0_9ck110 FIND v(dout0_9) AT=555.025n

* CHECK dout0_10 Vdout0_10ck110 = 0 time = 555
.meas tran vdout0_10ck110 FIND v(dout0_10) AT=555.025n

* CHECK dout0_11 Vdout0_11ck110 = 0.9 time = 555
.meas tran vdout0_11ck110 FIND v(dout0_11) AT=555.025n

* CHECK dout0_12 Vdout0_12ck110 = 0.9 time = 555
.meas tran vdout0_12ck110 FIND v(dout0_12) AT=555.025n

* CHECK dout0_13 Vdout0_13ck110 = 0 time = 555
.meas tran vdout0_13ck110 FIND v(dout0_13) AT=555.025n

* CHECK dout0_14 Vdout0_14ck110 = 0 time = 555
.meas tran vdout0_14ck110 FIND v(dout0_14) AT=555.025n

* CHECK dout0_15 Vdout0_15ck110 = 0 time = 555
.meas tran vdout0_15ck110 FIND v(dout0_15) AT=555.025n

* CHECK dout0_16 Vdout0_16ck110 = 0.9 time = 555
.meas tran vdout0_16ck110 FIND v(dout0_16) AT=555.025n

* CHECK dout0_17 Vdout0_17ck110 = 0.9 time = 555
.meas tran vdout0_17ck110 FIND v(dout0_17) AT=555.025n

* CHECK dout0_18 Vdout0_18ck110 = 0 time = 555
.meas tran vdout0_18ck110 FIND v(dout0_18) AT=555.025n

* CHECK dout0_19 Vdout0_19ck110 = 0 time = 555
.meas tran vdout0_19ck110 FIND v(dout0_19) AT=555.025n

* CHECK dout0_20 Vdout0_20ck110 = 0.9 time = 555
.meas tran vdout0_20ck110 FIND v(dout0_20) AT=555.025n

* CHECK dout0_21 Vdout0_21ck110 = 0.9 time = 555
.meas tran vdout0_21ck110 FIND v(dout0_21) AT=555.025n

* CHECK dout0_22 Vdout0_22ck110 = 0.9 time = 555
.meas tran vdout0_22ck110 FIND v(dout0_22) AT=555.025n

* CHECK dout0_23 Vdout0_23ck110 = 0.9 time = 555
.meas tran vdout0_23ck110 FIND v(dout0_23) AT=555.025n

* CHECK dout0_24 Vdout0_24ck110 = 0 time = 555
.meas tran vdout0_24ck110 FIND v(dout0_24) AT=555.025n

* CHECK dout0_25 Vdout0_25ck110 = 0.9 time = 555
.meas tran vdout0_25ck110 FIND v(dout0_25) AT=555.025n

* CHECK dout0_26 Vdout0_26ck110 = 0.9 time = 555
.meas tran vdout0_26ck110 FIND v(dout0_26) AT=555.025n

* CHECK dout0_27 Vdout0_27ck110 = 0.9 time = 555
.meas tran vdout0_27ck110 FIND v(dout0_27) AT=555.025n

* CHECK dout0_28 Vdout0_28ck110 = 0 time = 555
.meas tran vdout0_28ck110 FIND v(dout0_28) AT=555.025n

* CHECK dout0_29 Vdout0_29ck110 = 0 time = 555
.meas tran vdout0_29ck110 FIND v(dout0_29) AT=555.025n

* CHECK dout0_30 Vdout0_30ck110 = 0 time = 555
.meas tran vdout0_30ck110 FIND v(dout0_30) AT=555.025n

* CHECK dout0_31 Vdout0_31ck110 = 0.9 time = 555
.meas tran vdout0_31ck110 FIND v(dout0_31) AT=555.025n

* CHECK dout0_32 Vdout0_32ck110 = 0.9 time = 555
.meas tran vdout0_32ck110 FIND v(dout0_32) AT=555.025n

* CHECK dout0_33 Vdout0_33ck110 = 0 time = 555
.meas tran vdout0_33ck110 FIND v(dout0_33) AT=555.025n

* CHECK dout0_34 Vdout0_34ck110 = 0.9 time = 555
.meas tran vdout0_34ck110 FIND v(dout0_34) AT=555.025n

* CHECK dout0_35 Vdout0_35ck110 = 0 time = 555
.meas tran vdout0_35ck110 FIND v(dout0_35) AT=555.025n

* CHECK dout0_36 Vdout0_36ck110 = 0 time = 555
.meas tran vdout0_36ck110 FIND v(dout0_36) AT=555.025n

* CHECK dout0_37 Vdout0_37ck110 = 0.9 time = 555
.meas tran vdout0_37ck110 FIND v(dout0_37) AT=555.025n

* CHECK dout0_38 Vdout0_38ck110 = 0.9 time = 555
.meas tran vdout0_38ck110 FIND v(dout0_38) AT=555.025n

* CHECK dout0_39 Vdout0_39ck110 = 0.9 time = 555
.meas tran vdout0_39ck110 FIND v(dout0_39) AT=555.025n

* CHECK dout0_40 Vdout0_40ck110 = 0 time = 555
.meas tran vdout0_40ck110 FIND v(dout0_40) AT=555.025n

* CHECK dout0_41 Vdout0_41ck110 = 0.9 time = 555
.meas tran vdout0_41ck110 FIND v(dout0_41) AT=555.025n

* CHECK dout0_42 Vdout0_42ck110 = 0 time = 555
.meas tran vdout0_42ck110 FIND v(dout0_42) AT=555.025n

* CHECK dout0_43 Vdout0_43ck110 = 0.9 time = 555
.meas tran vdout0_43ck110 FIND v(dout0_43) AT=555.025n

* CHECK dout0_44 Vdout0_44ck110 = 0.9 time = 555
.meas tran vdout0_44ck110 FIND v(dout0_44) AT=555.025n

* CHECK dout0_45 Vdout0_45ck110 = 0.9 time = 555
.meas tran vdout0_45ck110 FIND v(dout0_45) AT=555.025n

* CHECK dout0_46 Vdout0_46ck110 = 0.9 time = 555
.meas tran vdout0_46ck110 FIND v(dout0_46) AT=555.025n

* CHECK dout0_47 Vdout0_47ck110 = 0 time = 555
.meas tran vdout0_47ck110 FIND v(dout0_47) AT=555.025n

* CHECK dout0_48 Vdout0_48ck110 = 0.9 time = 555
.meas tran vdout0_48ck110 FIND v(dout0_48) AT=555.025n

* CHECK dout0_49 Vdout0_49ck110 = 0.9 time = 555
.meas tran vdout0_49ck110 FIND v(dout0_49) AT=555.025n

* CHECK dout0_50 Vdout0_50ck110 = 0 time = 555
.meas tran vdout0_50ck110 FIND v(dout0_50) AT=555.025n

* CHECK dout0_51 Vdout0_51ck110 = 0.9 time = 555
.meas tran vdout0_51ck110 FIND v(dout0_51) AT=555.025n

* CHECK dout0_52 Vdout0_52ck110 = 0 time = 555
.meas tran vdout0_52ck110 FIND v(dout0_52) AT=555.025n

* CHECK dout0_53 Vdout0_53ck110 = 0.9 time = 555
.meas tran vdout0_53ck110 FIND v(dout0_53) AT=555.025n

* CHECK dout0_54 Vdout0_54ck110 = 0.9 time = 555
.meas tran vdout0_54ck110 FIND v(dout0_54) AT=555.025n

* CHECK dout0_55 Vdout0_55ck110 = 0 time = 555
.meas tran vdout0_55ck110 FIND v(dout0_55) AT=555.025n

* CHECK dout0_56 Vdout0_56ck110 = 0 time = 555
.meas tran vdout0_56ck110 FIND v(dout0_56) AT=555.025n

* CHECK dout0_57 Vdout0_57ck110 = 0.9 time = 555
.meas tran vdout0_57ck110 FIND v(dout0_57) AT=555.025n

* CHECK dout0_58 Vdout0_58ck110 = 0.9 time = 555
.meas tran vdout0_58ck110 FIND v(dout0_58) AT=555.025n

* CHECK dout0_59 Vdout0_59ck110 = 0.9 time = 555
.meas tran vdout0_59ck110 FIND v(dout0_59) AT=555.025n

* CHECK dout0_60 Vdout0_60ck110 = 0.9 time = 555
.meas tran vdout0_60ck110 FIND v(dout0_60) AT=555.025n

* CHECK dout0_61 Vdout0_61ck110 = 0 time = 555
.meas tran vdout0_61ck110 FIND v(dout0_61) AT=555.025n

* CHECK dout0_62 Vdout0_62ck110 = 0 time = 555
.meas tran vdout0_62ck110 FIND v(dout0_62) AT=555.025n

* CHECK dout0_63 Vdout0_63ck110 = 0 time = 555
.meas tran vdout0_63ck110 FIND v(dout0_63) AT=555.025n

* CHECK dout0_0 Vdout0_0ck116 = 0 time = 585
.meas tran vdout0_0ck116 FIND v(dout0_0) AT=585.025n

* CHECK dout0_1 Vdout0_1ck116 = 0.9 time = 585
.meas tran vdout0_1ck116 FIND v(dout0_1) AT=585.025n

* CHECK dout0_2 Vdout0_2ck116 = 0 time = 585
.meas tran vdout0_2ck116 FIND v(dout0_2) AT=585.025n

* CHECK dout0_3 Vdout0_3ck116 = 0.9 time = 585
.meas tran vdout0_3ck116 FIND v(dout0_3) AT=585.025n

* CHECK dout0_4 Vdout0_4ck116 = 0 time = 585
.meas tran vdout0_4ck116 FIND v(dout0_4) AT=585.025n

* CHECK dout0_5 Vdout0_5ck116 = 0 time = 585
.meas tran vdout0_5ck116 FIND v(dout0_5) AT=585.025n

* CHECK dout0_6 Vdout0_6ck116 = 0 time = 585
.meas tran vdout0_6ck116 FIND v(dout0_6) AT=585.025n

* CHECK dout0_7 Vdout0_7ck116 = 0.9 time = 585
.meas tran vdout0_7ck116 FIND v(dout0_7) AT=585.025n

* CHECK dout0_8 Vdout0_8ck116 = 0.9 time = 585
.meas tran vdout0_8ck116 FIND v(dout0_8) AT=585.025n

* CHECK dout0_9 Vdout0_9ck116 = 0 time = 585
.meas tran vdout0_9ck116 FIND v(dout0_9) AT=585.025n

* CHECK dout0_10 Vdout0_10ck116 = 0.9 time = 585
.meas tran vdout0_10ck116 FIND v(dout0_10) AT=585.025n

* CHECK dout0_11 Vdout0_11ck116 = 0.9 time = 585
.meas tran vdout0_11ck116 FIND v(dout0_11) AT=585.025n

* CHECK dout0_12 Vdout0_12ck116 = 0 time = 585
.meas tran vdout0_12ck116 FIND v(dout0_12) AT=585.025n

* CHECK dout0_13 Vdout0_13ck116 = 0.9 time = 585
.meas tran vdout0_13ck116 FIND v(dout0_13) AT=585.025n

* CHECK dout0_14 Vdout0_14ck116 = 0.9 time = 585
.meas tran vdout0_14ck116 FIND v(dout0_14) AT=585.025n

* CHECK dout0_15 Vdout0_15ck116 = 0.9 time = 585
.meas tran vdout0_15ck116 FIND v(dout0_15) AT=585.025n

* CHECK dout0_16 Vdout0_16ck116 = 0 time = 585
.meas tran vdout0_16ck116 FIND v(dout0_16) AT=585.025n

* CHECK dout0_17 Vdout0_17ck116 = 0.9 time = 585
.meas tran vdout0_17ck116 FIND v(dout0_17) AT=585.025n

* CHECK dout0_18 Vdout0_18ck116 = 0 time = 585
.meas tran vdout0_18ck116 FIND v(dout0_18) AT=585.025n

* CHECK dout0_19 Vdout0_19ck116 = 0 time = 585
.meas tran vdout0_19ck116 FIND v(dout0_19) AT=585.025n

* CHECK dout0_20 Vdout0_20ck116 = 0 time = 585
.meas tran vdout0_20ck116 FIND v(dout0_20) AT=585.025n

* CHECK dout0_21 Vdout0_21ck116 = 0.9 time = 585
.meas tran vdout0_21ck116 FIND v(dout0_21) AT=585.025n

* CHECK dout0_22 Vdout0_22ck116 = 0.9 time = 585
.meas tran vdout0_22ck116 FIND v(dout0_22) AT=585.025n

* CHECK dout0_23 Vdout0_23ck116 = 0.9 time = 585
.meas tran vdout0_23ck116 FIND v(dout0_23) AT=585.025n

* CHECK dout0_24 Vdout0_24ck116 = 0 time = 585
.meas tran vdout0_24ck116 FIND v(dout0_24) AT=585.025n

* CHECK dout0_25 Vdout0_25ck116 = 0 time = 585
.meas tran vdout0_25ck116 FIND v(dout0_25) AT=585.025n

* CHECK dout0_26 Vdout0_26ck116 = 0 time = 585
.meas tran vdout0_26ck116 FIND v(dout0_26) AT=585.025n

* CHECK dout0_27 Vdout0_27ck116 = 0.9 time = 585
.meas tran vdout0_27ck116 FIND v(dout0_27) AT=585.025n

* CHECK dout0_28 Vdout0_28ck116 = 0.9 time = 585
.meas tran vdout0_28ck116 FIND v(dout0_28) AT=585.025n

* CHECK dout0_29 Vdout0_29ck116 = 0 time = 585
.meas tran vdout0_29ck116 FIND v(dout0_29) AT=585.025n

* CHECK dout0_30 Vdout0_30ck116 = 0.9 time = 585
.meas tran vdout0_30ck116 FIND v(dout0_30) AT=585.025n

* CHECK dout0_31 Vdout0_31ck116 = 0 time = 585
.meas tran vdout0_31ck116 FIND v(dout0_31) AT=585.025n

* CHECK dout0_32 Vdout0_32ck116 = 0 time = 585
.meas tran vdout0_32ck116 FIND v(dout0_32) AT=585.025n

* CHECK dout0_33 Vdout0_33ck116 = 0.9 time = 585
.meas tran vdout0_33ck116 FIND v(dout0_33) AT=585.025n

* CHECK dout0_34 Vdout0_34ck116 = 0.9 time = 585
.meas tran vdout0_34ck116 FIND v(dout0_34) AT=585.025n

* CHECK dout0_35 Vdout0_35ck116 = 0 time = 585
.meas tran vdout0_35ck116 FIND v(dout0_35) AT=585.025n

* CHECK dout0_36 Vdout0_36ck116 = 0 time = 585
.meas tran vdout0_36ck116 FIND v(dout0_36) AT=585.025n

* CHECK dout0_37 Vdout0_37ck116 = 0.9 time = 585
.meas tran vdout0_37ck116 FIND v(dout0_37) AT=585.025n

* CHECK dout0_38 Vdout0_38ck116 = 0.9 time = 585
.meas tran vdout0_38ck116 FIND v(dout0_38) AT=585.025n

* CHECK dout0_39 Vdout0_39ck116 = 0.9 time = 585
.meas tran vdout0_39ck116 FIND v(dout0_39) AT=585.025n

* CHECK dout0_40 Vdout0_40ck116 = 0 time = 585
.meas tran vdout0_40ck116 FIND v(dout0_40) AT=585.025n

* CHECK dout0_41 Vdout0_41ck116 = 0 time = 585
.meas tran vdout0_41ck116 FIND v(dout0_41) AT=585.025n

* CHECK dout0_42 Vdout0_42ck116 = 0.9 time = 585
.meas tran vdout0_42ck116 FIND v(dout0_42) AT=585.025n

* CHECK dout0_43 Vdout0_43ck116 = 0 time = 585
.meas tran vdout0_43ck116 FIND v(dout0_43) AT=585.025n

* CHECK dout0_44 Vdout0_44ck116 = 0 time = 585
.meas tran vdout0_44ck116 FIND v(dout0_44) AT=585.025n

* CHECK dout0_45 Vdout0_45ck116 = 0.9 time = 585
.meas tran vdout0_45ck116 FIND v(dout0_45) AT=585.025n

* CHECK dout0_46 Vdout0_46ck116 = 0.9 time = 585
.meas tran vdout0_46ck116 FIND v(dout0_46) AT=585.025n

* CHECK dout0_47 Vdout0_47ck116 = 0.9 time = 585
.meas tran vdout0_47ck116 FIND v(dout0_47) AT=585.025n

* CHECK dout0_48 Vdout0_48ck116 = 0 time = 585
.meas tran vdout0_48ck116 FIND v(dout0_48) AT=585.025n

* CHECK dout0_49 Vdout0_49ck116 = 0.9 time = 585
.meas tran vdout0_49ck116 FIND v(dout0_49) AT=585.025n

* CHECK dout0_50 Vdout0_50ck116 = 0 time = 585
.meas tran vdout0_50ck116 FIND v(dout0_50) AT=585.025n

* CHECK dout0_51 Vdout0_51ck116 = 0 time = 585
.meas tran vdout0_51ck116 FIND v(dout0_51) AT=585.025n

* CHECK dout0_52 Vdout0_52ck116 = 0.9 time = 585
.meas tran vdout0_52ck116 FIND v(dout0_52) AT=585.025n

* CHECK dout0_53 Vdout0_53ck116 = 0 time = 585
.meas tran vdout0_53ck116 FIND v(dout0_53) AT=585.025n

* CHECK dout0_54 Vdout0_54ck116 = 0.9 time = 585
.meas tran vdout0_54ck116 FIND v(dout0_54) AT=585.025n

* CHECK dout0_55 Vdout0_55ck116 = 0 time = 585
.meas tran vdout0_55ck116 FIND v(dout0_55) AT=585.025n

* CHECK dout0_56 Vdout0_56ck116 = 0 time = 585
.meas tran vdout0_56ck116 FIND v(dout0_56) AT=585.025n

* CHECK dout0_57 Vdout0_57ck116 = 0 time = 585
.meas tran vdout0_57ck116 FIND v(dout0_57) AT=585.025n

* CHECK dout0_58 Vdout0_58ck116 = 0.9 time = 585
.meas tran vdout0_58ck116 FIND v(dout0_58) AT=585.025n

* CHECK dout0_59 Vdout0_59ck116 = 0 time = 585
.meas tran vdout0_59ck116 FIND v(dout0_59) AT=585.025n

* CHECK dout0_60 Vdout0_60ck116 = 0.9 time = 585
.meas tran vdout0_60ck116 FIND v(dout0_60) AT=585.025n

* CHECK dout0_61 Vdout0_61ck116 = 0.9 time = 585
.meas tran vdout0_61ck116 FIND v(dout0_61) AT=585.025n

* CHECK dout0_62 Vdout0_62ck116 = 0 time = 585
.meas tran vdout0_62ck116 FIND v(dout0_62) AT=585.025n

* CHECK dout0_63 Vdout0_63ck116 = 0 time = 585
.meas tran vdout0_63ck116 FIND v(dout0_63) AT=585.025n

* CHECK dout0_0 Vdout0_0ck118 = 0 time = 595
.meas tran vdout0_0ck118 FIND v(dout0_0) AT=595.025n

* CHECK dout0_1 Vdout0_1ck118 = 0.9 time = 595
.meas tran vdout0_1ck118 FIND v(dout0_1) AT=595.025n

* CHECK dout0_2 Vdout0_2ck118 = 0 time = 595
.meas tran vdout0_2ck118 FIND v(dout0_2) AT=595.025n

* CHECK dout0_3 Vdout0_3ck118 = 0.9 time = 595
.meas tran vdout0_3ck118 FIND v(dout0_3) AT=595.025n

* CHECK dout0_4 Vdout0_4ck118 = 0.9 time = 595
.meas tran vdout0_4ck118 FIND v(dout0_4) AT=595.025n

* CHECK dout0_5 Vdout0_5ck118 = 0 time = 595
.meas tran vdout0_5ck118 FIND v(dout0_5) AT=595.025n

* CHECK dout0_6 Vdout0_6ck118 = 0.9 time = 595
.meas tran vdout0_6ck118 FIND v(dout0_6) AT=595.025n

* CHECK dout0_7 Vdout0_7ck118 = 0 time = 595
.meas tran vdout0_7ck118 FIND v(dout0_7) AT=595.025n

* CHECK dout0_8 Vdout0_8ck118 = 0 time = 595
.meas tran vdout0_8ck118 FIND v(dout0_8) AT=595.025n

* CHECK dout0_9 Vdout0_9ck118 = 0 time = 595
.meas tran vdout0_9ck118 FIND v(dout0_9) AT=595.025n

* CHECK dout0_10 Vdout0_10ck118 = 0.9 time = 595
.meas tran vdout0_10ck118 FIND v(dout0_10) AT=595.025n

* CHECK dout0_11 Vdout0_11ck118 = 0.9 time = 595
.meas tran vdout0_11ck118 FIND v(dout0_11) AT=595.025n

* CHECK dout0_12 Vdout0_12ck118 = 0 time = 595
.meas tran vdout0_12ck118 FIND v(dout0_12) AT=595.025n

* CHECK dout0_13 Vdout0_13ck118 = 0.9 time = 595
.meas tran vdout0_13ck118 FIND v(dout0_13) AT=595.025n

* CHECK dout0_14 Vdout0_14ck118 = 0.9 time = 595
.meas tran vdout0_14ck118 FIND v(dout0_14) AT=595.025n

* CHECK dout0_15 Vdout0_15ck118 = 0 time = 595
.meas tran vdout0_15ck118 FIND v(dout0_15) AT=595.025n

* CHECK dout0_16 Vdout0_16ck118 = 0 time = 595
.meas tran vdout0_16ck118 FIND v(dout0_16) AT=595.025n

* CHECK dout0_17 Vdout0_17ck118 = 0 time = 595
.meas tran vdout0_17ck118 FIND v(dout0_17) AT=595.025n

* CHECK dout0_18 Vdout0_18ck118 = 0 time = 595
.meas tran vdout0_18ck118 FIND v(dout0_18) AT=595.025n

* CHECK dout0_19 Vdout0_19ck118 = 0 time = 595
.meas tran vdout0_19ck118 FIND v(dout0_19) AT=595.025n

* CHECK dout0_20 Vdout0_20ck118 = 0.9 time = 595
.meas tran vdout0_20ck118 FIND v(dout0_20) AT=595.025n

* CHECK dout0_21 Vdout0_21ck118 = 0.9 time = 595
.meas tran vdout0_21ck118 FIND v(dout0_21) AT=595.025n

* CHECK dout0_22 Vdout0_22ck118 = 0.9 time = 595
.meas tran vdout0_22ck118 FIND v(dout0_22) AT=595.025n

* CHECK dout0_23 Vdout0_23ck118 = 0 time = 595
.meas tran vdout0_23ck118 FIND v(dout0_23) AT=595.025n

* CHECK dout0_24 Vdout0_24ck118 = 0.9 time = 595
.meas tran vdout0_24ck118 FIND v(dout0_24) AT=595.025n

* CHECK dout0_25 Vdout0_25ck118 = 0 time = 595
.meas tran vdout0_25ck118 FIND v(dout0_25) AT=595.025n

* CHECK dout0_26 Vdout0_26ck118 = 0.9 time = 595
.meas tran vdout0_26ck118 FIND v(dout0_26) AT=595.025n

* CHECK dout0_27 Vdout0_27ck118 = 0.9 time = 595
.meas tran vdout0_27ck118 FIND v(dout0_27) AT=595.025n

* CHECK dout0_28 Vdout0_28ck118 = 0.9 time = 595
.meas tran vdout0_28ck118 FIND v(dout0_28) AT=595.025n

* CHECK dout0_29 Vdout0_29ck118 = 0 time = 595
.meas tran vdout0_29ck118 FIND v(dout0_29) AT=595.025n

* CHECK dout0_30 Vdout0_30ck118 = 0.9 time = 595
.meas tran vdout0_30ck118 FIND v(dout0_30) AT=595.025n

* CHECK dout0_31 Vdout0_31ck118 = 0.9 time = 595
.meas tran vdout0_31ck118 FIND v(dout0_31) AT=595.025n

* CHECK dout0_32 Vdout0_32ck118 = 0 time = 595
.meas tran vdout0_32ck118 FIND v(dout0_32) AT=595.025n

* CHECK dout0_33 Vdout0_33ck118 = 0.9 time = 595
.meas tran vdout0_33ck118 FIND v(dout0_33) AT=595.025n

* CHECK dout0_34 Vdout0_34ck118 = 0.9 time = 595
.meas tran vdout0_34ck118 FIND v(dout0_34) AT=595.025n

* CHECK dout0_35 Vdout0_35ck118 = 0.9 time = 595
.meas tran vdout0_35ck118 FIND v(dout0_35) AT=595.025n

* CHECK dout0_36 Vdout0_36ck118 = 0 time = 595
.meas tran vdout0_36ck118 FIND v(dout0_36) AT=595.025n

* CHECK dout0_37 Vdout0_37ck118 = 0.9 time = 595
.meas tran vdout0_37ck118 FIND v(dout0_37) AT=595.025n

* CHECK dout0_38 Vdout0_38ck118 = 0.9 time = 595
.meas tran vdout0_38ck118 FIND v(dout0_38) AT=595.025n

* CHECK dout0_39 Vdout0_39ck118 = 0 time = 595
.meas tran vdout0_39ck118 FIND v(dout0_39) AT=595.025n

* CHECK dout0_40 Vdout0_40ck118 = 0 time = 595
.meas tran vdout0_40ck118 FIND v(dout0_40) AT=595.025n

* CHECK dout0_41 Vdout0_41ck118 = 0 time = 595
.meas tran vdout0_41ck118 FIND v(dout0_41) AT=595.025n

* CHECK dout0_42 Vdout0_42ck118 = 0.9 time = 595
.meas tran vdout0_42ck118 FIND v(dout0_42) AT=595.025n

* CHECK dout0_43 Vdout0_43ck118 = 0 time = 595
.meas tran vdout0_43ck118 FIND v(dout0_43) AT=595.025n

* CHECK dout0_44 Vdout0_44ck118 = 0 time = 595
.meas tran vdout0_44ck118 FIND v(dout0_44) AT=595.025n

* CHECK dout0_45 Vdout0_45ck118 = 0 time = 595
.meas tran vdout0_45ck118 FIND v(dout0_45) AT=595.025n

* CHECK dout0_46 Vdout0_46ck118 = 0.9 time = 595
.meas tran vdout0_46ck118 FIND v(dout0_46) AT=595.025n

* CHECK dout0_47 Vdout0_47ck118 = 0.9 time = 595
.meas tran vdout0_47ck118 FIND v(dout0_47) AT=595.025n

* CHECK dout0_48 Vdout0_48ck118 = 0.9 time = 595
.meas tran vdout0_48ck118 FIND v(dout0_48) AT=595.025n

* CHECK dout0_49 Vdout0_49ck118 = 0.9 time = 595
.meas tran vdout0_49ck118 FIND v(dout0_49) AT=595.025n

* CHECK dout0_50 Vdout0_50ck118 = 0.9 time = 595
.meas tran vdout0_50ck118 FIND v(dout0_50) AT=595.025n

* CHECK dout0_51 Vdout0_51ck118 = 0.9 time = 595
.meas tran vdout0_51ck118 FIND v(dout0_51) AT=595.025n

* CHECK dout0_52 Vdout0_52ck118 = 0.9 time = 595
.meas tran vdout0_52ck118 FIND v(dout0_52) AT=595.025n

* CHECK dout0_53 Vdout0_53ck118 = 0 time = 595
.meas tran vdout0_53ck118 FIND v(dout0_53) AT=595.025n

* CHECK dout0_54 Vdout0_54ck118 = 0 time = 595
.meas tran vdout0_54ck118 FIND v(dout0_54) AT=595.025n

* CHECK dout0_55 Vdout0_55ck118 = 0.9 time = 595
.meas tran vdout0_55ck118 FIND v(dout0_55) AT=595.025n

* CHECK dout0_56 Vdout0_56ck118 = 0.9 time = 595
.meas tran vdout0_56ck118 FIND v(dout0_56) AT=595.025n

* CHECK dout0_57 Vdout0_57ck118 = 0.9 time = 595
.meas tran vdout0_57ck118 FIND v(dout0_57) AT=595.025n

* CHECK dout0_58 Vdout0_58ck118 = 0.9 time = 595
.meas tran vdout0_58ck118 FIND v(dout0_58) AT=595.025n

* CHECK dout0_59 Vdout0_59ck118 = 0.9 time = 595
.meas tran vdout0_59ck118 FIND v(dout0_59) AT=595.025n

* CHECK dout0_60 Vdout0_60ck118 = 0.9 time = 595
.meas tran vdout0_60ck118 FIND v(dout0_60) AT=595.025n

* CHECK dout0_61 Vdout0_61ck118 = 0 time = 595
.meas tran vdout0_61ck118 FIND v(dout0_61) AT=595.025n

* CHECK dout0_62 Vdout0_62ck118 = 0 time = 595
.meas tran vdout0_62ck118 FIND v(dout0_62) AT=595.025n

* CHECK dout0_63 Vdout0_63ck118 = 0 time = 595
.meas tran vdout0_63ck118 FIND v(dout0_63) AT=595.025n

* CHECK dout0_0 Vdout0_0ck119 = 0 time = 600
.meas tran vdout0_0ck119 FIND v(dout0_0) AT=600.025n

* CHECK dout0_1 Vdout0_1ck119 = 0 time = 600
.meas tran vdout0_1ck119 FIND v(dout0_1) AT=600.025n

* CHECK dout0_2 Vdout0_2ck119 = 0.9 time = 600
.meas tran vdout0_2ck119 FIND v(dout0_2) AT=600.025n

* CHECK dout0_3 Vdout0_3ck119 = 0.9 time = 600
.meas tran vdout0_3ck119 FIND v(dout0_3) AT=600.025n

* CHECK dout0_4 Vdout0_4ck119 = 0 time = 600
.meas tran vdout0_4ck119 FIND v(dout0_4) AT=600.025n

* CHECK dout0_5 Vdout0_5ck119 = 0 time = 600
.meas tran vdout0_5ck119 FIND v(dout0_5) AT=600.025n

* CHECK dout0_6 Vdout0_6ck119 = 0.9 time = 600
.meas tran vdout0_6ck119 FIND v(dout0_6) AT=600.025n

* CHECK dout0_7 Vdout0_7ck119 = 0 time = 600
.meas tran vdout0_7ck119 FIND v(dout0_7) AT=600.025n

* CHECK dout0_8 Vdout0_8ck119 = 0 time = 600
.meas tran vdout0_8ck119 FIND v(dout0_8) AT=600.025n

* CHECK dout0_9 Vdout0_9ck119 = 0.9 time = 600
.meas tran vdout0_9ck119 FIND v(dout0_9) AT=600.025n

* CHECK dout0_10 Vdout0_10ck119 = 0 time = 600
.meas tran vdout0_10ck119 FIND v(dout0_10) AT=600.025n

* CHECK dout0_11 Vdout0_11ck119 = 0 time = 600
.meas tran vdout0_11ck119 FIND v(dout0_11) AT=600.025n

* CHECK dout0_12 Vdout0_12ck119 = 0 time = 600
.meas tran vdout0_12ck119 FIND v(dout0_12) AT=600.025n

* CHECK dout0_13 Vdout0_13ck119 = 0.9 time = 600
.meas tran vdout0_13ck119 FIND v(dout0_13) AT=600.025n

* CHECK dout0_14 Vdout0_14ck119 = 0.9 time = 600
.meas tran vdout0_14ck119 FIND v(dout0_14) AT=600.025n

* CHECK dout0_15 Vdout0_15ck119 = 0 time = 600
.meas tran vdout0_15ck119 FIND v(dout0_15) AT=600.025n

* CHECK dout0_16 Vdout0_16ck119 = 0.9 time = 600
.meas tran vdout0_16ck119 FIND v(dout0_16) AT=600.025n

* CHECK dout0_17 Vdout0_17ck119 = 0.9 time = 600
.meas tran vdout0_17ck119 FIND v(dout0_17) AT=600.025n

* CHECK dout0_18 Vdout0_18ck119 = 0 time = 600
.meas tran vdout0_18ck119 FIND v(dout0_18) AT=600.025n

* CHECK dout0_19 Vdout0_19ck119 = 0.9 time = 600
.meas tran vdout0_19ck119 FIND v(dout0_19) AT=600.025n

* CHECK dout0_20 Vdout0_20ck119 = 0 time = 600
.meas tran vdout0_20ck119 FIND v(dout0_20) AT=600.025n

* CHECK dout0_21 Vdout0_21ck119 = 0 time = 600
.meas tran vdout0_21ck119 FIND v(dout0_21) AT=600.025n

* CHECK dout0_22 Vdout0_22ck119 = 0.9 time = 600
.meas tran vdout0_22ck119 FIND v(dout0_22) AT=600.025n

* CHECK dout0_23 Vdout0_23ck119 = 0.9 time = 600
.meas tran vdout0_23ck119 FIND v(dout0_23) AT=600.025n

* CHECK dout0_24 Vdout0_24ck119 = 0.9 time = 600
.meas tran vdout0_24ck119 FIND v(dout0_24) AT=600.025n

* CHECK dout0_25 Vdout0_25ck119 = 0 time = 600
.meas tran vdout0_25ck119 FIND v(dout0_25) AT=600.025n

* CHECK dout0_26 Vdout0_26ck119 = 0.9 time = 600
.meas tran vdout0_26ck119 FIND v(dout0_26) AT=600.025n

* CHECK dout0_27 Vdout0_27ck119 = 0.9 time = 600
.meas tran vdout0_27ck119 FIND v(dout0_27) AT=600.025n

* CHECK dout0_28 Vdout0_28ck119 = 0 time = 600
.meas tran vdout0_28ck119 FIND v(dout0_28) AT=600.025n

* CHECK dout0_29 Vdout0_29ck119 = 0.9 time = 600
.meas tran vdout0_29ck119 FIND v(dout0_29) AT=600.025n

* CHECK dout0_30 Vdout0_30ck119 = 0.9 time = 600
.meas tran vdout0_30ck119 FIND v(dout0_30) AT=600.025n

* CHECK dout0_31 Vdout0_31ck119 = 0 time = 600
.meas tran vdout0_31ck119 FIND v(dout0_31) AT=600.025n

* CHECK dout0_32 Vdout0_32ck119 = 0 time = 600
.meas tran vdout0_32ck119 FIND v(dout0_32) AT=600.025n

* CHECK dout0_33 Vdout0_33ck119 = 0 time = 600
.meas tran vdout0_33ck119 FIND v(dout0_33) AT=600.025n

* CHECK dout0_34 Vdout0_34ck119 = 0 time = 600
.meas tran vdout0_34ck119 FIND v(dout0_34) AT=600.025n

* CHECK dout0_35 Vdout0_35ck119 = 0 time = 600
.meas tran vdout0_35ck119 FIND v(dout0_35) AT=600.025n

* CHECK dout0_36 Vdout0_36ck119 = 0.9 time = 600
.meas tran vdout0_36ck119 FIND v(dout0_36) AT=600.025n

* CHECK dout0_37 Vdout0_37ck119 = 0 time = 600
.meas tran vdout0_37ck119 FIND v(dout0_37) AT=600.025n

* CHECK dout0_38 Vdout0_38ck119 = 0 time = 600
.meas tran vdout0_38ck119 FIND v(dout0_38) AT=600.025n

* CHECK dout0_39 Vdout0_39ck119 = 0 time = 600
.meas tran vdout0_39ck119 FIND v(dout0_39) AT=600.025n

* CHECK dout0_40 Vdout0_40ck119 = 0.9 time = 600
.meas tran vdout0_40ck119 FIND v(dout0_40) AT=600.025n

* CHECK dout0_41 Vdout0_41ck119 = 0.9 time = 600
.meas tran vdout0_41ck119 FIND v(dout0_41) AT=600.025n

* CHECK dout0_42 Vdout0_42ck119 = 0.9 time = 600
.meas tran vdout0_42ck119 FIND v(dout0_42) AT=600.025n

* CHECK dout0_43 Vdout0_43ck119 = 0.9 time = 600
.meas tran vdout0_43ck119 FIND v(dout0_43) AT=600.025n

* CHECK dout0_44 Vdout0_44ck119 = 0 time = 600
.meas tran vdout0_44ck119 FIND v(dout0_44) AT=600.025n

* CHECK dout0_45 Vdout0_45ck119 = 0.9 time = 600
.meas tran vdout0_45ck119 FIND v(dout0_45) AT=600.025n

* CHECK dout0_46 Vdout0_46ck119 = 0 time = 600
.meas tran vdout0_46ck119 FIND v(dout0_46) AT=600.025n

* CHECK dout0_47 Vdout0_47ck119 = 0.9 time = 600
.meas tran vdout0_47ck119 FIND v(dout0_47) AT=600.025n

* CHECK dout0_48 Vdout0_48ck119 = 0.9 time = 600
.meas tran vdout0_48ck119 FIND v(dout0_48) AT=600.025n

* CHECK dout0_49 Vdout0_49ck119 = 0.9 time = 600
.meas tran vdout0_49ck119 FIND v(dout0_49) AT=600.025n

* CHECK dout0_50 Vdout0_50ck119 = 0 time = 600
.meas tran vdout0_50ck119 FIND v(dout0_50) AT=600.025n

* CHECK dout0_51 Vdout0_51ck119 = 0.9 time = 600
.meas tran vdout0_51ck119 FIND v(dout0_51) AT=600.025n

* CHECK dout0_52 Vdout0_52ck119 = 0.9 time = 600
.meas tran vdout0_52ck119 FIND v(dout0_52) AT=600.025n

* CHECK dout0_53 Vdout0_53ck119 = 0.9 time = 600
.meas tran vdout0_53ck119 FIND v(dout0_53) AT=600.025n

* CHECK dout0_54 Vdout0_54ck119 = 0 time = 600
.meas tran vdout0_54ck119 FIND v(dout0_54) AT=600.025n

* CHECK dout0_55 Vdout0_55ck119 = 0.9 time = 600
.meas tran vdout0_55ck119 FIND v(dout0_55) AT=600.025n

* CHECK dout0_56 Vdout0_56ck119 = 0 time = 600
.meas tran vdout0_56ck119 FIND v(dout0_56) AT=600.025n

* CHECK dout0_57 Vdout0_57ck119 = 0.9 time = 600
.meas tran vdout0_57ck119 FIND v(dout0_57) AT=600.025n

* CHECK dout0_58 Vdout0_58ck119 = 0 time = 600
.meas tran vdout0_58ck119 FIND v(dout0_58) AT=600.025n

* CHECK dout0_59 Vdout0_59ck119 = 0.9 time = 600
.meas tran vdout0_59ck119 FIND v(dout0_59) AT=600.025n

* CHECK dout0_60 Vdout0_60ck119 = 0 time = 600
.meas tran vdout0_60ck119 FIND v(dout0_60) AT=600.025n

* CHECK dout0_61 Vdout0_61ck119 = 0 time = 600
.meas tran vdout0_61ck119 FIND v(dout0_61) AT=600.025n

* CHECK dout0_62 Vdout0_62ck119 = 0.9 time = 600
.meas tran vdout0_62ck119 FIND v(dout0_62) AT=600.025n

* CHECK dout0_63 Vdout0_63ck119 = 0.9 time = 600
.meas tran vdout0_63ck119 FIND v(dout0_63) AT=600.025n

* CHECK dout0_0 Vdout0_0ck120 = 0 time = 605
.meas tran vdout0_0ck120 FIND v(dout0_0) AT=605.025n

* CHECK dout0_1 Vdout0_1ck120 = 0 time = 605
.meas tran vdout0_1ck120 FIND v(dout0_1) AT=605.025n

* CHECK dout0_2 Vdout0_2ck120 = 0 time = 605
.meas tran vdout0_2ck120 FIND v(dout0_2) AT=605.025n

* CHECK dout0_3 Vdout0_3ck120 = 0 time = 605
.meas tran vdout0_3ck120 FIND v(dout0_3) AT=605.025n

* CHECK dout0_4 Vdout0_4ck120 = 0.9 time = 605
.meas tran vdout0_4ck120 FIND v(dout0_4) AT=605.025n

* CHECK dout0_5 Vdout0_5ck120 = 0.9 time = 605
.meas tran vdout0_5ck120 FIND v(dout0_5) AT=605.025n

* CHECK dout0_6 Vdout0_6ck120 = 0 time = 605
.meas tran vdout0_6ck120 FIND v(dout0_6) AT=605.025n

* CHECK dout0_7 Vdout0_7ck120 = 0.9 time = 605
.meas tran vdout0_7ck120 FIND v(dout0_7) AT=605.025n

* CHECK dout0_8 Vdout0_8ck120 = 0 time = 605
.meas tran vdout0_8ck120 FIND v(dout0_8) AT=605.025n

* CHECK dout0_9 Vdout0_9ck120 = 0 time = 605
.meas tran vdout0_9ck120 FIND v(dout0_9) AT=605.025n

* CHECK dout0_10 Vdout0_10ck120 = 0 time = 605
.meas tran vdout0_10ck120 FIND v(dout0_10) AT=605.025n

* CHECK dout0_11 Vdout0_11ck120 = 0.9 time = 605
.meas tran vdout0_11ck120 FIND v(dout0_11) AT=605.025n

* CHECK dout0_12 Vdout0_12ck120 = 0.9 time = 605
.meas tran vdout0_12ck120 FIND v(dout0_12) AT=605.025n

* CHECK dout0_13 Vdout0_13ck120 = 0.9 time = 605
.meas tran vdout0_13ck120 FIND v(dout0_13) AT=605.025n

* CHECK dout0_14 Vdout0_14ck120 = 0.9 time = 605
.meas tran vdout0_14ck120 FIND v(dout0_14) AT=605.025n

* CHECK dout0_15 Vdout0_15ck120 = 0.9 time = 605
.meas tran vdout0_15ck120 FIND v(dout0_15) AT=605.025n

* CHECK dout0_16 Vdout0_16ck120 = 0.9 time = 605
.meas tran vdout0_16ck120 FIND v(dout0_16) AT=605.025n

* CHECK dout0_17 Vdout0_17ck120 = 0 time = 605
.meas tran vdout0_17ck120 FIND v(dout0_17) AT=605.025n

* CHECK dout0_18 Vdout0_18ck120 = 0 time = 605
.meas tran vdout0_18ck120 FIND v(dout0_18) AT=605.025n

* CHECK dout0_19 Vdout0_19ck120 = 0.9 time = 605
.meas tran vdout0_19ck120 FIND v(dout0_19) AT=605.025n

* CHECK dout0_20 Vdout0_20ck120 = 0 time = 605
.meas tran vdout0_20ck120 FIND v(dout0_20) AT=605.025n

* CHECK dout0_21 Vdout0_21ck120 = 0.9 time = 605
.meas tran vdout0_21ck120 FIND v(dout0_21) AT=605.025n

* CHECK dout0_22 Vdout0_22ck120 = 0.9 time = 605
.meas tran vdout0_22ck120 FIND v(dout0_22) AT=605.025n

* CHECK dout0_23 Vdout0_23ck120 = 0 time = 605
.meas tran vdout0_23ck120 FIND v(dout0_23) AT=605.025n

* CHECK dout0_24 Vdout0_24ck120 = 0 time = 605
.meas tran vdout0_24ck120 FIND v(dout0_24) AT=605.025n

* CHECK dout0_25 Vdout0_25ck120 = 0.9 time = 605
.meas tran vdout0_25ck120 FIND v(dout0_25) AT=605.025n

* CHECK dout0_26 Vdout0_26ck120 = 0.9 time = 605
.meas tran vdout0_26ck120 FIND v(dout0_26) AT=605.025n

* CHECK dout0_27 Vdout0_27ck120 = 0.9 time = 605
.meas tran vdout0_27ck120 FIND v(dout0_27) AT=605.025n

* CHECK dout0_28 Vdout0_28ck120 = 0.9 time = 605
.meas tran vdout0_28ck120 FIND v(dout0_28) AT=605.025n

* CHECK dout0_29 Vdout0_29ck120 = 0.9 time = 605
.meas tran vdout0_29ck120 FIND v(dout0_29) AT=605.025n

* CHECK dout0_30 Vdout0_30ck120 = 0 time = 605
.meas tran vdout0_30ck120 FIND v(dout0_30) AT=605.025n

* CHECK dout0_31 Vdout0_31ck120 = 0 time = 605
.meas tran vdout0_31ck120 FIND v(dout0_31) AT=605.025n

* CHECK dout0_32 Vdout0_32ck120 = 0.9 time = 605
.meas tran vdout0_32ck120 FIND v(dout0_32) AT=605.025n

* CHECK dout0_33 Vdout0_33ck120 = 0.9 time = 605
.meas tran vdout0_33ck120 FIND v(dout0_33) AT=605.025n

* CHECK dout0_34 Vdout0_34ck120 = 0.9 time = 605
.meas tran vdout0_34ck120 FIND v(dout0_34) AT=605.025n

* CHECK dout0_35 Vdout0_35ck120 = 0.9 time = 605
.meas tran vdout0_35ck120 FIND v(dout0_35) AT=605.025n

* CHECK dout0_36 Vdout0_36ck120 = 0.9 time = 605
.meas tran vdout0_36ck120 FIND v(dout0_36) AT=605.025n

* CHECK dout0_37 Vdout0_37ck120 = 0.9 time = 605
.meas tran vdout0_37ck120 FIND v(dout0_37) AT=605.025n

* CHECK dout0_38 Vdout0_38ck120 = 0.9 time = 605
.meas tran vdout0_38ck120 FIND v(dout0_38) AT=605.025n

* CHECK dout0_39 Vdout0_39ck120 = 0 time = 605
.meas tran vdout0_39ck120 FIND v(dout0_39) AT=605.025n

* CHECK dout0_40 Vdout0_40ck120 = 0 time = 605
.meas tran vdout0_40ck120 FIND v(dout0_40) AT=605.025n

* CHECK dout0_41 Vdout0_41ck120 = 0 time = 605
.meas tran vdout0_41ck120 FIND v(dout0_41) AT=605.025n

* CHECK dout0_42 Vdout0_42ck120 = 0.9 time = 605
.meas tran vdout0_42ck120 FIND v(dout0_42) AT=605.025n

* CHECK dout0_43 Vdout0_43ck120 = 0 time = 605
.meas tran vdout0_43ck120 FIND v(dout0_43) AT=605.025n

* CHECK dout0_44 Vdout0_44ck120 = 0.9 time = 605
.meas tran vdout0_44ck120 FIND v(dout0_44) AT=605.025n

* CHECK dout0_45 Vdout0_45ck120 = 0.9 time = 605
.meas tran vdout0_45ck120 FIND v(dout0_45) AT=605.025n

* CHECK dout0_46 Vdout0_46ck120 = 0.9 time = 605
.meas tran vdout0_46ck120 FIND v(dout0_46) AT=605.025n

* CHECK dout0_47 Vdout0_47ck120 = 0 time = 605
.meas tran vdout0_47ck120 FIND v(dout0_47) AT=605.025n

* CHECK dout0_48 Vdout0_48ck120 = 0 time = 605
.meas tran vdout0_48ck120 FIND v(dout0_48) AT=605.025n

* CHECK dout0_49 Vdout0_49ck120 = 0 time = 605
.meas tran vdout0_49ck120 FIND v(dout0_49) AT=605.025n

* CHECK dout0_50 Vdout0_50ck120 = 0 time = 605
.meas tran vdout0_50ck120 FIND v(dout0_50) AT=605.025n

* CHECK dout0_51 Vdout0_51ck120 = 0.9 time = 605
.meas tran vdout0_51ck120 FIND v(dout0_51) AT=605.025n

* CHECK dout0_52 Vdout0_52ck120 = 0 time = 605
.meas tran vdout0_52ck120 FIND v(dout0_52) AT=605.025n

* CHECK dout0_53 Vdout0_53ck120 = 0.9 time = 605
.meas tran vdout0_53ck120 FIND v(dout0_53) AT=605.025n

* CHECK dout0_54 Vdout0_54ck120 = 0 time = 605
.meas tran vdout0_54ck120 FIND v(dout0_54) AT=605.025n

* CHECK dout0_55 Vdout0_55ck120 = 0.9 time = 605
.meas tran vdout0_55ck120 FIND v(dout0_55) AT=605.025n

* CHECK dout0_56 Vdout0_56ck120 = 0.9 time = 605
.meas tran vdout0_56ck120 FIND v(dout0_56) AT=605.025n

* CHECK dout0_57 Vdout0_57ck120 = 0 time = 605
.meas tran vdout0_57ck120 FIND v(dout0_57) AT=605.025n

* CHECK dout0_58 Vdout0_58ck120 = 0.9 time = 605
.meas tran vdout0_58ck120 FIND v(dout0_58) AT=605.025n

* CHECK dout0_59 Vdout0_59ck120 = 0 time = 605
.meas tran vdout0_59ck120 FIND v(dout0_59) AT=605.025n

* CHECK dout0_60 Vdout0_60ck120 = 0 time = 605
.meas tran vdout0_60ck120 FIND v(dout0_60) AT=605.025n

* CHECK dout0_61 Vdout0_61ck120 = 0.9 time = 605
.meas tran vdout0_61ck120 FIND v(dout0_61) AT=605.025n

* CHECK dout0_62 Vdout0_62ck120 = 0 time = 605
.meas tran vdout0_62ck120 FIND v(dout0_62) AT=605.025n

* CHECK dout0_63 Vdout0_63ck120 = 0 time = 605
.meas tran vdout0_63ck120 FIND v(dout0_63) AT=605.025n

* CHECK dout0_0 Vdout0_0ck123 = 0.9 time = 620
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=620.025n

* CHECK dout0_1 Vdout0_1ck123 = 0 time = 620
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=620.025n

* CHECK dout0_2 Vdout0_2ck123 = 0.9 time = 620
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=620.025n

* CHECK dout0_3 Vdout0_3ck123 = 0 time = 620
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=620.025n

* CHECK dout0_4 Vdout0_4ck123 = 0 time = 620
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=620.025n

* CHECK dout0_5 Vdout0_5ck123 = 0.9 time = 620
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=620.025n

* CHECK dout0_6 Vdout0_6ck123 = 0 time = 620
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=620.025n

* CHECK dout0_7 Vdout0_7ck123 = 0 time = 620
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=620.025n

* CHECK dout0_8 Vdout0_8ck123 = 0.9 time = 620
.meas tran vdout0_8ck123 FIND v(dout0_8) AT=620.025n

* CHECK dout0_9 Vdout0_9ck123 = 0.9 time = 620
.meas tran vdout0_9ck123 FIND v(dout0_9) AT=620.025n

* CHECK dout0_10 Vdout0_10ck123 = 0 time = 620
.meas tran vdout0_10ck123 FIND v(dout0_10) AT=620.025n

* CHECK dout0_11 Vdout0_11ck123 = 0 time = 620
.meas tran vdout0_11ck123 FIND v(dout0_11) AT=620.025n

* CHECK dout0_12 Vdout0_12ck123 = 0 time = 620
.meas tran vdout0_12ck123 FIND v(dout0_12) AT=620.025n

* CHECK dout0_13 Vdout0_13ck123 = 0 time = 620
.meas tran vdout0_13ck123 FIND v(dout0_13) AT=620.025n

* CHECK dout0_14 Vdout0_14ck123 = 0.9 time = 620
.meas tran vdout0_14ck123 FIND v(dout0_14) AT=620.025n

* CHECK dout0_15 Vdout0_15ck123 = 0.9 time = 620
.meas tran vdout0_15ck123 FIND v(dout0_15) AT=620.025n

* CHECK dout0_16 Vdout0_16ck123 = 0 time = 620
.meas tran vdout0_16ck123 FIND v(dout0_16) AT=620.025n

* CHECK dout0_17 Vdout0_17ck123 = 0.9 time = 620
.meas tran vdout0_17ck123 FIND v(dout0_17) AT=620.025n

* CHECK dout0_18 Vdout0_18ck123 = 0.9 time = 620
.meas tran vdout0_18ck123 FIND v(dout0_18) AT=620.025n

* CHECK dout0_19 Vdout0_19ck123 = 0 time = 620
.meas tran vdout0_19ck123 FIND v(dout0_19) AT=620.025n

* CHECK dout0_20 Vdout0_20ck123 = 0 time = 620
.meas tran vdout0_20ck123 FIND v(dout0_20) AT=620.025n

* CHECK dout0_21 Vdout0_21ck123 = 0 time = 620
.meas tran vdout0_21ck123 FIND v(dout0_21) AT=620.025n

* CHECK dout0_22 Vdout0_22ck123 = 0 time = 620
.meas tran vdout0_22ck123 FIND v(dout0_22) AT=620.025n

* CHECK dout0_23 Vdout0_23ck123 = 0 time = 620
.meas tran vdout0_23ck123 FIND v(dout0_23) AT=620.025n

* CHECK dout0_24 Vdout0_24ck123 = 0 time = 620
.meas tran vdout0_24ck123 FIND v(dout0_24) AT=620.025n

* CHECK dout0_25 Vdout0_25ck123 = 0.9 time = 620
.meas tran vdout0_25ck123 FIND v(dout0_25) AT=620.025n

* CHECK dout0_26 Vdout0_26ck123 = 0.9 time = 620
.meas tran vdout0_26ck123 FIND v(dout0_26) AT=620.025n

* CHECK dout0_27 Vdout0_27ck123 = 0.9 time = 620
.meas tran vdout0_27ck123 FIND v(dout0_27) AT=620.025n

* CHECK dout0_28 Vdout0_28ck123 = 0.9 time = 620
.meas tran vdout0_28ck123 FIND v(dout0_28) AT=620.025n

* CHECK dout0_29 Vdout0_29ck123 = 0.9 time = 620
.meas tran vdout0_29ck123 FIND v(dout0_29) AT=620.025n

* CHECK dout0_30 Vdout0_30ck123 = 0.9 time = 620
.meas tran vdout0_30ck123 FIND v(dout0_30) AT=620.025n

* CHECK dout0_31 Vdout0_31ck123 = 0 time = 620
.meas tran vdout0_31ck123 FIND v(dout0_31) AT=620.025n

* CHECK dout0_32 Vdout0_32ck123 = 0 time = 620
.meas tran vdout0_32ck123 FIND v(dout0_32) AT=620.025n

* CHECK dout0_33 Vdout0_33ck123 = 0.9 time = 620
.meas tran vdout0_33ck123 FIND v(dout0_33) AT=620.025n

* CHECK dout0_34 Vdout0_34ck123 = 0 time = 620
.meas tran vdout0_34ck123 FIND v(dout0_34) AT=620.025n

* CHECK dout0_35 Vdout0_35ck123 = 0 time = 620
.meas tran vdout0_35ck123 FIND v(dout0_35) AT=620.025n

* CHECK dout0_36 Vdout0_36ck123 = 0 time = 620
.meas tran vdout0_36ck123 FIND v(dout0_36) AT=620.025n

* CHECK dout0_37 Vdout0_37ck123 = 0.9 time = 620
.meas tran vdout0_37ck123 FIND v(dout0_37) AT=620.025n

* CHECK dout0_38 Vdout0_38ck123 = 0.9 time = 620
.meas tran vdout0_38ck123 FIND v(dout0_38) AT=620.025n

* CHECK dout0_39 Vdout0_39ck123 = 0.9 time = 620
.meas tran vdout0_39ck123 FIND v(dout0_39) AT=620.025n

* CHECK dout0_40 Vdout0_40ck123 = 0.9 time = 620
.meas tran vdout0_40ck123 FIND v(dout0_40) AT=620.025n

* CHECK dout0_41 Vdout0_41ck123 = 0.9 time = 620
.meas tran vdout0_41ck123 FIND v(dout0_41) AT=620.025n

* CHECK dout0_42 Vdout0_42ck123 = 0 time = 620
.meas tran vdout0_42ck123 FIND v(dout0_42) AT=620.025n

* CHECK dout0_43 Vdout0_43ck123 = 0 time = 620
.meas tran vdout0_43ck123 FIND v(dout0_43) AT=620.025n

* CHECK dout0_44 Vdout0_44ck123 = 0 time = 620
.meas tran vdout0_44ck123 FIND v(dout0_44) AT=620.025n

* CHECK dout0_45 Vdout0_45ck123 = 0 time = 620
.meas tran vdout0_45ck123 FIND v(dout0_45) AT=620.025n

* CHECK dout0_46 Vdout0_46ck123 = 0 time = 620
.meas tran vdout0_46ck123 FIND v(dout0_46) AT=620.025n

* CHECK dout0_47 Vdout0_47ck123 = 0.9 time = 620
.meas tran vdout0_47ck123 FIND v(dout0_47) AT=620.025n

* CHECK dout0_48 Vdout0_48ck123 = 0.9 time = 620
.meas tran vdout0_48ck123 FIND v(dout0_48) AT=620.025n

* CHECK dout0_49 Vdout0_49ck123 = 0 time = 620
.meas tran vdout0_49ck123 FIND v(dout0_49) AT=620.025n

* CHECK dout0_50 Vdout0_50ck123 = 0.9 time = 620
.meas tran vdout0_50ck123 FIND v(dout0_50) AT=620.025n

* CHECK dout0_51 Vdout0_51ck123 = 0 time = 620
.meas tran vdout0_51ck123 FIND v(dout0_51) AT=620.025n

* CHECK dout0_52 Vdout0_52ck123 = 0 time = 620
.meas tran vdout0_52ck123 FIND v(dout0_52) AT=620.025n

* CHECK dout0_53 Vdout0_53ck123 = 0.9 time = 620
.meas tran vdout0_53ck123 FIND v(dout0_53) AT=620.025n

* CHECK dout0_54 Vdout0_54ck123 = 0 time = 620
.meas tran vdout0_54ck123 FIND v(dout0_54) AT=620.025n

* CHECK dout0_55 Vdout0_55ck123 = 0.9 time = 620
.meas tran vdout0_55ck123 FIND v(dout0_55) AT=620.025n

* CHECK dout0_56 Vdout0_56ck123 = 0.9 time = 620
.meas tran vdout0_56ck123 FIND v(dout0_56) AT=620.025n

* CHECK dout0_57 Vdout0_57ck123 = 0 time = 620
.meas tran vdout0_57ck123 FIND v(dout0_57) AT=620.025n

* CHECK dout0_58 Vdout0_58ck123 = 0.9 time = 620
.meas tran vdout0_58ck123 FIND v(dout0_58) AT=620.025n

* CHECK dout0_59 Vdout0_59ck123 = 0 time = 620
.meas tran vdout0_59ck123 FIND v(dout0_59) AT=620.025n

* CHECK dout0_60 Vdout0_60ck123 = 0.9 time = 620
.meas tran vdout0_60ck123 FIND v(dout0_60) AT=620.025n

* CHECK dout0_61 Vdout0_61ck123 = 0 time = 620
.meas tran vdout0_61ck123 FIND v(dout0_61) AT=620.025n

* CHECK dout0_62 Vdout0_62ck123 = 0 time = 620
.meas tran vdout0_62ck123 FIND v(dout0_62) AT=620.025n

* CHECK dout0_63 Vdout0_63ck123 = 0 time = 620
.meas tran vdout0_63ck123 FIND v(dout0_63) AT=620.025n

* CHECK dout0_0 Vdout0_0ck124 = 0.9 time = 625
.meas tran vdout0_0ck124 FIND v(dout0_0) AT=625.025n

* CHECK dout0_1 Vdout0_1ck124 = 0 time = 625
.meas tran vdout0_1ck124 FIND v(dout0_1) AT=625.025n

* CHECK dout0_2 Vdout0_2ck124 = 0.9 time = 625
.meas tran vdout0_2ck124 FIND v(dout0_2) AT=625.025n

* CHECK dout0_3 Vdout0_3ck124 = 0 time = 625
.meas tran vdout0_3ck124 FIND v(dout0_3) AT=625.025n

* CHECK dout0_4 Vdout0_4ck124 = 0 time = 625
.meas tran vdout0_4ck124 FIND v(dout0_4) AT=625.025n

* CHECK dout0_5 Vdout0_5ck124 = 0.9 time = 625
.meas tran vdout0_5ck124 FIND v(dout0_5) AT=625.025n

* CHECK dout0_6 Vdout0_6ck124 = 0 time = 625
.meas tran vdout0_6ck124 FIND v(dout0_6) AT=625.025n

* CHECK dout0_7 Vdout0_7ck124 = 0 time = 625
.meas tran vdout0_7ck124 FIND v(dout0_7) AT=625.025n

* CHECK dout0_8 Vdout0_8ck124 = 0.9 time = 625
.meas tran vdout0_8ck124 FIND v(dout0_8) AT=625.025n

* CHECK dout0_9 Vdout0_9ck124 = 0.9 time = 625
.meas tran vdout0_9ck124 FIND v(dout0_9) AT=625.025n

* CHECK dout0_10 Vdout0_10ck124 = 0 time = 625
.meas tran vdout0_10ck124 FIND v(dout0_10) AT=625.025n

* CHECK dout0_11 Vdout0_11ck124 = 0 time = 625
.meas tran vdout0_11ck124 FIND v(dout0_11) AT=625.025n

* CHECK dout0_12 Vdout0_12ck124 = 0 time = 625
.meas tran vdout0_12ck124 FIND v(dout0_12) AT=625.025n

* CHECK dout0_13 Vdout0_13ck124 = 0 time = 625
.meas tran vdout0_13ck124 FIND v(dout0_13) AT=625.025n

* CHECK dout0_14 Vdout0_14ck124 = 0.9 time = 625
.meas tran vdout0_14ck124 FIND v(dout0_14) AT=625.025n

* CHECK dout0_15 Vdout0_15ck124 = 0.9 time = 625
.meas tran vdout0_15ck124 FIND v(dout0_15) AT=625.025n

* CHECK dout0_16 Vdout0_16ck124 = 0 time = 625
.meas tran vdout0_16ck124 FIND v(dout0_16) AT=625.025n

* CHECK dout0_17 Vdout0_17ck124 = 0.9 time = 625
.meas tran vdout0_17ck124 FIND v(dout0_17) AT=625.025n

* CHECK dout0_18 Vdout0_18ck124 = 0.9 time = 625
.meas tran vdout0_18ck124 FIND v(dout0_18) AT=625.025n

* CHECK dout0_19 Vdout0_19ck124 = 0 time = 625
.meas tran vdout0_19ck124 FIND v(dout0_19) AT=625.025n

* CHECK dout0_20 Vdout0_20ck124 = 0 time = 625
.meas tran vdout0_20ck124 FIND v(dout0_20) AT=625.025n

* CHECK dout0_21 Vdout0_21ck124 = 0 time = 625
.meas tran vdout0_21ck124 FIND v(dout0_21) AT=625.025n

* CHECK dout0_22 Vdout0_22ck124 = 0 time = 625
.meas tran vdout0_22ck124 FIND v(dout0_22) AT=625.025n

* CHECK dout0_23 Vdout0_23ck124 = 0 time = 625
.meas tran vdout0_23ck124 FIND v(dout0_23) AT=625.025n

* CHECK dout0_24 Vdout0_24ck124 = 0 time = 625
.meas tran vdout0_24ck124 FIND v(dout0_24) AT=625.025n

* CHECK dout0_25 Vdout0_25ck124 = 0.9 time = 625
.meas tran vdout0_25ck124 FIND v(dout0_25) AT=625.025n

* CHECK dout0_26 Vdout0_26ck124 = 0.9 time = 625
.meas tran vdout0_26ck124 FIND v(dout0_26) AT=625.025n

* CHECK dout0_27 Vdout0_27ck124 = 0.9 time = 625
.meas tran vdout0_27ck124 FIND v(dout0_27) AT=625.025n

* CHECK dout0_28 Vdout0_28ck124 = 0.9 time = 625
.meas tran vdout0_28ck124 FIND v(dout0_28) AT=625.025n

* CHECK dout0_29 Vdout0_29ck124 = 0.9 time = 625
.meas tran vdout0_29ck124 FIND v(dout0_29) AT=625.025n

* CHECK dout0_30 Vdout0_30ck124 = 0.9 time = 625
.meas tran vdout0_30ck124 FIND v(dout0_30) AT=625.025n

* CHECK dout0_31 Vdout0_31ck124 = 0 time = 625
.meas tran vdout0_31ck124 FIND v(dout0_31) AT=625.025n

* CHECK dout0_32 Vdout0_32ck124 = 0 time = 625
.meas tran vdout0_32ck124 FIND v(dout0_32) AT=625.025n

* CHECK dout0_33 Vdout0_33ck124 = 0.9 time = 625
.meas tran vdout0_33ck124 FIND v(dout0_33) AT=625.025n

* CHECK dout0_34 Vdout0_34ck124 = 0 time = 625
.meas tran vdout0_34ck124 FIND v(dout0_34) AT=625.025n

* CHECK dout0_35 Vdout0_35ck124 = 0 time = 625
.meas tran vdout0_35ck124 FIND v(dout0_35) AT=625.025n

* CHECK dout0_36 Vdout0_36ck124 = 0 time = 625
.meas tran vdout0_36ck124 FIND v(dout0_36) AT=625.025n

* CHECK dout0_37 Vdout0_37ck124 = 0.9 time = 625
.meas tran vdout0_37ck124 FIND v(dout0_37) AT=625.025n

* CHECK dout0_38 Vdout0_38ck124 = 0.9 time = 625
.meas tran vdout0_38ck124 FIND v(dout0_38) AT=625.025n

* CHECK dout0_39 Vdout0_39ck124 = 0.9 time = 625
.meas tran vdout0_39ck124 FIND v(dout0_39) AT=625.025n

* CHECK dout0_40 Vdout0_40ck124 = 0.9 time = 625
.meas tran vdout0_40ck124 FIND v(dout0_40) AT=625.025n

* CHECK dout0_41 Vdout0_41ck124 = 0.9 time = 625
.meas tran vdout0_41ck124 FIND v(dout0_41) AT=625.025n

* CHECK dout0_42 Vdout0_42ck124 = 0 time = 625
.meas tran vdout0_42ck124 FIND v(dout0_42) AT=625.025n

* CHECK dout0_43 Vdout0_43ck124 = 0 time = 625
.meas tran vdout0_43ck124 FIND v(dout0_43) AT=625.025n

* CHECK dout0_44 Vdout0_44ck124 = 0 time = 625
.meas tran vdout0_44ck124 FIND v(dout0_44) AT=625.025n

* CHECK dout0_45 Vdout0_45ck124 = 0 time = 625
.meas tran vdout0_45ck124 FIND v(dout0_45) AT=625.025n

* CHECK dout0_46 Vdout0_46ck124 = 0 time = 625
.meas tran vdout0_46ck124 FIND v(dout0_46) AT=625.025n

* CHECK dout0_47 Vdout0_47ck124 = 0.9 time = 625
.meas tran vdout0_47ck124 FIND v(dout0_47) AT=625.025n

* CHECK dout0_48 Vdout0_48ck124 = 0.9 time = 625
.meas tran vdout0_48ck124 FIND v(dout0_48) AT=625.025n

* CHECK dout0_49 Vdout0_49ck124 = 0 time = 625
.meas tran vdout0_49ck124 FIND v(dout0_49) AT=625.025n

* CHECK dout0_50 Vdout0_50ck124 = 0.9 time = 625
.meas tran vdout0_50ck124 FIND v(dout0_50) AT=625.025n

* CHECK dout0_51 Vdout0_51ck124 = 0 time = 625
.meas tran vdout0_51ck124 FIND v(dout0_51) AT=625.025n

* CHECK dout0_52 Vdout0_52ck124 = 0 time = 625
.meas tran vdout0_52ck124 FIND v(dout0_52) AT=625.025n

* CHECK dout0_53 Vdout0_53ck124 = 0.9 time = 625
.meas tran vdout0_53ck124 FIND v(dout0_53) AT=625.025n

* CHECK dout0_54 Vdout0_54ck124 = 0 time = 625
.meas tran vdout0_54ck124 FIND v(dout0_54) AT=625.025n

* CHECK dout0_55 Vdout0_55ck124 = 0.9 time = 625
.meas tran vdout0_55ck124 FIND v(dout0_55) AT=625.025n

* CHECK dout0_56 Vdout0_56ck124 = 0.9 time = 625
.meas tran vdout0_56ck124 FIND v(dout0_56) AT=625.025n

* CHECK dout0_57 Vdout0_57ck124 = 0 time = 625
.meas tran vdout0_57ck124 FIND v(dout0_57) AT=625.025n

* CHECK dout0_58 Vdout0_58ck124 = 0.9 time = 625
.meas tran vdout0_58ck124 FIND v(dout0_58) AT=625.025n

* CHECK dout0_59 Vdout0_59ck124 = 0 time = 625
.meas tran vdout0_59ck124 FIND v(dout0_59) AT=625.025n

* CHECK dout0_60 Vdout0_60ck124 = 0.9 time = 625
.meas tran vdout0_60ck124 FIND v(dout0_60) AT=625.025n

* CHECK dout0_61 Vdout0_61ck124 = 0 time = 625
.meas tran vdout0_61ck124 FIND v(dout0_61) AT=625.025n

* CHECK dout0_62 Vdout0_62ck124 = 0 time = 625
.meas tran vdout0_62ck124 FIND v(dout0_62) AT=625.025n

* CHECK dout0_63 Vdout0_63ck124 = 0 time = 625
.meas tran vdout0_63ck124 FIND v(dout0_63) AT=625.025n

* CHECK dout0_0 Vdout0_0ck128 = 0 time = 645
.meas tran vdout0_0ck128 FIND v(dout0_0) AT=645.025n

* CHECK dout0_1 Vdout0_1ck128 = 0 time = 645
.meas tran vdout0_1ck128 FIND v(dout0_1) AT=645.025n

* CHECK dout0_2 Vdout0_2ck128 = 0.9 time = 645
.meas tran vdout0_2ck128 FIND v(dout0_2) AT=645.025n

* CHECK dout0_3 Vdout0_3ck128 = 0.9 time = 645
.meas tran vdout0_3ck128 FIND v(dout0_3) AT=645.025n

* CHECK dout0_4 Vdout0_4ck128 = 0 time = 645
.meas tran vdout0_4ck128 FIND v(dout0_4) AT=645.025n

* CHECK dout0_5 Vdout0_5ck128 = 0.9 time = 645
.meas tran vdout0_5ck128 FIND v(dout0_5) AT=645.025n

* CHECK dout0_6 Vdout0_6ck128 = 0 time = 645
.meas tran vdout0_6ck128 FIND v(dout0_6) AT=645.025n

* CHECK dout0_7 Vdout0_7ck128 = 0 time = 645
.meas tran vdout0_7ck128 FIND v(dout0_7) AT=645.025n

* CHECK dout0_8 Vdout0_8ck128 = 0 time = 645
.meas tran vdout0_8ck128 FIND v(dout0_8) AT=645.025n

* CHECK dout0_9 Vdout0_9ck128 = 0.9 time = 645
.meas tran vdout0_9ck128 FIND v(dout0_9) AT=645.025n

* CHECK dout0_10 Vdout0_10ck128 = 0.9 time = 645
.meas tran vdout0_10ck128 FIND v(dout0_10) AT=645.025n

* CHECK dout0_11 Vdout0_11ck128 = 0.9 time = 645
.meas tran vdout0_11ck128 FIND v(dout0_11) AT=645.025n

* CHECK dout0_12 Vdout0_12ck128 = 0.9 time = 645
.meas tran vdout0_12ck128 FIND v(dout0_12) AT=645.025n

* CHECK dout0_13 Vdout0_13ck128 = 0.9 time = 645
.meas tran vdout0_13ck128 FIND v(dout0_13) AT=645.025n

* CHECK dout0_14 Vdout0_14ck128 = 0.9 time = 645
.meas tran vdout0_14ck128 FIND v(dout0_14) AT=645.025n

* CHECK dout0_15 Vdout0_15ck128 = 0 time = 645
.meas tran vdout0_15ck128 FIND v(dout0_15) AT=645.025n

* CHECK dout0_16 Vdout0_16ck128 = 0.9 time = 645
.meas tran vdout0_16ck128 FIND v(dout0_16) AT=645.025n

* CHECK dout0_17 Vdout0_17ck128 = 0.9 time = 645
.meas tran vdout0_17ck128 FIND v(dout0_17) AT=645.025n

* CHECK dout0_18 Vdout0_18ck128 = 0.9 time = 645
.meas tran vdout0_18ck128 FIND v(dout0_18) AT=645.025n

* CHECK dout0_19 Vdout0_19ck128 = 0 time = 645
.meas tran vdout0_19ck128 FIND v(dout0_19) AT=645.025n

* CHECK dout0_20 Vdout0_20ck128 = 0 time = 645
.meas tran vdout0_20ck128 FIND v(dout0_20) AT=645.025n

* CHECK dout0_21 Vdout0_21ck128 = 0.9 time = 645
.meas tran vdout0_21ck128 FIND v(dout0_21) AT=645.025n

* CHECK dout0_22 Vdout0_22ck128 = 0 time = 645
.meas tran vdout0_22ck128 FIND v(dout0_22) AT=645.025n

* CHECK dout0_23 Vdout0_23ck128 = 0.9 time = 645
.meas tran vdout0_23ck128 FIND v(dout0_23) AT=645.025n

* CHECK dout0_24 Vdout0_24ck128 = 0.9 time = 645
.meas tran vdout0_24ck128 FIND v(dout0_24) AT=645.025n

* CHECK dout0_25 Vdout0_25ck128 = 0 time = 645
.meas tran vdout0_25ck128 FIND v(dout0_25) AT=645.025n

* CHECK dout0_26 Vdout0_26ck128 = 0 time = 645
.meas tran vdout0_26ck128 FIND v(dout0_26) AT=645.025n

* CHECK dout0_27 Vdout0_27ck128 = 0.9 time = 645
.meas tran vdout0_27ck128 FIND v(dout0_27) AT=645.025n

* CHECK dout0_28 Vdout0_28ck128 = 0 time = 645
.meas tran vdout0_28ck128 FIND v(dout0_28) AT=645.025n

* CHECK dout0_29 Vdout0_29ck128 = 0.9 time = 645
.meas tran vdout0_29ck128 FIND v(dout0_29) AT=645.025n

* CHECK dout0_30 Vdout0_30ck128 = 0 time = 645
.meas tran vdout0_30ck128 FIND v(dout0_30) AT=645.025n

* CHECK dout0_31 Vdout0_31ck128 = 0 time = 645
.meas tran vdout0_31ck128 FIND v(dout0_31) AT=645.025n

* CHECK dout0_32 Vdout0_32ck128 = 0.9 time = 645
.meas tran vdout0_32ck128 FIND v(dout0_32) AT=645.025n

* CHECK dout0_33 Vdout0_33ck128 = 0 time = 645
.meas tran vdout0_33ck128 FIND v(dout0_33) AT=645.025n

* CHECK dout0_34 Vdout0_34ck128 = 0 time = 645
.meas tran vdout0_34ck128 FIND v(dout0_34) AT=645.025n

* CHECK dout0_35 Vdout0_35ck128 = 0.9 time = 645
.meas tran vdout0_35ck128 FIND v(dout0_35) AT=645.025n

* CHECK dout0_36 Vdout0_36ck128 = 0 time = 645
.meas tran vdout0_36ck128 FIND v(dout0_36) AT=645.025n

* CHECK dout0_37 Vdout0_37ck128 = 0.9 time = 645
.meas tran vdout0_37ck128 FIND v(dout0_37) AT=645.025n

* CHECK dout0_38 Vdout0_38ck128 = 0.9 time = 645
.meas tran vdout0_38ck128 FIND v(dout0_38) AT=645.025n

* CHECK dout0_39 Vdout0_39ck128 = 0.9 time = 645
.meas tran vdout0_39ck128 FIND v(dout0_39) AT=645.025n

* CHECK dout0_40 Vdout0_40ck128 = 0 time = 645
.meas tran vdout0_40ck128 FIND v(dout0_40) AT=645.025n

* CHECK dout0_41 Vdout0_41ck128 = 0 time = 645
.meas tran vdout0_41ck128 FIND v(dout0_41) AT=645.025n

* CHECK dout0_42 Vdout0_42ck128 = 0 time = 645
.meas tran vdout0_42ck128 FIND v(dout0_42) AT=645.025n

* CHECK dout0_43 Vdout0_43ck128 = 0.9 time = 645
.meas tran vdout0_43ck128 FIND v(dout0_43) AT=645.025n

* CHECK dout0_44 Vdout0_44ck128 = 0 time = 645
.meas tran vdout0_44ck128 FIND v(dout0_44) AT=645.025n

* CHECK dout0_45 Vdout0_45ck128 = 0.9 time = 645
.meas tran vdout0_45ck128 FIND v(dout0_45) AT=645.025n

* CHECK dout0_46 Vdout0_46ck128 = 0 time = 645
.meas tran vdout0_46ck128 FIND v(dout0_46) AT=645.025n

* CHECK dout0_47 Vdout0_47ck128 = 0.9 time = 645
.meas tran vdout0_47ck128 FIND v(dout0_47) AT=645.025n

* CHECK dout0_48 Vdout0_48ck128 = 0.9 time = 645
.meas tran vdout0_48ck128 FIND v(dout0_48) AT=645.025n

* CHECK dout0_49 Vdout0_49ck128 = 0.9 time = 645
.meas tran vdout0_49ck128 FIND v(dout0_49) AT=645.025n

* CHECK dout0_50 Vdout0_50ck128 = 0 time = 645
.meas tran vdout0_50ck128 FIND v(dout0_50) AT=645.025n

* CHECK dout0_51 Vdout0_51ck128 = 0.9 time = 645
.meas tran vdout0_51ck128 FIND v(dout0_51) AT=645.025n

* CHECK dout0_52 Vdout0_52ck128 = 0.9 time = 645
.meas tran vdout0_52ck128 FIND v(dout0_52) AT=645.025n

* CHECK dout0_53 Vdout0_53ck128 = 0 time = 645
.meas tran vdout0_53ck128 FIND v(dout0_53) AT=645.025n

* CHECK dout0_54 Vdout0_54ck128 = 0.9 time = 645
.meas tran vdout0_54ck128 FIND v(dout0_54) AT=645.025n

* CHECK dout0_55 Vdout0_55ck128 = 0 time = 645
.meas tran vdout0_55ck128 FIND v(dout0_55) AT=645.025n

* CHECK dout0_56 Vdout0_56ck128 = 0 time = 645
.meas tran vdout0_56ck128 FIND v(dout0_56) AT=645.025n

* CHECK dout0_57 Vdout0_57ck128 = 0.9 time = 645
.meas tran vdout0_57ck128 FIND v(dout0_57) AT=645.025n

* CHECK dout0_58 Vdout0_58ck128 = 0.9 time = 645
.meas tran vdout0_58ck128 FIND v(dout0_58) AT=645.025n

* CHECK dout0_59 Vdout0_59ck128 = 0.9 time = 645
.meas tran vdout0_59ck128 FIND v(dout0_59) AT=645.025n

* CHECK dout0_60 Vdout0_60ck128 = 0.9 time = 645
.meas tran vdout0_60ck128 FIND v(dout0_60) AT=645.025n

* CHECK dout0_61 Vdout0_61ck128 = 0 time = 645
.meas tran vdout0_61ck128 FIND v(dout0_61) AT=645.025n

* CHECK dout0_62 Vdout0_62ck128 = 0 time = 645
.meas tran vdout0_62ck128 FIND v(dout0_62) AT=645.025n

* CHECK dout0_63 Vdout0_63ck128 = 0 time = 645
.meas tran vdout0_63ck128 FIND v(dout0_63) AT=645.025n

* CHECK dout0_0 Vdout0_0ck129 = 0.9 time = 650
.meas tran vdout0_0ck129 FIND v(dout0_0) AT=650.025n

* CHECK dout0_1 Vdout0_1ck129 = 0 time = 650
.meas tran vdout0_1ck129 FIND v(dout0_1) AT=650.025n

* CHECK dout0_2 Vdout0_2ck129 = 0.9 time = 650
.meas tran vdout0_2ck129 FIND v(dout0_2) AT=650.025n

* CHECK dout0_3 Vdout0_3ck129 = 0 time = 650
.meas tran vdout0_3ck129 FIND v(dout0_3) AT=650.025n

* CHECK dout0_4 Vdout0_4ck129 = 0 time = 650
.meas tran vdout0_4ck129 FIND v(dout0_4) AT=650.025n

* CHECK dout0_5 Vdout0_5ck129 = 0.9 time = 650
.meas tran vdout0_5ck129 FIND v(dout0_5) AT=650.025n

* CHECK dout0_6 Vdout0_6ck129 = 0 time = 650
.meas tran vdout0_6ck129 FIND v(dout0_6) AT=650.025n

* CHECK dout0_7 Vdout0_7ck129 = 0 time = 650
.meas tran vdout0_7ck129 FIND v(dout0_7) AT=650.025n

* CHECK dout0_8 Vdout0_8ck129 = 0.9 time = 650
.meas tran vdout0_8ck129 FIND v(dout0_8) AT=650.025n

* CHECK dout0_9 Vdout0_9ck129 = 0.9 time = 650
.meas tran vdout0_9ck129 FIND v(dout0_9) AT=650.025n

* CHECK dout0_10 Vdout0_10ck129 = 0.9 time = 650
.meas tran vdout0_10ck129 FIND v(dout0_10) AT=650.025n

* CHECK dout0_11 Vdout0_11ck129 = 0.9 time = 650
.meas tran vdout0_11ck129 FIND v(dout0_11) AT=650.025n

* CHECK dout0_12 Vdout0_12ck129 = 0 time = 650
.meas tran vdout0_12ck129 FIND v(dout0_12) AT=650.025n

* CHECK dout0_13 Vdout0_13ck129 = 0.9 time = 650
.meas tran vdout0_13ck129 FIND v(dout0_13) AT=650.025n

* CHECK dout0_14 Vdout0_14ck129 = 0.9 time = 650
.meas tran vdout0_14ck129 FIND v(dout0_14) AT=650.025n

* CHECK dout0_15 Vdout0_15ck129 = 0 time = 650
.meas tran vdout0_15ck129 FIND v(dout0_15) AT=650.025n

* CHECK dout0_16 Vdout0_16ck129 = 0.9 time = 650
.meas tran vdout0_16ck129 FIND v(dout0_16) AT=650.025n

* CHECK dout0_17 Vdout0_17ck129 = 0.9 time = 650
.meas tran vdout0_17ck129 FIND v(dout0_17) AT=650.025n

* CHECK dout0_18 Vdout0_18ck129 = 0 time = 650
.meas tran vdout0_18ck129 FIND v(dout0_18) AT=650.025n

* CHECK dout0_19 Vdout0_19ck129 = 0.9 time = 650
.meas tran vdout0_19ck129 FIND v(dout0_19) AT=650.025n

* CHECK dout0_20 Vdout0_20ck129 = 0 time = 650
.meas tran vdout0_20ck129 FIND v(dout0_20) AT=650.025n

* CHECK dout0_21 Vdout0_21ck129 = 0.9 time = 650
.meas tran vdout0_21ck129 FIND v(dout0_21) AT=650.025n

* CHECK dout0_22 Vdout0_22ck129 = 0 time = 650
.meas tran vdout0_22ck129 FIND v(dout0_22) AT=650.025n

* CHECK dout0_23 Vdout0_23ck129 = 0.9 time = 650
.meas tran vdout0_23ck129 FIND v(dout0_23) AT=650.025n

* CHECK dout0_24 Vdout0_24ck129 = 0.9 time = 650
.meas tran vdout0_24ck129 FIND v(dout0_24) AT=650.025n

* CHECK dout0_25 Vdout0_25ck129 = 0.9 time = 650
.meas tran vdout0_25ck129 FIND v(dout0_25) AT=650.025n

* CHECK dout0_26 Vdout0_26ck129 = 0 time = 650
.meas tran vdout0_26ck129 FIND v(dout0_26) AT=650.025n

* CHECK dout0_27 Vdout0_27ck129 = 0.9 time = 650
.meas tran vdout0_27ck129 FIND v(dout0_27) AT=650.025n

* CHECK dout0_28 Vdout0_28ck129 = 0.9 time = 650
.meas tran vdout0_28ck129 FIND v(dout0_28) AT=650.025n

* CHECK dout0_29 Vdout0_29ck129 = 0 time = 650
.meas tran vdout0_29ck129 FIND v(dout0_29) AT=650.025n

* CHECK dout0_30 Vdout0_30ck129 = 0 time = 650
.meas tran vdout0_30ck129 FIND v(dout0_30) AT=650.025n

* CHECK dout0_31 Vdout0_31ck129 = 0.9 time = 650
.meas tran vdout0_31ck129 FIND v(dout0_31) AT=650.025n

* CHECK dout0_32 Vdout0_32ck129 = 0 time = 650
.meas tran vdout0_32ck129 FIND v(dout0_32) AT=650.025n

* CHECK dout0_33 Vdout0_33ck129 = 0 time = 650
.meas tran vdout0_33ck129 FIND v(dout0_33) AT=650.025n

* CHECK dout0_34 Vdout0_34ck129 = 0.9 time = 650
.meas tran vdout0_34ck129 FIND v(dout0_34) AT=650.025n

* CHECK dout0_35 Vdout0_35ck129 = 0.9 time = 650
.meas tran vdout0_35ck129 FIND v(dout0_35) AT=650.025n

* CHECK dout0_36 Vdout0_36ck129 = 0.9 time = 650
.meas tran vdout0_36ck129 FIND v(dout0_36) AT=650.025n

* CHECK dout0_37 Vdout0_37ck129 = 0 time = 650
.meas tran vdout0_37ck129 FIND v(dout0_37) AT=650.025n

* CHECK dout0_38 Vdout0_38ck129 = 0 time = 650
.meas tran vdout0_38ck129 FIND v(dout0_38) AT=650.025n

* CHECK dout0_39 Vdout0_39ck129 = 0 time = 650
.meas tran vdout0_39ck129 FIND v(dout0_39) AT=650.025n

* CHECK dout0_40 Vdout0_40ck129 = 0.9 time = 650
.meas tran vdout0_40ck129 FIND v(dout0_40) AT=650.025n

* CHECK dout0_41 Vdout0_41ck129 = 0 time = 650
.meas tran vdout0_41ck129 FIND v(dout0_41) AT=650.025n

* CHECK dout0_42 Vdout0_42ck129 = 0 time = 650
.meas tran vdout0_42ck129 FIND v(dout0_42) AT=650.025n

* CHECK dout0_43 Vdout0_43ck129 = 0 time = 650
.meas tran vdout0_43ck129 FIND v(dout0_43) AT=650.025n

* CHECK dout0_44 Vdout0_44ck129 = 0 time = 650
.meas tran vdout0_44ck129 FIND v(dout0_44) AT=650.025n

* CHECK dout0_45 Vdout0_45ck129 = 0 time = 650
.meas tran vdout0_45ck129 FIND v(dout0_45) AT=650.025n

* CHECK dout0_46 Vdout0_46ck129 = 0.9 time = 650
.meas tran vdout0_46ck129 FIND v(dout0_46) AT=650.025n

* CHECK dout0_47 Vdout0_47ck129 = 0.9 time = 650
.meas tran vdout0_47ck129 FIND v(dout0_47) AT=650.025n

* CHECK dout0_48 Vdout0_48ck129 = 0 time = 650
.meas tran vdout0_48ck129 FIND v(dout0_48) AT=650.025n

* CHECK dout0_49 Vdout0_49ck129 = 0.9 time = 650
.meas tran vdout0_49ck129 FIND v(dout0_49) AT=650.025n

* CHECK dout0_50 Vdout0_50ck129 = 0 time = 650
.meas tran vdout0_50ck129 FIND v(dout0_50) AT=650.025n

* CHECK dout0_51 Vdout0_51ck129 = 0 time = 650
.meas tran vdout0_51ck129 FIND v(dout0_51) AT=650.025n

* CHECK dout0_52 Vdout0_52ck129 = 0.9 time = 650
.meas tran vdout0_52ck129 FIND v(dout0_52) AT=650.025n

* CHECK dout0_53 Vdout0_53ck129 = 0.9 time = 650
.meas tran vdout0_53ck129 FIND v(dout0_53) AT=650.025n

* CHECK dout0_54 Vdout0_54ck129 = 0 time = 650
.meas tran vdout0_54ck129 FIND v(dout0_54) AT=650.025n

* CHECK dout0_55 Vdout0_55ck129 = 0.9 time = 650
.meas tran vdout0_55ck129 FIND v(dout0_55) AT=650.025n

* CHECK dout0_56 Vdout0_56ck129 = 0 time = 650
.meas tran vdout0_56ck129 FIND v(dout0_56) AT=650.025n

* CHECK dout0_57 Vdout0_57ck129 = 0 time = 650
.meas tran vdout0_57ck129 FIND v(dout0_57) AT=650.025n

* CHECK dout0_58 Vdout0_58ck129 = 0.9 time = 650
.meas tran vdout0_58ck129 FIND v(dout0_58) AT=650.025n

* CHECK dout0_59 Vdout0_59ck129 = 0.9 time = 650
.meas tran vdout0_59ck129 FIND v(dout0_59) AT=650.025n

* CHECK dout0_60 Vdout0_60ck129 = 0 time = 650
.meas tran vdout0_60ck129 FIND v(dout0_60) AT=650.025n

* CHECK dout0_61 Vdout0_61ck129 = 0.9 time = 650
.meas tran vdout0_61ck129 FIND v(dout0_61) AT=650.025n

* CHECK dout0_62 Vdout0_62ck129 = 0 time = 650
.meas tran vdout0_62ck129 FIND v(dout0_62) AT=650.025n

* CHECK dout0_63 Vdout0_63ck129 = 0.9 time = 650
.meas tran vdout0_63ck129 FIND v(dout0_63) AT=650.025n

* CHECK dout0_0 Vdout0_0ck131 = 0 time = 660
.meas tran vdout0_0ck131 FIND v(dout0_0) AT=660.025n

* CHECK dout0_1 Vdout0_1ck131 = 0 time = 660
.meas tran vdout0_1ck131 FIND v(dout0_1) AT=660.025n

* CHECK dout0_2 Vdout0_2ck131 = 0.9 time = 660
.meas tran vdout0_2ck131 FIND v(dout0_2) AT=660.025n

* CHECK dout0_3 Vdout0_3ck131 = 0.9 time = 660
.meas tran vdout0_3ck131 FIND v(dout0_3) AT=660.025n

* CHECK dout0_4 Vdout0_4ck131 = 0 time = 660
.meas tran vdout0_4ck131 FIND v(dout0_4) AT=660.025n

* CHECK dout0_5 Vdout0_5ck131 = 0.9 time = 660
.meas tran vdout0_5ck131 FIND v(dout0_5) AT=660.025n

* CHECK dout0_6 Vdout0_6ck131 = 0 time = 660
.meas tran vdout0_6ck131 FIND v(dout0_6) AT=660.025n

* CHECK dout0_7 Vdout0_7ck131 = 0 time = 660
.meas tran vdout0_7ck131 FIND v(dout0_7) AT=660.025n

* CHECK dout0_8 Vdout0_8ck131 = 0 time = 660
.meas tran vdout0_8ck131 FIND v(dout0_8) AT=660.025n

* CHECK dout0_9 Vdout0_9ck131 = 0.9 time = 660
.meas tran vdout0_9ck131 FIND v(dout0_9) AT=660.025n

* CHECK dout0_10 Vdout0_10ck131 = 0.9 time = 660
.meas tran vdout0_10ck131 FIND v(dout0_10) AT=660.025n

* CHECK dout0_11 Vdout0_11ck131 = 0.9 time = 660
.meas tran vdout0_11ck131 FIND v(dout0_11) AT=660.025n

* CHECK dout0_12 Vdout0_12ck131 = 0.9 time = 660
.meas tran vdout0_12ck131 FIND v(dout0_12) AT=660.025n

* CHECK dout0_13 Vdout0_13ck131 = 0.9 time = 660
.meas tran vdout0_13ck131 FIND v(dout0_13) AT=660.025n

* CHECK dout0_14 Vdout0_14ck131 = 0.9 time = 660
.meas tran vdout0_14ck131 FIND v(dout0_14) AT=660.025n

* CHECK dout0_15 Vdout0_15ck131 = 0 time = 660
.meas tran vdout0_15ck131 FIND v(dout0_15) AT=660.025n

* CHECK dout0_16 Vdout0_16ck131 = 0.9 time = 660
.meas tran vdout0_16ck131 FIND v(dout0_16) AT=660.025n

* CHECK dout0_17 Vdout0_17ck131 = 0.9 time = 660
.meas tran vdout0_17ck131 FIND v(dout0_17) AT=660.025n

* CHECK dout0_18 Vdout0_18ck131 = 0.9 time = 660
.meas tran vdout0_18ck131 FIND v(dout0_18) AT=660.025n

* CHECK dout0_19 Vdout0_19ck131 = 0 time = 660
.meas tran vdout0_19ck131 FIND v(dout0_19) AT=660.025n

* CHECK dout0_20 Vdout0_20ck131 = 0 time = 660
.meas tran vdout0_20ck131 FIND v(dout0_20) AT=660.025n

* CHECK dout0_21 Vdout0_21ck131 = 0.9 time = 660
.meas tran vdout0_21ck131 FIND v(dout0_21) AT=660.025n

* CHECK dout0_22 Vdout0_22ck131 = 0 time = 660
.meas tran vdout0_22ck131 FIND v(dout0_22) AT=660.025n

* CHECK dout0_23 Vdout0_23ck131 = 0.9 time = 660
.meas tran vdout0_23ck131 FIND v(dout0_23) AT=660.025n

* CHECK dout0_24 Vdout0_24ck131 = 0.9 time = 660
.meas tran vdout0_24ck131 FIND v(dout0_24) AT=660.025n

* CHECK dout0_25 Vdout0_25ck131 = 0 time = 660
.meas tran vdout0_25ck131 FIND v(dout0_25) AT=660.025n

* CHECK dout0_26 Vdout0_26ck131 = 0 time = 660
.meas tran vdout0_26ck131 FIND v(dout0_26) AT=660.025n

* CHECK dout0_27 Vdout0_27ck131 = 0.9 time = 660
.meas tran vdout0_27ck131 FIND v(dout0_27) AT=660.025n

* CHECK dout0_28 Vdout0_28ck131 = 0 time = 660
.meas tran vdout0_28ck131 FIND v(dout0_28) AT=660.025n

* CHECK dout0_29 Vdout0_29ck131 = 0.9 time = 660
.meas tran vdout0_29ck131 FIND v(dout0_29) AT=660.025n

* CHECK dout0_30 Vdout0_30ck131 = 0 time = 660
.meas tran vdout0_30ck131 FIND v(dout0_30) AT=660.025n

* CHECK dout0_31 Vdout0_31ck131 = 0 time = 660
.meas tran vdout0_31ck131 FIND v(dout0_31) AT=660.025n

* CHECK dout0_32 Vdout0_32ck131 = 0.9 time = 660
.meas tran vdout0_32ck131 FIND v(dout0_32) AT=660.025n

* CHECK dout0_33 Vdout0_33ck131 = 0 time = 660
.meas tran vdout0_33ck131 FIND v(dout0_33) AT=660.025n

* CHECK dout0_34 Vdout0_34ck131 = 0 time = 660
.meas tran vdout0_34ck131 FIND v(dout0_34) AT=660.025n

* CHECK dout0_35 Vdout0_35ck131 = 0.9 time = 660
.meas tran vdout0_35ck131 FIND v(dout0_35) AT=660.025n

* CHECK dout0_36 Vdout0_36ck131 = 0 time = 660
.meas tran vdout0_36ck131 FIND v(dout0_36) AT=660.025n

* CHECK dout0_37 Vdout0_37ck131 = 0.9 time = 660
.meas tran vdout0_37ck131 FIND v(dout0_37) AT=660.025n

* CHECK dout0_38 Vdout0_38ck131 = 0.9 time = 660
.meas tran vdout0_38ck131 FIND v(dout0_38) AT=660.025n

* CHECK dout0_39 Vdout0_39ck131 = 0.9 time = 660
.meas tran vdout0_39ck131 FIND v(dout0_39) AT=660.025n

* CHECK dout0_40 Vdout0_40ck131 = 0 time = 660
.meas tran vdout0_40ck131 FIND v(dout0_40) AT=660.025n

* CHECK dout0_41 Vdout0_41ck131 = 0 time = 660
.meas tran vdout0_41ck131 FIND v(dout0_41) AT=660.025n

* CHECK dout0_42 Vdout0_42ck131 = 0 time = 660
.meas tran vdout0_42ck131 FIND v(dout0_42) AT=660.025n

* CHECK dout0_43 Vdout0_43ck131 = 0.9 time = 660
.meas tran vdout0_43ck131 FIND v(dout0_43) AT=660.025n

* CHECK dout0_44 Vdout0_44ck131 = 0 time = 660
.meas tran vdout0_44ck131 FIND v(dout0_44) AT=660.025n

* CHECK dout0_45 Vdout0_45ck131 = 0.9 time = 660
.meas tran vdout0_45ck131 FIND v(dout0_45) AT=660.025n

* CHECK dout0_46 Vdout0_46ck131 = 0 time = 660
.meas tran vdout0_46ck131 FIND v(dout0_46) AT=660.025n

* CHECK dout0_47 Vdout0_47ck131 = 0.9 time = 660
.meas tran vdout0_47ck131 FIND v(dout0_47) AT=660.025n

* CHECK dout0_48 Vdout0_48ck131 = 0.9 time = 660
.meas tran vdout0_48ck131 FIND v(dout0_48) AT=660.025n

* CHECK dout0_49 Vdout0_49ck131 = 0.9 time = 660
.meas tran vdout0_49ck131 FIND v(dout0_49) AT=660.025n

* CHECK dout0_50 Vdout0_50ck131 = 0 time = 660
.meas tran vdout0_50ck131 FIND v(dout0_50) AT=660.025n

* CHECK dout0_51 Vdout0_51ck131 = 0.9 time = 660
.meas tran vdout0_51ck131 FIND v(dout0_51) AT=660.025n

* CHECK dout0_52 Vdout0_52ck131 = 0.9 time = 660
.meas tran vdout0_52ck131 FIND v(dout0_52) AT=660.025n

* CHECK dout0_53 Vdout0_53ck131 = 0 time = 660
.meas tran vdout0_53ck131 FIND v(dout0_53) AT=660.025n

* CHECK dout0_54 Vdout0_54ck131 = 0.9 time = 660
.meas tran vdout0_54ck131 FIND v(dout0_54) AT=660.025n

* CHECK dout0_55 Vdout0_55ck131 = 0 time = 660
.meas tran vdout0_55ck131 FIND v(dout0_55) AT=660.025n

* CHECK dout0_56 Vdout0_56ck131 = 0 time = 660
.meas tran vdout0_56ck131 FIND v(dout0_56) AT=660.025n

* CHECK dout0_57 Vdout0_57ck131 = 0.9 time = 660
.meas tran vdout0_57ck131 FIND v(dout0_57) AT=660.025n

* CHECK dout0_58 Vdout0_58ck131 = 0.9 time = 660
.meas tran vdout0_58ck131 FIND v(dout0_58) AT=660.025n

* CHECK dout0_59 Vdout0_59ck131 = 0.9 time = 660
.meas tran vdout0_59ck131 FIND v(dout0_59) AT=660.025n

* CHECK dout0_60 Vdout0_60ck131 = 0.9 time = 660
.meas tran vdout0_60ck131 FIND v(dout0_60) AT=660.025n

* CHECK dout0_61 Vdout0_61ck131 = 0 time = 660
.meas tran vdout0_61ck131 FIND v(dout0_61) AT=660.025n

* CHECK dout0_62 Vdout0_62ck131 = 0 time = 660
.meas tran vdout0_62ck131 FIND v(dout0_62) AT=660.025n

* CHECK dout0_63 Vdout0_63ck131 = 0 time = 660
.meas tran vdout0_63ck131 FIND v(dout0_63) AT=660.025n

* CHECK dout0_0 Vdout0_0ck133 = 0.9 time = 670
.meas tran vdout0_0ck133 FIND v(dout0_0) AT=670.025n

* CHECK dout0_1 Vdout0_1ck133 = 0 time = 670
.meas tran vdout0_1ck133 FIND v(dout0_1) AT=670.025n

* CHECK dout0_2 Vdout0_2ck133 = 0.9 time = 670
.meas tran vdout0_2ck133 FIND v(dout0_2) AT=670.025n

* CHECK dout0_3 Vdout0_3ck133 = 0 time = 670
.meas tran vdout0_3ck133 FIND v(dout0_3) AT=670.025n

* CHECK dout0_4 Vdout0_4ck133 = 0 time = 670
.meas tran vdout0_4ck133 FIND v(dout0_4) AT=670.025n

* CHECK dout0_5 Vdout0_5ck133 = 0 time = 670
.meas tran vdout0_5ck133 FIND v(dout0_5) AT=670.025n

* CHECK dout0_6 Vdout0_6ck133 = 0.9 time = 670
.meas tran vdout0_6ck133 FIND v(dout0_6) AT=670.025n

* CHECK dout0_7 Vdout0_7ck133 = 0.9 time = 670
.meas tran vdout0_7ck133 FIND v(dout0_7) AT=670.025n

* CHECK dout0_8 Vdout0_8ck133 = 0 time = 670
.meas tran vdout0_8ck133 FIND v(dout0_8) AT=670.025n

* CHECK dout0_9 Vdout0_9ck133 = 0 time = 670
.meas tran vdout0_9ck133 FIND v(dout0_9) AT=670.025n

* CHECK dout0_10 Vdout0_10ck133 = 0.9 time = 670
.meas tran vdout0_10ck133 FIND v(dout0_10) AT=670.025n

* CHECK dout0_11 Vdout0_11ck133 = 0 time = 670
.meas tran vdout0_11ck133 FIND v(dout0_11) AT=670.025n

* CHECK dout0_12 Vdout0_12ck133 = 0 time = 670
.meas tran vdout0_12ck133 FIND v(dout0_12) AT=670.025n

* CHECK dout0_13 Vdout0_13ck133 = 0 time = 670
.meas tran vdout0_13ck133 FIND v(dout0_13) AT=670.025n

* CHECK dout0_14 Vdout0_14ck133 = 0.9 time = 670
.meas tran vdout0_14ck133 FIND v(dout0_14) AT=670.025n

* CHECK dout0_15 Vdout0_15ck133 = 0 time = 670
.meas tran vdout0_15ck133 FIND v(dout0_15) AT=670.025n

* CHECK dout0_16 Vdout0_16ck133 = 0.9 time = 670
.meas tran vdout0_16ck133 FIND v(dout0_16) AT=670.025n

* CHECK dout0_17 Vdout0_17ck133 = 0.9 time = 670
.meas tran vdout0_17ck133 FIND v(dout0_17) AT=670.025n

* CHECK dout0_18 Vdout0_18ck133 = 0.9 time = 670
.meas tran vdout0_18ck133 FIND v(dout0_18) AT=670.025n

* CHECK dout0_19 Vdout0_19ck133 = 0 time = 670
.meas tran vdout0_19ck133 FIND v(dout0_19) AT=670.025n

* CHECK dout0_20 Vdout0_20ck133 = 0 time = 670
.meas tran vdout0_20ck133 FIND v(dout0_20) AT=670.025n

* CHECK dout0_21 Vdout0_21ck133 = 0.9 time = 670
.meas tran vdout0_21ck133 FIND v(dout0_21) AT=670.025n

* CHECK dout0_22 Vdout0_22ck133 = 0.9 time = 670
.meas tran vdout0_22ck133 FIND v(dout0_22) AT=670.025n

* CHECK dout0_23 Vdout0_23ck133 = 0.9 time = 670
.meas tran vdout0_23ck133 FIND v(dout0_23) AT=670.025n

* CHECK dout0_24 Vdout0_24ck133 = 0 time = 670
.meas tran vdout0_24ck133 FIND v(dout0_24) AT=670.025n

* CHECK dout0_25 Vdout0_25ck133 = 0 time = 670
.meas tran vdout0_25ck133 FIND v(dout0_25) AT=670.025n

* CHECK dout0_26 Vdout0_26ck133 = 0 time = 670
.meas tran vdout0_26ck133 FIND v(dout0_26) AT=670.025n

* CHECK dout0_27 Vdout0_27ck133 = 0.9 time = 670
.meas tran vdout0_27ck133 FIND v(dout0_27) AT=670.025n

* CHECK dout0_28 Vdout0_28ck133 = 0.9 time = 670
.meas tran vdout0_28ck133 FIND v(dout0_28) AT=670.025n

* CHECK dout0_29 Vdout0_29ck133 = 0.9 time = 670
.meas tran vdout0_29ck133 FIND v(dout0_29) AT=670.025n

* CHECK dout0_30 Vdout0_30ck133 = 0 time = 670
.meas tran vdout0_30ck133 FIND v(dout0_30) AT=670.025n

* CHECK dout0_31 Vdout0_31ck133 = 0.9 time = 670
.meas tran vdout0_31ck133 FIND v(dout0_31) AT=670.025n

* CHECK dout0_32 Vdout0_32ck133 = 0 time = 670
.meas tran vdout0_32ck133 FIND v(dout0_32) AT=670.025n

* CHECK dout0_33 Vdout0_33ck133 = 0.9 time = 670
.meas tran vdout0_33ck133 FIND v(dout0_33) AT=670.025n

* CHECK dout0_34 Vdout0_34ck133 = 0 time = 670
.meas tran vdout0_34ck133 FIND v(dout0_34) AT=670.025n

* CHECK dout0_35 Vdout0_35ck133 = 0 time = 670
.meas tran vdout0_35ck133 FIND v(dout0_35) AT=670.025n

* CHECK dout0_36 Vdout0_36ck133 = 0 time = 670
.meas tran vdout0_36ck133 FIND v(dout0_36) AT=670.025n

* CHECK dout0_37 Vdout0_37ck133 = 0.9 time = 670
.meas tran vdout0_37ck133 FIND v(dout0_37) AT=670.025n

* CHECK dout0_38 Vdout0_38ck133 = 0.9 time = 670
.meas tran vdout0_38ck133 FIND v(dout0_38) AT=670.025n

* CHECK dout0_39 Vdout0_39ck133 = 0.9 time = 670
.meas tran vdout0_39ck133 FIND v(dout0_39) AT=670.025n

* CHECK dout0_40 Vdout0_40ck133 = 0.9 time = 670
.meas tran vdout0_40ck133 FIND v(dout0_40) AT=670.025n

* CHECK dout0_41 Vdout0_41ck133 = 0 time = 670
.meas tran vdout0_41ck133 FIND v(dout0_41) AT=670.025n

* CHECK dout0_42 Vdout0_42ck133 = 0.9 time = 670
.meas tran vdout0_42ck133 FIND v(dout0_42) AT=670.025n

* CHECK dout0_43 Vdout0_43ck133 = 0.9 time = 670
.meas tran vdout0_43ck133 FIND v(dout0_43) AT=670.025n

* CHECK dout0_44 Vdout0_44ck133 = 0 time = 670
.meas tran vdout0_44ck133 FIND v(dout0_44) AT=670.025n

* CHECK dout0_45 Vdout0_45ck133 = 0.9 time = 670
.meas tran vdout0_45ck133 FIND v(dout0_45) AT=670.025n

* CHECK dout0_46 Vdout0_46ck133 = 0 time = 670
.meas tran vdout0_46ck133 FIND v(dout0_46) AT=670.025n

* CHECK dout0_47 Vdout0_47ck133 = 0 time = 670
.meas tran vdout0_47ck133 FIND v(dout0_47) AT=670.025n

* CHECK dout0_48 Vdout0_48ck133 = 0 time = 670
.meas tran vdout0_48ck133 FIND v(dout0_48) AT=670.025n

* CHECK dout0_49 Vdout0_49ck133 = 0 time = 670
.meas tran vdout0_49ck133 FIND v(dout0_49) AT=670.025n

* CHECK dout0_50 Vdout0_50ck133 = 0 time = 670
.meas tran vdout0_50ck133 FIND v(dout0_50) AT=670.025n

* CHECK dout0_51 Vdout0_51ck133 = 0 time = 670
.meas tran vdout0_51ck133 FIND v(dout0_51) AT=670.025n

* CHECK dout0_52 Vdout0_52ck133 = 0.9 time = 670
.meas tran vdout0_52ck133 FIND v(dout0_52) AT=670.025n

* CHECK dout0_53 Vdout0_53ck133 = 0 time = 670
.meas tran vdout0_53ck133 FIND v(dout0_53) AT=670.025n

* CHECK dout0_54 Vdout0_54ck133 = 0.9 time = 670
.meas tran vdout0_54ck133 FIND v(dout0_54) AT=670.025n

* CHECK dout0_55 Vdout0_55ck133 = 0.9 time = 670
.meas tran vdout0_55ck133 FIND v(dout0_55) AT=670.025n

* CHECK dout0_56 Vdout0_56ck133 = 0 time = 670
.meas tran vdout0_56ck133 FIND v(dout0_56) AT=670.025n

* CHECK dout0_57 Vdout0_57ck133 = 0 time = 670
.meas tran vdout0_57ck133 FIND v(dout0_57) AT=670.025n

* CHECK dout0_58 Vdout0_58ck133 = 0 time = 670
.meas tran vdout0_58ck133 FIND v(dout0_58) AT=670.025n

* CHECK dout0_59 Vdout0_59ck133 = 0 time = 670
.meas tran vdout0_59ck133 FIND v(dout0_59) AT=670.025n

* CHECK dout0_60 Vdout0_60ck133 = 0 time = 670
.meas tran vdout0_60ck133 FIND v(dout0_60) AT=670.025n

* CHECK dout0_61 Vdout0_61ck133 = 0 time = 670
.meas tran vdout0_61ck133 FIND v(dout0_61) AT=670.025n

* CHECK dout0_62 Vdout0_62ck133 = 0.9 time = 670
.meas tran vdout0_62ck133 FIND v(dout0_62) AT=670.025n

* CHECK dout0_63 Vdout0_63ck133 = 0 time = 670
.meas tran vdout0_63ck133 FIND v(dout0_63) AT=670.025n

* CHECK dout0_0 Vdout0_0ck135 = 0.9 time = 680
.meas tran vdout0_0ck135 FIND v(dout0_0) AT=680.025n

* CHECK dout0_1 Vdout0_1ck135 = 0 time = 680
.meas tran vdout0_1ck135 FIND v(dout0_1) AT=680.025n

* CHECK dout0_2 Vdout0_2ck135 = 0.9 time = 680
.meas tran vdout0_2ck135 FIND v(dout0_2) AT=680.025n

* CHECK dout0_3 Vdout0_3ck135 = 0 time = 680
.meas tran vdout0_3ck135 FIND v(dout0_3) AT=680.025n

* CHECK dout0_4 Vdout0_4ck135 = 0 time = 680
.meas tran vdout0_4ck135 FIND v(dout0_4) AT=680.025n

* CHECK dout0_5 Vdout0_5ck135 = 0.9 time = 680
.meas tran vdout0_5ck135 FIND v(dout0_5) AT=680.025n

* CHECK dout0_6 Vdout0_6ck135 = 0 time = 680
.meas tran vdout0_6ck135 FIND v(dout0_6) AT=680.025n

* CHECK dout0_7 Vdout0_7ck135 = 0 time = 680
.meas tran vdout0_7ck135 FIND v(dout0_7) AT=680.025n

* CHECK dout0_8 Vdout0_8ck135 = 0.9 time = 680
.meas tran vdout0_8ck135 FIND v(dout0_8) AT=680.025n

* CHECK dout0_9 Vdout0_9ck135 = 0.9 time = 680
.meas tran vdout0_9ck135 FIND v(dout0_9) AT=680.025n

* CHECK dout0_10 Vdout0_10ck135 = 0.9 time = 680
.meas tran vdout0_10ck135 FIND v(dout0_10) AT=680.025n

* CHECK dout0_11 Vdout0_11ck135 = 0.9 time = 680
.meas tran vdout0_11ck135 FIND v(dout0_11) AT=680.025n

* CHECK dout0_12 Vdout0_12ck135 = 0 time = 680
.meas tran vdout0_12ck135 FIND v(dout0_12) AT=680.025n

* CHECK dout0_13 Vdout0_13ck135 = 0.9 time = 680
.meas tran vdout0_13ck135 FIND v(dout0_13) AT=680.025n

* CHECK dout0_14 Vdout0_14ck135 = 0.9 time = 680
.meas tran vdout0_14ck135 FIND v(dout0_14) AT=680.025n

* CHECK dout0_15 Vdout0_15ck135 = 0 time = 680
.meas tran vdout0_15ck135 FIND v(dout0_15) AT=680.025n

* CHECK dout0_16 Vdout0_16ck135 = 0.9 time = 680
.meas tran vdout0_16ck135 FIND v(dout0_16) AT=680.025n

* CHECK dout0_17 Vdout0_17ck135 = 0.9 time = 680
.meas tran vdout0_17ck135 FIND v(dout0_17) AT=680.025n

* CHECK dout0_18 Vdout0_18ck135 = 0 time = 680
.meas tran vdout0_18ck135 FIND v(dout0_18) AT=680.025n

* CHECK dout0_19 Vdout0_19ck135 = 0.9 time = 680
.meas tran vdout0_19ck135 FIND v(dout0_19) AT=680.025n

* CHECK dout0_20 Vdout0_20ck135 = 0 time = 680
.meas tran vdout0_20ck135 FIND v(dout0_20) AT=680.025n

* CHECK dout0_21 Vdout0_21ck135 = 0.9 time = 680
.meas tran vdout0_21ck135 FIND v(dout0_21) AT=680.025n

* CHECK dout0_22 Vdout0_22ck135 = 0 time = 680
.meas tran vdout0_22ck135 FIND v(dout0_22) AT=680.025n

* CHECK dout0_23 Vdout0_23ck135 = 0.9 time = 680
.meas tran vdout0_23ck135 FIND v(dout0_23) AT=680.025n

* CHECK dout0_24 Vdout0_24ck135 = 0.9 time = 680
.meas tran vdout0_24ck135 FIND v(dout0_24) AT=680.025n

* CHECK dout0_25 Vdout0_25ck135 = 0.9 time = 680
.meas tran vdout0_25ck135 FIND v(dout0_25) AT=680.025n

* CHECK dout0_26 Vdout0_26ck135 = 0 time = 680
.meas tran vdout0_26ck135 FIND v(dout0_26) AT=680.025n

* CHECK dout0_27 Vdout0_27ck135 = 0.9 time = 680
.meas tran vdout0_27ck135 FIND v(dout0_27) AT=680.025n

* CHECK dout0_28 Vdout0_28ck135 = 0.9 time = 680
.meas tran vdout0_28ck135 FIND v(dout0_28) AT=680.025n

* CHECK dout0_29 Vdout0_29ck135 = 0 time = 680
.meas tran vdout0_29ck135 FIND v(dout0_29) AT=680.025n

* CHECK dout0_30 Vdout0_30ck135 = 0 time = 680
.meas tran vdout0_30ck135 FIND v(dout0_30) AT=680.025n

* CHECK dout0_31 Vdout0_31ck135 = 0.9 time = 680
.meas tran vdout0_31ck135 FIND v(dout0_31) AT=680.025n

* CHECK dout0_32 Vdout0_32ck135 = 0 time = 680
.meas tran vdout0_32ck135 FIND v(dout0_32) AT=680.025n

* CHECK dout0_33 Vdout0_33ck135 = 0 time = 680
.meas tran vdout0_33ck135 FIND v(dout0_33) AT=680.025n

* CHECK dout0_34 Vdout0_34ck135 = 0.9 time = 680
.meas tran vdout0_34ck135 FIND v(dout0_34) AT=680.025n

* CHECK dout0_35 Vdout0_35ck135 = 0.9 time = 680
.meas tran vdout0_35ck135 FIND v(dout0_35) AT=680.025n

* CHECK dout0_36 Vdout0_36ck135 = 0.9 time = 680
.meas tran vdout0_36ck135 FIND v(dout0_36) AT=680.025n

* CHECK dout0_37 Vdout0_37ck135 = 0 time = 680
.meas tran vdout0_37ck135 FIND v(dout0_37) AT=680.025n

* CHECK dout0_38 Vdout0_38ck135 = 0 time = 680
.meas tran vdout0_38ck135 FIND v(dout0_38) AT=680.025n

* CHECK dout0_39 Vdout0_39ck135 = 0 time = 680
.meas tran vdout0_39ck135 FIND v(dout0_39) AT=680.025n

* CHECK dout0_40 Vdout0_40ck135 = 0.9 time = 680
.meas tran vdout0_40ck135 FIND v(dout0_40) AT=680.025n

* CHECK dout0_41 Vdout0_41ck135 = 0 time = 680
.meas tran vdout0_41ck135 FIND v(dout0_41) AT=680.025n

* CHECK dout0_42 Vdout0_42ck135 = 0 time = 680
.meas tran vdout0_42ck135 FIND v(dout0_42) AT=680.025n

* CHECK dout0_43 Vdout0_43ck135 = 0 time = 680
.meas tran vdout0_43ck135 FIND v(dout0_43) AT=680.025n

* CHECK dout0_44 Vdout0_44ck135 = 0 time = 680
.meas tran vdout0_44ck135 FIND v(dout0_44) AT=680.025n

* CHECK dout0_45 Vdout0_45ck135 = 0 time = 680
.meas tran vdout0_45ck135 FIND v(dout0_45) AT=680.025n

* CHECK dout0_46 Vdout0_46ck135 = 0.9 time = 680
.meas tran vdout0_46ck135 FIND v(dout0_46) AT=680.025n

* CHECK dout0_47 Vdout0_47ck135 = 0.9 time = 680
.meas tran vdout0_47ck135 FIND v(dout0_47) AT=680.025n

* CHECK dout0_48 Vdout0_48ck135 = 0 time = 680
.meas tran vdout0_48ck135 FIND v(dout0_48) AT=680.025n

* CHECK dout0_49 Vdout0_49ck135 = 0.9 time = 680
.meas tran vdout0_49ck135 FIND v(dout0_49) AT=680.025n

* CHECK dout0_50 Vdout0_50ck135 = 0 time = 680
.meas tran vdout0_50ck135 FIND v(dout0_50) AT=680.025n

* CHECK dout0_51 Vdout0_51ck135 = 0 time = 680
.meas tran vdout0_51ck135 FIND v(dout0_51) AT=680.025n

* CHECK dout0_52 Vdout0_52ck135 = 0.9 time = 680
.meas tran vdout0_52ck135 FIND v(dout0_52) AT=680.025n

* CHECK dout0_53 Vdout0_53ck135 = 0.9 time = 680
.meas tran vdout0_53ck135 FIND v(dout0_53) AT=680.025n

* CHECK dout0_54 Vdout0_54ck135 = 0 time = 680
.meas tran vdout0_54ck135 FIND v(dout0_54) AT=680.025n

* CHECK dout0_55 Vdout0_55ck135 = 0.9 time = 680
.meas tran vdout0_55ck135 FIND v(dout0_55) AT=680.025n

* CHECK dout0_56 Vdout0_56ck135 = 0 time = 680
.meas tran vdout0_56ck135 FIND v(dout0_56) AT=680.025n

* CHECK dout0_57 Vdout0_57ck135 = 0 time = 680
.meas tran vdout0_57ck135 FIND v(dout0_57) AT=680.025n

* CHECK dout0_58 Vdout0_58ck135 = 0.9 time = 680
.meas tran vdout0_58ck135 FIND v(dout0_58) AT=680.025n

* CHECK dout0_59 Vdout0_59ck135 = 0.9 time = 680
.meas tran vdout0_59ck135 FIND v(dout0_59) AT=680.025n

* CHECK dout0_60 Vdout0_60ck135 = 0 time = 680
.meas tran vdout0_60ck135 FIND v(dout0_60) AT=680.025n

* CHECK dout0_61 Vdout0_61ck135 = 0.9 time = 680
.meas tran vdout0_61ck135 FIND v(dout0_61) AT=680.025n

* CHECK dout0_62 Vdout0_62ck135 = 0 time = 680
.meas tran vdout0_62ck135 FIND v(dout0_62) AT=680.025n

* CHECK dout0_63 Vdout0_63ck135 = 0.9 time = 680
.meas tran vdout0_63ck135 FIND v(dout0_63) AT=680.025n

* CHECK dout0_0 Vdout0_0ck138 = 0.9 time = 695
.meas tran vdout0_0ck138 FIND v(dout0_0) AT=695.025n

* CHECK dout0_1 Vdout0_1ck138 = 0 time = 695
.meas tran vdout0_1ck138 FIND v(dout0_1) AT=695.025n

* CHECK dout0_2 Vdout0_2ck138 = 0.9 time = 695
.meas tran vdout0_2ck138 FIND v(dout0_2) AT=695.025n

* CHECK dout0_3 Vdout0_3ck138 = 0.9 time = 695
.meas tran vdout0_3ck138 FIND v(dout0_3) AT=695.025n

* CHECK dout0_4 Vdout0_4ck138 = 0.9 time = 695
.meas tran vdout0_4ck138 FIND v(dout0_4) AT=695.025n

* CHECK dout0_5 Vdout0_5ck138 = 0.9 time = 695
.meas tran vdout0_5ck138 FIND v(dout0_5) AT=695.025n

* CHECK dout0_6 Vdout0_6ck138 = 0 time = 695
.meas tran vdout0_6ck138 FIND v(dout0_6) AT=695.025n

* CHECK dout0_7 Vdout0_7ck138 = 0 time = 695
.meas tran vdout0_7ck138 FIND v(dout0_7) AT=695.025n

* CHECK dout0_8 Vdout0_8ck138 = 0.9 time = 695
.meas tran vdout0_8ck138 FIND v(dout0_8) AT=695.025n

* CHECK dout0_9 Vdout0_9ck138 = 0.9 time = 695
.meas tran vdout0_9ck138 FIND v(dout0_9) AT=695.025n

* CHECK dout0_10 Vdout0_10ck138 = 0 time = 695
.meas tran vdout0_10ck138 FIND v(dout0_10) AT=695.025n

* CHECK dout0_11 Vdout0_11ck138 = 0.9 time = 695
.meas tran vdout0_11ck138 FIND v(dout0_11) AT=695.025n

* CHECK dout0_12 Vdout0_12ck138 = 0.9 time = 695
.meas tran vdout0_12ck138 FIND v(dout0_12) AT=695.025n

* CHECK dout0_13 Vdout0_13ck138 = 0.9 time = 695
.meas tran vdout0_13ck138 FIND v(dout0_13) AT=695.025n

* CHECK dout0_14 Vdout0_14ck138 = 0 time = 695
.meas tran vdout0_14ck138 FIND v(dout0_14) AT=695.025n

* CHECK dout0_15 Vdout0_15ck138 = 0 time = 695
.meas tran vdout0_15ck138 FIND v(dout0_15) AT=695.025n

* CHECK dout0_16 Vdout0_16ck138 = 0.9 time = 695
.meas tran vdout0_16ck138 FIND v(dout0_16) AT=695.025n

* CHECK dout0_17 Vdout0_17ck138 = 0 time = 695
.meas tran vdout0_17ck138 FIND v(dout0_17) AT=695.025n

* CHECK dout0_18 Vdout0_18ck138 = 0.9 time = 695
.meas tran vdout0_18ck138 FIND v(dout0_18) AT=695.025n

* CHECK dout0_19 Vdout0_19ck138 = 0 time = 695
.meas tran vdout0_19ck138 FIND v(dout0_19) AT=695.025n

* CHECK dout0_20 Vdout0_20ck138 = 0 time = 695
.meas tran vdout0_20ck138 FIND v(dout0_20) AT=695.025n

* CHECK dout0_21 Vdout0_21ck138 = 0.9 time = 695
.meas tran vdout0_21ck138 FIND v(dout0_21) AT=695.025n

* CHECK dout0_22 Vdout0_22ck138 = 0.9 time = 695
.meas tran vdout0_22ck138 FIND v(dout0_22) AT=695.025n

* CHECK dout0_23 Vdout0_23ck138 = 0.9 time = 695
.meas tran vdout0_23ck138 FIND v(dout0_23) AT=695.025n

* CHECK dout0_24 Vdout0_24ck138 = 0 time = 695
.meas tran vdout0_24ck138 FIND v(dout0_24) AT=695.025n

* CHECK dout0_25 Vdout0_25ck138 = 0 time = 695
.meas tran vdout0_25ck138 FIND v(dout0_25) AT=695.025n

* CHECK dout0_26 Vdout0_26ck138 = 0 time = 695
.meas tran vdout0_26ck138 FIND v(dout0_26) AT=695.025n

* CHECK dout0_27 Vdout0_27ck138 = 0.9 time = 695
.meas tran vdout0_27ck138 FIND v(dout0_27) AT=695.025n

* CHECK dout0_28 Vdout0_28ck138 = 0 time = 695
.meas tran vdout0_28ck138 FIND v(dout0_28) AT=695.025n

* CHECK dout0_29 Vdout0_29ck138 = 0 time = 695
.meas tran vdout0_29ck138 FIND v(dout0_29) AT=695.025n

* CHECK dout0_30 Vdout0_30ck138 = 0 time = 695
.meas tran vdout0_30ck138 FIND v(dout0_30) AT=695.025n

* CHECK dout0_31 Vdout0_31ck138 = 0 time = 695
.meas tran vdout0_31ck138 FIND v(dout0_31) AT=695.025n

* CHECK dout0_32 Vdout0_32ck138 = 0.9 time = 695
.meas tran vdout0_32ck138 FIND v(dout0_32) AT=695.025n

* CHECK dout0_33 Vdout0_33ck138 = 0.9 time = 695
.meas tran vdout0_33ck138 FIND v(dout0_33) AT=695.025n

* CHECK dout0_34 Vdout0_34ck138 = 0 time = 695
.meas tran vdout0_34ck138 FIND v(dout0_34) AT=695.025n

* CHECK dout0_35 Vdout0_35ck138 = 0.9 time = 695
.meas tran vdout0_35ck138 FIND v(dout0_35) AT=695.025n

* CHECK dout0_36 Vdout0_36ck138 = 0.9 time = 695
.meas tran vdout0_36ck138 FIND v(dout0_36) AT=695.025n

* CHECK dout0_37 Vdout0_37ck138 = 0 time = 695
.meas tran vdout0_37ck138 FIND v(dout0_37) AT=695.025n

* CHECK dout0_38 Vdout0_38ck138 = 0.9 time = 695
.meas tran vdout0_38ck138 FIND v(dout0_38) AT=695.025n

* CHECK dout0_39 Vdout0_39ck138 = 0.9 time = 695
.meas tran vdout0_39ck138 FIND v(dout0_39) AT=695.025n

* CHECK dout0_40 Vdout0_40ck138 = 0 time = 695
.meas tran vdout0_40ck138 FIND v(dout0_40) AT=695.025n

* CHECK dout0_41 Vdout0_41ck138 = 0.9 time = 695
.meas tran vdout0_41ck138 FIND v(dout0_41) AT=695.025n

* CHECK dout0_42 Vdout0_42ck138 = 0 time = 695
.meas tran vdout0_42ck138 FIND v(dout0_42) AT=695.025n

* CHECK dout0_43 Vdout0_43ck138 = 0.9 time = 695
.meas tran vdout0_43ck138 FIND v(dout0_43) AT=695.025n

* CHECK dout0_44 Vdout0_44ck138 = 0.9 time = 695
.meas tran vdout0_44ck138 FIND v(dout0_44) AT=695.025n

* CHECK dout0_45 Vdout0_45ck138 = 0.9 time = 695
.meas tran vdout0_45ck138 FIND v(dout0_45) AT=695.025n

* CHECK dout0_46 Vdout0_46ck138 = 0 time = 695
.meas tran vdout0_46ck138 FIND v(dout0_46) AT=695.025n

* CHECK dout0_47 Vdout0_47ck138 = 0.9 time = 695
.meas tran vdout0_47ck138 FIND v(dout0_47) AT=695.025n

* CHECK dout0_48 Vdout0_48ck138 = 0.9 time = 695
.meas tran vdout0_48ck138 FIND v(dout0_48) AT=695.025n

* CHECK dout0_49 Vdout0_49ck138 = 0 time = 695
.meas tran vdout0_49ck138 FIND v(dout0_49) AT=695.025n

* CHECK dout0_50 Vdout0_50ck138 = 0.9 time = 695
.meas tran vdout0_50ck138 FIND v(dout0_50) AT=695.025n

* CHECK dout0_51 Vdout0_51ck138 = 0.9 time = 695
.meas tran vdout0_51ck138 FIND v(dout0_51) AT=695.025n

* CHECK dout0_52 Vdout0_52ck138 = 0 time = 695
.meas tran vdout0_52ck138 FIND v(dout0_52) AT=695.025n

* CHECK dout0_53 Vdout0_53ck138 = 0.9 time = 695
.meas tran vdout0_53ck138 FIND v(dout0_53) AT=695.025n

* CHECK dout0_54 Vdout0_54ck138 = 0.9 time = 695
.meas tran vdout0_54ck138 FIND v(dout0_54) AT=695.025n

* CHECK dout0_55 Vdout0_55ck138 = 0.9 time = 695
.meas tran vdout0_55ck138 FIND v(dout0_55) AT=695.025n

* CHECK dout0_56 Vdout0_56ck138 = 0 time = 695
.meas tran vdout0_56ck138 FIND v(dout0_56) AT=695.025n

* CHECK dout0_57 Vdout0_57ck138 = 0.9 time = 695
.meas tran vdout0_57ck138 FIND v(dout0_57) AT=695.025n

* CHECK dout0_58 Vdout0_58ck138 = 0 time = 695
.meas tran vdout0_58ck138 FIND v(dout0_58) AT=695.025n

* CHECK dout0_59 Vdout0_59ck138 = 0.9 time = 695
.meas tran vdout0_59ck138 FIND v(dout0_59) AT=695.025n

* CHECK dout0_60 Vdout0_60ck138 = 0 time = 695
.meas tran vdout0_60ck138 FIND v(dout0_60) AT=695.025n

* CHECK dout0_61 Vdout0_61ck138 = 0 time = 695
.meas tran vdout0_61ck138 FIND v(dout0_61) AT=695.025n

* CHECK dout0_62 Vdout0_62ck138 = 0 time = 695
.meas tran vdout0_62ck138 FIND v(dout0_62) AT=695.025n

* CHECK dout0_63 Vdout0_63ck138 = 0 time = 695
.meas tran vdout0_63ck138 FIND v(dout0_63) AT=695.025n

* CHECK dout0_0 Vdout0_0ck140 = 0 time = 705
.meas tran vdout0_0ck140 FIND v(dout0_0) AT=705.025n

* CHECK dout0_1 Vdout0_1ck140 = 0 time = 705
.meas tran vdout0_1ck140 FIND v(dout0_1) AT=705.025n

* CHECK dout0_2 Vdout0_2ck140 = 0 time = 705
.meas tran vdout0_2ck140 FIND v(dout0_2) AT=705.025n

* CHECK dout0_3 Vdout0_3ck140 = 0.9 time = 705
.meas tran vdout0_3ck140 FIND v(dout0_3) AT=705.025n

* CHECK dout0_4 Vdout0_4ck140 = 0.9 time = 705
.meas tran vdout0_4ck140 FIND v(dout0_4) AT=705.025n

* CHECK dout0_5 Vdout0_5ck140 = 0 time = 705
.meas tran vdout0_5ck140 FIND v(dout0_5) AT=705.025n

* CHECK dout0_6 Vdout0_6ck140 = 0.9 time = 705
.meas tran vdout0_6ck140 FIND v(dout0_6) AT=705.025n

* CHECK dout0_7 Vdout0_7ck140 = 0.9 time = 705
.meas tran vdout0_7ck140 FIND v(dout0_7) AT=705.025n

* CHECK dout0_8 Vdout0_8ck140 = 0.9 time = 705
.meas tran vdout0_8ck140 FIND v(dout0_8) AT=705.025n

* CHECK dout0_9 Vdout0_9ck140 = 0.9 time = 705
.meas tran vdout0_9ck140 FIND v(dout0_9) AT=705.025n

* CHECK dout0_10 Vdout0_10ck140 = 0.9 time = 705
.meas tran vdout0_10ck140 FIND v(dout0_10) AT=705.025n

* CHECK dout0_11 Vdout0_11ck140 = 0.9 time = 705
.meas tran vdout0_11ck140 FIND v(dout0_11) AT=705.025n

* CHECK dout0_12 Vdout0_12ck140 = 0 time = 705
.meas tran vdout0_12ck140 FIND v(dout0_12) AT=705.025n

* CHECK dout0_13 Vdout0_13ck140 = 0.9 time = 705
.meas tran vdout0_13ck140 FIND v(dout0_13) AT=705.025n

* CHECK dout0_14 Vdout0_14ck140 = 0 time = 705
.meas tran vdout0_14ck140 FIND v(dout0_14) AT=705.025n

* CHECK dout0_15 Vdout0_15ck140 = 0.9 time = 705
.meas tran vdout0_15ck140 FIND v(dout0_15) AT=705.025n

* CHECK dout0_16 Vdout0_16ck140 = 0 time = 705
.meas tran vdout0_16ck140 FIND v(dout0_16) AT=705.025n

* CHECK dout0_17 Vdout0_17ck140 = 0 time = 705
.meas tran vdout0_17ck140 FIND v(dout0_17) AT=705.025n

* CHECK dout0_18 Vdout0_18ck140 = 0 time = 705
.meas tran vdout0_18ck140 FIND v(dout0_18) AT=705.025n

* CHECK dout0_19 Vdout0_19ck140 = 0 time = 705
.meas tran vdout0_19ck140 FIND v(dout0_19) AT=705.025n

* CHECK dout0_20 Vdout0_20ck140 = 0 time = 705
.meas tran vdout0_20ck140 FIND v(dout0_20) AT=705.025n

* CHECK dout0_21 Vdout0_21ck140 = 0 time = 705
.meas tran vdout0_21ck140 FIND v(dout0_21) AT=705.025n

* CHECK dout0_22 Vdout0_22ck140 = 0.9 time = 705
.meas tran vdout0_22ck140 FIND v(dout0_22) AT=705.025n

* CHECK dout0_23 Vdout0_23ck140 = 0 time = 705
.meas tran vdout0_23ck140 FIND v(dout0_23) AT=705.025n

* CHECK dout0_24 Vdout0_24ck140 = 0 time = 705
.meas tran vdout0_24ck140 FIND v(dout0_24) AT=705.025n

* CHECK dout0_25 Vdout0_25ck140 = 0.9 time = 705
.meas tran vdout0_25ck140 FIND v(dout0_25) AT=705.025n

* CHECK dout0_26 Vdout0_26ck140 = 0 time = 705
.meas tran vdout0_26ck140 FIND v(dout0_26) AT=705.025n

* CHECK dout0_27 Vdout0_27ck140 = 0 time = 705
.meas tran vdout0_27ck140 FIND v(dout0_27) AT=705.025n

* CHECK dout0_28 Vdout0_28ck140 = 0.9 time = 705
.meas tran vdout0_28ck140 FIND v(dout0_28) AT=705.025n

* CHECK dout0_29 Vdout0_29ck140 = 0 time = 705
.meas tran vdout0_29ck140 FIND v(dout0_29) AT=705.025n

* CHECK dout0_30 Vdout0_30ck140 = 0 time = 705
.meas tran vdout0_30ck140 FIND v(dout0_30) AT=705.025n

* CHECK dout0_31 Vdout0_31ck140 = 0.9 time = 705
.meas tran vdout0_31ck140 FIND v(dout0_31) AT=705.025n

* CHECK dout0_32 Vdout0_32ck140 = 0.9 time = 705
.meas tran vdout0_32ck140 FIND v(dout0_32) AT=705.025n

* CHECK dout0_33 Vdout0_33ck140 = 0 time = 705
.meas tran vdout0_33ck140 FIND v(dout0_33) AT=705.025n

* CHECK dout0_34 Vdout0_34ck140 = 0.9 time = 705
.meas tran vdout0_34ck140 FIND v(dout0_34) AT=705.025n

* CHECK dout0_35 Vdout0_35ck140 = 0.9 time = 705
.meas tran vdout0_35ck140 FIND v(dout0_35) AT=705.025n

* CHECK dout0_36 Vdout0_36ck140 = 0 time = 705
.meas tran vdout0_36ck140 FIND v(dout0_36) AT=705.025n

* CHECK dout0_37 Vdout0_37ck140 = 0 time = 705
.meas tran vdout0_37ck140 FIND v(dout0_37) AT=705.025n

* CHECK dout0_38 Vdout0_38ck140 = 0 time = 705
.meas tran vdout0_38ck140 FIND v(dout0_38) AT=705.025n

* CHECK dout0_39 Vdout0_39ck140 = 0 time = 705
.meas tran vdout0_39ck140 FIND v(dout0_39) AT=705.025n

* CHECK dout0_40 Vdout0_40ck140 = 0 time = 705
.meas tran vdout0_40ck140 FIND v(dout0_40) AT=705.025n

* CHECK dout0_41 Vdout0_41ck140 = 0.9 time = 705
.meas tran vdout0_41ck140 FIND v(dout0_41) AT=705.025n

* CHECK dout0_42 Vdout0_42ck140 = 0.9 time = 705
.meas tran vdout0_42ck140 FIND v(dout0_42) AT=705.025n

* CHECK dout0_43 Vdout0_43ck140 = 0 time = 705
.meas tran vdout0_43ck140 FIND v(dout0_43) AT=705.025n

* CHECK dout0_44 Vdout0_44ck140 = 0 time = 705
.meas tran vdout0_44ck140 FIND v(dout0_44) AT=705.025n

* CHECK dout0_45 Vdout0_45ck140 = 0.9 time = 705
.meas tran vdout0_45ck140 FIND v(dout0_45) AT=705.025n

* CHECK dout0_46 Vdout0_46ck140 = 0.9 time = 705
.meas tran vdout0_46ck140 FIND v(dout0_46) AT=705.025n

* CHECK dout0_47 Vdout0_47ck140 = 0.9 time = 705
.meas tran vdout0_47ck140 FIND v(dout0_47) AT=705.025n

* CHECK dout0_48 Vdout0_48ck140 = 0 time = 705
.meas tran vdout0_48ck140 FIND v(dout0_48) AT=705.025n

* CHECK dout0_49 Vdout0_49ck140 = 0 time = 705
.meas tran vdout0_49ck140 FIND v(dout0_49) AT=705.025n

* CHECK dout0_50 Vdout0_50ck140 = 0.9 time = 705
.meas tran vdout0_50ck140 FIND v(dout0_50) AT=705.025n

* CHECK dout0_51 Vdout0_51ck140 = 0.9 time = 705
.meas tran vdout0_51ck140 FIND v(dout0_51) AT=705.025n

* CHECK dout0_52 Vdout0_52ck140 = 0 time = 705
.meas tran vdout0_52ck140 FIND v(dout0_52) AT=705.025n

* CHECK dout0_53 Vdout0_53ck140 = 0 time = 705
.meas tran vdout0_53ck140 FIND v(dout0_53) AT=705.025n

* CHECK dout0_54 Vdout0_54ck140 = 0 time = 705
.meas tran vdout0_54ck140 FIND v(dout0_54) AT=705.025n

* CHECK dout0_55 Vdout0_55ck140 = 0 time = 705
.meas tran vdout0_55ck140 FIND v(dout0_55) AT=705.025n

* CHECK dout0_56 Vdout0_56ck140 = 0 time = 705
.meas tran vdout0_56ck140 FIND v(dout0_56) AT=705.025n

* CHECK dout0_57 Vdout0_57ck140 = 0.9 time = 705
.meas tran vdout0_57ck140 FIND v(dout0_57) AT=705.025n

* CHECK dout0_58 Vdout0_58ck140 = 0 time = 705
.meas tran vdout0_58ck140 FIND v(dout0_58) AT=705.025n

* CHECK dout0_59 Vdout0_59ck140 = 0 time = 705
.meas tran vdout0_59ck140 FIND v(dout0_59) AT=705.025n

* CHECK dout0_60 Vdout0_60ck140 = 0 time = 705
.meas tran vdout0_60ck140 FIND v(dout0_60) AT=705.025n

* CHECK dout0_61 Vdout0_61ck140 = 0 time = 705
.meas tran vdout0_61ck140 FIND v(dout0_61) AT=705.025n

* CHECK dout0_62 Vdout0_62ck140 = 0 time = 705
.meas tran vdout0_62ck140 FIND v(dout0_62) AT=705.025n

* CHECK dout0_63 Vdout0_63ck140 = 0.9 time = 705
.meas tran vdout0_63ck140 FIND v(dout0_63) AT=705.025n

* CHECK dout0_0 Vdout0_0ck141 = 0 time = 710
.meas tran vdout0_0ck141 FIND v(dout0_0) AT=710.025n

* CHECK dout0_1 Vdout0_1ck141 = 0 time = 710
.meas tran vdout0_1ck141 FIND v(dout0_1) AT=710.025n

* CHECK dout0_2 Vdout0_2ck141 = 0 time = 710
.meas tran vdout0_2ck141 FIND v(dout0_2) AT=710.025n

* CHECK dout0_3 Vdout0_3ck141 = 0.9 time = 710
.meas tran vdout0_3ck141 FIND v(dout0_3) AT=710.025n

* CHECK dout0_4 Vdout0_4ck141 = 0.9 time = 710
.meas tran vdout0_4ck141 FIND v(dout0_4) AT=710.025n

* CHECK dout0_5 Vdout0_5ck141 = 0 time = 710
.meas tran vdout0_5ck141 FIND v(dout0_5) AT=710.025n

* CHECK dout0_6 Vdout0_6ck141 = 0.9 time = 710
.meas tran vdout0_6ck141 FIND v(dout0_6) AT=710.025n

* CHECK dout0_7 Vdout0_7ck141 = 0.9 time = 710
.meas tran vdout0_7ck141 FIND v(dout0_7) AT=710.025n

* CHECK dout0_8 Vdout0_8ck141 = 0.9 time = 710
.meas tran vdout0_8ck141 FIND v(dout0_8) AT=710.025n

* CHECK dout0_9 Vdout0_9ck141 = 0.9 time = 710
.meas tran vdout0_9ck141 FIND v(dout0_9) AT=710.025n

* CHECK dout0_10 Vdout0_10ck141 = 0.9 time = 710
.meas tran vdout0_10ck141 FIND v(dout0_10) AT=710.025n

* CHECK dout0_11 Vdout0_11ck141 = 0.9 time = 710
.meas tran vdout0_11ck141 FIND v(dout0_11) AT=710.025n

* CHECK dout0_12 Vdout0_12ck141 = 0 time = 710
.meas tran vdout0_12ck141 FIND v(dout0_12) AT=710.025n

* CHECK dout0_13 Vdout0_13ck141 = 0.9 time = 710
.meas tran vdout0_13ck141 FIND v(dout0_13) AT=710.025n

* CHECK dout0_14 Vdout0_14ck141 = 0 time = 710
.meas tran vdout0_14ck141 FIND v(dout0_14) AT=710.025n

* CHECK dout0_15 Vdout0_15ck141 = 0.9 time = 710
.meas tran vdout0_15ck141 FIND v(dout0_15) AT=710.025n

* CHECK dout0_16 Vdout0_16ck141 = 0 time = 710
.meas tran vdout0_16ck141 FIND v(dout0_16) AT=710.025n

* CHECK dout0_17 Vdout0_17ck141 = 0 time = 710
.meas tran vdout0_17ck141 FIND v(dout0_17) AT=710.025n

* CHECK dout0_18 Vdout0_18ck141 = 0 time = 710
.meas tran vdout0_18ck141 FIND v(dout0_18) AT=710.025n

* CHECK dout0_19 Vdout0_19ck141 = 0 time = 710
.meas tran vdout0_19ck141 FIND v(dout0_19) AT=710.025n

* CHECK dout0_20 Vdout0_20ck141 = 0 time = 710
.meas tran vdout0_20ck141 FIND v(dout0_20) AT=710.025n

* CHECK dout0_21 Vdout0_21ck141 = 0 time = 710
.meas tran vdout0_21ck141 FIND v(dout0_21) AT=710.025n

* CHECK dout0_22 Vdout0_22ck141 = 0.9 time = 710
.meas tran vdout0_22ck141 FIND v(dout0_22) AT=710.025n

* CHECK dout0_23 Vdout0_23ck141 = 0 time = 710
.meas tran vdout0_23ck141 FIND v(dout0_23) AT=710.025n

* CHECK dout0_24 Vdout0_24ck141 = 0 time = 710
.meas tran vdout0_24ck141 FIND v(dout0_24) AT=710.025n

* CHECK dout0_25 Vdout0_25ck141 = 0.9 time = 710
.meas tran vdout0_25ck141 FIND v(dout0_25) AT=710.025n

* CHECK dout0_26 Vdout0_26ck141 = 0 time = 710
.meas tran vdout0_26ck141 FIND v(dout0_26) AT=710.025n

* CHECK dout0_27 Vdout0_27ck141 = 0 time = 710
.meas tran vdout0_27ck141 FIND v(dout0_27) AT=710.025n

* CHECK dout0_28 Vdout0_28ck141 = 0.9 time = 710
.meas tran vdout0_28ck141 FIND v(dout0_28) AT=710.025n

* CHECK dout0_29 Vdout0_29ck141 = 0 time = 710
.meas tran vdout0_29ck141 FIND v(dout0_29) AT=710.025n

* CHECK dout0_30 Vdout0_30ck141 = 0 time = 710
.meas tran vdout0_30ck141 FIND v(dout0_30) AT=710.025n

* CHECK dout0_31 Vdout0_31ck141 = 0.9 time = 710
.meas tran vdout0_31ck141 FIND v(dout0_31) AT=710.025n

* CHECK dout0_32 Vdout0_32ck141 = 0.9 time = 710
.meas tran vdout0_32ck141 FIND v(dout0_32) AT=710.025n

* CHECK dout0_33 Vdout0_33ck141 = 0 time = 710
.meas tran vdout0_33ck141 FIND v(dout0_33) AT=710.025n

* CHECK dout0_34 Vdout0_34ck141 = 0.9 time = 710
.meas tran vdout0_34ck141 FIND v(dout0_34) AT=710.025n

* CHECK dout0_35 Vdout0_35ck141 = 0.9 time = 710
.meas tran vdout0_35ck141 FIND v(dout0_35) AT=710.025n

* CHECK dout0_36 Vdout0_36ck141 = 0 time = 710
.meas tran vdout0_36ck141 FIND v(dout0_36) AT=710.025n

* CHECK dout0_37 Vdout0_37ck141 = 0 time = 710
.meas tran vdout0_37ck141 FIND v(dout0_37) AT=710.025n

* CHECK dout0_38 Vdout0_38ck141 = 0 time = 710
.meas tran vdout0_38ck141 FIND v(dout0_38) AT=710.025n

* CHECK dout0_39 Vdout0_39ck141 = 0 time = 710
.meas tran vdout0_39ck141 FIND v(dout0_39) AT=710.025n

* CHECK dout0_40 Vdout0_40ck141 = 0 time = 710
.meas tran vdout0_40ck141 FIND v(dout0_40) AT=710.025n

* CHECK dout0_41 Vdout0_41ck141 = 0.9 time = 710
.meas tran vdout0_41ck141 FIND v(dout0_41) AT=710.025n

* CHECK dout0_42 Vdout0_42ck141 = 0.9 time = 710
.meas tran vdout0_42ck141 FIND v(dout0_42) AT=710.025n

* CHECK dout0_43 Vdout0_43ck141 = 0 time = 710
.meas tran vdout0_43ck141 FIND v(dout0_43) AT=710.025n

* CHECK dout0_44 Vdout0_44ck141 = 0 time = 710
.meas tran vdout0_44ck141 FIND v(dout0_44) AT=710.025n

* CHECK dout0_45 Vdout0_45ck141 = 0.9 time = 710
.meas tran vdout0_45ck141 FIND v(dout0_45) AT=710.025n

* CHECK dout0_46 Vdout0_46ck141 = 0.9 time = 710
.meas tran vdout0_46ck141 FIND v(dout0_46) AT=710.025n

* CHECK dout0_47 Vdout0_47ck141 = 0.9 time = 710
.meas tran vdout0_47ck141 FIND v(dout0_47) AT=710.025n

* CHECK dout0_48 Vdout0_48ck141 = 0 time = 710
.meas tran vdout0_48ck141 FIND v(dout0_48) AT=710.025n

* CHECK dout0_49 Vdout0_49ck141 = 0 time = 710
.meas tran vdout0_49ck141 FIND v(dout0_49) AT=710.025n

* CHECK dout0_50 Vdout0_50ck141 = 0.9 time = 710
.meas tran vdout0_50ck141 FIND v(dout0_50) AT=710.025n

* CHECK dout0_51 Vdout0_51ck141 = 0.9 time = 710
.meas tran vdout0_51ck141 FIND v(dout0_51) AT=710.025n

* CHECK dout0_52 Vdout0_52ck141 = 0 time = 710
.meas tran vdout0_52ck141 FIND v(dout0_52) AT=710.025n

* CHECK dout0_53 Vdout0_53ck141 = 0 time = 710
.meas tran vdout0_53ck141 FIND v(dout0_53) AT=710.025n

* CHECK dout0_54 Vdout0_54ck141 = 0 time = 710
.meas tran vdout0_54ck141 FIND v(dout0_54) AT=710.025n

* CHECK dout0_55 Vdout0_55ck141 = 0 time = 710
.meas tran vdout0_55ck141 FIND v(dout0_55) AT=710.025n

* CHECK dout0_56 Vdout0_56ck141 = 0 time = 710
.meas tran vdout0_56ck141 FIND v(dout0_56) AT=710.025n

* CHECK dout0_57 Vdout0_57ck141 = 0.9 time = 710
.meas tran vdout0_57ck141 FIND v(dout0_57) AT=710.025n

* CHECK dout0_58 Vdout0_58ck141 = 0 time = 710
.meas tran vdout0_58ck141 FIND v(dout0_58) AT=710.025n

* CHECK dout0_59 Vdout0_59ck141 = 0 time = 710
.meas tran vdout0_59ck141 FIND v(dout0_59) AT=710.025n

* CHECK dout0_60 Vdout0_60ck141 = 0 time = 710
.meas tran vdout0_60ck141 FIND v(dout0_60) AT=710.025n

* CHECK dout0_61 Vdout0_61ck141 = 0 time = 710
.meas tran vdout0_61ck141 FIND v(dout0_61) AT=710.025n

* CHECK dout0_62 Vdout0_62ck141 = 0 time = 710
.meas tran vdout0_62ck141 FIND v(dout0_62) AT=710.025n

* CHECK dout0_63 Vdout0_63ck141 = 0.9 time = 710
.meas tran vdout0_63ck141 FIND v(dout0_63) AT=710.025n

* CHECK dout0_0 Vdout0_0ck144 = 0 time = 725
.meas tran vdout0_0ck144 FIND v(dout0_0) AT=725.025n

* CHECK dout0_1 Vdout0_1ck144 = 0 time = 725
.meas tran vdout0_1ck144 FIND v(dout0_1) AT=725.025n

* CHECK dout0_2 Vdout0_2ck144 = 0.9 time = 725
.meas tran vdout0_2ck144 FIND v(dout0_2) AT=725.025n

* CHECK dout0_3 Vdout0_3ck144 = 0.9 time = 725
.meas tran vdout0_3ck144 FIND v(dout0_3) AT=725.025n

* CHECK dout0_4 Vdout0_4ck144 = 0 time = 725
.meas tran vdout0_4ck144 FIND v(dout0_4) AT=725.025n

* CHECK dout0_5 Vdout0_5ck144 = 0.9 time = 725
.meas tran vdout0_5ck144 FIND v(dout0_5) AT=725.025n

* CHECK dout0_6 Vdout0_6ck144 = 0 time = 725
.meas tran vdout0_6ck144 FIND v(dout0_6) AT=725.025n

* CHECK dout0_7 Vdout0_7ck144 = 0 time = 725
.meas tran vdout0_7ck144 FIND v(dout0_7) AT=725.025n

* CHECK dout0_8 Vdout0_8ck144 = 0 time = 725
.meas tran vdout0_8ck144 FIND v(dout0_8) AT=725.025n

* CHECK dout0_9 Vdout0_9ck144 = 0.9 time = 725
.meas tran vdout0_9ck144 FIND v(dout0_9) AT=725.025n

* CHECK dout0_10 Vdout0_10ck144 = 0.9 time = 725
.meas tran vdout0_10ck144 FIND v(dout0_10) AT=725.025n

* CHECK dout0_11 Vdout0_11ck144 = 0.9 time = 725
.meas tran vdout0_11ck144 FIND v(dout0_11) AT=725.025n

* CHECK dout0_12 Vdout0_12ck144 = 0.9 time = 725
.meas tran vdout0_12ck144 FIND v(dout0_12) AT=725.025n

* CHECK dout0_13 Vdout0_13ck144 = 0.9 time = 725
.meas tran vdout0_13ck144 FIND v(dout0_13) AT=725.025n

* CHECK dout0_14 Vdout0_14ck144 = 0.9 time = 725
.meas tran vdout0_14ck144 FIND v(dout0_14) AT=725.025n

* CHECK dout0_15 Vdout0_15ck144 = 0 time = 725
.meas tran vdout0_15ck144 FIND v(dout0_15) AT=725.025n

* CHECK dout0_16 Vdout0_16ck144 = 0.9 time = 725
.meas tran vdout0_16ck144 FIND v(dout0_16) AT=725.025n

* CHECK dout0_17 Vdout0_17ck144 = 0.9 time = 725
.meas tran vdout0_17ck144 FIND v(dout0_17) AT=725.025n

* CHECK dout0_18 Vdout0_18ck144 = 0.9 time = 725
.meas tran vdout0_18ck144 FIND v(dout0_18) AT=725.025n

* CHECK dout0_19 Vdout0_19ck144 = 0 time = 725
.meas tran vdout0_19ck144 FIND v(dout0_19) AT=725.025n

* CHECK dout0_20 Vdout0_20ck144 = 0 time = 725
.meas tran vdout0_20ck144 FIND v(dout0_20) AT=725.025n

* CHECK dout0_21 Vdout0_21ck144 = 0.9 time = 725
.meas tran vdout0_21ck144 FIND v(dout0_21) AT=725.025n

* CHECK dout0_22 Vdout0_22ck144 = 0 time = 725
.meas tran vdout0_22ck144 FIND v(dout0_22) AT=725.025n

* CHECK dout0_23 Vdout0_23ck144 = 0.9 time = 725
.meas tran vdout0_23ck144 FIND v(dout0_23) AT=725.025n

* CHECK dout0_24 Vdout0_24ck144 = 0.9 time = 725
.meas tran vdout0_24ck144 FIND v(dout0_24) AT=725.025n

* CHECK dout0_25 Vdout0_25ck144 = 0 time = 725
.meas tran vdout0_25ck144 FIND v(dout0_25) AT=725.025n

* CHECK dout0_26 Vdout0_26ck144 = 0 time = 725
.meas tran vdout0_26ck144 FIND v(dout0_26) AT=725.025n

* CHECK dout0_27 Vdout0_27ck144 = 0.9 time = 725
.meas tran vdout0_27ck144 FIND v(dout0_27) AT=725.025n

* CHECK dout0_28 Vdout0_28ck144 = 0 time = 725
.meas tran vdout0_28ck144 FIND v(dout0_28) AT=725.025n

* CHECK dout0_29 Vdout0_29ck144 = 0.9 time = 725
.meas tran vdout0_29ck144 FIND v(dout0_29) AT=725.025n

* CHECK dout0_30 Vdout0_30ck144 = 0 time = 725
.meas tran vdout0_30ck144 FIND v(dout0_30) AT=725.025n

* CHECK dout0_31 Vdout0_31ck144 = 0 time = 725
.meas tran vdout0_31ck144 FIND v(dout0_31) AT=725.025n

* CHECK dout0_32 Vdout0_32ck144 = 0.9 time = 725
.meas tran vdout0_32ck144 FIND v(dout0_32) AT=725.025n

* CHECK dout0_33 Vdout0_33ck144 = 0 time = 725
.meas tran vdout0_33ck144 FIND v(dout0_33) AT=725.025n

* CHECK dout0_34 Vdout0_34ck144 = 0 time = 725
.meas tran vdout0_34ck144 FIND v(dout0_34) AT=725.025n

* CHECK dout0_35 Vdout0_35ck144 = 0.9 time = 725
.meas tran vdout0_35ck144 FIND v(dout0_35) AT=725.025n

* CHECK dout0_36 Vdout0_36ck144 = 0 time = 725
.meas tran vdout0_36ck144 FIND v(dout0_36) AT=725.025n

* CHECK dout0_37 Vdout0_37ck144 = 0.9 time = 725
.meas tran vdout0_37ck144 FIND v(dout0_37) AT=725.025n

* CHECK dout0_38 Vdout0_38ck144 = 0.9 time = 725
.meas tran vdout0_38ck144 FIND v(dout0_38) AT=725.025n

* CHECK dout0_39 Vdout0_39ck144 = 0.9 time = 725
.meas tran vdout0_39ck144 FIND v(dout0_39) AT=725.025n

* CHECK dout0_40 Vdout0_40ck144 = 0 time = 725
.meas tran vdout0_40ck144 FIND v(dout0_40) AT=725.025n

* CHECK dout0_41 Vdout0_41ck144 = 0 time = 725
.meas tran vdout0_41ck144 FIND v(dout0_41) AT=725.025n

* CHECK dout0_42 Vdout0_42ck144 = 0 time = 725
.meas tran vdout0_42ck144 FIND v(dout0_42) AT=725.025n

* CHECK dout0_43 Vdout0_43ck144 = 0.9 time = 725
.meas tran vdout0_43ck144 FIND v(dout0_43) AT=725.025n

* CHECK dout0_44 Vdout0_44ck144 = 0 time = 725
.meas tran vdout0_44ck144 FIND v(dout0_44) AT=725.025n

* CHECK dout0_45 Vdout0_45ck144 = 0.9 time = 725
.meas tran vdout0_45ck144 FIND v(dout0_45) AT=725.025n

* CHECK dout0_46 Vdout0_46ck144 = 0 time = 725
.meas tran vdout0_46ck144 FIND v(dout0_46) AT=725.025n

* CHECK dout0_47 Vdout0_47ck144 = 0.9 time = 725
.meas tran vdout0_47ck144 FIND v(dout0_47) AT=725.025n

* CHECK dout0_48 Vdout0_48ck144 = 0.9 time = 725
.meas tran vdout0_48ck144 FIND v(dout0_48) AT=725.025n

* CHECK dout0_49 Vdout0_49ck144 = 0.9 time = 725
.meas tran vdout0_49ck144 FIND v(dout0_49) AT=725.025n

* CHECK dout0_50 Vdout0_50ck144 = 0 time = 725
.meas tran vdout0_50ck144 FIND v(dout0_50) AT=725.025n

* CHECK dout0_51 Vdout0_51ck144 = 0.9 time = 725
.meas tran vdout0_51ck144 FIND v(dout0_51) AT=725.025n

* CHECK dout0_52 Vdout0_52ck144 = 0.9 time = 725
.meas tran vdout0_52ck144 FIND v(dout0_52) AT=725.025n

* CHECK dout0_53 Vdout0_53ck144 = 0 time = 725
.meas tran vdout0_53ck144 FIND v(dout0_53) AT=725.025n

* CHECK dout0_54 Vdout0_54ck144 = 0.9 time = 725
.meas tran vdout0_54ck144 FIND v(dout0_54) AT=725.025n

* CHECK dout0_55 Vdout0_55ck144 = 0 time = 725
.meas tran vdout0_55ck144 FIND v(dout0_55) AT=725.025n

* CHECK dout0_56 Vdout0_56ck144 = 0 time = 725
.meas tran vdout0_56ck144 FIND v(dout0_56) AT=725.025n

* CHECK dout0_57 Vdout0_57ck144 = 0.9 time = 725
.meas tran vdout0_57ck144 FIND v(dout0_57) AT=725.025n

* CHECK dout0_58 Vdout0_58ck144 = 0.9 time = 725
.meas tran vdout0_58ck144 FIND v(dout0_58) AT=725.025n

* CHECK dout0_59 Vdout0_59ck144 = 0.9 time = 725
.meas tran vdout0_59ck144 FIND v(dout0_59) AT=725.025n

* CHECK dout0_60 Vdout0_60ck144 = 0.9 time = 725
.meas tran vdout0_60ck144 FIND v(dout0_60) AT=725.025n

* CHECK dout0_61 Vdout0_61ck144 = 0 time = 725
.meas tran vdout0_61ck144 FIND v(dout0_61) AT=725.025n

* CHECK dout0_62 Vdout0_62ck144 = 0 time = 725
.meas tran vdout0_62ck144 FIND v(dout0_62) AT=725.025n

* CHECK dout0_63 Vdout0_63ck144 = 0 time = 725
.meas tran vdout0_63ck144 FIND v(dout0_63) AT=725.025n

* CHECK dout0_0 Vdout0_0ck149 = 0.9 time = 750
.meas tran vdout0_0ck149 FIND v(dout0_0) AT=750.025n

* CHECK dout0_1 Vdout0_1ck149 = 0.9 time = 750
.meas tran vdout0_1ck149 FIND v(dout0_1) AT=750.025n

* CHECK dout0_2 Vdout0_2ck149 = 0.9 time = 750
.meas tran vdout0_2ck149 FIND v(dout0_2) AT=750.025n

* CHECK dout0_3 Vdout0_3ck149 = 0 time = 750
.meas tran vdout0_3ck149 FIND v(dout0_3) AT=750.025n

* CHECK dout0_4 Vdout0_4ck149 = 0.9 time = 750
.meas tran vdout0_4ck149 FIND v(dout0_4) AT=750.025n

* CHECK dout0_5 Vdout0_5ck149 = 0 time = 750
.meas tran vdout0_5ck149 FIND v(dout0_5) AT=750.025n

* CHECK dout0_6 Vdout0_6ck149 = 0 time = 750
.meas tran vdout0_6ck149 FIND v(dout0_6) AT=750.025n

* CHECK dout0_7 Vdout0_7ck149 = 0.9 time = 750
.meas tran vdout0_7ck149 FIND v(dout0_7) AT=750.025n

* CHECK dout0_8 Vdout0_8ck149 = 0.9 time = 750
.meas tran vdout0_8ck149 FIND v(dout0_8) AT=750.025n

* CHECK dout0_9 Vdout0_9ck149 = 0.9 time = 750
.meas tran vdout0_9ck149 FIND v(dout0_9) AT=750.025n

* CHECK dout0_10 Vdout0_10ck149 = 0.9 time = 750
.meas tran vdout0_10ck149 FIND v(dout0_10) AT=750.025n

* CHECK dout0_11 Vdout0_11ck149 = 0.9 time = 750
.meas tran vdout0_11ck149 FIND v(dout0_11) AT=750.025n

* CHECK dout0_12 Vdout0_12ck149 = 0 time = 750
.meas tran vdout0_12ck149 FIND v(dout0_12) AT=750.025n

* CHECK dout0_13 Vdout0_13ck149 = 0.9 time = 750
.meas tran vdout0_13ck149 FIND v(dout0_13) AT=750.025n

* CHECK dout0_14 Vdout0_14ck149 = 0 time = 750
.meas tran vdout0_14ck149 FIND v(dout0_14) AT=750.025n

* CHECK dout0_15 Vdout0_15ck149 = 0 time = 750
.meas tran vdout0_15ck149 FIND v(dout0_15) AT=750.025n

* CHECK dout0_16 Vdout0_16ck149 = 0 time = 750
.meas tran vdout0_16ck149 FIND v(dout0_16) AT=750.025n

* CHECK dout0_17 Vdout0_17ck149 = 0.9 time = 750
.meas tran vdout0_17ck149 FIND v(dout0_17) AT=750.025n

* CHECK dout0_18 Vdout0_18ck149 = 0 time = 750
.meas tran vdout0_18ck149 FIND v(dout0_18) AT=750.025n

* CHECK dout0_19 Vdout0_19ck149 = 0 time = 750
.meas tran vdout0_19ck149 FIND v(dout0_19) AT=750.025n

* CHECK dout0_20 Vdout0_20ck149 = 0 time = 750
.meas tran vdout0_20ck149 FIND v(dout0_20) AT=750.025n

* CHECK dout0_21 Vdout0_21ck149 = 0.9 time = 750
.meas tran vdout0_21ck149 FIND v(dout0_21) AT=750.025n

* CHECK dout0_22 Vdout0_22ck149 = 0.9 time = 750
.meas tran vdout0_22ck149 FIND v(dout0_22) AT=750.025n

* CHECK dout0_23 Vdout0_23ck149 = 0.9 time = 750
.meas tran vdout0_23ck149 FIND v(dout0_23) AT=750.025n

* CHECK dout0_24 Vdout0_24ck149 = 0.9 time = 750
.meas tran vdout0_24ck149 FIND v(dout0_24) AT=750.025n

* CHECK dout0_25 Vdout0_25ck149 = 0.9 time = 750
.meas tran vdout0_25ck149 FIND v(dout0_25) AT=750.025n

* CHECK dout0_26 Vdout0_26ck149 = 0 time = 750
.meas tran vdout0_26ck149 FIND v(dout0_26) AT=750.025n

* CHECK dout0_27 Vdout0_27ck149 = 0.9 time = 750
.meas tran vdout0_27ck149 FIND v(dout0_27) AT=750.025n

* CHECK dout0_28 Vdout0_28ck149 = 0 time = 750
.meas tran vdout0_28ck149 FIND v(dout0_28) AT=750.025n

* CHECK dout0_29 Vdout0_29ck149 = 0 time = 750
.meas tran vdout0_29ck149 FIND v(dout0_29) AT=750.025n

* CHECK dout0_30 Vdout0_30ck149 = 0.9 time = 750
.meas tran vdout0_30ck149 FIND v(dout0_30) AT=750.025n

* CHECK dout0_31 Vdout0_31ck149 = 0 time = 750
.meas tran vdout0_31ck149 FIND v(dout0_31) AT=750.025n

* CHECK dout0_32 Vdout0_32ck149 = 0 time = 750
.meas tran vdout0_32ck149 FIND v(dout0_32) AT=750.025n

* CHECK dout0_33 Vdout0_33ck149 = 0.9 time = 750
.meas tran vdout0_33ck149 FIND v(dout0_33) AT=750.025n

* CHECK dout0_34 Vdout0_34ck149 = 0 time = 750
.meas tran vdout0_34ck149 FIND v(dout0_34) AT=750.025n

* CHECK dout0_35 Vdout0_35ck149 = 0 time = 750
.meas tran vdout0_35ck149 FIND v(dout0_35) AT=750.025n

* CHECK dout0_36 Vdout0_36ck149 = 0 time = 750
.meas tran vdout0_36ck149 FIND v(dout0_36) AT=750.025n

* CHECK dout0_37 Vdout0_37ck149 = 0.9 time = 750
.meas tran vdout0_37ck149 FIND v(dout0_37) AT=750.025n

* CHECK dout0_38 Vdout0_38ck149 = 0.9 time = 750
.meas tran vdout0_38ck149 FIND v(dout0_38) AT=750.025n

* CHECK dout0_39 Vdout0_39ck149 = 0 time = 750
.meas tran vdout0_39ck149 FIND v(dout0_39) AT=750.025n

* CHECK dout0_40 Vdout0_40ck149 = 0 time = 750
.meas tran vdout0_40ck149 FIND v(dout0_40) AT=750.025n

* CHECK dout0_41 Vdout0_41ck149 = 0.9 time = 750
.meas tran vdout0_41ck149 FIND v(dout0_41) AT=750.025n

* CHECK dout0_42 Vdout0_42ck149 = 0 time = 750
.meas tran vdout0_42ck149 FIND v(dout0_42) AT=750.025n

* CHECK dout0_43 Vdout0_43ck149 = 0 time = 750
.meas tran vdout0_43ck149 FIND v(dout0_43) AT=750.025n

* CHECK dout0_44 Vdout0_44ck149 = 0.9 time = 750
.meas tran vdout0_44ck149 FIND v(dout0_44) AT=750.025n

* CHECK dout0_45 Vdout0_45ck149 = 0 time = 750
.meas tran vdout0_45ck149 FIND v(dout0_45) AT=750.025n

* CHECK dout0_46 Vdout0_46ck149 = 0.9 time = 750
.meas tran vdout0_46ck149 FIND v(dout0_46) AT=750.025n

* CHECK dout0_47 Vdout0_47ck149 = 0 time = 750
.meas tran vdout0_47ck149 FIND v(dout0_47) AT=750.025n

* CHECK dout0_48 Vdout0_48ck149 = 0 time = 750
.meas tran vdout0_48ck149 FIND v(dout0_48) AT=750.025n

* CHECK dout0_49 Vdout0_49ck149 = 0 time = 750
.meas tran vdout0_49ck149 FIND v(dout0_49) AT=750.025n

* CHECK dout0_50 Vdout0_50ck149 = 0 time = 750
.meas tran vdout0_50ck149 FIND v(dout0_50) AT=750.025n

* CHECK dout0_51 Vdout0_51ck149 = 0.9 time = 750
.meas tran vdout0_51ck149 FIND v(dout0_51) AT=750.025n

* CHECK dout0_52 Vdout0_52ck149 = 0 time = 750
.meas tran vdout0_52ck149 FIND v(dout0_52) AT=750.025n

* CHECK dout0_53 Vdout0_53ck149 = 0.9 time = 750
.meas tran vdout0_53ck149 FIND v(dout0_53) AT=750.025n

* CHECK dout0_54 Vdout0_54ck149 = 0.9 time = 750
.meas tran vdout0_54ck149 FIND v(dout0_54) AT=750.025n

* CHECK dout0_55 Vdout0_55ck149 = 0 time = 750
.meas tran vdout0_55ck149 FIND v(dout0_55) AT=750.025n

* CHECK dout0_56 Vdout0_56ck149 = 0 time = 750
.meas tran vdout0_56ck149 FIND v(dout0_56) AT=750.025n

* CHECK dout0_57 Vdout0_57ck149 = 0.9 time = 750
.meas tran vdout0_57ck149 FIND v(dout0_57) AT=750.025n

* CHECK dout0_58 Vdout0_58ck149 = 0.9 time = 750
.meas tran vdout0_58ck149 FIND v(dout0_58) AT=750.025n

* CHECK dout0_59 Vdout0_59ck149 = 0.9 time = 750
.meas tran vdout0_59ck149 FIND v(dout0_59) AT=750.025n

* CHECK dout0_60 Vdout0_60ck149 = 0 time = 750
.meas tran vdout0_60ck149 FIND v(dout0_60) AT=750.025n

* CHECK dout0_61 Vdout0_61ck149 = 0 time = 750
.meas tran vdout0_61ck149 FIND v(dout0_61) AT=750.025n

* CHECK dout0_62 Vdout0_62ck149 = 0.9 time = 750
.meas tran vdout0_62ck149 FIND v(dout0_62) AT=750.025n

* CHECK dout0_63 Vdout0_63ck149 = 0.9 time = 750
.meas tran vdout0_63ck149 FIND v(dout0_63) AT=750.025n

* CHECK dout0_0 Vdout0_0ck151 = 0 time = 760
.meas tran vdout0_0ck151 FIND v(dout0_0) AT=760.025n

* CHECK dout0_1 Vdout0_1ck151 = 0.9 time = 760
.meas tran vdout0_1ck151 FIND v(dout0_1) AT=760.025n

* CHECK dout0_2 Vdout0_2ck151 = 0.9 time = 760
.meas tran vdout0_2ck151 FIND v(dout0_2) AT=760.025n

* CHECK dout0_3 Vdout0_3ck151 = 0 time = 760
.meas tran vdout0_3ck151 FIND v(dout0_3) AT=760.025n

* CHECK dout0_4 Vdout0_4ck151 = 0.9 time = 760
.meas tran vdout0_4ck151 FIND v(dout0_4) AT=760.025n

* CHECK dout0_5 Vdout0_5ck151 = 0 time = 760
.meas tran vdout0_5ck151 FIND v(dout0_5) AT=760.025n

* CHECK dout0_6 Vdout0_6ck151 = 0 time = 760
.meas tran vdout0_6ck151 FIND v(dout0_6) AT=760.025n

* CHECK dout0_7 Vdout0_7ck151 = 0 time = 760
.meas tran vdout0_7ck151 FIND v(dout0_7) AT=760.025n

* CHECK dout0_8 Vdout0_8ck151 = 0.9 time = 760
.meas tran vdout0_8ck151 FIND v(dout0_8) AT=760.025n

* CHECK dout0_9 Vdout0_9ck151 = 0.9 time = 760
.meas tran vdout0_9ck151 FIND v(dout0_9) AT=760.025n

* CHECK dout0_10 Vdout0_10ck151 = 0 time = 760
.meas tran vdout0_10ck151 FIND v(dout0_10) AT=760.025n

* CHECK dout0_11 Vdout0_11ck151 = 0.9 time = 760
.meas tran vdout0_11ck151 FIND v(dout0_11) AT=760.025n

* CHECK dout0_12 Vdout0_12ck151 = 0.9 time = 760
.meas tran vdout0_12ck151 FIND v(dout0_12) AT=760.025n

* CHECK dout0_13 Vdout0_13ck151 = 0 time = 760
.meas tran vdout0_13ck151 FIND v(dout0_13) AT=760.025n

* CHECK dout0_14 Vdout0_14ck151 = 0 time = 760
.meas tran vdout0_14ck151 FIND v(dout0_14) AT=760.025n

* CHECK dout0_15 Vdout0_15ck151 = 0.9 time = 760
.meas tran vdout0_15ck151 FIND v(dout0_15) AT=760.025n

* CHECK dout0_16 Vdout0_16ck151 = 0 time = 760
.meas tran vdout0_16ck151 FIND v(dout0_16) AT=760.025n

* CHECK dout0_17 Vdout0_17ck151 = 0 time = 760
.meas tran vdout0_17ck151 FIND v(dout0_17) AT=760.025n

* CHECK dout0_18 Vdout0_18ck151 = 0 time = 760
.meas tran vdout0_18ck151 FIND v(dout0_18) AT=760.025n

* CHECK dout0_19 Vdout0_19ck151 = 0.9 time = 760
.meas tran vdout0_19ck151 FIND v(dout0_19) AT=760.025n

* CHECK dout0_20 Vdout0_20ck151 = 0.9 time = 760
.meas tran vdout0_20ck151 FIND v(dout0_20) AT=760.025n

* CHECK dout0_21 Vdout0_21ck151 = 0 time = 760
.meas tran vdout0_21ck151 FIND v(dout0_21) AT=760.025n

* CHECK dout0_22 Vdout0_22ck151 = 0 time = 760
.meas tran vdout0_22ck151 FIND v(dout0_22) AT=760.025n

* CHECK dout0_23 Vdout0_23ck151 = 0 time = 760
.meas tran vdout0_23ck151 FIND v(dout0_23) AT=760.025n

* CHECK dout0_24 Vdout0_24ck151 = 0.9 time = 760
.meas tran vdout0_24ck151 FIND v(dout0_24) AT=760.025n

* CHECK dout0_25 Vdout0_25ck151 = 0 time = 760
.meas tran vdout0_25ck151 FIND v(dout0_25) AT=760.025n

* CHECK dout0_26 Vdout0_26ck151 = 0.9 time = 760
.meas tran vdout0_26ck151 FIND v(dout0_26) AT=760.025n

* CHECK dout0_27 Vdout0_27ck151 = 0 time = 760
.meas tran vdout0_27ck151 FIND v(dout0_27) AT=760.025n

* CHECK dout0_28 Vdout0_28ck151 = 0 time = 760
.meas tran vdout0_28ck151 FIND v(dout0_28) AT=760.025n

* CHECK dout0_29 Vdout0_29ck151 = 0.9 time = 760
.meas tran vdout0_29ck151 FIND v(dout0_29) AT=760.025n

* CHECK dout0_30 Vdout0_30ck151 = 0 time = 760
.meas tran vdout0_30ck151 FIND v(dout0_30) AT=760.025n

* CHECK dout0_31 Vdout0_31ck151 = 0 time = 760
.meas tran vdout0_31ck151 FIND v(dout0_31) AT=760.025n

* CHECK dout0_32 Vdout0_32ck151 = 0.9 time = 760
.meas tran vdout0_32ck151 FIND v(dout0_32) AT=760.025n

* CHECK dout0_33 Vdout0_33ck151 = 0.9 time = 760
.meas tran vdout0_33ck151 FIND v(dout0_33) AT=760.025n

* CHECK dout0_34 Vdout0_34ck151 = 0.9 time = 760
.meas tran vdout0_34ck151 FIND v(dout0_34) AT=760.025n

* CHECK dout0_35 Vdout0_35ck151 = 0 time = 760
.meas tran vdout0_35ck151 FIND v(dout0_35) AT=760.025n

* CHECK dout0_36 Vdout0_36ck151 = 0 time = 760
.meas tran vdout0_36ck151 FIND v(dout0_36) AT=760.025n

* CHECK dout0_37 Vdout0_37ck151 = 0 time = 760
.meas tran vdout0_37ck151 FIND v(dout0_37) AT=760.025n

* CHECK dout0_38 Vdout0_38ck151 = 0 time = 760
.meas tran vdout0_38ck151 FIND v(dout0_38) AT=760.025n

* CHECK dout0_39 Vdout0_39ck151 = 0.9 time = 760
.meas tran vdout0_39ck151 FIND v(dout0_39) AT=760.025n

* CHECK dout0_40 Vdout0_40ck151 = 0 time = 760
.meas tran vdout0_40ck151 FIND v(dout0_40) AT=760.025n

* CHECK dout0_41 Vdout0_41ck151 = 0.9 time = 760
.meas tran vdout0_41ck151 FIND v(dout0_41) AT=760.025n

* CHECK dout0_42 Vdout0_42ck151 = 0.9 time = 760
.meas tran vdout0_42ck151 FIND v(dout0_42) AT=760.025n

* CHECK dout0_43 Vdout0_43ck151 = 0 time = 760
.meas tran vdout0_43ck151 FIND v(dout0_43) AT=760.025n

* CHECK dout0_44 Vdout0_44ck151 = 0 time = 760
.meas tran vdout0_44ck151 FIND v(dout0_44) AT=760.025n

* CHECK dout0_45 Vdout0_45ck151 = 0 time = 760
.meas tran vdout0_45ck151 FIND v(dout0_45) AT=760.025n

* CHECK dout0_46 Vdout0_46ck151 = 0.9 time = 760
.meas tran vdout0_46ck151 FIND v(dout0_46) AT=760.025n

* CHECK dout0_47 Vdout0_47ck151 = 0.9 time = 760
.meas tran vdout0_47ck151 FIND v(dout0_47) AT=760.025n

* CHECK dout0_48 Vdout0_48ck151 = 0 time = 760
.meas tran vdout0_48ck151 FIND v(dout0_48) AT=760.025n

* CHECK dout0_49 Vdout0_49ck151 = 0 time = 760
.meas tran vdout0_49ck151 FIND v(dout0_49) AT=760.025n

* CHECK dout0_50 Vdout0_50ck151 = 0.9 time = 760
.meas tran vdout0_50ck151 FIND v(dout0_50) AT=760.025n

* CHECK dout0_51 Vdout0_51ck151 = 0.9 time = 760
.meas tran vdout0_51ck151 FIND v(dout0_51) AT=760.025n

* CHECK dout0_52 Vdout0_52ck151 = 0 time = 760
.meas tran vdout0_52ck151 FIND v(dout0_52) AT=760.025n

* CHECK dout0_53 Vdout0_53ck151 = 0 time = 760
.meas tran vdout0_53ck151 FIND v(dout0_53) AT=760.025n

* CHECK dout0_54 Vdout0_54ck151 = 0.9 time = 760
.meas tran vdout0_54ck151 FIND v(dout0_54) AT=760.025n

* CHECK dout0_55 Vdout0_55ck151 = 0.9 time = 760
.meas tran vdout0_55ck151 FIND v(dout0_55) AT=760.025n

* CHECK dout0_56 Vdout0_56ck151 = 0.9 time = 760
.meas tran vdout0_56ck151 FIND v(dout0_56) AT=760.025n

* CHECK dout0_57 Vdout0_57ck151 = 0.9 time = 760
.meas tran vdout0_57ck151 FIND v(dout0_57) AT=760.025n

* CHECK dout0_58 Vdout0_58ck151 = 0.9 time = 760
.meas tran vdout0_58ck151 FIND v(dout0_58) AT=760.025n

* CHECK dout0_59 Vdout0_59ck151 = 0 time = 760
.meas tran vdout0_59ck151 FIND v(dout0_59) AT=760.025n

* CHECK dout0_60 Vdout0_60ck151 = 0 time = 760
.meas tran vdout0_60ck151 FIND v(dout0_60) AT=760.025n

* CHECK dout0_61 Vdout0_61ck151 = 0.9 time = 760
.meas tran vdout0_61ck151 FIND v(dout0_61) AT=760.025n

* CHECK dout0_62 Vdout0_62ck151 = 0 time = 760
.meas tran vdout0_62ck151 FIND v(dout0_62) AT=760.025n

* CHECK dout0_63 Vdout0_63ck151 = 0 time = 760
.meas tran vdout0_63ck151 FIND v(dout0_63) AT=760.025n

* CHECK dout0_0 Vdout0_0ck152 = 0.9 time = 765
.meas tran vdout0_0ck152 FIND v(dout0_0) AT=765.025n

* CHECK dout0_1 Vdout0_1ck152 = 0.9 time = 765
.meas tran vdout0_1ck152 FIND v(dout0_1) AT=765.025n

* CHECK dout0_2 Vdout0_2ck152 = 0.9 time = 765
.meas tran vdout0_2ck152 FIND v(dout0_2) AT=765.025n

* CHECK dout0_3 Vdout0_3ck152 = 0 time = 765
.meas tran vdout0_3ck152 FIND v(dout0_3) AT=765.025n

* CHECK dout0_4 Vdout0_4ck152 = 0.9 time = 765
.meas tran vdout0_4ck152 FIND v(dout0_4) AT=765.025n

* CHECK dout0_5 Vdout0_5ck152 = 0 time = 765
.meas tran vdout0_5ck152 FIND v(dout0_5) AT=765.025n

* CHECK dout0_6 Vdout0_6ck152 = 0 time = 765
.meas tran vdout0_6ck152 FIND v(dout0_6) AT=765.025n

* CHECK dout0_7 Vdout0_7ck152 = 0.9 time = 765
.meas tran vdout0_7ck152 FIND v(dout0_7) AT=765.025n

* CHECK dout0_8 Vdout0_8ck152 = 0.9 time = 765
.meas tran vdout0_8ck152 FIND v(dout0_8) AT=765.025n

* CHECK dout0_9 Vdout0_9ck152 = 0.9 time = 765
.meas tran vdout0_9ck152 FIND v(dout0_9) AT=765.025n

* CHECK dout0_10 Vdout0_10ck152 = 0.9 time = 765
.meas tran vdout0_10ck152 FIND v(dout0_10) AT=765.025n

* CHECK dout0_11 Vdout0_11ck152 = 0.9 time = 765
.meas tran vdout0_11ck152 FIND v(dout0_11) AT=765.025n

* CHECK dout0_12 Vdout0_12ck152 = 0 time = 765
.meas tran vdout0_12ck152 FIND v(dout0_12) AT=765.025n

* CHECK dout0_13 Vdout0_13ck152 = 0.9 time = 765
.meas tran vdout0_13ck152 FIND v(dout0_13) AT=765.025n

* CHECK dout0_14 Vdout0_14ck152 = 0 time = 765
.meas tran vdout0_14ck152 FIND v(dout0_14) AT=765.025n

* CHECK dout0_15 Vdout0_15ck152 = 0 time = 765
.meas tran vdout0_15ck152 FIND v(dout0_15) AT=765.025n

* CHECK dout0_16 Vdout0_16ck152 = 0 time = 765
.meas tran vdout0_16ck152 FIND v(dout0_16) AT=765.025n

* CHECK dout0_17 Vdout0_17ck152 = 0.9 time = 765
.meas tran vdout0_17ck152 FIND v(dout0_17) AT=765.025n

* CHECK dout0_18 Vdout0_18ck152 = 0 time = 765
.meas tran vdout0_18ck152 FIND v(dout0_18) AT=765.025n

* CHECK dout0_19 Vdout0_19ck152 = 0 time = 765
.meas tran vdout0_19ck152 FIND v(dout0_19) AT=765.025n

* CHECK dout0_20 Vdout0_20ck152 = 0 time = 765
.meas tran vdout0_20ck152 FIND v(dout0_20) AT=765.025n

* CHECK dout0_21 Vdout0_21ck152 = 0.9 time = 765
.meas tran vdout0_21ck152 FIND v(dout0_21) AT=765.025n

* CHECK dout0_22 Vdout0_22ck152 = 0.9 time = 765
.meas tran vdout0_22ck152 FIND v(dout0_22) AT=765.025n

* CHECK dout0_23 Vdout0_23ck152 = 0.9 time = 765
.meas tran vdout0_23ck152 FIND v(dout0_23) AT=765.025n

* CHECK dout0_24 Vdout0_24ck152 = 0.9 time = 765
.meas tran vdout0_24ck152 FIND v(dout0_24) AT=765.025n

* CHECK dout0_25 Vdout0_25ck152 = 0.9 time = 765
.meas tran vdout0_25ck152 FIND v(dout0_25) AT=765.025n

* CHECK dout0_26 Vdout0_26ck152 = 0 time = 765
.meas tran vdout0_26ck152 FIND v(dout0_26) AT=765.025n

* CHECK dout0_27 Vdout0_27ck152 = 0.9 time = 765
.meas tran vdout0_27ck152 FIND v(dout0_27) AT=765.025n

* CHECK dout0_28 Vdout0_28ck152 = 0 time = 765
.meas tran vdout0_28ck152 FIND v(dout0_28) AT=765.025n

* CHECK dout0_29 Vdout0_29ck152 = 0 time = 765
.meas tran vdout0_29ck152 FIND v(dout0_29) AT=765.025n

* CHECK dout0_30 Vdout0_30ck152 = 0.9 time = 765
.meas tran vdout0_30ck152 FIND v(dout0_30) AT=765.025n

* CHECK dout0_31 Vdout0_31ck152 = 0 time = 765
.meas tran vdout0_31ck152 FIND v(dout0_31) AT=765.025n

* CHECK dout0_32 Vdout0_32ck152 = 0 time = 765
.meas tran vdout0_32ck152 FIND v(dout0_32) AT=765.025n

* CHECK dout0_33 Vdout0_33ck152 = 0.9 time = 765
.meas tran vdout0_33ck152 FIND v(dout0_33) AT=765.025n

* CHECK dout0_34 Vdout0_34ck152 = 0 time = 765
.meas tran vdout0_34ck152 FIND v(dout0_34) AT=765.025n

* CHECK dout0_35 Vdout0_35ck152 = 0 time = 765
.meas tran vdout0_35ck152 FIND v(dout0_35) AT=765.025n

* CHECK dout0_36 Vdout0_36ck152 = 0 time = 765
.meas tran vdout0_36ck152 FIND v(dout0_36) AT=765.025n

* CHECK dout0_37 Vdout0_37ck152 = 0.9 time = 765
.meas tran vdout0_37ck152 FIND v(dout0_37) AT=765.025n

* CHECK dout0_38 Vdout0_38ck152 = 0.9 time = 765
.meas tran vdout0_38ck152 FIND v(dout0_38) AT=765.025n

* CHECK dout0_39 Vdout0_39ck152 = 0 time = 765
.meas tran vdout0_39ck152 FIND v(dout0_39) AT=765.025n

* CHECK dout0_40 Vdout0_40ck152 = 0 time = 765
.meas tran vdout0_40ck152 FIND v(dout0_40) AT=765.025n

* CHECK dout0_41 Vdout0_41ck152 = 0.9 time = 765
.meas tran vdout0_41ck152 FIND v(dout0_41) AT=765.025n

* CHECK dout0_42 Vdout0_42ck152 = 0 time = 765
.meas tran vdout0_42ck152 FIND v(dout0_42) AT=765.025n

* CHECK dout0_43 Vdout0_43ck152 = 0 time = 765
.meas tran vdout0_43ck152 FIND v(dout0_43) AT=765.025n

* CHECK dout0_44 Vdout0_44ck152 = 0.9 time = 765
.meas tran vdout0_44ck152 FIND v(dout0_44) AT=765.025n

* CHECK dout0_45 Vdout0_45ck152 = 0 time = 765
.meas tran vdout0_45ck152 FIND v(dout0_45) AT=765.025n

* CHECK dout0_46 Vdout0_46ck152 = 0.9 time = 765
.meas tran vdout0_46ck152 FIND v(dout0_46) AT=765.025n

* CHECK dout0_47 Vdout0_47ck152 = 0 time = 765
.meas tran vdout0_47ck152 FIND v(dout0_47) AT=765.025n

* CHECK dout0_48 Vdout0_48ck152 = 0 time = 765
.meas tran vdout0_48ck152 FIND v(dout0_48) AT=765.025n

* CHECK dout0_49 Vdout0_49ck152 = 0 time = 765
.meas tran vdout0_49ck152 FIND v(dout0_49) AT=765.025n

* CHECK dout0_50 Vdout0_50ck152 = 0 time = 765
.meas tran vdout0_50ck152 FIND v(dout0_50) AT=765.025n

* CHECK dout0_51 Vdout0_51ck152 = 0.9 time = 765
.meas tran vdout0_51ck152 FIND v(dout0_51) AT=765.025n

* CHECK dout0_52 Vdout0_52ck152 = 0 time = 765
.meas tran vdout0_52ck152 FIND v(dout0_52) AT=765.025n

* CHECK dout0_53 Vdout0_53ck152 = 0.9 time = 765
.meas tran vdout0_53ck152 FIND v(dout0_53) AT=765.025n

* CHECK dout0_54 Vdout0_54ck152 = 0.9 time = 765
.meas tran vdout0_54ck152 FIND v(dout0_54) AT=765.025n

* CHECK dout0_55 Vdout0_55ck152 = 0 time = 765
.meas tran vdout0_55ck152 FIND v(dout0_55) AT=765.025n

* CHECK dout0_56 Vdout0_56ck152 = 0 time = 765
.meas tran vdout0_56ck152 FIND v(dout0_56) AT=765.025n

* CHECK dout0_57 Vdout0_57ck152 = 0.9 time = 765
.meas tran vdout0_57ck152 FIND v(dout0_57) AT=765.025n

* CHECK dout0_58 Vdout0_58ck152 = 0.9 time = 765
.meas tran vdout0_58ck152 FIND v(dout0_58) AT=765.025n

* CHECK dout0_59 Vdout0_59ck152 = 0.9 time = 765
.meas tran vdout0_59ck152 FIND v(dout0_59) AT=765.025n

* CHECK dout0_60 Vdout0_60ck152 = 0 time = 765
.meas tran vdout0_60ck152 FIND v(dout0_60) AT=765.025n

* CHECK dout0_61 Vdout0_61ck152 = 0 time = 765
.meas tran vdout0_61ck152 FIND v(dout0_61) AT=765.025n

* CHECK dout0_62 Vdout0_62ck152 = 0.9 time = 765
.meas tran vdout0_62ck152 FIND v(dout0_62) AT=765.025n

* CHECK dout0_63 Vdout0_63ck152 = 0.9 time = 765
.meas tran vdout0_63ck152 FIND v(dout0_63) AT=765.025n

* CHECK dout0_0 Vdout0_0ck153 = 0.9 time = 770
.meas tran vdout0_0ck153 FIND v(dout0_0) AT=770.025n

* CHECK dout0_1 Vdout0_1ck153 = 0 time = 770
.meas tran vdout0_1ck153 FIND v(dout0_1) AT=770.025n

* CHECK dout0_2 Vdout0_2ck153 = 0 time = 770
.meas tran vdout0_2ck153 FIND v(dout0_2) AT=770.025n

* CHECK dout0_3 Vdout0_3ck153 = 0.9 time = 770
.meas tran vdout0_3ck153 FIND v(dout0_3) AT=770.025n

* CHECK dout0_4 Vdout0_4ck153 = 0.9 time = 770
.meas tran vdout0_4ck153 FIND v(dout0_4) AT=770.025n

* CHECK dout0_5 Vdout0_5ck153 = 0 time = 770
.meas tran vdout0_5ck153 FIND v(dout0_5) AT=770.025n

* CHECK dout0_6 Vdout0_6ck153 = 0.9 time = 770
.meas tran vdout0_6ck153 FIND v(dout0_6) AT=770.025n

* CHECK dout0_7 Vdout0_7ck153 = 0 time = 770
.meas tran vdout0_7ck153 FIND v(dout0_7) AT=770.025n

* CHECK dout0_8 Vdout0_8ck153 = 0.9 time = 770
.meas tran vdout0_8ck153 FIND v(dout0_8) AT=770.025n

* CHECK dout0_9 Vdout0_9ck153 = 0 time = 770
.meas tran vdout0_9ck153 FIND v(dout0_9) AT=770.025n

* CHECK dout0_10 Vdout0_10ck153 = 0.9 time = 770
.meas tran vdout0_10ck153 FIND v(dout0_10) AT=770.025n

* CHECK dout0_11 Vdout0_11ck153 = 0.9 time = 770
.meas tran vdout0_11ck153 FIND v(dout0_11) AT=770.025n

* CHECK dout0_12 Vdout0_12ck153 = 0.9 time = 770
.meas tran vdout0_12ck153 FIND v(dout0_12) AT=770.025n

* CHECK dout0_13 Vdout0_13ck153 = 0.9 time = 770
.meas tran vdout0_13ck153 FIND v(dout0_13) AT=770.025n

* CHECK dout0_14 Vdout0_14ck153 = 0 time = 770
.meas tran vdout0_14ck153 FIND v(dout0_14) AT=770.025n

* CHECK dout0_15 Vdout0_15ck153 = 0.9 time = 770
.meas tran vdout0_15ck153 FIND v(dout0_15) AT=770.025n

* CHECK dout0_16 Vdout0_16ck153 = 0 time = 770
.meas tran vdout0_16ck153 FIND v(dout0_16) AT=770.025n

* CHECK dout0_17 Vdout0_17ck153 = 0 time = 770
.meas tran vdout0_17ck153 FIND v(dout0_17) AT=770.025n

* CHECK dout0_18 Vdout0_18ck153 = 0.9 time = 770
.meas tran vdout0_18ck153 FIND v(dout0_18) AT=770.025n

* CHECK dout0_19 Vdout0_19ck153 = 0 time = 770
.meas tran vdout0_19ck153 FIND v(dout0_19) AT=770.025n

* CHECK dout0_20 Vdout0_20ck153 = 0 time = 770
.meas tran vdout0_20ck153 FIND v(dout0_20) AT=770.025n

* CHECK dout0_21 Vdout0_21ck153 = 0 time = 770
.meas tran vdout0_21ck153 FIND v(dout0_21) AT=770.025n

* CHECK dout0_22 Vdout0_22ck153 = 0 time = 770
.meas tran vdout0_22ck153 FIND v(dout0_22) AT=770.025n

* CHECK dout0_23 Vdout0_23ck153 = 0.9 time = 770
.meas tran vdout0_23ck153 FIND v(dout0_23) AT=770.025n

* CHECK dout0_24 Vdout0_24ck153 = 0 time = 770
.meas tran vdout0_24ck153 FIND v(dout0_24) AT=770.025n

* CHECK dout0_25 Vdout0_25ck153 = 0.9 time = 770
.meas tran vdout0_25ck153 FIND v(dout0_25) AT=770.025n

* CHECK dout0_26 Vdout0_26ck153 = 0 time = 770
.meas tran vdout0_26ck153 FIND v(dout0_26) AT=770.025n

* CHECK dout0_27 Vdout0_27ck153 = 0.9 time = 770
.meas tran vdout0_27ck153 FIND v(dout0_27) AT=770.025n

* CHECK dout0_28 Vdout0_28ck153 = 0 time = 770
.meas tran vdout0_28ck153 FIND v(dout0_28) AT=770.025n

* CHECK dout0_29 Vdout0_29ck153 = 0.9 time = 770
.meas tran vdout0_29ck153 FIND v(dout0_29) AT=770.025n

* CHECK dout0_30 Vdout0_30ck153 = 0.9 time = 770
.meas tran vdout0_30ck153 FIND v(dout0_30) AT=770.025n

* CHECK dout0_31 Vdout0_31ck153 = 0 time = 770
.meas tran vdout0_31ck153 FIND v(dout0_31) AT=770.025n

* CHECK dout0_32 Vdout0_32ck153 = 0.9 time = 770
.meas tran vdout0_32ck153 FIND v(dout0_32) AT=770.025n

* CHECK dout0_33 Vdout0_33ck153 = 0.9 time = 770
.meas tran vdout0_33ck153 FIND v(dout0_33) AT=770.025n

* CHECK dout0_34 Vdout0_34ck153 = 0.9 time = 770
.meas tran vdout0_34ck153 FIND v(dout0_34) AT=770.025n

* CHECK dout0_35 Vdout0_35ck153 = 0.9 time = 770
.meas tran vdout0_35ck153 FIND v(dout0_35) AT=770.025n

* CHECK dout0_36 Vdout0_36ck153 = 0.9 time = 770
.meas tran vdout0_36ck153 FIND v(dout0_36) AT=770.025n

* CHECK dout0_37 Vdout0_37ck153 = 0 time = 770
.meas tran vdout0_37ck153 FIND v(dout0_37) AT=770.025n

* CHECK dout0_38 Vdout0_38ck153 = 0 time = 770
.meas tran vdout0_38ck153 FIND v(dout0_38) AT=770.025n

* CHECK dout0_39 Vdout0_39ck153 = 0 time = 770
.meas tran vdout0_39ck153 FIND v(dout0_39) AT=770.025n

* CHECK dout0_40 Vdout0_40ck153 = 0 time = 770
.meas tran vdout0_40ck153 FIND v(dout0_40) AT=770.025n

* CHECK dout0_41 Vdout0_41ck153 = 0.9 time = 770
.meas tran vdout0_41ck153 FIND v(dout0_41) AT=770.025n

* CHECK dout0_42 Vdout0_42ck153 = 0 time = 770
.meas tran vdout0_42ck153 FIND v(dout0_42) AT=770.025n

* CHECK dout0_43 Vdout0_43ck153 = 0 time = 770
.meas tran vdout0_43ck153 FIND v(dout0_43) AT=770.025n

* CHECK dout0_44 Vdout0_44ck153 = 0.9 time = 770
.meas tran vdout0_44ck153 FIND v(dout0_44) AT=770.025n

* CHECK dout0_45 Vdout0_45ck153 = 0.9 time = 770
.meas tran vdout0_45ck153 FIND v(dout0_45) AT=770.025n

* CHECK dout0_46 Vdout0_46ck153 = 0.9 time = 770
.meas tran vdout0_46ck153 FIND v(dout0_46) AT=770.025n

* CHECK dout0_47 Vdout0_47ck153 = 0 time = 770
.meas tran vdout0_47ck153 FIND v(dout0_47) AT=770.025n

* CHECK dout0_48 Vdout0_48ck153 = 0 time = 770
.meas tran vdout0_48ck153 FIND v(dout0_48) AT=770.025n

* CHECK dout0_49 Vdout0_49ck153 = 0 time = 770
.meas tran vdout0_49ck153 FIND v(dout0_49) AT=770.025n

* CHECK dout0_50 Vdout0_50ck153 = 0.9 time = 770
.meas tran vdout0_50ck153 FIND v(dout0_50) AT=770.025n

* CHECK dout0_51 Vdout0_51ck153 = 0 time = 770
.meas tran vdout0_51ck153 FIND v(dout0_51) AT=770.025n

* CHECK dout0_52 Vdout0_52ck153 = 0 time = 770
.meas tran vdout0_52ck153 FIND v(dout0_52) AT=770.025n

* CHECK dout0_53 Vdout0_53ck153 = 0 time = 770
.meas tran vdout0_53ck153 FIND v(dout0_53) AT=770.025n

* CHECK dout0_54 Vdout0_54ck153 = 0.9 time = 770
.meas tran vdout0_54ck153 FIND v(dout0_54) AT=770.025n

* CHECK dout0_55 Vdout0_55ck153 = 0 time = 770
.meas tran vdout0_55ck153 FIND v(dout0_55) AT=770.025n

* CHECK dout0_56 Vdout0_56ck153 = 0 time = 770
.meas tran vdout0_56ck153 FIND v(dout0_56) AT=770.025n

* CHECK dout0_57 Vdout0_57ck153 = 0.9 time = 770
.meas tran vdout0_57ck153 FIND v(dout0_57) AT=770.025n

* CHECK dout0_58 Vdout0_58ck153 = 0.9 time = 770
.meas tran vdout0_58ck153 FIND v(dout0_58) AT=770.025n

* CHECK dout0_59 Vdout0_59ck153 = 0.9 time = 770
.meas tran vdout0_59ck153 FIND v(dout0_59) AT=770.025n

* CHECK dout0_60 Vdout0_60ck153 = 0 time = 770
.meas tran vdout0_60ck153 FIND v(dout0_60) AT=770.025n

* CHECK dout0_61 Vdout0_61ck153 = 0.9 time = 770
.meas tran vdout0_61ck153 FIND v(dout0_61) AT=770.025n

* CHECK dout0_62 Vdout0_62ck153 = 0 time = 770
.meas tran vdout0_62ck153 FIND v(dout0_62) AT=770.025n

* CHECK dout0_63 Vdout0_63ck153 = 0 time = 770
.meas tran vdout0_63ck153 FIND v(dout0_63) AT=770.025n

* CHECK dout0_0 Vdout0_0ck154 = 0.9 time = 775
.meas tran vdout0_0ck154 FIND v(dout0_0) AT=775.025n

* CHECK dout0_1 Vdout0_1ck154 = 0.9 time = 775
.meas tran vdout0_1ck154 FIND v(dout0_1) AT=775.025n

* CHECK dout0_2 Vdout0_2ck154 = 0.9 time = 775
.meas tran vdout0_2ck154 FIND v(dout0_2) AT=775.025n

* CHECK dout0_3 Vdout0_3ck154 = 0 time = 775
.meas tran vdout0_3ck154 FIND v(dout0_3) AT=775.025n

* CHECK dout0_4 Vdout0_4ck154 = 0.9 time = 775
.meas tran vdout0_4ck154 FIND v(dout0_4) AT=775.025n

* CHECK dout0_5 Vdout0_5ck154 = 0 time = 775
.meas tran vdout0_5ck154 FIND v(dout0_5) AT=775.025n

* CHECK dout0_6 Vdout0_6ck154 = 0 time = 775
.meas tran vdout0_6ck154 FIND v(dout0_6) AT=775.025n

* CHECK dout0_7 Vdout0_7ck154 = 0.9 time = 775
.meas tran vdout0_7ck154 FIND v(dout0_7) AT=775.025n

* CHECK dout0_8 Vdout0_8ck154 = 0.9 time = 775
.meas tran vdout0_8ck154 FIND v(dout0_8) AT=775.025n

* CHECK dout0_9 Vdout0_9ck154 = 0.9 time = 775
.meas tran vdout0_9ck154 FIND v(dout0_9) AT=775.025n

* CHECK dout0_10 Vdout0_10ck154 = 0.9 time = 775
.meas tran vdout0_10ck154 FIND v(dout0_10) AT=775.025n

* CHECK dout0_11 Vdout0_11ck154 = 0.9 time = 775
.meas tran vdout0_11ck154 FIND v(dout0_11) AT=775.025n

* CHECK dout0_12 Vdout0_12ck154 = 0 time = 775
.meas tran vdout0_12ck154 FIND v(dout0_12) AT=775.025n

* CHECK dout0_13 Vdout0_13ck154 = 0.9 time = 775
.meas tran vdout0_13ck154 FIND v(dout0_13) AT=775.025n

* CHECK dout0_14 Vdout0_14ck154 = 0 time = 775
.meas tran vdout0_14ck154 FIND v(dout0_14) AT=775.025n

* CHECK dout0_15 Vdout0_15ck154 = 0 time = 775
.meas tran vdout0_15ck154 FIND v(dout0_15) AT=775.025n

* CHECK dout0_16 Vdout0_16ck154 = 0 time = 775
.meas tran vdout0_16ck154 FIND v(dout0_16) AT=775.025n

* CHECK dout0_17 Vdout0_17ck154 = 0.9 time = 775
.meas tran vdout0_17ck154 FIND v(dout0_17) AT=775.025n

* CHECK dout0_18 Vdout0_18ck154 = 0 time = 775
.meas tran vdout0_18ck154 FIND v(dout0_18) AT=775.025n

* CHECK dout0_19 Vdout0_19ck154 = 0 time = 775
.meas tran vdout0_19ck154 FIND v(dout0_19) AT=775.025n

* CHECK dout0_20 Vdout0_20ck154 = 0 time = 775
.meas tran vdout0_20ck154 FIND v(dout0_20) AT=775.025n

* CHECK dout0_21 Vdout0_21ck154 = 0.9 time = 775
.meas tran vdout0_21ck154 FIND v(dout0_21) AT=775.025n

* CHECK dout0_22 Vdout0_22ck154 = 0.9 time = 775
.meas tran vdout0_22ck154 FIND v(dout0_22) AT=775.025n

* CHECK dout0_23 Vdout0_23ck154 = 0.9 time = 775
.meas tran vdout0_23ck154 FIND v(dout0_23) AT=775.025n

* CHECK dout0_24 Vdout0_24ck154 = 0.9 time = 775
.meas tran vdout0_24ck154 FIND v(dout0_24) AT=775.025n

* CHECK dout0_25 Vdout0_25ck154 = 0.9 time = 775
.meas tran vdout0_25ck154 FIND v(dout0_25) AT=775.025n

* CHECK dout0_26 Vdout0_26ck154 = 0 time = 775
.meas tran vdout0_26ck154 FIND v(dout0_26) AT=775.025n

* CHECK dout0_27 Vdout0_27ck154 = 0.9 time = 775
.meas tran vdout0_27ck154 FIND v(dout0_27) AT=775.025n

* CHECK dout0_28 Vdout0_28ck154 = 0 time = 775
.meas tran vdout0_28ck154 FIND v(dout0_28) AT=775.025n

* CHECK dout0_29 Vdout0_29ck154 = 0 time = 775
.meas tran vdout0_29ck154 FIND v(dout0_29) AT=775.025n

* CHECK dout0_30 Vdout0_30ck154 = 0.9 time = 775
.meas tran vdout0_30ck154 FIND v(dout0_30) AT=775.025n

* CHECK dout0_31 Vdout0_31ck154 = 0 time = 775
.meas tran vdout0_31ck154 FIND v(dout0_31) AT=775.025n

* CHECK dout0_32 Vdout0_32ck154 = 0 time = 775
.meas tran vdout0_32ck154 FIND v(dout0_32) AT=775.025n

* CHECK dout0_33 Vdout0_33ck154 = 0.9 time = 775
.meas tran vdout0_33ck154 FIND v(dout0_33) AT=775.025n

* CHECK dout0_34 Vdout0_34ck154 = 0 time = 775
.meas tran vdout0_34ck154 FIND v(dout0_34) AT=775.025n

* CHECK dout0_35 Vdout0_35ck154 = 0 time = 775
.meas tran vdout0_35ck154 FIND v(dout0_35) AT=775.025n

* CHECK dout0_36 Vdout0_36ck154 = 0 time = 775
.meas tran vdout0_36ck154 FIND v(dout0_36) AT=775.025n

* CHECK dout0_37 Vdout0_37ck154 = 0.9 time = 775
.meas tran vdout0_37ck154 FIND v(dout0_37) AT=775.025n

* CHECK dout0_38 Vdout0_38ck154 = 0.9 time = 775
.meas tran vdout0_38ck154 FIND v(dout0_38) AT=775.025n

* CHECK dout0_39 Vdout0_39ck154 = 0 time = 775
.meas tran vdout0_39ck154 FIND v(dout0_39) AT=775.025n

* CHECK dout0_40 Vdout0_40ck154 = 0 time = 775
.meas tran vdout0_40ck154 FIND v(dout0_40) AT=775.025n

* CHECK dout0_41 Vdout0_41ck154 = 0.9 time = 775
.meas tran vdout0_41ck154 FIND v(dout0_41) AT=775.025n

* CHECK dout0_42 Vdout0_42ck154 = 0 time = 775
.meas tran vdout0_42ck154 FIND v(dout0_42) AT=775.025n

* CHECK dout0_43 Vdout0_43ck154 = 0 time = 775
.meas tran vdout0_43ck154 FIND v(dout0_43) AT=775.025n

* CHECK dout0_44 Vdout0_44ck154 = 0.9 time = 775
.meas tran vdout0_44ck154 FIND v(dout0_44) AT=775.025n

* CHECK dout0_45 Vdout0_45ck154 = 0 time = 775
.meas tran vdout0_45ck154 FIND v(dout0_45) AT=775.025n

* CHECK dout0_46 Vdout0_46ck154 = 0.9 time = 775
.meas tran vdout0_46ck154 FIND v(dout0_46) AT=775.025n

* CHECK dout0_47 Vdout0_47ck154 = 0 time = 775
.meas tran vdout0_47ck154 FIND v(dout0_47) AT=775.025n

* CHECK dout0_48 Vdout0_48ck154 = 0 time = 775
.meas tran vdout0_48ck154 FIND v(dout0_48) AT=775.025n

* CHECK dout0_49 Vdout0_49ck154 = 0 time = 775
.meas tran vdout0_49ck154 FIND v(dout0_49) AT=775.025n

* CHECK dout0_50 Vdout0_50ck154 = 0 time = 775
.meas tran vdout0_50ck154 FIND v(dout0_50) AT=775.025n

* CHECK dout0_51 Vdout0_51ck154 = 0.9 time = 775
.meas tran vdout0_51ck154 FIND v(dout0_51) AT=775.025n

* CHECK dout0_52 Vdout0_52ck154 = 0 time = 775
.meas tran vdout0_52ck154 FIND v(dout0_52) AT=775.025n

* CHECK dout0_53 Vdout0_53ck154 = 0.9 time = 775
.meas tran vdout0_53ck154 FIND v(dout0_53) AT=775.025n

* CHECK dout0_54 Vdout0_54ck154 = 0.9 time = 775
.meas tran vdout0_54ck154 FIND v(dout0_54) AT=775.025n

* CHECK dout0_55 Vdout0_55ck154 = 0 time = 775
.meas tran vdout0_55ck154 FIND v(dout0_55) AT=775.025n

* CHECK dout0_56 Vdout0_56ck154 = 0 time = 775
.meas tran vdout0_56ck154 FIND v(dout0_56) AT=775.025n

* CHECK dout0_57 Vdout0_57ck154 = 0.9 time = 775
.meas tran vdout0_57ck154 FIND v(dout0_57) AT=775.025n

* CHECK dout0_58 Vdout0_58ck154 = 0.9 time = 775
.meas tran vdout0_58ck154 FIND v(dout0_58) AT=775.025n

* CHECK dout0_59 Vdout0_59ck154 = 0.9 time = 775
.meas tran vdout0_59ck154 FIND v(dout0_59) AT=775.025n

* CHECK dout0_60 Vdout0_60ck154 = 0 time = 775
.meas tran vdout0_60ck154 FIND v(dout0_60) AT=775.025n

* CHECK dout0_61 Vdout0_61ck154 = 0 time = 775
.meas tran vdout0_61ck154 FIND v(dout0_61) AT=775.025n

* CHECK dout0_62 Vdout0_62ck154 = 0.9 time = 775
.meas tran vdout0_62ck154 FIND v(dout0_62) AT=775.025n

* CHECK dout0_63 Vdout0_63ck154 = 0.9 time = 775
.meas tran vdout0_63ck154 FIND v(dout0_63) AT=775.025n

* CHECK dout0_0 Vdout0_0ck157 = 0 time = 790
.meas tran vdout0_0ck157 FIND v(dout0_0) AT=790.025n

* CHECK dout0_1 Vdout0_1ck157 = 0 time = 790
.meas tran vdout0_1ck157 FIND v(dout0_1) AT=790.025n

* CHECK dout0_2 Vdout0_2ck157 = 0.9 time = 790
.meas tran vdout0_2ck157 FIND v(dout0_2) AT=790.025n

* CHECK dout0_3 Vdout0_3ck157 = 0.9 time = 790
.meas tran vdout0_3ck157 FIND v(dout0_3) AT=790.025n

* CHECK dout0_4 Vdout0_4ck157 = 0 time = 790
.meas tran vdout0_4ck157 FIND v(dout0_4) AT=790.025n

* CHECK dout0_5 Vdout0_5ck157 = 0.9 time = 790
.meas tran vdout0_5ck157 FIND v(dout0_5) AT=790.025n

* CHECK dout0_6 Vdout0_6ck157 = 0 time = 790
.meas tran vdout0_6ck157 FIND v(dout0_6) AT=790.025n

* CHECK dout0_7 Vdout0_7ck157 = 0 time = 790
.meas tran vdout0_7ck157 FIND v(dout0_7) AT=790.025n

* CHECK dout0_8 Vdout0_8ck157 = 0 time = 790
.meas tran vdout0_8ck157 FIND v(dout0_8) AT=790.025n

* CHECK dout0_9 Vdout0_9ck157 = 0.9 time = 790
.meas tran vdout0_9ck157 FIND v(dout0_9) AT=790.025n

* CHECK dout0_10 Vdout0_10ck157 = 0.9 time = 790
.meas tran vdout0_10ck157 FIND v(dout0_10) AT=790.025n

* CHECK dout0_11 Vdout0_11ck157 = 0.9 time = 790
.meas tran vdout0_11ck157 FIND v(dout0_11) AT=790.025n

* CHECK dout0_12 Vdout0_12ck157 = 0.9 time = 790
.meas tran vdout0_12ck157 FIND v(dout0_12) AT=790.025n

* CHECK dout0_13 Vdout0_13ck157 = 0.9 time = 790
.meas tran vdout0_13ck157 FIND v(dout0_13) AT=790.025n

* CHECK dout0_14 Vdout0_14ck157 = 0.9 time = 790
.meas tran vdout0_14ck157 FIND v(dout0_14) AT=790.025n

* CHECK dout0_15 Vdout0_15ck157 = 0 time = 790
.meas tran vdout0_15ck157 FIND v(dout0_15) AT=790.025n

* CHECK dout0_16 Vdout0_16ck157 = 0.9 time = 790
.meas tran vdout0_16ck157 FIND v(dout0_16) AT=790.025n

* CHECK dout0_17 Vdout0_17ck157 = 0.9 time = 790
.meas tran vdout0_17ck157 FIND v(dout0_17) AT=790.025n

* CHECK dout0_18 Vdout0_18ck157 = 0.9 time = 790
.meas tran vdout0_18ck157 FIND v(dout0_18) AT=790.025n

* CHECK dout0_19 Vdout0_19ck157 = 0 time = 790
.meas tran vdout0_19ck157 FIND v(dout0_19) AT=790.025n

* CHECK dout0_20 Vdout0_20ck157 = 0 time = 790
.meas tran vdout0_20ck157 FIND v(dout0_20) AT=790.025n

* CHECK dout0_21 Vdout0_21ck157 = 0.9 time = 790
.meas tran vdout0_21ck157 FIND v(dout0_21) AT=790.025n

* CHECK dout0_22 Vdout0_22ck157 = 0 time = 790
.meas tran vdout0_22ck157 FIND v(dout0_22) AT=790.025n

* CHECK dout0_23 Vdout0_23ck157 = 0.9 time = 790
.meas tran vdout0_23ck157 FIND v(dout0_23) AT=790.025n

* CHECK dout0_24 Vdout0_24ck157 = 0.9 time = 790
.meas tran vdout0_24ck157 FIND v(dout0_24) AT=790.025n

* CHECK dout0_25 Vdout0_25ck157 = 0 time = 790
.meas tran vdout0_25ck157 FIND v(dout0_25) AT=790.025n

* CHECK dout0_26 Vdout0_26ck157 = 0 time = 790
.meas tran vdout0_26ck157 FIND v(dout0_26) AT=790.025n

* CHECK dout0_27 Vdout0_27ck157 = 0.9 time = 790
.meas tran vdout0_27ck157 FIND v(dout0_27) AT=790.025n

* CHECK dout0_28 Vdout0_28ck157 = 0 time = 790
.meas tran vdout0_28ck157 FIND v(dout0_28) AT=790.025n

* CHECK dout0_29 Vdout0_29ck157 = 0.9 time = 790
.meas tran vdout0_29ck157 FIND v(dout0_29) AT=790.025n

* CHECK dout0_30 Vdout0_30ck157 = 0 time = 790
.meas tran vdout0_30ck157 FIND v(dout0_30) AT=790.025n

* CHECK dout0_31 Vdout0_31ck157 = 0 time = 790
.meas tran vdout0_31ck157 FIND v(dout0_31) AT=790.025n

* CHECK dout0_32 Vdout0_32ck157 = 0.9 time = 790
.meas tran vdout0_32ck157 FIND v(dout0_32) AT=790.025n

* CHECK dout0_33 Vdout0_33ck157 = 0 time = 790
.meas tran vdout0_33ck157 FIND v(dout0_33) AT=790.025n

* CHECK dout0_34 Vdout0_34ck157 = 0 time = 790
.meas tran vdout0_34ck157 FIND v(dout0_34) AT=790.025n

* CHECK dout0_35 Vdout0_35ck157 = 0.9 time = 790
.meas tran vdout0_35ck157 FIND v(dout0_35) AT=790.025n

* CHECK dout0_36 Vdout0_36ck157 = 0 time = 790
.meas tran vdout0_36ck157 FIND v(dout0_36) AT=790.025n

* CHECK dout0_37 Vdout0_37ck157 = 0.9 time = 790
.meas tran vdout0_37ck157 FIND v(dout0_37) AT=790.025n

* CHECK dout0_38 Vdout0_38ck157 = 0.9 time = 790
.meas tran vdout0_38ck157 FIND v(dout0_38) AT=790.025n

* CHECK dout0_39 Vdout0_39ck157 = 0.9 time = 790
.meas tran vdout0_39ck157 FIND v(dout0_39) AT=790.025n

* CHECK dout0_40 Vdout0_40ck157 = 0 time = 790
.meas tran vdout0_40ck157 FIND v(dout0_40) AT=790.025n

* CHECK dout0_41 Vdout0_41ck157 = 0 time = 790
.meas tran vdout0_41ck157 FIND v(dout0_41) AT=790.025n

* CHECK dout0_42 Vdout0_42ck157 = 0 time = 790
.meas tran vdout0_42ck157 FIND v(dout0_42) AT=790.025n

* CHECK dout0_43 Vdout0_43ck157 = 0.9 time = 790
.meas tran vdout0_43ck157 FIND v(dout0_43) AT=790.025n

* CHECK dout0_44 Vdout0_44ck157 = 0 time = 790
.meas tran vdout0_44ck157 FIND v(dout0_44) AT=790.025n

* CHECK dout0_45 Vdout0_45ck157 = 0.9 time = 790
.meas tran vdout0_45ck157 FIND v(dout0_45) AT=790.025n

* CHECK dout0_46 Vdout0_46ck157 = 0 time = 790
.meas tran vdout0_46ck157 FIND v(dout0_46) AT=790.025n

* CHECK dout0_47 Vdout0_47ck157 = 0.9 time = 790
.meas tran vdout0_47ck157 FIND v(dout0_47) AT=790.025n

* CHECK dout0_48 Vdout0_48ck157 = 0.9 time = 790
.meas tran vdout0_48ck157 FIND v(dout0_48) AT=790.025n

* CHECK dout0_49 Vdout0_49ck157 = 0.9 time = 790
.meas tran vdout0_49ck157 FIND v(dout0_49) AT=790.025n

* CHECK dout0_50 Vdout0_50ck157 = 0 time = 790
.meas tran vdout0_50ck157 FIND v(dout0_50) AT=790.025n

* CHECK dout0_51 Vdout0_51ck157 = 0.9 time = 790
.meas tran vdout0_51ck157 FIND v(dout0_51) AT=790.025n

* CHECK dout0_52 Vdout0_52ck157 = 0.9 time = 790
.meas tran vdout0_52ck157 FIND v(dout0_52) AT=790.025n

* CHECK dout0_53 Vdout0_53ck157 = 0 time = 790
.meas tran vdout0_53ck157 FIND v(dout0_53) AT=790.025n

* CHECK dout0_54 Vdout0_54ck157 = 0.9 time = 790
.meas tran vdout0_54ck157 FIND v(dout0_54) AT=790.025n

* CHECK dout0_55 Vdout0_55ck157 = 0 time = 790
.meas tran vdout0_55ck157 FIND v(dout0_55) AT=790.025n

* CHECK dout0_56 Vdout0_56ck157 = 0 time = 790
.meas tran vdout0_56ck157 FIND v(dout0_56) AT=790.025n

* CHECK dout0_57 Vdout0_57ck157 = 0.9 time = 790
.meas tran vdout0_57ck157 FIND v(dout0_57) AT=790.025n

* CHECK dout0_58 Vdout0_58ck157 = 0.9 time = 790
.meas tran vdout0_58ck157 FIND v(dout0_58) AT=790.025n

* CHECK dout0_59 Vdout0_59ck157 = 0.9 time = 790
.meas tran vdout0_59ck157 FIND v(dout0_59) AT=790.025n

* CHECK dout0_60 Vdout0_60ck157 = 0.9 time = 790
.meas tran vdout0_60ck157 FIND v(dout0_60) AT=790.025n

* CHECK dout0_61 Vdout0_61ck157 = 0 time = 790
.meas tran vdout0_61ck157 FIND v(dout0_61) AT=790.025n

* CHECK dout0_62 Vdout0_62ck157 = 0 time = 790
.meas tran vdout0_62ck157 FIND v(dout0_62) AT=790.025n

* CHECK dout0_63 Vdout0_63ck157 = 0 time = 790
.meas tran vdout0_63ck157 FIND v(dout0_63) AT=790.025n

* CHECK dout0_0 Vdout0_0ck158 = 0 time = 795
.meas tran vdout0_0ck158 FIND v(dout0_0) AT=795.025n

* CHECK dout0_1 Vdout0_1ck158 = 0 time = 795
.meas tran vdout0_1ck158 FIND v(dout0_1) AT=795.025n

* CHECK dout0_2 Vdout0_2ck158 = 0.9 time = 795
.meas tran vdout0_2ck158 FIND v(dout0_2) AT=795.025n

* CHECK dout0_3 Vdout0_3ck158 = 0.9 time = 795
.meas tran vdout0_3ck158 FIND v(dout0_3) AT=795.025n

* CHECK dout0_4 Vdout0_4ck158 = 0 time = 795
.meas tran vdout0_4ck158 FIND v(dout0_4) AT=795.025n

* CHECK dout0_5 Vdout0_5ck158 = 0.9 time = 795
.meas tran vdout0_5ck158 FIND v(dout0_5) AT=795.025n

* CHECK dout0_6 Vdout0_6ck158 = 0 time = 795
.meas tran vdout0_6ck158 FIND v(dout0_6) AT=795.025n

* CHECK dout0_7 Vdout0_7ck158 = 0 time = 795
.meas tran vdout0_7ck158 FIND v(dout0_7) AT=795.025n

* CHECK dout0_8 Vdout0_8ck158 = 0 time = 795
.meas tran vdout0_8ck158 FIND v(dout0_8) AT=795.025n

* CHECK dout0_9 Vdout0_9ck158 = 0.9 time = 795
.meas tran vdout0_9ck158 FIND v(dout0_9) AT=795.025n

* CHECK dout0_10 Vdout0_10ck158 = 0.9 time = 795
.meas tran vdout0_10ck158 FIND v(dout0_10) AT=795.025n

* CHECK dout0_11 Vdout0_11ck158 = 0.9 time = 795
.meas tran vdout0_11ck158 FIND v(dout0_11) AT=795.025n

* CHECK dout0_12 Vdout0_12ck158 = 0.9 time = 795
.meas tran vdout0_12ck158 FIND v(dout0_12) AT=795.025n

* CHECK dout0_13 Vdout0_13ck158 = 0.9 time = 795
.meas tran vdout0_13ck158 FIND v(dout0_13) AT=795.025n

* CHECK dout0_14 Vdout0_14ck158 = 0.9 time = 795
.meas tran vdout0_14ck158 FIND v(dout0_14) AT=795.025n

* CHECK dout0_15 Vdout0_15ck158 = 0 time = 795
.meas tran vdout0_15ck158 FIND v(dout0_15) AT=795.025n

* CHECK dout0_16 Vdout0_16ck158 = 0.9 time = 795
.meas tran vdout0_16ck158 FIND v(dout0_16) AT=795.025n

* CHECK dout0_17 Vdout0_17ck158 = 0.9 time = 795
.meas tran vdout0_17ck158 FIND v(dout0_17) AT=795.025n

* CHECK dout0_18 Vdout0_18ck158 = 0.9 time = 795
.meas tran vdout0_18ck158 FIND v(dout0_18) AT=795.025n

* CHECK dout0_19 Vdout0_19ck158 = 0 time = 795
.meas tran vdout0_19ck158 FIND v(dout0_19) AT=795.025n

* CHECK dout0_20 Vdout0_20ck158 = 0 time = 795
.meas tran vdout0_20ck158 FIND v(dout0_20) AT=795.025n

* CHECK dout0_21 Vdout0_21ck158 = 0.9 time = 795
.meas tran vdout0_21ck158 FIND v(dout0_21) AT=795.025n

* CHECK dout0_22 Vdout0_22ck158 = 0 time = 795
.meas tran vdout0_22ck158 FIND v(dout0_22) AT=795.025n

* CHECK dout0_23 Vdout0_23ck158 = 0.9 time = 795
.meas tran vdout0_23ck158 FIND v(dout0_23) AT=795.025n

* CHECK dout0_24 Vdout0_24ck158 = 0.9 time = 795
.meas tran vdout0_24ck158 FIND v(dout0_24) AT=795.025n

* CHECK dout0_25 Vdout0_25ck158 = 0 time = 795
.meas tran vdout0_25ck158 FIND v(dout0_25) AT=795.025n

* CHECK dout0_26 Vdout0_26ck158 = 0 time = 795
.meas tran vdout0_26ck158 FIND v(dout0_26) AT=795.025n

* CHECK dout0_27 Vdout0_27ck158 = 0.9 time = 795
.meas tran vdout0_27ck158 FIND v(dout0_27) AT=795.025n

* CHECK dout0_28 Vdout0_28ck158 = 0 time = 795
.meas tran vdout0_28ck158 FIND v(dout0_28) AT=795.025n

* CHECK dout0_29 Vdout0_29ck158 = 0.9 time = 795
.meas tran vdout0_29ck158 FIND v(dout0_29) AT=795.025n

* CHECK dout0_30 Vdout0_30ck158 = 0 time = 795
.meas tran vdout0_30ck158 FIND v(dout0_30) AT=795.025n

* CHECK dout0_31 Vdout0_31ck158 = 0 time = 795
.meas tran vdout0_31ck158 FIND v(dout0_31) AT=795.025n

* CHECK dout0_32 Vdout0_32ck158 = 0.9 time = 795
.meas tran vdout0_32ck158 FIND v(dout0_32) AT=795.025n

* CHECK dout0_33 Vdout0_33ck158 = 0 time = 795
.meas tran vdout0_33ck158 FIND v(dout0_33) AT=795.025n

* CHECK dout0_34 Vdout0_34ck158 = 0 time = 795
.meas tran vdout0_34ck158 FIND v(dout0_34) AT=795.025n

* CHECK dout0_35 Vdout0_35ck158 = 0.9 time = 795
.meas tran vdout0_35ck158 FIND v(dout0_35) AT=795.025n

* CHECK dout0_36 Vdout0_36ck158 = 0 time = 795
.meas tran vdout0_36ck158 FIND v(dout0_36) AT=795.025n

* CHECK dout0_37 Vdout0_37ck158 = 0.9 time = 795
.meas tran vdout0_37ck158 FIND v(dout0_37) AT=795.025n

* CHECK dout0_38 Vdout0_38ck158 = 0.9 time = 795
.meas tran vdout0_38ck158 FIND v(dout0_38) AT=795.025n

* CHECK dout0_39 Vdout0_39ck158 = 0.9 time = 795
.meas tran vdout0_39ck158 FIND v(dout0_39) AT=795.025n

* CHECK dout0_40 Vdout0_40ck158 = 0 time = 795
.meas tran vdout0_40ck158 FIND v(dout0_40) AT=795.025n

* CHECK dout0_41 Vdout0_41ck158 = 0 time = 795
.meas tran vdout0_41ck158 FIND v(dout0_41) AT=795.025n

* CHECK dout0_42 Vdout0_42ck158 = 0 time = 795
.meas tran vdout0_42ck158 FIND v(dout0_42) AT=795.025n

* CHECK dout0_43 Vdout0_43ck158 = 0.9 time = 795
.meas tran vdout0_43ck158 FIND v(dout0_43) AT=795.025n

* CHECK dout0_44 Vdout0_44ck158 = 0 time = 795
.meas tran vdout0_44ck158 FIND v(dout0_44) AT=795.025n

* CHECK dout0_45 Vdout0_45ck158 = 0.9 time = 795
.meas tran vdout0_45ck158 FIND v(dout0_45) AT=795.025n

* CHECK dout0_46 Vdout0_46ck158 = 0 time = 795
.meas tran vdout0_46ck158 FIND v(dout0_46) AT=795.025n

* CHECK dout0_47 Vdout0_47ck158 = 0.9 time = 795
.meas tran vdout0_47ck158 FIND v(dout0_47) AT=795.025n

* CHECK dout0_48 Vdout0_48ck158 = 0.9 time = 795
.meas tran vdout0_48ck158 FIND v(dout0_48) AT=795.025n

* CHECK dout0_49 Vdout0_49ck158 = 0.9 time = 795
.meas tran vdout0_49ck158 FIND v(dout0_49) AT=795.025n

* CHECK dout0_50 Vdout0_50ck158 = 0 time = 795
.meas tran vdout0_50ck158 FIND v(dout0_50) AT=795.025n

* CHECK dout0_51 Vdout0_51ck158 = 0.9 time = 795
.meas tran vdout0_51ck158 FIND v(dout0_51) AT=795.025n

* CHECK dout0_52 Vdout0_52ck158 = 0.9 time = 795
.meas tran vdout0_52ck158 FIND v(dout0_52) AT=795.025n

* CHECK dout0_53 Vdout0_53ck158 = 0 time = 795
.meas tran vdout0_53ck158 FIND v(dout0_53) AT=795.025n

* CHECK dout0_54 Vdout0_54ck158 = 0.9 time = 795
.meas tran vdout0_54ck158 FIND v(dout0_54) AT=795.025n

* CHECK dout0_55 Vdout0_55ck158 = 0 time = 795
.meas tran vdout0_55ck158 FIND v(dout0_55) AT=795.025n

* CHECK dout0_56 Vdout0_56ck158 = 0 time = 795
.meas tran vdout0_56ck158 FIND v(dout0_56) AT=795.025n

* CHECK dout0_57 Vdout0_57ck158 = 0.9 time = 795
.meas tran vdout0_57ck158 FIND v(dout0_57) AT=795.025n

* CHECK dout0_58 Vdout0_58ck158 = 0.9 time = 795
.meas tran vdout0_58ck158 FIND v(dout0_58) AT=795.025n

* CHECK dout0_59 Vdout0_59ck158 = 0.9 time = 795
.meas tran vdout0_59ck158 FIND v(dout0_59) AT=795.025n

* CHECK dout0_60 Vdout0_60ck158 = 0.9 time = 795
.meas tran vdout0_60ck158 FIND v(dout0_60) AT=795.025n

* CHECK dout0_61 Vdout0_61ck158 = 0 time = 795
.meas tran vdout0_61ck158 FIND v(dout0_61) AT=795.025n

* CHECK dout0_62 Vdout0_62ck158 = 0 time = 795
.meas tran vdout0_62ck158 FIND v(dout0_62) AT=795.025n

* CHECK dout0_63 Vdout0_63ck158 = 0 time = 795
.meas tran vdout0_63ck158 FIND v(dout0_63) AT=795.025n

* CHECK dout0_0 Vdout0_0ck160 = 0 time = 805
.meas tran vdout0_0ck160 FIND v(dout0_0) AT=805.025n

* CHECK dout0_1 Vdout0_1ck160 = 0.9 time = 805
.meas tran vdout0_1ck160 FIND v(dout0_1) AT=805.025n

* CHECK dout0_2 Vdout0_2ck160 = 0 time = 805
.meas tran vdout0_2ck160 FIND v(dout0_2) AT=805.025n

* CHECK dout0_3 Vdout0_3ck160 = 0.9 time = 805
.meas tran vdout0_3ck160 FIND v(dout0_3) AT=805.025n

* CHECK dout0_4 Vdout0_4ck160 = 0.9 time = 805
.meas tran vdout0_4ck160 FIND v(dout0_4) AT=805.025n

* CHECK dout0_5 Vdout0_5ck160 = 0.9 time = 805
.meas tran vdout0_5ck160 FIND v(dout0_5) AT=805.025n

* CHECK dout0_6 Vdout0_6ck160 = 0 time = 805
.meas tran vdout0_6ck160 FIND v(dout0_6) AT=805.025n

* CHECK dout0_7 Vdout0_7ck160 = 0 time = 805
.meas tran vdout0_7ck160 FIND v(dout0_7) AT=805.025n

* CHECK dout0_8 Vdout0_8ck160 = 0.9 time = 805
.meas tran vdout0_8ck160 FIND v(dout0_8) AT=805.025n

* CHECK dout0_9 Vdout0_9ck160 = 0 time = 805
.meas tran vdout0_9ck160 FIND v(dout0_9) AT=805.025n

* CHECK dout0_10 Vdout0_10ck160 = 0.9 time = 805
.meas tran vdout0_10ck160 FIND v(dout0_10) AT=805.025n

* CHECK dout0_11 Vdout0_11ck160 = 0 time = 805
.meas tran vdout0_11ck160 FIND v(dout0_11) AT=805.025n

* CHECK dout0_12 Vdout0_12ck160 = 0 time = 805
.meas tran vdout0_12ck160 FIND v(dout0_12) AT=805.025n

* CHECK dout0_13 Vdout0_13ck160 = 0 time = 805
.meas tran vdout0_13ck160 FIND v(dout0_13) AT=805.025n

* CHECK dout0_14 Vdout0_14ck160 = 0.9 time = 805
.meas tran vdout0_14ck160 FIND v(dout0_14) AT=805.025n

* CHECK dout0_15 Vdout0_15ck160 = 0.9 time = 805
.meas tran vdout0_15ck160 FIND v(dout0_15) AT=805.025n

* CHECK dout0_16 Vdout0_16ck160 = 0.9 time = 805
.meas tran vdout0_16ck160 FIND v(dout0_16) AT=805.025n

* CHECK dout0_17 Vdout0_17ck160 = 0 time = 805
.meas tran vdout0_17ck160 FIND v(dout0_17) AT=805.025n

* CHECK dout0_18 Vdout0_18ck160 = 0.9 time = 805
.meas tran vdout0_18ck160 FIND v(dout0_18) AT=805.025n

* CHECK dout0_19 Vdout0_19ck160 = 0 time = 805
.meas tran vdout0_19ck160 FIND v(dout0_19) AT=805.025n

* CHECK dout0_20 Vdout0_20ck160 = 0 time = 805
.meas tran vdout0_20ck160 FIND v(dout0_20) AT=805.025n

* CHECK dout0_21 Vdout0_21ck160 = 0 time = 805
.meas tran vdout0_21ck160 FIND v(dout0_21) AT=805.025n

* CHECK dout0_22 Vdout0_22ck160 = 0.9 time = 805
.meas tran vdout0_22ck160 FIND v(dout0_22) AT=805.025n

* CHECK dout0_23 Vdout0_23ck160 = 0 time = 805
.meas tran vdout0_23ck160 FIND v(dout0_23) AT=805.025n

* CHECK dout0_24 Vdout0_24ck160 = 0 time = 805
.meas tran vdout0_24ck160 FIND v(dout0_24) AT=805.025n

* CHECK dout0_25 Vdout0_25ck160 = 0.9 time = 805
.meas tran vdout0_25ck160 FIND v(dout0_25) AT=805.025n

* CHECK dout0_26 Vdout0_26ck160 = 0.9 time = 805
.meas tran vdout0_26ck160 FIND v(dout0_26) AT=805.025n

* CHECK dout0_27 Vdout0_27ck160 = 0.9 time = 805
.meas tran vdout0_27ck160 FIND v(dout0_27) AT=805.025n

* CHECK dout0_28 Vdout0_28ck160 = 0.9 time = 805
.meas tran vdout0_28ck160 FIND v(dout0_28) AT=805.025n

* CHECK dout0_29 Vdout0_29ck160 = 0 time = 805
.meas tran vdout0_29ck160 FIND v(dout0_29) AT=805.025n

* CHECK dout0_30 Vdout0_30ck160 = 0 time = 805
.meas tran vdout0_30ck160 FIND v(dout0_30) AT=805.025n

* CHECK dout0_31 Vdout0_31ck160 = 0 time = 805
.meas tran vdout0_31ck160 FIND v(dout0_31) AT=805.025n

* CHECK dout0_32 Vdout0_32ck160 = 0.9 time = 805
.meas tran vdout0_32ck160 FIND v(dout0_32) AT=805.025n

* CHECK dout0_33 Vdout0_33ck160 = 0.9 time = 805
.meas tran vdout0_33ck160 FIND v(dout0_33) AT=805.025n

* CHECK dout0_34 Vdout0_34ck160 = 0.9 time = 805
.meas tran vdout0_34ck160 FIND v(dout0_34) AT=805.025n

* CHECK dout0_35 Vdout0_35ck160 = 0 time = 805
.meas tran vdout0_35ck160 FIND v(dout0_35) AT=805.025n

* CHECK dout0_36 Vdout0_36ck160 = 0.9 time = 805
.meas tran vdout0_36ck160 FIND v(dout0_36) AT=805.025n

* CHECK dout0_37 Vdout0_37ck160 = 0 time = 805
.meas tran vdout0_37ck160 FIND v(dout0_37) AT=805.025n

* CHECK dout0_38 Vdout0_38ck160 = 0 time = 805
.meas tran vdout0_38ck160 FIND v(dout0_38) AT=805.025n

* CHECK dout0_39 Vdout0_39ck160 = 0.9 time = 805
.meas tran vdout0_39ck160 FIND v(dout0_39) AT=805.025n

* CHECK dout0_40 Vdout0_40ck160 = 0 time = 805
.meas tran vdout0_40ck160 FIND v(dout0_40) AT=805.025n

* CHECK dout0_41 Vdout0_41ck160 = 0.9 time = 805
.meas tran vdout0_41ck160 FIND v(dout0_41) AT=805.025n

* CHECK dout0_42 Vdout0_42ck160 = 0 time = 805
.meas tran vdout0_42ck160 FIND v(dout0_42) AT=805.025n

* CHECK dout0_43 Vdout0_43ck160 = 0 time = 805
.meas tran vdout0_43ck160 FIND v(dout0_43) AT=805.025n

* CHECK dout0_44 Vdout0_44ck160 = 0.9 time = 805
.meas tran vdout0_44ck160 FIND v(dout0_44) AT=805.025n

* CHECK dout0_45 Vdout0_45ck160 = 0.9 time = 805
.meas tran vdout0_45ck160 FIND v(dout0_45) AT=805.025n

* CHECK dout0_46 Vdout0_46ck160 = 0.9 time = 805
.meas tran vdout0_46ck160 FIND v(dout0_46) AT=805.025n

* CHECK dout0_47 Vdout0_47ck160 = 0 time = 805
.meas tran vdout0_47ck160 FIND v(dout0_47) AT=805.025n

* CHECK dout0_48 Vdout0_48ck160 = 0 time = 805
.meas tran vdout0_48ck160 FIND v(dout0_48) AT=805.025n

* CHECK dout0_49 Vdout0_49ck160 = 0.9 time = 805
.meas tran vdout0_49ck160 FIND v(dout0_49) AT=805.025n

* CHECK dout0_50 Vdout0_50ck160 = 0.9 time = 805
.meas tran vdout0_50ck160 FIND v(dout0_50) AT=805.025n

* CHECK dout0_51 Vdout0_51ck160 = 0 time = 805
.meas tran vdout0_51ck160 FIND v(dout0_51) AT=805.025n

* CHECK dout0_52 Vdout0_52ck160 = 0 time = 805
.meas tran vdout0_52ck160 FIND v(dout0_52) AT=805.025n

* CHECK dout0_53 Vdout0_53ck160 = 0 time = 805
.meas tran vdout0_53ck160 FIND v(dout0_53) AT=805.025n

* CHECK dout0_54 Vdout0_54ck160 = 0 time = 805
.meas tran vdout0_54ck160 FIND v(dout0_54) AT=805.025n

* CHECK dout0_55 Vdout0_55ck160 = 0 time = 805
.meas tran vdout0_55ck160 FIND v(dout0_55) AT=805.025n

* CHECK dout0_56 Vdout0_56ck160 = 0 time = 805
.meas tran vdout0_56ck160 FIND v(dout0_56) AT=805.025n

* CHECK dout0_57 Vdout0_57ck160 = 0 time = 805
.meas tran vdout0_57ck160 FIND v(dout0_57) AT=805.025n

* CHECK dout0_58 Vdout0_58ck160 = 0 time = 805
.meas tran vdout0_58ck160 FIND v(dout0_58) AT=805.025n

* CHECK dout0_59 Vdout0_59ck160 = 0 time = 805
.meas tran vdout0_59ck160 FIND v(dout0_59) AT=805.025n

* CHECK dout0_60 Vdout0_60ck160 = 0.9 time = 805
.meas tran vdout0_60ck160 FIND v(dout0_60) AT=805.025n

* CHECK dout0_61 Vdout0_61ck160 = 0.9 time = 805
.meas tran vdout0_61ck160 FIND v(dout0_61) AT=805.025n

* CHECK dout0_62 Vdout0_62ck160 = 0 time = 805
.meas tran vdout0_62ck160 FIND v(dout0_62) AT=805.025n

* CHECK dout0_63 Vdout0_63ck160 = 0 time = 805
.meas tran vdout0_63ck160 FIND v(dout0_63) AT=805.025n

* CHECK dout0_0 Vdout0_0ck161 = 0.9 time = 810
.meas tran vdout0_0ck161 FIND v(dout0_0) AT=810.025n

* CHECK dout0_1 Vdout0_1ck161 = 0 time = 810
.meas tran vdout0_1ck161 FIND v(dout0_1) AT=810.025n

* CHECK dout0_2 Vdout0_2ck161 = 0 time = 810
.meas tran vdout0_2ck161 FIND v(dout0_2) AT=810.025n

* CHECK dout0_3 Vdout0_3ck161 = 0.9 time = 810
.meas tran vdout0_3ck161 FIND v(dout0_3) AT=810.025n

* CHECK dout0_4 Vdout0_4ck161 = 0.9 time = 810
.meas tran vdout0_4ck161 FIND v(dout0_4) AT=810.025n

* CHECK dout0_5 Vdout0_5ck161 = 0 time = 810
.meas tran vdout0_5ck161 FIND v(dout0_5) AT=810.025n

* CHECK dout0_6 Vdout0_6ck161 = 0.9 time = 810
.meas tran vdout0_6ck161 FIND v(dout0_6) AT=810.025n

* CHECK dout0_7 Vdout0_7ck161 = 0 time = 810
.meas tran vdout0_7ck161 FIND v(dout0_7) AT=810.025n

* CHECK dout0_8 Vdout0_8ck161 = 0.9 time = 810
.meas tran vdout0_8ck161 FIND v(dout0_8) AT=810.025n

* CHECK dout0_9 Vdout0_9ck161 = 0 time = 810
.meas tran vdout0_9ck161 FIND v(dout0_9) AT=810.025n

* CHECK dout0_10 Vdout0_10ck161 = 0.9 time = 810
.meas tran vdout0_10ck161 FIND v(dout0_10) AT=810.025n

* CHECK dout0_11 Vdout0_11ck161 = 0.9 time = 810
.meas tran vdout0_11ck161 FIND v(dout0_11) AT=810.025n

* CHECK dout0_12 Vdout0_12ck161 = 0.9 time = 810
.meas tran vdout0_12ck161 FIND v(dout0_12) AT=810.025n

* CHECK dout0_13 Vdout0_13ck161 = 0.9 time = 810
.meas tran vdout0_13ck161 FIND v(dout0_13) AT=810.025n

* CHECK dout0_14 Vdout0_14ck161 = 0 time = 810
.meas tran vdout0_14ck161 FIND v(dout0_14) AT=810.025n

* CHECK dout0_15 Vdout0_15ck161 = 0.9 time = 810
.meas tran vdout0_15ck161 FIND v(dout0_15) AT=810.025n

* CHECK dout0_16 Vdout0_16ck161 = 0 time = 810
.meas tran vdout0_16ck161 FIND v(dout0_16) AT=810.025n

* CHECK dout0_17 Vdout0_17ck161 = 0 time = 810
.meas tran vdout0_17ck161 FIND v(dout0_17) AT=810.025n

* CHECK dout0_18 Vdout0_18ck161 = 0.9 time = 810
.meas tran vdout0_18ck161 FIND v(dout0_18) AT=810.025n

* CHECK dout0_19 Vdout0_19ck161 = 0 time = 810
.meas tran vdout0_19ck161 FIND v(dout0_19) AT=810.025n

* CHECK dout0_20 Vdout0_20ck161 = 0 time = 810
.meas tran vdout0_20ck161 FIND v(dout0_20) AT=810.025n

* CHECK dout0_21 Vdout0_21ck161 = 0 time = 810
.meas tran vdout0_21ck161 FIND v(dout0_21) AT=810.025n

* CHECK dout0_22 Vdout0_22ck161 = 0 time = 810
.meas tran vdout0_22ck161 FIND v(dout0_22) AT=810.025n

* CHECK dout0_23 Vdout0_23ck161 = 0.9 time = 810
.meas tran vdout0_23ck161 FIND v(dout0_23) AT=810.025n

* CHECK dout0_24 Vdout0_24ck161 = 0 time = 810
.meas tran vdout0_24ck161 FIND v(dout0_24) AT=810.025n

* CHECK dout0_25 Vdout0_25ck161 = 0.9 time = 810
.meas tran vdout0_25ck161 FIND v(dout0_25) AT=810.025n

* CHECK dout0_26 Vdout0_26ck161 = 0 time = 810
.meas tran vdout0_26ck161 FIND v(dout0_26) AT=810.025n

* CHECK dout0_27 Vdout0_27ck161 = 0.9 time = 810
.meas tran vdout0_27ck161 FIND v(dout0_27) AT=810.025n

* CHECK dout0_28 Vdout0_28ck161 = 0 time = 810
.meas tran vdout0_28ck161 FIND v(dout0_28) AT=810.025n

* CHECK dout0_29 Vdout0_29ck161 = 0.9 time = 810
.meas tran vdout0_29ck161 FIND v(dout0_29) AT=810.025n

* CHECK dout0_30 Vdout0_30ck161 = 0.9 time = 810
.meas tran vdout0_30ck161 FIND v(dout0_30) AT=810.025n

* CHECK dout0_31 Vdout0_31ck161 = 0 time = 810
.meas tran vdout0_31ck161 FIND v(dout0_31) AT=810.025n

* CHECK dout0_32 Vdout0_32ck161 = 0.9 time = 810
.meas tran vdout0_32ck161 FIND v(dout0_32) AT=810.025n

* CHECK dout0_33 Vdout0_33ck161 = 0.9 time = 810
.meas tran vdout0_33ck161 FIND v(dout0_33) AT=810.025n

* CHECK dout0_34 Vdout0_34ck161 = 0.9 time = 810
.meas tran vdout0_34ck161 FIND v(dout0_34) AT=810.025n

* CHECK dout0_35 Vdout0_35ck161 = 0.9 time = 810
.meas tran vdout0_35ck161 FIND v(dout0_35) AT=810.025n

* CHECK dout0_36 Vdout0_36ck161 = 0.9 time = 810
.meas tran vdout0_36ck161 FIND v(dout0_36) AT=810.025n

* CHECK dout0_37 Vdout0_37ck161 = 0 time = 810
.meas tran vdout0_37ck161 FIND v(dout0_37) AT=810.025n

* CHECK dout0_38 Vdout0_38ck161 = 0 time = 810
.meas tran vdout0_38ck161 FIND v(dout0_38) AT=810.025n

* CHECK dout0_39 Vdout0_39ck161 = 0 time = 810
.meas tran vdout0_39ck161 FIND v(dout0_39) AT=810.025n

* CHECK dout0_40 Vdout0_40ck161 = 0 time = 810
.meas tran vdout0_40ck161 FIND v(dout0_40) AT=810.025n

* CHECK dout0_41 Vdout0_41ck161 = 0.9 time = 810
.meas tran vdout0_41ck161 FIND v(dout0_41) AT=810.025n

* CHECK dout0_42 Vdout0_42ck161 = 0 time = 810
.meas tran vdout0_42ck161 FIND v(dout0_42) AT=810.025n

* CHECK dout0_43 Vdout0_43ck161 = 0 time = 810
.meas tran vdout0_43ck161 FIND v(dout0_43) AT=810.025n

* CHECK dout0_44 Vdout0_44ck161 = 0.9 time = 810
.meas tran vdout0_44ck161 FIND v(dout0_44) AT=810.025n

* CHECK dout0_45 Vdout0_45ck161 = 0.9 time = 810
.meas tran vdout0_45ck161 FIND v(dout0_45) AT=810.025n

* CHECK dout0_46 Vdout0_46ck161 = 0.9 time = 810
.meas tran vdout0_46ck161 FIND v(dout0_46) AT=810.025n

* CHECK dout0_47 Vdout0_47ck161 = 0 time = 810
.meas tran vdout0_47ck161 FIND v(dout0_47) AT=810.025n

* CHECK dout0_48 Vdout0_48ck161 = 0 time = 810
.meas tran vdout0_48ck161 FIND v(dout0_48) AT=810.025n

* CHECK dout0_49 Vdout0_49ck161 = 0 time = 810
.meas tran vdout0_49ck161 FIND v(dout0_49) AT=810.025n

* CHECK dout0_50 Vdout0_50ck161 = 0.9 time = 810
.meas tran vdout0_50ck161 FIND v(dout0_50) AT=810.025n

* CHECK dout0_51 Vdout0_51ck161 = 0 time = 810
.meas tran vdout0_51ck161 FIND v(dout0_51) AT=810.025n

* CHECK dout0_52 Vdout0_52ck161 = 0 time = 810
.meas tran vdout0_52ck161 FIND v(dout0_52) AT=810.025n

* CHECK dout0_53 Vdout0_53ck161 = 0 time = 810
.meas tran vdout0_53ck161 FIND v(dout0_53) AT=810.025n

* CHECK dout0_54 Vdout0_54ck161 = 0.9 time = 810
.meas tran vdout0_54ck161 FIND v(dout0_54) AT=810.025n

* CHECK dout0_55 Vdout0_55ck161 = 0 time = 810
.meas tran vdout0_55ck161 FIND v(dout0_55) AT=810.025n

* CHECK dout0_56 Vdout0_56ck161 = 0 time = 810
.meas tran vdout0_56ck161 FIND v(dout0_56) AT=810.025n

* CHECK dout0_57 Vdout0_57ck161 = 0.9 time = 810
.meas tran vdout0_57ck161 FIND v(dout0_57) AT=810.025n

* CHECK dout0_58 Vdout0_58ck161 = 0.9 time = 810
.meas tran vdout0_58ck161 FIND v(dout0_58) AT=810.025n

* CHECK dout0_59 Vdout0_59ck161 = 0.9 time = 810
.meas tran vdout0_59ck161 FIND v(dout0_59) AT=810.025n

* CHECK dout0_60 Vdout0_60ck161 = 0 time = 810
.meas tran vdout0_60ck161 FIND v(dout0_60) AT=810.025n

* CHECK dout0_61 Vdout0_61ck161 = 0.9 time = 810
.meas tran vdout0_61ck161 FIND v(dout0_61) AT=810.025n

* CHECK dout0_62 Vdout0_62ck161 = 0 time = 810
.meas tran vdout0_62ck161 FIND v(dout0_62) AT=810.025n

* CHECK dout0_63 Vdout0_63ck161 = 0 time = 810
.meas tran vdout0_63ck161 FIND v(dout0_63) AT=810.025n

* CHECK dout0_0 Vdout0_0ck162 = 0 time = 815
.meas tran vdout0_0ck162 FIND v(dout0_0) AT=815.025n

* CHECK dout0_1 Vdout0_1ck162 = 0 time = 815
.meas tran vdout0_1ck162 FIND v(dout0_1) AT=815.025n

* CHECK dout0_2 Vdout0_2ck162 = 0.9 time = 815
.meas tran vdout0_2ck162 FIND v(dout0_2) AT=815.025n

* CHECK dout0_3 Vdout0_3ck162 = 0.9 time = 815
.meas tran vdout0_3ck162 FIND v(dout0_3) AT=815.025n

* CHECK dout0_4 Vdout0_4ck162 = 0 time = 815
.meas tran vdout0_4ck162 FIND v(dout0_4) AT=815.025n

* CHECK dout0_5 Vdout0_5ck162 = 0.9 time = 815
.meas tran vdout0_5ck162 FIND v(dout0_5) AT=815.025n

* CHECK dout0_6 Vdout0_6ck162 = 0 time = 815
.meas tran vdout0_6ck162 FIND v(dout0_6) AT=815.025n

* CHECK dout0_7 Vdout0_7ck162 = 0 time = 815
.meas tran vdout0_7ck162 FIND v(dout0_7) AT=815.025n

* CHECK dout0_8 Vdout0_8ck162 = 0 time = 815
.meas tran vdout0_8ck162 FIND v(dout0_8) AT=815.025n

* CHECK dout0_9 Vdout0_9ck162 = 0.9 time = 815
.meas tran vdout0_9ck162 FIND v(dout0_9) AT=815.025n

* CHECK dout0_10 Vdout0_10ck162 = 0.9 time = 815
.meas tran vdout0_10ck162 FIND v(dout0_10) AT=815.025n

* CHECK dout0_11 Vdout0_11ck162 = 0.9 time = 815
.meas tran vdout0_11ck162 FIND v(dout0_11) AT=815.025n

* CHECK dout0_12 Vdout0_12ck162 = 0.9 time = 815
.meas tran vdout0_12ck162 FIND v(dout0_12) AT=815.025n

* CHECK dout0_13 Vdout0_13ck162 = 0.9 time = 815
.meas tran vdout0_13ck162 FIND v(dout0_13) AT=815.025n

* CHECK dout0_14 Vdout0_14ck162 = 0.9 time = 815
.meas tran vdout0_14ck162 FIND v(dout0_14) AT=815.025n

* CHECK dout0_15 Vdout0_15ck162 = 0 time = 815
.meas tran vdout0_15ck162 FIND v(dout0_15) AT=815.025n

* CHECK dout0_16 Vdout0_16ck162 = 0.9 time = 815
.meas tran vdout0_16ck162 FIND v(dout0_16) AT=815.025n

* CHECK dout0_17 Vdout0_17ck162 = 0.9 time = 815
.meas tran vdout0_17ck162 FIND v(dout0_17) AT=815.025n

* CHECK dout0_18 Vdout0_18ck162 = 0.9 time = 815
.meas tran vdout0_18ck162 FIND v(dout0_18) AT=815.025n

* CHECK dout0_19 Vdout0_19ck162 = 0 time = 815
.meas tran vdout0_19ck162 FIND v(dout0_19) AT=815.025n

* CHECK dout0_20 Vdout0_20ck162 = 0 time = 815
.meas tran vdout0_20ck162 FIND v(dout0_20) AT=815.025n

* CHECK dout0_21 Vdout0_21ck162 = 0.9 time = 815
.meas tran vdout0_21ck162 FIND v(dout0_21) AT=815.025n

* CHECK dout0_22 Vdout0_22ck162 = 0 time = 815
.meas tran vdout0_22ck162 FIND v(dout0_22) AT=815.025n

* CHECK dout0_23 Vdout0_23ck162 = 0.9 time = 815
.meas tran vdout0_23ck162 FIND v(dout0_23) AT=815.025n

* CHECK dout0_24 Vdout0_24ck162 = 0.9 time = 815
.meas tran vdout0_24ck162 FIND v(dout0_24) AT=815.025n

* CHECK dout0_25 Vdout0_25ck162 = 0 time = 815
.meas tran vdout0_25ck162 FIND v(dout0_25) AT=815.025n

* CHECK dout0_26 Vdout0_26ck162 = 0 time = 815
.meas tran vdout0_26ck162 FIND v(dout0_26) AT=815.025n

* CHECK dout0_27 Vdout0_27ck162 = 0.9 time = 815
.meas tran vdout0_27ck162 FIND v(dout0_27) AT=815.025n

* CHECK dout0_28 Vdout0_28ck162 = 0 time = 815
.meas tran vdout0_28ck162 FIND v(dout0_28) AT=815.025n

* CHECK dout0_29 Vdout0_29ck162 = 0.9 time = 815
.meas tran vdout0_29ck162 FIND v(dout0_29) AT=815.025n

* CHECK dout0_30 Vdout0_30ck162 = 0 time = 815
.meas tran vdout0_30ck162 FIND v(dout0_30) AT=815.025n

* CHECK dout0_31 Vdout0_31ck162 = 0 time = 815
.meas tran vdout0_31ck162 FIND v(dout0_31) AT=815.025n

* CHECK dout0_32 Vdout0_32ck162 = 0.9 time = 815
.meas tran vdout0_32ck162 FIND v(dout0_32) AT=815.025n

* CHECK dout0_33 Vdout0_33ck162 = 0 time = 815
.meas tran vdout0_33ck162 FIND v(dout0_33) AT=815.025n

* CHECK dout0_34 Vdout0_34ck162 = 0 time = 815
.meas tran vdout0_34ck162 FIND v(dout0_34) AT=815.025n

* CHECK dout0_35 Vdout0_35ck162 = 0.9 time = 815
.meas tran vdout0_35ck162 FIND v(dout0_35) AT=815.025n

* CHECK dout0_36 Vdout0_36ck162 = 0 time = 815
.meas tran vdout0_36ck162 FIND v(dout0_36) AT=815.025n

* CHECK dout0_37 Vdout0_37ck162 = 0.9 time = 815
.meas tran vdout0_37ck162 FIND v(dout0_37) AT=815.025n

* CHECK dout0_38 Vdout0_38ck162 = 0.9 time = 815
.meas tran vdout0_38ck162 FIND v(dout0_38) AT=815.025n

* CHECK dout0_39 Vdout0_39ck162 = 0.9 time = 815
.meas tran vdout0_39ck162 FIND v(dout0_39) AT=815.025n

* CHECK dout0_40 Vdout0_40ck162 = 0 time = 815
.meas tran vdout0_40ck162 FIND v(dout0_40) AT=815.025n

* CHECK dout0_41 Vdout0_41ck162 = 0 time = 815
.meas tran vdout0_41ck162 FIND v(dout0_41) AT=815.025n

* CHECK dout0_42 Vdout0_42ck162 = 0 time = 815
.meas tran vdout0_42ck162 FIND v(dout0_42) AT=815.025n

* CHECK dout0_43 Vdout0_43ck162 = 0.9 time = 815
.meas tran vdout0_43ck162 FIND v(dout0_43) AT=815.025n

* CHECK dout0_44 Vdout0_44ck162 = 0 time = 815
.meas tran vdout0_44ck162 FIND v(dout0_44) AT=815.025n

* CHECK dout0_45 Vdout0_45ck162 = 0.9 time = 815
.meas tran vdout0_45ck162 FIND v(dout0_45) AT=815.025n

* CHECK dout0_46 Vdout0_46ck162 = 0 time = 815
.meas tran vdout0_46ck162 FIND v(dout0_46) AT=815.025n

* CHECK dout0_47 Vdout0_47ck162 = 0.9 time = 815
.meas tran vdout0_47ck162 FIND v(dout0_47) AT=815.025n

* CHECK dout0_48 Vdout0_48ck162 = 0.9 time = 815
.meas tran vdout0_48ck162 FIND v(dout0_48) AT=815.025n

* CHECK dout0_49 Vdout0_49ck162 = 0.9 time = 815
.meas tran vdout0_49ck162 FIND v(dout0_49) AT=815.025n

* CHECK dout0_50 Vdout0_50ck162 = 0 time = 815
.meas tran vdout0_50ck162 FIND v(dout0_50) AT=815.025n

* CHECK dout0_51 Vdout0_51ck162 = 0.9 time = 815
.meas tran vdout0_51ck162 FIND v(dout0_51) AT=815.025n

* CHECK dout0_52 Vdout0_52ck162 = 0.9 time = 815
.meas tran vdout0_52ck162 FIND v(dout0_52) AT=815.025n

* CHECK dout0_53 Vdout0_53ck162 = 0 time = 815
.meas tran vdout0_53ck162 FIND v(dout0_53) AT=815.025n

* CHECK dout0_54 Vdout0_54ck162 = 0.9 time = 815
.meas tran vdout0_54ck162 FIND v(dout0_54) AT=815.025n

* CHECK dout0_55 Vdout0_55ck162 = 0 time = 815
.meas tran vdout0_55ck162 FIND v(dout0_55) AT=815.025n

* CHECK dout0_56 Vdout0_56ck162 = 0 time = 815
.meas tran vdout0_56ck162 FIND v(dout0_56) AT=815.025n

* CHECK dout0_57 Vdout0_57ck162 = 0.9 time = 815
.meas tran vdout0_57ck162 FIND v(dout0_57) AT=815.025n

* CHECK dout0_58 Vdout0_58ck162 = 0.9 time = 815
.meas tran vdout0_58ck162 FIND v(dout0_58) AT=815.025n

* CHECK dout0_59 Vdout0_59ck162 = 0.9 time = 815
.meas tran vdout0_59ck162 FIND v(dout0_59) AT=815.025n

* CHECK dout0_60 Vdout0_60ck162 = 0.9 time = 815
.meas tran vdout0_60ck162 FIND v(dout0_60) AT=815.025n

* CHECK dout0_61 Vdout0_61ck162 = 0 time = 815
.meas tran vdout0_61ck162 FIND v(dout0_61) AT=815.025n

* CHECK dout0_62 Vdout0_62ck162 = 0 time = 815
.meas tran vdout0_62ck162 FIND v(dout0_62) AT=815.025n

* CHECK dout0_63 Vdout0_63ck162 = 0 time = 815
.meas tran vdout0_63ck162 FIND v(dout0_63) AT=815.025n

* CHECK dout0_0 Vdout0_0ck163 = 0.9 time = 820
.meas tran vdout0_0ck163 FIND v(dout0_0) AT=820.025n

* CHECK dout0_1 Vdout0_1ck163 = 0 time = 820
.meas tran vdout0_1ck163 FIND v(dout0_1) AT=820.025n

* CHECK dout0_2 Vdout0_2ck163 = 0.9 time = 820
.meas tran vdout0_2ck163 FIND v(dout0_2) AT=820.025n

* CHECK dout0_3 Vdout0_3ck163 = 0.9 time = 820
.meas tran vdout0_3ck163 FIND v(dout0_3) AT=820.025n

* CHECK dout0_4 Vdout0_4ck163 = 0 time = 820
.meas tran vdout0_4ck163 FIND v(dout0_4) AT=820.025n

* CHECK dout0_5 Vdout0_5ck163 = 0 time = 820
.meas tran vdout0_5ck163 FIND v(dout0_5) AT=820.025n

* CHECK dout0_6 Vdout0_6ck163 = 0.9 time = 820
.meas tran vdout0_6ck163 FIND v(dout0_6) AT=820.025n

* CHECK dout0_7 Vdout0_7ck163 = 0.9 time = 820
.meas tran vdout0_7ck163 FIND v(dout0_7) AT=820.025n

* CHECK dout0_8 Vdout0_8ck163 = 0 time = 820
.meas tran vdout0_8ck163 FIND v(dout0_8) AT=820.025n

* CHECK dout0_9 Vdout0_9ck163 = 0 time = 820
.meas tran vdout0_9ck163 FIND v(dout0_9) AT=820.025n

* CHECK dout0_10 Vdout0_10ck163 = 0 time = 820
.meas tran vdout0_10ck163 FIND v(dout0_10) AT=820.025n

* CHECK dout0_11 Vdout0_11ck163 = 0.9 time = 820
.meas tran vdout0_11ck163 FIND v(dout0_11) AT=820.025n

* CHECK dout0_12 Vdout0_12ck163 = 0.9 time = 820
.meas tran vdout0_12ck163 FIND v(dout0_12) AT=820.025n

* CHECK dout0_13 Vdout0_13ck163 = 0 time = 820
.meas tran vdout0_13ck163 FIND v(dout0_13) AT=820.025n

* CHECK dout0_14 Vdout0_14ck163 = 0.9 time = 820
.meas tran vdout0_14ck163 FIND v(dout0_14) AT=820.025n

* CHECK dout0_15 Vdout0_15ck163 = 0.9 time = 820
.meas tran vdout0_15ck163 FIND v(dout0_15) AT=820.025n

* CHECK dout0_16 Vdout0_16ck163 = 0.9 time = 820
.meas tran vdout0_16ck163 FIND v(dout0_16) AT=820.025n

* CHECK dout0_17 Vdout0_17ck163 = 0 time = 820
.meas tran vdout0_17ck163 FIND v(dout0_17) AT=820.025n

* CHECK dout0_18 Vdout0_18ck163 = 0.9 time = 820
.meas tran vdout0_18ck163 FIND v(dout0_18) AT=820.025n

* CHECK dout0_19 Vdout0_19ck163 = 0.9 time = 820
.meas tran vdout0_19ck163 FIND v(dout0_19) AT=820.025n

* CHECK dout0_20 Vdout0_20ck163 = 0 time = 820
.meas tran vdout0_20ck163 FIND v(dout0_20) AT=820.025n

* CHECK dout0_21 Vdout0_21ck163 = 0 time = 820
.meas tran vdout0_21ck163 FIND v(dout0_21) AT=820.025n

* CHECK dout0_22 Vdout0_22ck163 = 0.9 time = 820
.meas tran vdout0_22ck163 FIND v(dout0_22) AT=820.025n

* CHECK dout0_23 Vdout0_23ck163 = 0 time = 820
.meas tran vdout0_23ck163 FIND v(dout0_23) AT=820.025n

* CHECK dout0_24 Vdout0_24ck163 = 0 time = 820
.meas tran vdout0_24ck163 FIND v(dout0_24) AT=820.025n

* CHECK dout0_25 Vdout0_25ck163 = 0 time = 820
.meas tran vdout0_25ck163 FIND v(dout0_25) AT=820.025n

* CHECK dout0_26 Vdout0_26ck163 = 0 time = 820
.meas tran vdout0_26ck163 FIND v(dout0_26) AT=820.025n

* CHECK dout0_27 Vdout0_27ck163 = 0.9 time = 820
.meas tran vdout0_27ck163 FIND v(dout0_27) AT=820.025n

* CHECK dout0_28 Vdout0_28ck163 = 0.9 time = 820
.meas tran vdout0_28ck163 FIND v(dout0_28) AT=820.025n

* CHECK dout0_29 Vdout0_29ck163 = 0 time = 820
.meas tran vdout0_29ck163 FIND v(dout0_29) AT=820.025n

* CHECK dout0_30 Vdout0_30ck163 = 0.9 time = 820
.meas tran vdout0_30ck163 FIND v(dout0_30) AT=820.025n

* CHECK dout0_31 Vdout0_31ck163 = 0.9 time = 820
.meas tran vdout0_31ck163 FIND v(dout0_31) AT=820.025n

* CHECK dout0_32 Vdout0_32ck163 = 0.9 time = 820
.meas tran vdout0_32ck163 FIND v(dout0_32) AT=820.025n

* CHECK dout0_33 Vdout0_33ck163 = 0.9 time = 820
.meas tran vdout0_33ck163 FIND v(dout0_33) AT=820.025n

* CHECK dout0_34 Vdout0_34ck163 = 0 time = 820
.meas tran vdout0_34ck163 FIND v(dout0_34) AT=820.025n

* CHECK dout0_35 Vdout0_35ck163 = 0.9 time = 820
.meas tran vdout0_35ck163 FIND v(dout0_35) AT=820.025n

* CHECK dout0_36 Vdout0_36ck163 = 0 time = 820
.meas tran vdout0_36ck163 FIND v(dout0_36) AT=820.025n

* CHECK dout0_37 Vdout0_37ck163 = 0.9 time = 820
.meas tran vdout0_37ck163 FIND v(dout0_37) AT=820.025n

* CHECK dout0_38 Vdout0_38ck163 = 0.9 time = 820
.meas tran vdout0_38ck163 FIND v(dout0_38) AT=820.025n

* CHECK dout0_39 Vdout0_39ck163 = 0.9 time = 820
.meas tran vdout0_39ck163 FIND v(dout0_39) AT=820.025n

* CHECK dout0_40 Vdout0_40ck163 = 0 time = 820
.meas tran vdout0_40ck163 FIND v(dout0_40) AT=820.025n

* CHECK dout0_41 Vdout0_41ck163 = 0.9 time = 820
.meas tran vdout0_41ck163 FIND v(dout0_41) AT=820.025n

* CHECK dout0_42 Vdout0_42ck163 = 0 time = 820
.meas tran vdout0_42ck163 FIND v(dout0_42) AT=820.025n

* CHECK dout0_43 Vdout0_43ck163 = 0 time = 820
.meas tran vdout0_43ck163 FIND v(dout0_43) AT=820.025n

* CHECK dout0_44 Vdout0_44ck163 = 0 time = 820
.meas tran vdout0_44ck163 FIND v(dout0_44) AT=820.025n

* CHECK dout0_45 Vdout0_45ck163 = 0 time = 820
.meas tran vdout0_45ck163 FIND v(dout0_45) AT=820.025n

* CHECK dout0_46 Vdout0_46ck163 = 0 time = 820
.meas tran vdout0_46ck163 FIND v(dout0_46) AT=820.025n

* CHECK dout0_47 Vdout0_47ck163 = 0.9 time = 820
.meas tran vdout0_47ck163 FIND v(dout0_47) AT=820.025n

* CHECK dout0_48 Vdout0_48ck163 = 0 time = 820
.meas tran vdout0_48ck163 FIND v(dout0_48) AT=820.025n

* CHECK dout0_49 Vdout0_49ck163 = 0 time = 820
.meas tran vdout0_49ck163 FIND v(dout0_49) AT=820.025n

* CHECK dout0_50 Vdout0_50ck163 = 0.9 time = 820
.meas tran vdout0_50ck163 FIND v(dout0_50) AT=820.025n

* CHECK dout0_51 Vdout0_51ck163 = 0.9 time = 820
.meas tran vdout0_51ck163 FIND v(dout0_51) AT=820.025n

* CHECK dout0_52 Vdout0_52ck163 = 0 time = 820
.meas tran vdout0_52ck163 FIND v(dout0_52) AT=820.025n

* CHECK dout0_53 Vdout0_53ck163 = 0 time = 820
.meas tran vdout0_53ck163 FIND v(dout0_53) AT=820.025n

* CHECK dout0_54 Vdout0_54ck163 = 0.9 time = 820
.meas tran vdout0_54ck163 FIND v(dout0_54) AT=820.025n

* CHECK dout0_55 Vdout0_55ck163 = 0.9 time = 820
.meas tran vdout0_55ck163 FIND v(dout0_55) AT=820.025n

* CHECK dout0_56 Vdout0_56ck163 = 0.9 time = 820
.meas tran vdout0_56ck163 FIND v(dout0_56) AT=820.025n

* CHECK dout0_57 Vdout0_57ck163 = 0 time = 820
.meas tran vdout0_57ck163 FIND v(dout0_57) AT=820.025n

* CHECK dout0_58 Vdout0_58ck163 = 0.9 time = 820
.meas tran vdout0_58ck163 FIND v(dout0_58) AT=820.025n

* CHECK dout0_59 Vdout0_59ck163 = 0 time = 820
.meas tran vdout0_59ck163 FIND v(dout0_59) AT=820.025n

* CHECK dout0_60 Vdout0_60ck163 = 0 time = 820
.meas tran vdout0_60ck163 FIND v(dout0_60) AT=820.025n

* CHECK dout0_61 Vdout0_61ck163 = 0 time = 820
.meas tran vdout0_61ck163 FIND v(dout0_61) AT=820.025n

* CHECK dout0_62 Vdout0_62ck163 = 0 time = 820
.meas tran vdout0_62ck163 FIND v(dout0_62) AT=820.025n

* CHECK dout0_63 Vdout0_63ck163 = 0.9 time = 820
.meas tran vdout0_63ck163 FIND v(dout0_63) AT=820.025n

* CHECK dout0_0 Vdout0_0ck166 = 0 time = 835
.meas tran vdout0_0ck166 FIND v(dout0_0) AT=835.025n

* CHECK dout0_1 Vdout0_1ck166 = 0 time = 835
.meas tran vdout0_1ck166 FIND v(dout0_1) AT=835.025n

* CHECK dout0_2 Vdout0_2ck166 = 0 time = 835
.meas tran vdout0_2ck166 FIND v(dout0_2) AT=835.025n

* CHECK dout0_3 Vdout0_3ck166 = 0.9 time = 835
.meas tran vdout0_3ck166 FIND v(dout0_3) AT=835.025n

* CHECK dout0_4 Vdout0_4ck166 = 0 time = 835
.meas tran vdout0_4ck166 FIND v(dout0_4) AT=835.025n

* CHECK dout0_5 Vdout0_5ck166 = 0.9 time = 835
.meas tran vdout0_5ck166 FIND v(dout0_5) AT=835.025n

* CHECK dout0_6 Vdout0_6ck166 = 0.9 time = 835
.meas tran vdout0_6ck166 FIND v(dout0_6) AT=835.025n

* CHECK dout0_7 Vdout0_7ck166 = 0 time = 835
.meas tran vdout0_7ck166 FIND v(dout0_7) AT=835.025n

* CHECK dout0_8 Vdout0_8ck166 = 0 time = 835
.meas tran vdout0_8ck166 FIND v(dout0_8) AT=835.025n

* CHECK dout0_9 Vdout0_9ck166 = 0 time = 835
.meas tran vdout0_9ck166 FIND v(dout0_9) AT=835.025n

* CHECK dout0_10 Vdout0_10ck166 = 0.9 time = 835
.meas tran vdout0_10ck166 FIND v(dout0_10) AT=835.025n

* CHECK dout0_11 Vdout0_11ck166 = 0.9 time = 835
.meas tran vdout0_11ck166 FIND v(dout0_11) AT=835.025n

* CHECK dout0_12 Vdout0_12ck166 = 0.9 time = 835
.meas tran vdout0_12ck166 FIND v(dout0_12) AT=835.025n

* CHECK dout0_13 Vdout0_13ck166 = 0.9 time = 835
.meas tran vdout0_13ck166 FIND v(dout0_13) AT=835.025n

* CHECK dout0_14 Vdout0_14ck166 = 0 time = 835
.meas tran vdout0_14ck166 FIND v(dout0_14) AT=835.025n

* CHECK dout0_15 Vdout0_15ck166 = 0.9 time = 835
.meas tran vdout0_15ck166 FIND v(dout0_15) AT=835.025n

* CHECK dout0_16 Vdout0_16ck166 = 0 time = 835
.meas tran vdout0_16ck166 FIND v(dout0_16) AT=835.025n

* CHECK dout0_17 Vdout0_17ck166 = 0 time = 835
.meas tran vdout0_17ck166 FIND v(dout0_17) AT=835.025n

* CHECK dout0_18 Vdout0_18ck166 = 0.9 time = 835
.meas tran vdout0_18ck166 FIND v(dout0_18) AT=835.025n

* CHECK dout0_19 Vdout0_19ck166 = 0.9 time = 835
.meas tran vdout0_19ck166 FIND v(dout0_19) AT=835.025n

* CHECK dout0_20 Vdout0_20ck166 = 0 time = 835
.meas tran vdout0_20ck166 FIND v(dout0_20) AT=835.025n

* CHECK dout0_21 Vdout0_21ck166 = 0 time = 835
.meas tran vdout0_21ck166 FIND v(dout0_21) AT=835.025n

* CHECK dout0_22 Vdout0_22ck166 = 0.9 time = 835
.meas tran vdout0_22ck166 FIND v(dout0_22) AT=835.025n

* CHECK dout0_23 Vdout0_23ck166 = 0 time = 835
.meas tran vdout0_23ck166 FIND v(dout0_23) AT=835.025n

* CHECK dout0_24 Vdout0_24ck166 = 0.9 time = 835
.meas tran vdout0_24ck166 FIND v(dout0_24) AT=835.025n

* CHECK dout0_25 Vdout0_25ck166 = 0.9 time = 835
.meas tran vdout0_25ck166 FIND v(dout0_25) AT=835.025n

* CHECK dout0_26 Vdout0_26ck166 = 0 time = 835
.meas tran vdout0_26ck166 FIND v(dout0_26) AT=835.025n

* CHECK dout0_27 Vdout0_27ck166 = 0 time = 835
.meas tran vdout0_27ck166 FIND v(dout0_27) AT=835.025n

* CHECK dout0_28 Vdout0_28ck166 = 0 time = 835
.meas tran vdout0_28ck166 FIND v(dout0_28) AT=835.025n

* CHECK dout0_29 Vdout0_29ck166 = 0 time = 835
.meas tran vdout0_29ck166 FIND v(dout0_29) AT=835.025n

* CHECK dout0_30 Vdout0_30ck166 = 0 time = 835
.meas tran vdout0_30ck166 FIND v(dout0_30) AT=835.025n

* CHECK dout0_31 Vdout0_31ck166 = 0 time = 835
.meas tran vdout0_31ck166 FIND v(dout0_31) AT=835.025n

* CHECK dout0_32 Vdout0_32ck166 = 0 time = 835
.meas tran vdout0_32ck166 FIND v(dout0_32) AT=835.025n

* CHECK dout0_33 Vdout0_33ck166 = 0.9 time = 835
.meas tran vdout0_33ck166 FIND v(dout0_33) AT=835.025n

* CHECK dout0_34 Vdout0_34ck166 = 0 time = 835
.meas tran vdout0_34ck166 FIND v(dout0_34) AT=835.025n

* CHECK dout0_35 Vdout0_35ck166 = 0 time = 835
.meas tran vdout0_35ck166 FIND v(dout0_35) AT=835.025n

* CHECK dout0_36 Vdout0_36ck166 = 0 time = 835
.meas tran vdout0_36ck166 FIND v(dout0_36) AT=835.025n

* CHECK dout0_37 Vdout0_37ck166 = 0.9 time = 835
.meas tran vdout0_37ck166 FIND v(dout0_37) AT=835.025n

* CHECK dout0_38 Vdout0_38ck166 = 0 time = 835
.meas tran vdout0_38ck166 FIND v(dout0_38) AT=835.025n

* CHECK dout0_39 Vdout0_39ck166 = 0 time = 835
.meas tran vdout0_39ck166 FIND v(dout0_39) AT=835.025n

* CHECK dout0_40 Vdout0_40ck166 = 0.9 time = 835
.meas tran vdout0_40ck166 FIND v(dout0_40) AT=835.025n

* CHECK dout0_41 Vdout0_41ck166 = 0.9 time = 835
.meas tran vdout0_41ck166 FIND v(dout0_41) AT=835.025n

* CHECK dout0_42 Vdout0_42ck166 = 0 time = 835
.meas tran vdout0_42ck166 FIND v(dout0_42) AT=835.025n

* CHECK dout0_43 Vdout0_43ck166 = 0 time = 835
.meas tran vdout0_43ck166 FIND v(dout0_43) AT=835.025n

* CHECK dout0_44 Vdout0_44ck166 = 0 time = 835
.meas tran vdout0_44ck166 FIND v(dout0_44) AT=835.025n

* CHECK dout0_45 Vdout0_45ck166 = 0 time = 835
.meas tran vdout0_45ck166 FIND v(dout0_45) AT=835.025n

* CHECK dout0_46 Vdout0_46ck166 = 0 time = 835
.meas tran vdout0_46ck166 FIND v(dout0_46) AT=835.025n

* CHECK dout0_47 Vdout0_47ck166 = 0 time = 835
.meas tran vdout0_47ck166 FIND v(dout0_47) AT=835.025n

* CHECK dout0_48 Vdout0_48ck166 = 0.9 time = 835
.meas tran vdout0_48ck166 FIND v(dout0_48) AT=835.025n

* CHECK dout0_49 Vdout0_49ck166 = 0 time = 835
.meas tran vdout0_49ck166 FIND v(dout0_49) AT=835.025n

* CHECK dout0_50 Vdout0_50ck166 = 0 time = 835
.meas tran vdout0_50ck166 FIND v(dout0_50) AT=835.025n

* CHECK dout0_51 Vdout0_51ck166 = 0 time = 835
.meas tran vdout0_51ck166 FIND v(dout0_51) AT=835.025n

* CHECK dout0_52 Vdout0_52ck166 = 0.9 time = 835
.meas tran vdout0_52ck166 FIND v(dout0_52) AT=835.025n

* CHECK dout0_53 Vdout0_53ck166 = 0.9 time = 835
.meas tran vdout0_53ck166 FIND v(dout0_53) AT=835.025n

* CHECK dout0_54 Vdout0_54ck166 = 0.9 time = 835
.meas tran vdout0_54ck166 FIND v(dout0_54) AT=835.025n

* CHECK dout0_55 Vdout0_55ck166 = 0.9 time = 835
.meas tran vdout0_55ck166 FIND v(dout0_55) AT=835.025n

* CHECK dout0_56 Vdout0_56ck166 = 0.9 time = 835
.meas tran vdout0_56ck166 FIND v(dout0_56) AT=835.025n

* CHECK dout0_57 Vdout0_57ck166 = 0 time = 835
.meas tran vdout0_57ck166 FIND v(dout0_57) AT=835.025n

* CHECK dout0_58 Vdout0_58ck166 = 0 time = 835
.meas tran vdout0_58ck166 FIND v(dout0_58) AT=835.025n

* CHECK dout0_59 Vdout0_59ck166 = 0.9 time = 835
.meas tran vdout0_59ck166 FIND v(dout0_59) AT=835.025n

* CHECK dout0_60 Vdout0_60ck166 = 0.9 time = 835
.meas tran vdout0_60ck166 FIND v(dout0_60) AT=835.025n

* CHECK dout0_61 Vdout0_61ck166 = 0 time = 835
.meas tran vdout0_61ck166 FIND v(dout0_61) AT=835.025n

* CHECK dout0_62 Vdout0_62ck166 = 0 time = 835
.meas tran vdout0_62ck166 FIND v(dout0_62) AT=835.025n

* CHECK dout0_63 Vdout0_63ck166 = 0.9 time = 835
.meas tran vdout0_63ck166 FIND v(dout0_63) AT=835.025n

* CHECK dout0_0 Vdout0_0ck169 = 0 time = 850
.meas tran vdout0_0ck169 FIND v(dout0_0) AT=850.025n

* CHECK dout0_1 Vdout0_1ck169 = 0.9 time = 850
.meas tran vdout0_1ck169 FIND v(dout0_1) AT=850.025n

* CHECK dout0_2 Vdout0_2ck169 = 0.9 time = 850
.meas tran vdout0_2ck169 FIND v(dout0_2) AT=850.025n

* CHECK dout0_3 Vdout0_3ck169 = 0 time = 850
.meas tran vdout0_3ck169 FIND v(dout0_3) AT=850.025n

* CHECK dout0_4 Vdout0_4ck169 = 0.9 time = 850
.meas tran vdout0_4ck169 FIND v(dout0_4) AT=850.025n

* CHECK dout0_5 Vdout0_5ck169 = 0 time = 850
.meas tran vdout0_5ck169 FIND v(dout0_5) AT=850.025n

* CHECK dout0_6 Vdout0_6ck169 = 0 time = 850
.meas tran vdout0_6ck169 FIND v(dout0_6) AT=850.025n

* CHECK dout0_7 Vdout0_7ck169 = 0 time = 850
.meas tran vdout0_7ck169 FIND v(dout0_7) AT=850.025n

* CHECK dout0_8 Vdout0_8ck169 = 0.9 time = 850
.meas tran vdout0_8ck169 FIND v(dout0_8) AT=850.025n

* CHECK dout0_9 Vdout0_9ck169 = 0.9 time = 850
.meas tran vdout0_9ck169 FIND v(dout0_9) AT=850.025n

* CHECK dout0_10 Vdout0_10ck169 = 0 time = 850
.meas tran vdout0_10ck169 FIND v(dout0_10) AT=850.025n

* CHECK dout0_11 Vdout0_11ck169 = 0.9 time = 850
.meas tran vdout0_11ck169 FIND v(dout0_11) AT=850.025n

* CHECK dout0_12 Vdout0_12ck169 = 0.9 time = 850
.meas tran vdout0_12ck169 FIND v(dout0_12) AT=850.025n

* CHECK dout0_13 Vdout0_13ck169 = 0 time = 850
.meas tran vdout0_13ck169 FIND v(dout0_13) AT=850.025n

* CHECK dout0_14 Vdout0_14ck169 = 0 time = 850
.meas tran vdout0_14ck169 FIND v(dout0_14) AT=850.025n

* CHECK dout0_15 Vdout0_15ck169 = 0.9 time = 850
.meas tran vdout0_15ck169 FIND v(dout0_15) AT=850.025n

* CHECK dout0_16 Vdout0_16ck169 = 0 time = 850
.meas tran vdout0_16ck169 FIND v(dout0_16) AT=850.025n

* CHECK dout0_17 Vdout0_17ck169 = 0 time = 850
.meas tran vdout0_17ck169 FIND v(dout0_17) AT=850.025n

* CHECK dout0_18 Vdout0_18ck169 = 0 time = 850
.meas tran vdout0_18ck169 FIND v(dout0_18) AT=850.025n

* CHECK dout0_19 Vdout0_19ck169 = 0.9 time = 850
.meas tran vdout0_19ck169 FIND v(dout0_19) AT=850.025n

* CHECK dout0_20 Vdout0_20ck169 = 0.9 time = 850
.meas tran vdout0_20ck169 FIND v(dout0_20) AT=850.025n

* CHECK dout0_21 Vdout0_21ck169 = 0 time = 850
.meas tran vdout0_21ck169 FIND v(dout0_21) AT=850.025n

* CHECK dout0_22 Vdout0_22ck169 = 0 time = 850
.meas tran vdout0_22ck169 FIND v(dout0_22) AT=850.025n

* CHECK dout0_23 Vdout0_23ck169 = 0 time = 850
.meas tran vdout0_23ck169 FIND v(dout0_23) AT=850.025n

* CHECK dout0_24 Vdout0_24ck169 = 0.9 time = 850
.meas tran vdout0_24ck169 FIND v(dout0_24) AT=850.025n

* CHECK dout0_25 Vdout0_25ck169 = 0 time = 850
.meas tran vdout0_25ck169 FIND v(dout0_25) AT=850.025n

* CHECK dout0_26 Vdout0_26ck169 = 0.9 time = 850
.meas tran vdout0_26ck169 FIND v(dout0_26) AT=850.025n

* CHECK dout0_27 Vdout0_27ck169 = 0 time = 850
.meas tran vdout0_27ck169 FIND v(dout0_27) AT=850.025n

* CHECK dout0_28 Vdout0_28ck169 = 0 time = 850
.meas tran vdout0_28ck169 FIND v(dout0_28) AT=850.025n

* CHECK dout0_29 Vdout0_29ck169 = 0.9 time = 850
.meas tran vdout0_29ck169 FIND v(dout0_29) AT=850.025n

* CHECK dout0_30 Vdout0_30ck169 = 0 time = 850
.meas tran vdout0_30ck169 FIND v(dout0_30) AT=850.025n

* CHECK dout0_31 Vdout0_31ck169 = 0 time = 850
.meas tran vdout0_31ck169 FIND v(dout0_31) AT=850.025n

* CHECK dout0_32 Vdout0_32ck169 = 0.9 time = 850
.meas tran vdout0_32ck169 FIND v(dout0_32) AT=850.025n

* CHECK dout0_33 Vdout0_33ck169 = 0.9 time = 850
.meas tran vdout0_33ck169 FIND v(dout0_33) AT=850.025n

* CHECK dout0_34 Vdout0_34ck169 = 0.9 time = 850
.meas tran vdout0_34ck169 FIND v(dout0_34) AT=850.025n

* CHECK dout0_35 Vdout0_35ck169 = 0 time = 850
.meas tran vdout0_35ck169 FIND v(dout0_35) AT=850.025n

* CHECK dout0_36 Vdout0_36ck169 = 0 time = 850
.meas tran vdout0_36ck169 FIND v(dout0_36) AT=850.025n

* CHECK dout0_37 Vdout0_37ck169 = 0 time = 850
.meas tran vdout0_37ck169 FIND v(dout0_37) AT=850.025n

* CHECK dout0_38 Vdout0_38ck169 = 0 time = 850
.meas tran vdout0_38ck169 FIND v(dout0_38) AT=850.025n

* CHECK dout0_39 Vdout0_39ck169 = 0.9 time = 850
.meas tran vdout0_39ck169 FIND v(dout0_39) AT=850.025n

* CHECK dout0_40 Vdout0_40ck169 = 0 time = 850
.meas tran vdout0_40ck169 FIND v(dout0_40) AT=850.025n

* CHECK dout0_41 Vdout0_41ck169 = 0.9 time = 850
.meas tran vdout0_41ck169 FIND v(dout0_41) AT=850.025n

* CHECK dout0_42 Vdout0_42ck169 = 0.9 time = 850
.meas tran vdout0_42ck169 FIND v(dout0_42) AT=850.025n

* CHECK dout0_43 Vdout0_43ck169 = 0 time = 850
.meas tran vdout0_43ck169 FIND v(dout0_43) AT=850.025n

* CHECK dout0_44 Vdout0_44ck169 = 0 time = 850
.meas tran vdout0_44ck169 FIND v(dout0_44) AT=850.025n

* CHECK dout0_45 Vdout0_45ck169 = 0 time = 850
.meas tran vdout0_45ck169 FIND v(dout0_45) AT=850.025n

* CHECK dout0_46 Vdout0_46ck169 = 0.9 time = 850
.meas tran vdout0_46ck169 FIND v(dout0_46) AT=850.025n

* CHECK dout0_47 Vdout0_47ck169 = 0.9 time = 850
.meas tran vdout0_47ck169 FIND v(dout0_47) AT=850.025n

* CHECK dout0_48 Vdout0_48ck169 = 0 time = 850
.meas tran vdout0_48ck169 FIND v(dout0_48) AT=850.025n

* CHECK dout0_49 Vdout0_49ck169 = 0 time = 850
.meas tran vdout0_49ck169 FIND v(dout0_49) AT=850.025n

* CHECK dout0_50 Vdout0_50ck169 = 0.9 time = 850
.meas tran vdout0_50ck169 FIND v(dout0_50) AT=850.025n

* CHECK dout0_51 Vdout0_51ck169 = 0.9 time = 850
.meas tran vdout0_51ck169 FIND v(dout0_51) AT=850.025n

* CHECK dout0_52 Vdout0_52ck169 = 0 time = 850
.meas tran vdout0_52ck169 FIND v(dout0_52) AT=850.025n

* CHECK dout0_53 Vdout0_53ck169 = 0 time = 850
.meas tran vdout0_53ck169 FIND v(dout0_53) AT=850.025n

* CHECK dout0_54 Vdout0_54ck169 = 0.9 time = 850
.meas tran vdout0_54ck169 FIND v(dout0_54) AT=850.025n

* CHECK dout0_55 Vdout0_55ck169 = 0.9 time = 850
.meas tran vdout0_55ck169 FIND v(dout0_55) AT=850.025n

* CHECK dout0_56 Vdout0_56ck169 = 0.9 time = 850
.meas tran vdout0_56ck169 FIND v(dout0_56) AT=850.025n

* CHECK dout0_57 Vdout0_57ck169 = 0.9 time = 850
.meas tran vdout0_57ck169 FIND v(dout0_57) AT=850.025n

* CHECK dout0_58 Vdout0_58ck169 = 0.9 time = 850
.meas tran vdout0_58ck169 FIND v(dout0_58) AT=850.025n

* CHECK dout0_59 Vdout0_59ck169 = 0 time = 850
.meas tran vdout0_59ck169 FIND v(dout0_59) AT=850.025n

* CHECK dout0_60 Vdout0_60ck169 = 0 time = 850
.meas tran vdout0_60ck169 FIND v(dout0_60) AT=850.025n

* CHECK dout0_61 Vdout0_61ck169 = 0.9 time = 850
.meas tran vdout0_61ck169 FIND v(dout0_61) AT=850.025n

* CHECK dout0_62 Vdout0_62ck169 = 0 time = 850
.meas tran vdout0_62ck169 FIND v(dout0_62) AT=850.025n

* CHECK dout0_63 Vdout0_63ck169 = 0 time = 850
.meas tran vdout0_63ck169 FIND v(dout0_63) AT=850.025n

* CHECK dout0_0 Vdout0_0ck171 = 0.9 time = 860
.meas tran vdout0_0ck171 FIND v(dout0_0) AT=860.025n

* CHECK dout0_1 Vdout0_1ck171 = 0 time = 860
.meas tran vdout0_1ck171 FIND v(dout0_1) AT=860.025n

* CHECK dout0_2 Vdout0_2ck171 = 0 time = 860
.meas tran vdout0_2ck171 FIND v(dout0_2) AT=860.025n

* CHECK dout0_3 Vdout0_3ck171 = 0.9 time = 860
.meas tran vdout0_3ck171 FIND v(dout0_3) AT=860.025n

* CHECK dout0_4 Vdout0_4ck171 = 0.9 time = 860
.meas tran vdout0_4ck171 FIND v(dout0_4) AT=860.025n

* CHECK dout0_5 Vdout0_5ck171 = 0 time = 860
.meas tran vdout0_5ck171 FIND v(dout0_5) AT=860.025n

* CHECK dout0_6 Vdout0_6ck171 = 0.9 time = 860
.meas tran vdout0_6ck171 FIND v(dout0_6) AT=860.025n

* CHECK dout0_7 Vdout0_7ck171 = 0 time = 860
.meas tran vdout0_7ck171 FIND v(dout0_7) AT=860.025n

* CHECK dout0_8 Vdout0_8ck171 = 0.9 time = 860
.meas tran vdout0_8ck171 FIND v(dout0_8) AT=860.025n

* CHECK dout0_9 Vdout0_9ck171 = 0 time = 860
.meas tran vdout0_9ck171 FIND v(dout0_9) AT=860.025n

* CHECK dout0_10 Vdout0_10ck171 = 0.9 time = 860
.meas tran vdout0_10ck171 FIND v(dout0_10) AT=860.025n

* CHECK dout0_11 Vdout0_11ck171 = 0.9 time = 860
.meas tran vdout0_11ck171 FIND v(dout0_11) AT=860.025n

* CHECK dout0_12 Vdout0_12ck171 = 0.9 time = 860
.meas tran vdout0_12ck171 FIND v(dout0_12) AT=860.025n

* CHECK dout0_13 Vdout0_13ck171 = 0.9 time = 860
.meas tran vdout0_13ck171 FIND v(dout0_13) AT=860.025n

* CHECK dout0_14 Vdout0_14ck171 = 0 time = 860
.meas tran vdout0_14ck171 FIND v(dout0_14) AT=860.025n

* CHECK dout0_15 Vdout0_15ck171 = 0.9 time = 860
.meas tran vdout0_15ck171 FIND v(dout0_15) AT=860.025n

* CHECK dout0_16 Vdout0_16ck171 = 0 time = 860
.meas tran vdout0_16ck171 FIND v(dout0_16) AT=860.025n

* CHECK dout0_17 Vdout0_17ck171 = 0 time = 860
.meas tran vdout0_17ck171 FIND v(dout0_17) AT=860.025n

* CHECK dout0_18 Vdout0_18ck171 = 0.9 time = 860
.meas tran vdout0_18ck171 FIND v(dout0_18) AT=860.025n

* CHECK dout0_19 Vdout0_19ck171 = 0 time = 860
.meas tran vdout0_19ck171 FIND v(dout0_19) AT=860.025n

* CHECK dout0_20 Vdout0_20ck171 = 0 time = 860
.meas tran vdout0_20ck171 FIND v(dout0_20) AT=860.025n

* CHECK dout0_21 Vdout0_21ck171 = 0 time = 860
.meas tran vdout0_21ck171 FIND v(dout0_21) AT=860.025n

* CHECK dout0_22 Vdout0_22ck171 = 0 time = 860
.meas tran vdout0_22ck171 FIND v(dout0_22) AT=860.025n

* CHECK dout0_23 Vdout0_23ck171 = 0.9 time = 860
.meas tran vdout0_23ck171 FIND v(dout0_23) AT=860.025n

* CHECK dout0_24 Vdout0_24ck171 = 0 time = 860
.meas tran vdout0_24ck171 FIND v(dout0_24) AT=860.025n

* CHECK dout0_25 Vdout0_25ck171 = 0.9 time = 860
.meas tran vdout0_25ck171 FIND v(dout0_25) AT=860.025n

* CHECK dout0_26 Vdout0_26ck171 = 0 time = 860
.meas tran vdout0_26ck171 FIND v(dout0_26) AT=860.025n

* CHECK dout0_27 Vdout0_27ck171 = 0.9 time = 860
.meas tran vdout0_27ck171 FIND v(dout0_27) AT=860.025n

* CHECK dout0_28 Vdout0_28ck171 = 0 time = 860
.meas tran vdout0_28ck171 FIND v(dout0_28) AT=860.025n

* CHECK dout0_29 Vdout0_29ck171 = 0.9 time = 860
.meas tran vdout0_29ck171 FIND v(dout0_29) AT=860.025n

* CHECK dout0_30 Vdout0_30ck171 = 0.9 time = 860
.meas tran vdout0_30ck171 FIND v(dout0_30) AT=860.025n

* CHECK dout0_31 Vdout0_31ck171 = 0 time = 860
.meas tran vdout0_31ck171 FIND v(dout0_31) AT=860.025n

* CHECK dout0_32 Vdout0_32ck171 = 0.9 time = 860
.meas tran vdout0_32ck171 FIND v(dout0_32) AT=860.025n

* CHECK dout0_33 Vdout0_33ck171 = 0.9 time = 860
.meas tran vdout0_33ck171 FIND v(dout0_33) AT=860.025n

* CHECK dout0_34 Vdout0_34ck171 = 0.9 time = 860
.meas tran vdout0_34ck171 FIND v(dout0_34) AT=860.025n

* CHECK dout0_35 Vdout0_35ck171 = 0.9 time = 860
.meas tran vdout0_35ck171 FIND v(dout0_35) AT=860.025n

* CHECK dout0_36 Vdout0_36ck171 = 0.9 time = 860
.meas tran vdout0_36ck171 FIND v(dout0_36) AT=860.025n

* CHECK dout0_37 Vdout0_37ck171 = 0 time = 860
.meas tran vdout0_37ck171 FIND v(dout0_37) AT=860.025n

* CHECK dout0_38 Vdout0_38ck171 = 0 time = 860
.meas tran vdout0_38ck171 FIND v(dout0_38) AT=860.025n

* CHECK dout0_39 Vdout0_39ck171 = 0 time = 860
.meas tran vdout0_39ck171 FIND v(dout0_39) AT=860.025n

* CHECK dout0_40 Vdout0_40ck171 = 0 time = 860
.meas tran vdout0_40ck171 FIND v(dout0_40) AT=860.025n

* CHECK dout0_41 Vdout0_41ck171 = 0.9 time = 860
.meas tran vdout0_41ck171 FIND v(dout0_41) AT=860.025n

* CHECK dout0_42 Vdout0_42ck171 = 0 time = 860
.meas tran vdout0_42ck171 FIND v(dout0_42) AT=860.025n

* CHECK dout0_43 Vdout0_43ck171 = 0 time = 860
.meas tran vdout0_43ck171 FIND v(dout0_43) AT=860.025n

* CHECK dout0_44 Vdout0_44ck171 = 0.9 time = 860
.meas tran vdout0_44ck171 FIND v(dout0_44) AT=860.025n

* CHECK dout0_45 Vdout0_45ck171 = 0.9 time = 860
.meas tran vdout0_45ck171 FIND v(dout0_45) AT=860.025n

* CHECK dout0_46 Vdout0_46ck171 = 0.9 time = 860
.meas tran vdout0_46ck171 FIND v(dout0_46) AT=860.025n

* CHECK dout0_47 Vdout0_47ck171 = 0 time = 860
.meas tran vdout0_47ck171 FIND v(dout0_47) AT=860.025n

* CHECK dout0_48 Vdout0_48ck171 = 0 time = 860
.meas tran vdout0_48ck171 FIND v(dout0_48) AT=860.025n

* CHECK dout0_49 Vdout0_49ck171 = 0 time = 860
.meas tran vdout0_49ck171 FIND v(dout0_49) AT=860.025n

* CHECK dout0_50 Vdout0_50ck171 = 0.9 time = 860
.meas tran vdout0_50ck171 FIND v(dout0_50) AT=860.025n

* CHECK dout0_51 Vdout0_51ck171 = 0 time = 860
.meas tran vdout0_51ck171 FIND v(dout0_51) AT=860.025n

* CHECK dout0_52 Vdout0_52ck171 = 0 time = 860
.meas tran vdout0_52ck171 FIND v(dout0_52) AT=860.025n

* CHECK dout0_53 Vdout0_53ck171 = 0 time = 860
.meas tran vdout0_53ck171 FIND v(dout0_53) AT=860.025n

* CHECK dout0_54 Vdout0_54ck171 = 0.9 time = 860
.meas tran vdout0_54ck171 FIND v(dout0_54) AT=860.025n

* CHECK dout0_55 Vdout0_55ck171 = 0 time = 860
.meas tran vdout0_55ck171 FIND v(dout0_55) AT=860.025n

* CHECK dout0_56 Vdout0_56ck171 = 0 time = 860
.meas tran vdout0_56ck171 FIND v(dout0_56) AT=860.025n

* CHECK dout0_57 Vdout0_57ck171 = 0.9 time = 860
.meas tran vdout0_57ck171 FIND v(dout0_57) AT=860.025n

* CHECK dout0_58 Vdout0_58ck171 = 0.9 time = 860
.meas tran vdout0_58ck171 FIND v(dout0_58) AT=860.025n

* CHECK dout0_59 Vdout0_59ck171 = 0.9 time = 860
.meas tran vdout0_59ck171 FIND v(dout0_59) AT=860.025n

* CHECK dout0_60 Vdout0_60ck171 = 0 time = 860
.meas tran vdout0_60ck171 FIND v(dout0_60) AT=860.025n

* CHECK dout0_61 Vdout0_61ck171 = 0.9 time = 860
.meas tran vdout0_61ck171 FIND v(dout0_61) AT=860.025n

* CHECK dout0_62 Vdout0_62ck171 = 0 time = 860
.meas tran vdout0_62ck171 FIND v(dout0_62) AT=860.025n

* CHECK dout0_63 Vdout0_63ck171 = 0 time = 860
.meas tran vdout0_63ck171 FIND v(dout0_63) AT=860.025n

* CHECK dout0_0 Vdout0_0ck172 = 0.9 time = 865
.meas tran vdout0_0ck172 FIND v(dout0_0) AT=865.025n

* CHECK dout0_1 Vdout0_1ck172 = 0 time = 865
.meas tran vdout0_1ck172 FIND v(dout0_1) AT=865.025n

* CHECK dout0_2 Vdout0_2ck172 = 0 time = 865
.meas tran vdout0_2ck172 FIND v(dout0_2) AT=865.025n

* CHECK dout0_3 Vdout0_3ck172 = 0.9 time = 865
.meas tran vdout0_3ck172 FIND v(dout0_3) AT=865.025n

* CHECK dout0_4 Vdout0_4ck172 = 0.9 time = 865
.meas tran vdout0_4ck172 FIND v(dout0_4) AT=865.025n

* CHECK dout0_5 Vdout0_5ck172 = 0 time = 865
.meas tran vdout0_5ck172 FIND v(dout0_5) AT=865.025n

* CHECK dout0_6 Vdout0_6ck172 = 0.9 time = 865
.meas tran vdout0_6ck172 FIND v(dout0_6) AT=865.025n

* CHECK dout0_7 Vdout0_7ck172 = 0 time = 865
.meas tran vdout0_7ck172 FIND v(dout0_7) AT=865.025n

* CHECK dout0_8 Vdout0_8ck172 = 0.9 time = 865
.meas tran vdout0_8ck172 FIND v(dout0_8) AT=865.025n

* CHECK dout0_9 Vdout0_9ck172 = 0.9 time = 865
.meas tran vdout0_9ck172 FIND v(dout0_9) AT=865.025n

* CHECK dout0_10 Vdout0_10ck172 = 0.9 time = 865
.meas tran vdout0_10ck172 FIND v(dout0_10) AT=865.025n

* CHECK dout0_11 Vdout0_11ck172 = 0.9 time = 865
.meas tran vdout0_11ck172 FIND v(dout0_11) AT=865.025n

* CHECK dout0_12 Vdout0_12ck172 = 0.9 time = 865
.meas tran vdout0_12ck172 FIND v(dout0_12) AT=865.025n

* CHECK dout0_13 Vdout0_13ck172 = 0 time = 865
.meas tran vdout0_13ck172 FIND v(dout0_13) AT=865.025n

* CHECK dout0_14 Vdout0_14ck172 = 0.9 time = 865
.meas tran vdout0_14ck172 FIND v(dout0_14) AT=865.025n

* CHECK dout0_15 Vdout0_15ck172 = 0 time = 865
.meas tran vdout0_15ck172 FIND v(dout0_15) AT=865.025n

* CHECK dout0_16 Vdout0_16ck172 = 0 time = 865
.meas tran vdout0_16ck172 FIND v(dout0_16) AT=865.025n

* CHECK dout0_17 Vdout0_17ck172 = 0.9 time = 865
.meas tran vdout0_17ck172 FIND v(dout0_17) AT=865.025n

* CHECK dout0_18 Vdout0_18ck172 = 0.9 time = 865
.meas tran vdout0_18ck172 FIND v(dout0_18) AT=865.025n

* CHECK dout0_19 Vdout0_19ck172 = 0.9 time = 865
.meas tran vdout0_19ck172 FIND v(dout0_19) AT=865.025n

* CHECK dout0_20 Vdout0_20ck172 = 0 time = 865
.meas tran vdout0_20ck172 FIND v(dout0_20) AT=865.025n

* CHECK dout0_21 Vdout0_21ck172 = 0 time = 865
.meas tran vdout0_21ck172 FIND v(dout0_21) AT=865.025n

* CHECK dout0_22 Vdout0_22ck172 = 0 time = 865
.meas tran vdout0_22ck172 FIND v(dout0_22) AT=865.025n

* CHECK dout0_23 Vdout0_23ck172 = 0 time = 865
.meas tran vdout0_23ck172 FIND v(dout0_23) AT=865.025n

* CHECK dout0_24 Vdout0_24ck172 = 0.9 time = 865
.meas tran vdout0_24ck172 FIND v(dout0_24) AT=865.025n

* CHECK dout0_25 Vdout0_25ck172 = 0.9 time = 865
.meas tran vdout0_25ck172 FIND v(dout0_25) AT=865.025n

* CHECK dout0_26 Vdout0_26ck172 = 0 time = 865
.meas tran vdout0_26ck172 FIND v(dout0_26) AT=865.025n

* CHECK dout0_27 Vdout0_27ck172 = 0.9 time = 865
.meas tran vdout0_27ck172 FIND v(dout0_27) AT=865.025n

* CHECK dout0_28 Vdout0_28ck172 = 0.9 time = 865
.meas tran vdout0_28ck172 FIND v(dout0_28) AT=865.025n

* CHECK dout0_29 Vdout0_29ck172 = 0 time = 865
.meas tran vdout0_29ck172 FIND v(dout0_29) AT=865.025n

* CHECK dout0_30 Vdout0_30ck172 = 0.9 time = 865
.meas tran vdout0_30ck172 FIND v(dout0_30) AT=865.025n

* CHECK dout0_31 Vdout0_31ck172 = 0 time = 865
.meas tran vdout0_31ck172 FIND v(dout0_31) AT=865.025n

* CHECK dout0_32 Vdout0_32ck172 = 0 time = 865
.meas tran vdout0_32ck172 FIND v(dout0_32) AT=865.025n

* CHECK dout0_33 Vdout0_33ck172 = 0 time = 865
.meas tran vdout0_33ck172 FIND v(dout0_33) AT=865.025n

* CHECK dout0_34 Vdout0_34ck172 = 0.9 time = 865
.meas tran vdout0_34ck172 FIND v(dout0_34) AT=865.025n

* CHECK dout0_35 Vdout0_35ck172 = 0.9 time = 865
.meas tran vdout0_35ck172 FIND v(dout0_35) AT=865.025n

* CHECK dout0_36 Vdout0_36ck172 = 0 time = 865
.meas tran vdout0_36ck172 FIND v(dout0_36) AT=865.025n

* CHECK dout0_37 Vdout0_37ck172 = 0 time = 865
.meas tran vdout0_37ck172 FIND v(dout0_37) AT=865.025n

* CHECK dout0_38 Vdout0_38ck172 = 0 time = 865
.meas tran vdout0_38ck172 FIND v(dout0_38) AT=865.025n

* CHECK dout0_39 Vdout0_39ck172 = 0 time = 865
.meas tran vdout0_39ck172 FIND v(dout0_39) AT=865.025n

* CHECK dout0_40 Vdout0_40ck172 = 0 time = 865
.meas tran vdout0_40ck172 FIND v(dout0_40) AT=865.025n

* CHECK dout0_41 Vdout0_41ck172 = 0.9 time = 865
.meas tran vdout0_41ck172 FIND v(dout0_41) AT=865.025n

* CHECK dout0_42 Vdout0_42ck172 = 0.9 time = 865
.meas tran vdout0_42ck172 FIND v(dout0_42) AT=865.025n

* CHECK dout0_43 Vdout0_43ck172 = 0 time = 865
.meas tran vdout0_43ck172 FIND v(dout0_43) AT=865.025n

* CHECK dout0_44 Vdout0_44ck172 = 0.9 time = 865
.meas tran vdout0_44ck172 FIND v(dout0_44) AT=865.025n

* CHECK dout0_45 Vdout0_45ck172 = 0 time = 865
.meas tran vdout0_45ck172 FIND v(dout0_45) AT=865.025n

* CHECK dout0_46 Vdout0_46ck172 = 0 time = 865
.meas tran vdout0_46ck172 FIND v(dout0_46) AT=865.025n

* CHECK dout0_47 Vdout0_47ck172 = 0 time = 865
.meas tran vdout0_47ck172 FIND v(dout0_47) AT=865.025n

* CHECK dout0_48 Vdout0_48ck172 = 0 time = 865
.meas tran vdout0_48ck172 FIND v(dout0_48) AT=865.025n

* CHECK dout0_49 Vdout0_49ck172 = 0 time = 865
.meas tran vdout0_49ck172 FIND v(dout0_49) AT=865.025n

* CHECK dout0_50 Vdout0_50ck172 = 0.9 time = 865
.meas tran vdout0_50ck172 FIND v(dout0_50) AT=865.025n

* CHECK dout0_51 Vdout0_51ck172 = 0 time = 865
.meas tran vdout0_51ck172 FIND v(dout0_51) AT=865.025n

* CHECK dout0_52 Vdout0_52ck172 = 0.9 time = 865
.meas tran vdout0_52ck172 FIND v(dout0_52) AT=865.025n

* CHECK dout0_53 Vdout0_53ck172 = 0.9 time = 865
.meas tran vdout0_53ck172 FIND v(dout0_53) AT=865.025n

* CHECK dout0_54 Vdout0_54ck172 = 0 time = 865
.meas tran vdout0_54ck172 FIND v(dout0_54) AT=865.025n

* CHECK dout0_55 Vdout0_55ck172 = 0 time = 865
.meas tran vdout0_55ck172 FIND v(dout0_55) AT=865.025n

* CHECK dout0_56 Vdout0_56ck172 = 0 time = 865
.meas tran vdout0_56ck172 FIND v(dout0_56) AT=865.025n

* CHECK dout0_57 Vdout0_57ck172 = 0.9 time = 865
.meas tran vdout0_57ck172 FIND v(dout0_57) AT=865.025n

* CHECK dout0_58 Vdout0_58ck172 = 0 time = 865
.meas tran vdout0_58ck172 FIND v(dout0_58) AT=865.025n

* CHECK dout0_59 Vdout0_59ck172 = 0.9 time = 865
.meas tran vdout0_59ck172 FIND v(dout0_59) AT=865.025n

* CHECK dout0_60 Vdout0_60ck172 = 0 time = 865
.meas tran vdout0_60ck172 FIND v(dout0_60) AT=865.025n

* CHECK dout0_61 Vdout0_61ck172 = 0 time = 865
.meas tran vdout0_61ck172 FIND v(dout0_61) AT=865.025n

* CHECK dout0_62 Vdout0_62ck172 = 0 time = 865
.meas tran vdout0_62ck172 FIND v(dout0_62) AT=865.025n

* CHECK dout0_63 Vdout0_63ck172 = 0.9 time = 865
.meas tran vdout0_63ck172 FIND v(dout0_63) AT=865.025n

* CHECK dout0_0 Vdout0_0ck174 = 0 time = 875
.meas tran vdout0_0ck174 FIND v(dout0_0) AT=875.025n

* CHECK dout0_1 Vdout0_1ck174 = 0.9 time = 875
.meas tran vdout0_1ck174 FIND v(dout0_1) AT=875.025n

* CHECK dout0_2 Vdout0_2ck174 = 0 time = 875
.meas tran vdout0_2ck174 FIND v(dout0_2) AT=875.025n

* CHECK dout0_3 Vdout0_3ck174 = 0.9 time = 875
.meas tran vdout0_3ck174 FIND v(dout0_3) AT=875.025n

* CHECK dout0_4 Vdout0_4ck174 = 0.9 time = 875
.meas tran vdout0_4ck174 FIND v(dout0_4) AT=875.025n

* CHECK dout0_5 Vdout0_5ck174 = 0.9 time = 875
.meas tran vdout0_5ck174 FIND v(dout0_5) AT=875.025n

* CHECK dout0_6 Vdout0_6ck174 = 0 time = 875
.meas tran vdout0_6ck174 FIND v(dout0_6) AT=875.025n

* CHECK dout0_7 Vdout0_7ck174 = 0 time = 875
.meas tran vdout0_7ck174 FIND v(dout0_7) AT=875.025n

* CHECK dout0_8 Vdout0_8ck174 = 0.9 time = 875
.meas tran vdout0_8ck174 FIND v(dout0_8) AT=875.025n

* CHECK dout0_9 Vdout0_9ck174 = 0 time = 875
.meas tran vdout0_9ck174 FIND v(dout0_9) AT=875.025n

* CHECK dout0_10 Vdout0_10ck174 = 0.9 time = 875
.meas tran vdout0_10ck174 FIND v(dout0_10) AT=875.025n

* CHECK dout0_11 Vdout0_11ck174 = 0 time = 875
.meas tran vdout0_11ck174 FIND v(dout0_11) AT=875.025n

* CHECK dout0_12 Vdout0_12ck174 = 0 time = 875
.meas tran vdout0_12ck174 FIND v(dout0_12) AT=875.025n

* CHECK dout0_13 Vdout0_13ck174 = 0 time = 875
.meas tran vdout0_13ck174 FIND v(dout0_13) AT=875.025n

* CHECK dout0_14 Vdout0_14ck174 = 0.9 time = 875
.meas tran vdout0_14ck174 FIND v(dout0_14) AT=875.025n

* CHECK dout0_15 Vdout0_15ck174 = 0.9 time = 875
.meas tran vdout0_15ck174 FIND v(dout0_15) AT=875.025n

* CHECK dout0_16 Vdout0_16ck174 = 0.9 time = 875
.meas tran vdout0_16ck174 FIND v(dout0_16) AT=875.025n

* CHECK dout0_17 Vdout0_17ck174 = 0 time = 875
.meas tran vdout0_17ck174 FIND v(dout0_17) AT=875.025n

* CHECK dout0_18 Vdout0_18ck174 = 0.9 time = 875
.meas tran vdout0_18ck174 FIND v(dout0_18) AT=875.025n

* CHECK dout0_19 Vdout0_19ck174 = 0 time = 875
.meas tran vdout0_19ck174 FIND v(dout0_19) AT=875.025n

* CHECK dout0_20 Vdout0_20ck174 = 0 time = 875
.meas tran vdout0_20ck174 FIND v(dout0_20) AT=875.025n

* CHECK dout0_21 Vdout0_21ck174 = 0 time = 875
.meas tran vdout0_21ck174 FIND v(dout0_21) AT=875.025n

* CHECK dout0_22 Vdout0_22ck174 = 0.9 time = 875
.meas tran vdout0_22ck174 FIND v(dout0_22) AT=875.025n

* CHECK dout0_23 Vdout0_23ck174 = 0 time = 875
.meas tran vdout0_23ck174 FIND v(dout0_23) AT=875.025n

* CHECK dout0_24 Vdout0_24ck174 = 0 time = 875
.meas tran vdout0_24ck174 FIND v(dout0_24) AT=875.025n

* CHECK dout0_25 Vdout0_25ck174 = 0.9 time = 875
.meas tran vdout0_25ck174 FIND v(dout0_25) AT=875.025n

* CHECK dout0_26 Vdout0_26ck174 = 0.9 time = 875
.meas tran vdout0_26ck174 FIND v(dout0_26) AT=875.025n

* CHECK dout0_27 Vdout0_27ck174 = 0.9 time = 875
.meas tran vdout0_27ck174 FIND v(dout0_27) AT=875.025n

* CHECK dout0_28 Vdout0_28ck174 = 0.9 time = 875
.meas tran vdout0_28ck174 FIND v(dout0_28) AT=875.025n

* CHECK dout0_29 Vdout0_29ck174 = 0 time = 875
.meas tran vdout0_29ck174 FIND v(dout0_29) AT=875.025n

* CHECK dout0_30 Vdout0_30ck174 = 0 time = 875
.meas tran vdout0_30ck174 FIND v(dout0_30) AT=875.025n

* CHECK dout0_31 Vdout0_31ck174 = 0 time = 875
.meas tran vdout0_31ck174 FIND v(dout0_31) AT=875.025n

* CHECK dout0_32 Vdout0_32ck174 = 0.9 time = 875
.meas tran vdout0_32ck174 FIND v(dout0_32) AT=875.025n

* CHECK dout0_33 Vdout0_33ck174 = 0.9 time = 875
.meas tran vdout0_33ck174 FIND v(dout0_33) AT=875.025n

* CHECK dout0_34 Vdout0_34ck174 = 0.9 time = 875
.meas tran vdout0_34ck174 FIND v(dout0_34) AT=875.025n

* CHECK dout0_35 Vdout0_35ck174 = 0 time = 875
.meas tran vdout0_35ck174 FIND v(dout0_35) AT=875.025n

* CHECK dout0_36 Vdout0_36ck174 = 0.9 time = 875
.meas tran vdout0_36ck174 FIND v(dout0_36) AT=875.025n

* CHECK dout0_37 Vdout0_37ck174 = 0 time = 875
.meas tran vdout0_37ck174 FIND v(dout0_37) AT=875.025n

* CHECK dout0_38 Vdout0_38ck174 = 0 time = 875
.meas tran vdout0_38ck174 FIND v(dout0_38) AT=875.025n

* CHECK dout0_39 Vdout0_39ck174 = 0.9 time = 875
.meas tran vdout0_39ck174 FIND v(dout0_39) AT=875.025n

* CHECK dout0_40 Vdout0_40ck174 = 0 time = 875
.meas tran vdout0_40ck174 FIND v(dout0_40) AT=875.025n

* CHECK dout0_41 Vdout0_41ck174 = 0.9 time = 875
.meas tran vdout0_41ck174 FIND v(dout0_41) AT=875.025n

* CHECK dout0_42 Vdout0_42ck174 = 0 time = 875
.meas tran vdout0_42ck174 FIND v(dout0_42) AT=875.025n

* CHECK dout0_43 Vdout0_43ck174 = 0 time = 875
.meas tran vdout0_43ck174 FIND v(dout0_43) AT=875.025n

* CHECK dout0_44 Vdout0_44ck174 = 0.9 time = 875
.meas tran vdout0_44ck174 FIND v(dout0_44) AT=875.025n

* CHECK dout0_45 Vdout0_45ck174 = 0.9 time = 875
.meas tran vdout0_45ck174 FIND v(dout0_45) AT=875.025n

* CHECK dout0_46 Vdout0_46ck174 = 0.9 time = 875
.meas tran vdout0_46ck174 FIND v(dout0_46) AT=875.025n

* CHECK dout0_47 Vdout0_47ck174 = 0 time = 875
.meas tran vdout0_47ck174 FIND v(dout0_47) AT=875.025n

* CHECK dout0_48 Vdout0_48ck174 = 0 time = 875
.meas tran vdout0_48ck174 FIND v(dout0_48) AT=875.025n

* CHECK dout0_49 Vdout0_49ck174 = 0.9 time = 875
.meas tran vdout0_49ck174 FIND v(dout0_49) AT=875.025n

* CHECK dout0_50 Vdout0_50ck174 = 0.9 time = 875
.meas tran vdout0_50ck174 FIND v(dout0_50) AT=875.025n

* CHECK dout0_51 Vdout0_51ck174 = 0 time = 875
.meas tran vdout0_51ck174 FIND v(dout0_51) AT=875.025n

* CHECK dout0_52 Vdout0_52ck174 = 0 time = 875
.meas tran vdout0_52ck174 FIND v(dout0_52) AT=875.025n

* CHECK dout0_53 Vdout0_53ck174 = 0 time = 875
.meas tran vdout0_53ck174 FIND v(dout0_53) AT=875.025n

* CHECK dout0_54 Vdout0_54ck174 = 0 time = 875
.meas tran vdout0_54ck174 FIND v(dout0_54) AT=875.025n

* CHECK dout0_55 Vdout0_55ck174 = 0 time = 875
.meas tran vdout0_55ck174 FIND v(dout0_55) AT=875.025n

* CHECK dout0_56 Vdout0_56ck174 = 0 time = 875
.meas tran vdout0_56ck174 FIND v(dout0_56) AT=875.025n

* CHECK dout0_57 Vdout0_57ck174 = 0 time = 875
.meas tran vdout0_57ck174 FIND v(dout0_57) AT=875.025n

* CHECK dout0_58 Vdout0_58ck174 = 0 time = 875
.meas tran vdout0_58ck174 FIND v(dout0_58) AT=875.025n

* CHECK dout0_59 Vdout0_59ck174 = 0 time = 875
.meas tran vdout0_59ck174 FIND v(dout0_59) AT=875.025n

* CHECK dout0_60 Vdout0_60ck174 = 0.9 time = 875
.meas tran vdout0_60ck174 FIND v(dout0_60) AT=875.025n

* CHECK dout0_61 Vdout0_61ck174 = 0.9 time = 875
.meas tran vdout0_61ck174 FIND v(dout0_61) AT=875.025n

* CHECK dout0_62 Vdout0_62ck174 = 0 time = 875
.meas tran vdout0_62ck174 FIND v(dout0_62) AT=875.025n

* CHECK dout0_63 Vdout0_63ck174 = 0 time = 875
.meas tran vdout0_63ck174 FIND v(dout0_63) AT=875.025n

* CHECK dout0_0 Vdout0_0ck175 = 0 time = 880
.meas tran vdout0_0ck175 FIND v(dout0_0) AT=880.025n

* CHECK dout0_1 Vdout0_1ck175 = 0 time = 880
.meas tran vdout0_1ck175 FIND v(dout0_1) AT=880.025n

* CHECK dout0_2 Vdout0_2ck175 = 0 time = 880
.meas tran vdout0_2ck175 FIND v(dout0_2) AT=880.025n

* CHECK dout0_3 Vdout0_3ck175 = 0.9 time = 880
.meas tran vdout0_3ck175 FIND v(dout0_3) AT=880.025n

* CHECK dout0_4 Vdout0_4ck175 = 0 time = 880
.meas tran vdout0_4ck175 FIND v(dout0_4) AT=880.025n

* CHECK dout0_5 Vdout0_5ck175 = 0.9 time = 880
.meas tran vdout0_5ck175 FIND v(dout0_5) AT=880.025n

* CHECK dout0_6 Vdout0_6ck175 = 0.9 time = 880
.meas tran vdout0_6ck175 FIND v(dout0_6) AT=880.025n

* CHECK dout0_7 Vdout0_7ck175 = 0 time = 880
.meas tran vdout0_7ck175 FIND v(dout0_7) AT=880.025n

* CHECK dout0_8 Vdout0_8ck175 = 0 time = 880
.meas tran vdout0_8ck175 FIND v(dout0_8) AT=880.025n

* CHECK dout0_9 Vdout0_9ck175 = 0 time = 880
.meas tran vdout0_9ck175 FIND v(dout0_9) AT=880.025n

* CHECK dout0_10 Vdout0_10ck175 = 0.9 time = 880
.meas tran vdout0_10ck175 FIND v(dout0_10) AT=880.025n

* CHECK dout0_11 Vdout0_11ck175 = 0.9 time = 880
.meas tran vdout0_11ck175 FIND v(dout0_11) AT=880.025n

* CHECK dout0_12 Vdout0_12ck175 = 0.9 time = 880
.meas tran vdout0_12ck175 FIND v(dout0_12) AT=880.025n

* CHECK dout0_13 Vdout0_13ck175 = 0.9 time = 880
.meas tran vdout0_13ck175 FIND v(dout0_13) AT=880.025n

* CHECK dout0_14 Vdout0_14ck175 = 0 time = 880
.meas tran vdout0_14ck175 FIND v(dout0_14) AT=880.025n

* CHECK dout0_15 Vdout0_15ck175 = 0.9 time = 880
.meas tran vdout0_15ck175 FIND v(dout0_15) AT=880.025n

* CHECK dout0_16 Vdout0_16ck175 = 0 time = 880
.meas tran vdout0_16ck175 FIND v(dout0_16) AT=880.025n

* CHECK dout0_17 Vdout0_17ck175 = 0 time = 880
.meas tran vdout0_17ck175 FIND v(dout0_17) AT=880.025n

* CHECK dout0_18 Vdout0_18ck175 = 0.9 time = 880
.meas tran vdout0_18ck175 FIND v(dout0_18) AT=880.025n

* CHECK dout0_19 Vdout0_19ck175 = 0.9 time = 880
.meas tran vdout0_19ck175 FIND v(dout0_19) AT=880.025n

* CHECK dout0_20 Vdout0_20ck175 = 0 time = 880
.meas tran vdout0_20ck175 FIND v(dout0_20) AT=880.025n

* CHECK dout0_21 Vdout0_21ck175 = 0 time = 880
.meas tran vdout0_21ck175 FIND v(dout0_21) AT=880.025n

* CHECK dout0_22 Vdout0_22ck175 = 0.9 time = 880
.meas tran vdout0_22ck175 FIND v(dout0_22) AT=880.025n

* CHECK dout0_23 Vdout0_23ck175 = 0 time = 880
.meas tran vdout0_23ck175 FIND v(dout0_23) AT=880.025n

* CHECK dout0_24 Vdout0_24ck175 = 0.9 time = 880
.meas tran vdout0_24ck175 FIND v(dout0_24) AT=880.025n

* CHECK dout0_25 Vdout0_25ck175 = 0.9 time = 880
.meas tran vdout0_25ck175 FIND v(dout0_25) AT=880.025n

* CHECK dout0_26 Vdout0_26ck175 = 0 time = 880
.meas tran vdout0_26ck175 FIND v(dout0_26) AT=880.025n

* CHECK dout0_27 Vdout0_27ck175 = 0 time = 880
.meas tran vdout0_27ck175 FIND v(dout0_27) AT=880.025n

* CHECK dout0_28 Vdout0_28ck175 = 0 time = 880
.meas tran vdout0_28ck175 FIND v(dout0_28) AT=880.025n

* CHECK dout0_29 Vdout0_29ck175 = 0 time = 880
.meas tran vdout0_29ck175 FIND v(dout0_29) AT=880.025n

* CHECK dout0_30 Vdout0_30ck175 = 0 time = 880
.meas tran vdout0_30ck175 FIND v(dout0_30) AT=880.025n

* CHECK dout0_31 Vdout0_31ck175 = 0 time = 880
.meas tran vdout0_31ck175 FIND v(dout0_31) AT=880.025n

* CHECK dout0_32 Vdout0_32ck175 = 0 time = 880
.meas tran vdout0_32ck175 FIND v(dout0_32) AT=880.025n

* CHECK dout0_33 Vdout0_33ck175 = 0.9 time = 880
.meas tran vdout0_33ck175 FIND v(dout0_33) AT=880.025n

* CHECK dout0_34 Vdout0_34ck175 = 0 time = 880
.meas tran vdout0_34ck175 FIND v(dout0_34) AT=880.025n

* CHECK dout0_35 Vdout0_35ck175 = 0 time = 880
.meas tran vdout0_35ck175 FIND v(dout0_35) AT=880.025n

* CHECK dout0_36 Vdout0_36ck175 = 0 time = 880
.meas tran vdout0_36ck175 FIND v(dout0_36) AT=880.025n

* CHECK dout0_37 Vdout0_37ck175 = 0.9 time = 880
.meas tran vdout0_37ck175 FIND v(dout0_37) AT=880.025n

* CHECK dout0_38 Vdout0_38ck175 = 0 time = 880
.meas tran vdout0_38ck175 FIND v(dout0_38) AT=880.025n

* CHECK dout0_39 Vdout0_39ck175 = 0 time = 880
.meas tran vdout0_39ck175 FIND v(dout0_39) AT=880.025n

* CHECK dout0_40 Vdout0_40ck175 = 0.9 time = 880
.meas tran vdout0_40ck175 FIND v(dout0_40) AT=880.025n

* CHECK dout0_41 Vdout0_41ck175 = 0.9 time = 880
.meas tran vdout0_41ck175 FIND v(dout0_41) AT=880.025n

* CHECK dout0_42 Vdout0_42ck175 = 0 time = 880
.meas tran vdout0_42ck175 FIND v(dout0_42) AT=880.025n

* CHECK dout0_43 Vdout0_43ck175 = 0 time = 880
.meas tran vdout0_43ck175 FIND v(dout0_43) AT=880.025n

* CHECK dout0_44 Vdout0_44ck175 = 0 time = 880
.meas tran vdout0_44ck175 FIND v(dout0_44) AT=880.025n

* CHECK dout0_45 Vdout0_45ck175 = 0 time = 880
.meas tran vdout0_45ck175 FIND v(dout0_45) AT=880.025n

* CHECK dout0_46 Vdout0_46ck175 = 0 time = 880
.meas tran vdout0_46ck175 FIND v(dout0_46) AT=880.025n

* CHECK dout0_47 Vdout0_47ck175 = 0 time = 880
.meas tran vdout0_47ck175 FIND v(dout0_47) AT=880.025n

* CHECK dout0_48 Vdout0_48ck175 = 0.9 time = 880
.meas tran vdout0_48ck175 FIND v(dout0_48) AT=880.025n

* CHECK dout0_49 Vdout0_49ck175 = 0 time = 880
.meas tran vdout0_49ck175 FIND v(dout0_49) AT=880.025n

* CHECK dout0_50 Vdout0_50ck175 = 0 time = 880
.meas tran vdout0_50ck175 FIND v(dout0_50) AT=880.025n

* CHECK dout0_51 Vdout0_51ck175 = 0 time = 880
.meas tran vdout0_51ck175 FIND v(dout0_51) AT=880.025n

* CHECK dout0_52 Vdout0_52ck175 = 0.9 time = 880
.meas tran vdout0_52ck175 FIND v(dout0_52) AT=880.025n

* CHECK dout0_53 Vdout0_53ck175 = 0.9 time = 880
.meas tran vdout0_53ck175 FIND v(dout0_53) AT=880.025n

* CHECK dout0_54 Vdout0_54ck175 = 0.9 time = 880
.meas tran vdout0_54ck175 FIND v(dout0_54) AT=880.025n

* CHECK dout0_55 Vdout0_55ck175 = 0.9 time = 880
.meas tran vdout0_55ck175 FIND v(dout0_55) AT=880.025n

* CHECK dout0_56 Vdout0_56ck175 = 0.9 time = 880
.meas tran vdout0_56ck175 FIND v(dout0_56) AT=880.025n

* CHECK dout0_57 Vdout0_57ck175 = 0 time = 880
.meas tran vdout0_57ck175 FIND v(dout0_57) AT=880.025n

* CHECK dout0_58 Vdout0_58ck175 = 0 time = 880
.meas tran vdout0_58ck175 FIND v(dout0_58) AT=880.025n

* CHECK dout0_59 Vdout0_59ck175 = 0.9 time = 880
.meas tran vdout0_59ck175 FIND v(dout0_59) AT=880.025n

* CHECK dout0_60 Vdout0_60ck175 = 0.9 time = 880
.meas tran vdout0_60ck175 FIND v(dout0_60) AT=880.025n

* CHECK dout0_61 Vdout0_61ck175 = 0 time = 880
.meas tran vdout0_61ck175 FIND v(dout0_61) AT=880.025n

* CHECK dout0_62 Vdout0_62ck175 = 0 time = 880
.meas tran vdout0_62ck175 FIND v(dout0_62) AT=880.025n

* CHECK dout0_63 Vdout0_63ck175 = 0.9 time = 880
.meas tran vdout0_63ck175 FIND v(dout0_63) AT=880.025n

* CHECK dout0_0 Vdout0_0ck176 = 0 time = 885
.meas tran vdout0_0ck176 FIND v(dout0_0) AT=885.025n

* CHECK dout0_1 Vdout0_1ck176 = 0 time = 885
.meas tran vdout0_1ck176 FIND v(dout0_1) AT=885.025n

* CHECK dout0_2 Vdout0_2ck176 = 0 time = 885
.meas tran vdout0_2ck176 FIND v(dout0_2) AT=885.025n

* CHECK dout0_3 Vdout0_3ck176 = 0.9 time = 885
.meas tran vdout0_3ck176 FIND v(dout0_3) AT=885.025n

* CHECK dout0_4 Vdout0_4ck176 = 0 time = 885
.meas tran vdout0_4ck176 FIND v(dout0_4) AT=885.025n

* CHECK dout0_5 Vdout0_5ck176 = 0.9 time = 885
.meas tran vdout0_5ck176 FIND v(dout0_5) AT=885.025n

* CHECK dout0_6 Vdout0_6ck176 = 0.9 time = 885
.meas tran vdout0_6ck176 FIND v(dout0_6) AT=885.025n

* CHECK dout0_7 Vdout0_7ck176 = 0 time = 885
.meas tran vdout0_7ck176 FIND v(dout0_7) AT=885.025n

* CHECK dout0_8 Vdout0_8ck176 = 0 time = 885
.meas tran vdout0_8ck176 FIND v(dout0_8) AT=885.025n

* CHECK dout0_9 Vdout0_9ck176 = 0 time = 885
.meas tran vdout0_9ck176 FIND v(dout0_9) AT=885.025n

* CHECK dout0_10 Vdout0_10ck176 = 0.9 time = 885
.meas tran vdout0_10ck176 FIND v(dout0_10) AT=885.025n

* CHECK dout0_11 Vdout0_11ck176 = 0.9 time = 885
.meas tran vdout0_11ck176 FIND v(dout0_11) AT=885.025n

* CHECK dout0_12 Vdout0_12ck176 = 0.9 time = 885
.meas tran vdout0_12ck176 FIND v(dout0_12) AT=885.025n

* CHECK dout0_13 Vdout0_13ck176 = 0.9 time = 885
.meas tran vdout0_13ck176 FIND v(dout0_13) AT=885.025n

* CHECK dout0_14 Vdout0_14ck176 = 0 time = 885
.meas tran vdout0_14ck176 FIND v(dout0_14) AT=885.025n

* CHECK dout0_15 Vdout0_15ck176 = 0.9 time = 885
.meas tran vdout0_15ck176 FIND v(dout0_15) AT=885.025n

* CHECK dout0_16 Vdout0_16ck176 = 0 time = 885
.meas tran vdout0_16ck176 FIND v(dout0_16) AT=885.025n

* CHECK dout0_17 Vdout0_17ck176 = 0 time = 885
.meas tran vdout0_17ck176 FIND v(dout0_17) AT=885.025n

* CHECK dout0_18 Vdout0_18ck176 = 0.9 time = 885
.meas tran vdout0_18ck176 FIND v(dout0_18) AT=885.025n

* CHECK dout0_19 Vdout0_19ck176 = 0.9 time = 885
.meas tran vdout0_19ck176 FIND v(dout0_19) AT=885.025n

* CHECK dout0_20 Vdout0_20ck176 = 0 time = 885
.meas tran vdout0_20ck176 FIND v(dout0_20) AT=885.025n

* CHECK dout0_21 Vdout0_21ck176 = 0 time = 885
.meas tran vdout0_21ck176 FIND v(dout0_21) AT=885.025n

* CHECK dout0_22 Vdout0_22ck176 = 0.9 time = 885
.meas tran vdout0_22ck176 FIND v(dout0_22) AT=885.025n

* CHECK dout0_23 Vdout0_23ck176 = 0 time = 885
.meas tran vdout0_23ck176 FIND v(dout0_23) AT=885.025n

* CHECK dout0_24 Vdout0_24ck176 = 0.9 time = 885
.meas tran vdout0_24ck176 FIND v(dout0_24) AT=885.025n

* CHECK dout0_25 Vdout0_25ck176 = 0.9 time = 885
.meas tran vdout0_25ck176 FIND v(dout0_25) AT=885.025n

* CHECK dout0_26 Vdout0_26ck176 = 0 time = 885
.meas tran vdout0_26ck176 FIND v(dout0_26) AT=885.025n

* CHECK dout0_27 Vdout0_27ck176 = 0 time = 885
.meas tran vdout0_27ck176 FIND v(dout0_27) AT=885.025n

* CHECK dout0_28 Vdout0_28ck176 = 0 time = 885
.meas tran vdout0_28ck176 FIND v(dout0_28) AT=885.025n

* CHECK dout0_29 Vdout0_29ck176 = 0 time = 885
.meas tran vdout0_29ck176 FIND v(dout0_29) AT=885.025n

* CHECK dout0_30 Vdout0_30ck176 = 0 time = 885
.meas tran vdout0_30ck176 FIND v(dout0_30) AT=885.025n

* CHECK dout0_31 Vdout0_31ck176 = 0 time = 885
.meas tran vdout0_31ck176 FIND v(dout0_31) AT=885.025n

* CHECK dout0_32 Vdout0_32ck176 = 0 time = 885
.meas tran vdout0_32ck176 FIND v(dout0_32) AT=885.025n

* CHECK dout0_33 Vdout0_33ck176 = 0.9 time = 885
.meas tran vdout0_33ck176 FIND v(dout0_33) AT=885.025n

* CHECK dout0_34 Vdout0_34ck176 = 0 time = 885
.meas tran vdout0_34ck176 FIND v(dout0_34) AT=885.025n

* CHECK dout0_35 Vdout0_35ck176 = 0 time = 885
.meas tran vdout0_35ck176 FIND v(dout0_35) AT=885.025n

* CHECK dout0_36 Vdout0_36ck176 = 0 time = 885
.meas tran vdout0_36ck176 FIND v(dout0_36) AT=885.025n

* CHECK dout0_37 Vdout0_37ck176 = 0.9 time = 885
.meas tran vdout0_37ck176 FIND v(dout0_37) AT=885.025n

* CHECK dout0_38 Vdout0_38ck176 = 0 time = 885
.meas tran vdout0_38ck176 FIND v(dout0_38) AT=885.025n

* CHECK dout0_39 Vdout0_39ck176 = 0 time = 885
.meas tran vdout0_39ck176 FIND v(dout0_39) AT=885.025n

* CHECK dout0_40 Vdout0_40ck176 = 0.9 time = 885
.meas tran vdout0_40ck176 FIND v(dout0_40) AT=885.025n

* CHECK dout0_41 Vdout0_41ck176 = 0.9 time = 885
.meas tran vdout0_41ck176 FIND v(dout0_41) AT=885.025n

* CHECK dout0_42 Vdout0_42ck176 = 0 time = 885
.meas tran vdout0_42ck176 FIND v(dout0_42) AT=885.025n

* CHECK dout0_43 Vdout0_43ck176 = 0 time = 885
.meas tran vdout0_43ck176 FIND v(dout0_43) AT=885.025n

* CHECK dout0_44 Vdout0_44ck176 = 0 time = 885
.meas tran vdout0_44ck176 FIND v(dout0_44) AT=885.025n

* CHECK dout0_45 Vdout0_45ck176 = 0 time = 885
.meas tran vdout0_45ck176 FIND v(dout0_45) AT=885.025n

* CHECK dout0_46 Vdout0_46ck176 = 0 time = 885
.meas tran vdout0_46ck176 FIND v(dout0_46) AT=885.025n

* CHECK dout0_47 Vdout0_47ck176 = 0 time = 885
.meas tran vdout0_47ck176 FIND v(dout0_47) AT=885.025n

* CHECK dout0_48 Vdout0_48ck176 = 0.9 time = 885
.meas tran vdout0_48ck176 FIND v(dout0_48) AT=885.025n

* CHECK dout0_49 Vdout0_49ck176 = 0 time = 885
.meas tran vdout0_49ck176 FIND v(dout0_49) AT=885.025n

* CHECK dout0_50 Vdout0_50ck176 = 0 time = 885
.meas tran vdout0_50ck176 FIND v(dout0_50) AT=885.025n

* CHECK dout0_51 Vdout0_51ck176 = 0 time = 885
.meas tran vdout0_51ck176 FIND v(dout0_51) AT=885.025n

* CHECK dout0_52 Vdout0_52ck176 = 0.9 time = 885
.meas tran vdout0_52ck176 FIND v(dout0_52) AT=885.025n

* CHECK dout0_53 Vdout0_53ck176 = 0.9 time = 885
.meas tran vdout0_53ck176 FIND v(dout0_53) AT=885.025n

* CHECK dout0_54 Vdout0_54ck176 = 0.9 time = 885
.meas tran vdout0_54ck176 FIND v(dout0_54) AT=885.025n

* CHECK dout0_55 Vdout0_55ck176 = 0.9 time = 885
.meas tran vdout0_55ck176 FIND v(dout0_55) AT=885.025n

* CHECK dout0_56 Vdout0_56ck176 = 0.9 time = 885
.meas tran vdout0_56ck176 FIND v(dout0_56) AT=885.025n

* CHECK dout0_57 Vdout0_57ck176 = 0 time = 885
.meas tran vdout0_57ck176 FIND v(dout0_57) AT=885.025n

* CHECK dout0_58 Vdout0_58ck176 = 0 time = 885
.meas tran vdout0_58ck176 FIND v(dout0_58) AT=885.025n

* CHECK dout0_59 Vdout0_59ck176 = 0.9 time = 885
.meas tran vdout0_59ck176 FIND v(dout0_59) AT=885.025n

* CHECK dout0_60 Vdout0_60ck176 = 0.9 time = 885
.meas tran vdout0_60ck176 FIND v(dout0_60) AT=885.025n

* CHECK dout0_61 Vdout0_61ck176 = 0 time = 885
.meas tran vdout0_61ck176 FIND v(dout0_61) AT=885.025n

* CHECK dout0_62 Vdout0_62ck176 = 0 time = 885
.meas tran vdout0_62ck176 FIND v(dout0_62) AT=885.025n

* CHECK dout0_63 Vdout0_63ck176 = 0.9 time = 885
.meas tran vdout0_63ck176 FIND v(dout0_63) AT=885.025n

* CHECK dout0_0 Vdout0_0ck181 = 0 time = 910
.meas tran vdout0_0ck181 FIND v(dout0_0) AT=910.025n

* CHECK dout0_1 Vdout0_1ck181 = 0.9 time = 910
.meas tran vdout0_1ck181 FIND v(dout0_1) AT=910.025n

* CHECK dout0_2 Vdout0_2ck181 = 0.9 time = 910
.meas tran vdout0_2ck181 FIND v(dout0_2) AT=910.025n

* CHECK dout0_3 Vdout0_3ck181 = 0.9 time = 910
.meas tran vdout0_3ck181 FIND v(dout0_3) AT=910.025n

* CHECK dout0_4 Vdout0_4ck181 = 0 time = 910
.meas tran vdout0_4ck181 FIND v(dout0_4) AT=910.025n

* CHECK dout0_5 Vdout0_5ck181 = 0 time = 910
.meas tran vdout0_5ck181 FIND v(dout0_5) AT=910.025n

* CHECK dout0_6 Vdout0_6ck181 = 0 time = 910
.meas tran vdout0_6ck181 FIND v(dout0_6) AT=910.025n

* CHECK dout0_7 Vdout0_7ck181 = 0.9 time = 910
.meas tran vdout0_7ck181 FIND v(dout0_7) AT=910.025n

* CHECK dout0_8 Vdout0_8ck181 = 0 time = 910
.meas tran vdout0_8ck181 FIND v(dout0_8) AT=910.025n

* CHECK dout0_9 Vdout0_9ck181 = 0.9 time = 910
.meas tran vdout0_9ck181 FIND v(dout0_9) AT=910.025n

* CHECK dout0_10 Vdout0_10ck181 = 0 time = 910
.meas tran vdout0_10ck181 FIND v(dout0_10) AT=910.025n

* CHECK dout0_11 Vdout0_11ck181 = 0 time = 910
.meas tran vdout0_11ck181 FIND v(dout0_11) AT=910.025n

* CHECK dout0_12 Vdout0_12ck181 = 0 time = 910
.meas tran vdout0_12ck181 FIND v(dout0_12) AT=910.025n

* CHECK dout0_13 Vdout0_13ck181 = 0 time = 910
.meas tran vdout0_13ck181 FIND v(dout0_13) AT=910.025n

* CHECK dout0_14 Vdout0_14ck181 = 0.9 time = 910
.meas tran vdout0_14ck181 FIND v(dout0_14) AT=910.025n

* CHECK dout0_15 Vdout0_15ck181 = 0 time = 910
.meas tran vdout0_15ck181 FIND v(dout0_15) AT=910.025n

* CHECK dout0_16 Vdout0_16ck181 = 0.9 time = 910
.meas tran vdout0_16ck181 FIND v(dout0_16) AT=910.025n

* CHECK dout0_17 Vdout0_17ck181 = 0.9 time = 910
.meas tran vdout0_17ck181 FIND v(dout0_17) AT=910.025n

* CHECK dout0_18 Vdout0_18ck181 = 0 time = 910
.meas tran vdout0_18ck181 FIND v(dout0_18) AT=910.025n

* CHECK dout0_19 Vdout0_19ck181 = 0.9 time = 910
.meas tran vdout0_19ck181 FIND v(dout0_19) AT=910.025n

* CHECK dout0_20 Vdout0_20ck181 = 0 time = 910
.meas tran vdout0_20ck181 FIND v(dout0_20) AT=910.025n

* CHECK dout0_21 Vdout0_21ck181 = 0 time = 910
.meas tran vdout0_21ck181 FIND v(dout0_21) AT=910.025n

* CHECK dout0_22 Vdout0_22ck181 = 0 time = 910
.meas tran vdout0_22ck181 FIND v(dout0_22) AT=910.025n

* CHECK dout0_23 Vdout0_23ck181 = 0 time = 910
.meas tran vdout0_23ck181 FIND v(dout0_23) AT=910.025n

* CHECK dout0_24 Vdout0_24ck181 = 0 time = 910
.meas tran vdout0_24ck181 FIND v(dout0_24) AT=910.025n

* CHECK dout0_25 Vdout0_25ck181 = 0.9 time = 910
.meas tran vdout0_25ck181 FIND v(dout0_25) AT=910.025n

* CHECK dout0_26 Vdout0_26ck181 = 0 time = 910
.meas tran vdout0_26ck181 FIND v(dout0_26) AT=910.025n

* CHECK dout0_27 Vdout0_27ck181 = 0.9 time = 910
.meas tran vdout0_27ck181 FIND v(dout0_27) AT=910.025n

* CHECK dout0_28 Vdout0_28ck181 = 0 time = 910
.meas tran vdout0_28ck181 FIND v(dout0_28) AT=910.025n

* CHECK dout0_29 Vdout0_29ck181 = 0 time = 910
.meas tran vdout0_29ck181 FIND v(dout0_29) AT=910.025n

* CHECK dout0_30 Vdout0_30ck181 = 0 time = 910
.meas tran vdout0_30ck181 FIND v(dout0_30) AT=910.025n

* CHECK dout0_31 Vdout0_31ck181 = 0 time = 910
.meas tran vdout0_31ck181 FIND v(dout0_31) AT=910.025n

* CHECK dout0_32 Vdout0_32ck181 = 0 time = 910
.meas tran vdout0_32ck181 FIND v(dout0_32) AT=910.025n

* CHECK dout0_33 Vdout0_33ck181 = 0 time = 910
.meas tran vdout0_33ck181 FIND v(dout0_33) AT=910.025n

* CHECK dout0_34 Vdout0_34ck181 = 0 time = 910
.meas tran vdout0_34ck181 FIND v(dout0_34) AT=910.025n

* CHECK dout0_35 Vdout0_35ck181 = 0 time = 910
.meas tran vdout0_35ck181 FIND v(dout0_35) AT=910.025n

* CHECK dout0_36 Vdout0_36ck181 = 0.9 time = 910
.meas tran vdout0_36ck181 FIND v(dout0_36) AT=910.025n

* CHECK dout0_37 Vdout0_37ck181 = 0 time = 910
.meas tran vdout0_37ck181 FIND v(dout0_37) AT=910.025n

* CHECK dout0_38 Vdout0_38ck181 = 0.9 time = 910
.meas tran vdout0_38ck181 FIND v(dout0_38) AT=910.025n

* CHECK dout0_39 Vdout0_39ck181 = 0.9 time = 910
.meas tran vdout0_39ck181 FIND v(dout0_39) AT=910.025n

* CHECK dout0_40 Vdout0_40ck181 = 0.9 time = 910
.meas tran vdout0_40ck181 FIND v(dout0_40) AT=910.025n

* CHECK dout0_41 Vdout0_41ck181 = 0 time = 910
.meas tran vdout0_41ck181 FIND v(dout0_41) AT=910.025n

* CHECK dout0_42 Vdout0_42ck181 = 0.9 time = 910
.meas tran vdout0_42ck181 FIND v(dout0_42) AT=910.025n

* CHECK dout0_43 Vdout0_43ck181 = 0 time = 910
.meas tran vdout0_43ck181 FIND v(dout0_43) AT=910.025n

* CHECK dout0_44 Vdout0_44ck181 = 0.9 time = 910
.meas tran vdout0_44ck181 FIND v(dout0_44) AT=910.025n

* CHECK dout0_45 Vdout0_45ck181 = 0.9 time = 910
.meas tran vdout0_45ck181 FIND v(dout0_45) AT=910.025n

* CHECK dout0_46 Vdout0_46ck181 = 0.9 time = 910
.meas tran vdout0_46ck181 FIND v(dout0_46) AT=910.025n

* CHECK dout0_47 Vdout0_47ck181 = 0 time = 910
.meas tran vdout0_47ck181 FIND v(dout0_47) AT=910.025n

* CHECK dout0_48 Vdout0_48ck181 = 0.9 time = 910
.meas tran vdout0_48ck181 FIND v(dout0_48) AT=910.025n

* CHECK dout0_49 Vdout0_49ck181 = 0 time = 910
.meas tran vdout0_49ck181 FIND v(dout0_49) AT=910.025n

* CHECK dout0_50 Vdout0_50ck181 = 0.9 time = 910
.meas tran vdout0_50ck181 FIND v(dout0_50) AT=910.025n

* CHECK dout0_51 Vdout0_51ck181 = 0.9 time = 910
.meas tran vdout0_51ck181 FIND v(dout0_51) AT=910.025n

* CHECK dout0_52 Vdout0_52ck181 = 0 time = 910
.meas tran vdout0_52ck181 FIND v(dout0_52) AT=910.025n

* CHECK dout0_53 Vdout0_53ck181 = 0.9 time = 910
.meas tran vdout0_53ck181 FIND v(dout0_53) AT=910.025n

* CHECK dout0_54 Vdout0_54ck181 = 0 time = 910
.meas tran vdout0_54ck181 FIND v(dout0_54) AT=910.025n

* CHECK dout0_55 Vdout0_55ck181 = 0 time = 910
.meas tran vdout0_55ck181 FIND v(dout0_55) AT=910.025n

* CHECK dout0_56 Vdout0_56ck181 = 0 time = 910
.meas tran vdout0_56ck181 FIND v(dout0_56) AT=910.025n

* CHECK dout0_57 Vdout0_57ck181 = 0.9 time = 910
.meas tran vdout0_57ck181 FIND v(dout0_57) AT=910.025n

* CHECK dout0_58 Vdout0_58ck181 = 0 time = 910
.meas tran vdout0_58ck181 FIND v(dout0_58) AT=910.025n

* CHECK dout0_59 Vdout0_59ck181 = 0.9 time = 910
.meas tran vdout0_59ck181 FIND v(dout0_59) AT=910.025n

* CHECK dout0_60 Vdout0_60ck181 = 0.9 time = 910
.meas tran vdout0_60ck181 FIND v(dout0_60) AT=910.025n

* CHECK dout0_61 Vdout0_61ck181 = 0 time = 910
.meas tran vdout0_61ck181 FIND v(dout0_61) AT=910.025n

* CHECK dout0_62 Vdout0_62ck181 = 0 time = 910
.meas tran vdout0_62ck181 FIND v(dout0_62) AT=910.025n

* CHECK dout0_63 Vdout0_63ck181 = 0 time = 910
.meas tran vdout0_63ck181 FIND v(dout0_63) AT=910.025n

* CHECK dout0_0 Vdout0_0ck182 = 0.9 time = 915
.meas tran vdout0_0ck182 FIND v(dout0_0) AT=915.025n

* CHECK dout0_1 Vdout0_1ck182 = 0.9 time = 915
.meas tran vdout0_1ck182 FIND v(dout0_1) AT=915.025n

* CHECK dout0_2 Vdout0_2ck182 = 0 time = 915
.meas tran vdout0_2ck182 FIND v(dout0_2) AT=915.025n

* CHECK dout0_3 Vdout0_3ck182 = 0.9 time = 915
.meas tran vdout0_3ck182 FIND v(dout0_3) AT=915.025n

* CHECK dout0_4 Vdout0_4ck182 = 0 time = 915
.meas tran vdout0_4ck182 FIND v(dout0_4) AT=915.025n

* CHECK dout0_5 Vdout0_5ck182 = 0 time = 915
.meas tran vdout0_5ck182 FIND v(dout0_5) AT=915.025n

* CHECK dout0_6 Vdout0_6ck182 = 0 time = 915
.meas tran vdout0_6ck182 FIND v(dout0_6) AT=915.025n

* CHECK dout0_7 Vdout0_7ck182 = 0.9 time = 915
.meas tran vdout0_7ck182 FIND v(dout0_7) AT=915.025n

* CHECK dout0_8 Vdout0_8ck182 = 0.9 time = 915
.meas tran vdout0_8ck182 FIND v(dout0_8) AT=915.025n

* CHECK dout0_9 Vdout0_9ck182 = 0 time = 915
.meas tran vdout0_9ck182 FIND v(dout0_9) AT=915.025n

* CHECK dout0_10 Vdout0_10ck182 = 0 time = 915
.meas tran vdout0_10ck182 FIND v(dout0_10) AT=915.025n

* CHECK dout0_11 Vdout0_11ck182 = 0.9 time = 915
.meas tran vdout0_11ck182 FIND v(dout0_11) AT=915.025n

* CHECK dout0_12 Vdout0_12ck182 = 0.9 time = 915
.meas tran vdout0_12ck182 FIND v(dout0_12) AT=915.025n

* CHECK dout0_13 Vdout0_13ck182 = 0.9 time = 915
.meas tran vdout0_13ck182 FIND v(dout0_13) AT=915.025n

* CHECK dout0_14 Vdout0_14ck182 = 0.9 time = 915
.meas tran vdout0_14ck182 FIND v(dout0_14) AT=915.025n

* CHECK dout0_15 Vdout0_15ck182 = 0 time = 915
.meas tran vdout0_15ck182 FIND v(dout0_15) AT=915.025n

* CHECK dout0_16 Vdout0_16ck182 = 0.9 time = 915
.meas tran vdout0_16ck182 FIND v(dout0_16) AT=915.025n

* CHECK dout0_17 Vdout0_17ck182 = 0.9 time = 915
.meas tran vdout0_17ck182 FIND v(dout0_17) AT=915.025n

* CHECK dout0_18 Vdout0_18ck182 = 0.9 time = 915
.meas tran vdout0_18ck182 FIND v(dout0_18) AT=915.025n

* CHECK dout0_19 Vdout0_19ck182 = 0 time = 915
.meas tran vdout0_19ck182 FIND v(dout0_19) AT=915.025n

* CHECK dout0_20 Vdout0_20ck182 = 0.9 time = 915
.meas tran vdout0_20ck182 FIND v(dout0_20) AT=915.025n

* CHECK dout0_21 Vdout0_21ck182 = 0 time = 915
.meas tran vdout0_21ck182 FIND v(dout0_21) AT=915.025n

* CHECK dout0_22 Vdout0_22ck182 = 0 time = 915
.meas tran vdout0_22ck182 FIND v(dout0_22) AT=915.025n

* CHECK dout0_23 Vdout0_23ck182 = 0 time = 915
.meas tran vdout0_23ck182 FIND v(dout0_23) AT=915.025n

* CHECK dout0_24 Vdout0_24ck182 = 0 time = 915
.meas tran vdout0_24ck182 FIND v(dout0_24) AT=915.025n

* CHECK dout0_25 Vdout0_25ck182 = 0 time = 915
.meas tran vdout0_25ck182 FIND v(dout0_25) AT=915.025n

* CHECK dout0_26 Vdout0_26ck182 = 0 time = 915
.meas tran vdout0_26ck182 FIND v(dout0_26) AT=915.025n

* CHECK dout0_27 Vdout0_27ck182 = 0 time = 915
.meas tran vdout0_27ck182 FIND v(dout0_27) AT=915.025n

* CHECK dout0_28 Vdout0_28ck182 = 0.9 time = 915
.meas tran vdout0_28ck182 FIND v(dout0_28) AT=915.025n

* CHECK dout0_29 Vdout0_29ck182 = 0.9 time = 915
.meas tran vdout0_29ck182 FIND v(dout0_29) AT=915.025n

* CHECK dout0_30 Vdout0_30ck182 = 0.9 time = 915
.meas tran vdout0_30ck182 FIND v(dout0_30) AT=915.025n

* CHECK dout0_31 Vdout0_31ck182 = 0 time = 915
.meas tran vdout0_31ck182 FIND v(dout0_31) AT=915.025n

* CHECK dout0_32 Vdout0_32ck182 = 0.9 time = 915
.meas tran vdout0_32ck182 FIND v(dout0_32) AT=915.025n

* CHECK dout0_33 Vdout0_33ck182 = 0.9 time = 915
.meas tran vdout0_33ck182 FIND v(dout0_33) AT=915.025n

* CHECK dout0_34 Vdout0_34ck182 = 0 time = 915
.meas tran vdout0_34ck182 FIND v(dout0_34) AT=915.025n

* CHECK dout0_35 Vdout0_35ck182 = 0 time = 915
.meas tran vdout0_35ck182 FIND v(dout0_35) AT=915.025n

* CHECK dout0_36 Vdout0_36ck182 = 0.9 time = 915
.meas tran vdout0_36ck182 FIND v(dout0_36) AT=915.025n

* CHECK dout0_37 Vdout0_37ck182 = 0 time = 915
.meas tran vdout0_37ck182 FIND v(dout0_37) AT=915.025n

* CHECK dout0_38 Vdout0_38ck182 = 0 time = 915
.meas tran vdout0_38ck182 FIND v(dout0_38) AT=915.025n

* CHECK dout0_39 Vdout0_39ck182 = 0.9 time = 915
.meas tran vdout0_39ck182 FIND v(dout0_39) AT=915.025n

* CHECK dout0_40 Vdout0_40ck182 = 0 time = 915
.meas tran vdout0_40ck182 FIND v(dout0_40) AT=915.025n

* CHECK dout0_41 Vdout0_41ck182 = 0 time = 915
.meas tran vdout0_41ck182 FIND v(dout0_41) AT=915.025n

* CHECK dout0_42 Vdout0_42ck182 = 0 time = 915
.meas tran vdout0_42ck182 FIND v(dout0_42) AT=915.025n

* CHECK dout0_43 Vdout0_43ck182 = 0.9 time = 915
.meas tran vdout0_43ck182 FIND v(dout0_43) AT=915.025n

* CHECK dout0_44 Vdout0_44ck182 = 0 time = 915
.meas tran vdout0_44ck182 FIND v(dout0_44) AT=915.025n

* CHECK dout0_45 Vdout0_45ck182 = 0 time = 915
.meas tran vdout0_45ck182 FIND v(dout0_45) AT=915.025n

* CHECK dout0_46 Vdout0_46ck182 = 0.9 time = 915
.meas tran vdout0_46ck182 FIND v(dout0_46) AT=915.025n

* CHECK dout0_47 Vdout0_47ck182 = 0 time = 915
.meas tran vdout0_47ck182 FIND v(dout0_47) AT=915.025n

* CHECK dout0_48 Vdout0_48ck182 = 0.9 time = 915
.meas tran vdout0_48ck182 FIND v(dout0_48) AT=915.025n

* CHECK dout0_49 Vdout0_49ck182 = 0.9 time = 915
.meas tran vdout0_49ck182 FIND v(dout0_49) AT=915.025n

* CHECK dout0_50 Vdout0_50ck182 = 0 time = 915
.meas tran vdout0_50ck182 FIND v(dout0_50) AT=915.025n

* CHECK dout0_51 Vdout0_51ck182 = 0.9 time = 915
.meas tran vdout0_51ck182 FIND v(dout0_51) AT=915.025n

* CHECK dout0_52 Vdout0_52ck182 = 0.9 time = 915
.meas tran vdout0_52ck182 FIND v(dout0_52) AT=915.025n

* CHECK dout0_53 Vdout0_53ck182 = 0.9 time = 915
.meas tran vdout0_53ck182 FIND v(dout0_53) AT=915.025n

* CHECK dout0_54 Vdout0_54ck182 = 0 time = 915
.meas tran vdout0_54ck182 FIND v(dout0_54) AT=915.025n

* CHECK dout0_55 Vdout0_55ck182 = 0.9 time = 915
.meas tran vdout0_55ck182 FIND v(dout0_55) AT=915.025n

* CHECK dout0_56 Vdout0_56ck182 = 0.9 time = 915
.meas tran vdout0_56ck182 FIND v(dout0_56) AT=915.025n

* CHECK dout0_57 Vdout0_57ck182 = 0.9 time = 915
.meas tran vdout0_57ck182 FIND v(dout0_57) AT=915.025n

* CHECK dout0_58 Vdout0_58ck182 = 0.9 time = 915
.meas tran vdout0_58ck182 FIND v(dout0_58) AT=915.025n

* CHECK dout0_59 Vdout0_59ck182 = 0.9 time = 915
.meas tran vdout0_59ck182 FIND v(dout0_59) AT=915.025n

* CHECK dout0_60 Vdout0_60ck182 = 0 time = 915
.meas tran vdout0_60ck182 FIND v(dout0_60) AT=915.025n

* CHECK dout0_61 Vdout0_61ck182 = 0.9 time = 915
.meas tran vdout0_61ck182 FIND v(dout0_61) AT=915.025n

* CHECK dout0_62 Vdout0_62ck182 = 0 time = 915
.meas tran vdout0_62ck182 FIND v(dout0_62) AT=915.025n

* CHECK dout0_63 Vdout0_63ck182 = 0.9 time = 915
.meas tran vdout0_63ck182 FIND v(dout0_63) AT=915.025n

* CHECK dout0_0 Vdout0_0ck183 = 0 time = 920
.meas tran vdout0_0ck183 FIND v(dout0_0) AT=920.025n

* CHECK dout0_1 Vdout0_1ck183 = 0.9 time = 920
.meas tran vdout0_1ck183 FIND v(dout0_1) AT=920.025n

* CHECK dout0_2 Vdout0_2ck183 = 0.9 time = 920
.meas tran vdout0_2ck183 FIND v(dout0_2) AT=920.025n

* CHECK dout0_3 Vdout0_3ck183 = 0 time = 920
.meas tran vdout0_3ck183 FIND v(dout0_3) AT=920.025n

* CHECK dout0_4 Vdout0_4ck183 = 0.9 time = 920
.meas tran vdout0_4ck183 FIND v(dout0_4) AT=920.025n

* CHECK dout0_5 Vdout0_5ck183 = 0 time = 920
.meas tran vdout0_5ck183 FIND v(dout0_5) AT=920.025n

* CHECK dout0_6 Vdout0_6ck183 = 0 time = 920
.meas tran vdout0_6ck183 FIND v(dout0_6) AT=920.025n

* CHECK dout0_7 Vdout0_7ck183 = 0 time = 920
.meas tran vdout0_7ck183 FIND v(dout0_7) AT=920.025n

* CHECK dout0_8 Vdout0_8ck183 = 0.9 time = 920
.meas tran vdout0_8ck183 FIND v(dout0_8) AT=920.025n

* CHECK dout0_9 Vdout0_9ck183 = 0.9 time = 920
.meas tran vdout0_9ck183 FIND v(dout0_9) AT=920.025n

* CHECK dout0_10 Vdout0_10ck183 = 0 time = 920
.meas tran vdout0_10ck183 FIND v(dout0_10) AT=920.025n

* CHECK dout0_11 Vdout0_11ck183 = 0.9 time = 920
.meas tran vdout0_11ck183 FIND v(dout0_11) AT=920.025n

* CHECK dout0_12 Vdout0_12ck183 = 0.9 time = 920
.meas tran vdout0_12ck183 FIND v(dout0_12) AT=920.025n

* CHECK dout0_13 Vdout0_13ck183 = 0 time = 920
.meas tran vdout0_13ck183 FIND v(dout0_13) AT=920.025n

* CHECK dout0_14 Vdout0_14ck183 = 0 time = 920
.meas tran vdout0_14ck183 FIND v(dout0_14) AT=920.025n

* CHECK dout0_15 Vdout0_15ck183 = 0.9 time = 920
.meas tran vdout0_15ck183 FIND v(dout0_15) AT=920.025n

* CHECK dout0_16 Vdout0_16ck183 = 0 time = 920
.meas tran vdout0_16ck183 FIND v(dout0_16) AT=920.025n

* CHECK dout0_17 Vdout0_17ck183 = 0 time = 920
.meas tran vdout0_17ck183 FIND v(dout0_17) AT=920.025n

* CHECK dout0_18 Vdout0_18ck183 = 0 time = 920
.meas tran vdout0_18ck183 FIND v(dout0_18) AT=920.025n

* CHECK dout0_19 Vdout0_19ck183 = 0.9 time = 920
.meas tran vdout0_19ck183 FIND v(dout0_19) AT=920.025n

* CHECK dout0_20 Vdout0_20ck183 = 0.9 time = 920
.meas tran vdout0_20ck183 FIND v(dout0_20) AT=920.025n

* CHECK dout0_21 Vdout0_21ck183 = 0 time = 920
.meas tran vdout0_21ck183 FIND v(dout0_21) AT=920.025n

* CHECK dout0_22 Vdout0_22ck183 = 0 time = 920
.meas tran vdout0_22ck183 FIND v(dout0_22) AT=920.025n

* CHECK dout0_23 Vdout0_23ck183 = 0 time = 920
.meas tran vdout0_23ck183 FIND v(dout0_23) AT=920.025n

* CHECK dout0_24 Vdout0_24ck183 = 0.9 time = 920
.meas tran vdout0_24ck183 FIND v(dout0_24) AT=920.025n

* CHECK dout0_25 Vdout0_25ck183 = 0 time = 920
.meas tran vdout0_25ck183 FIND v(dout0_25) AT=920.025n

* CHECK dout0_26 Vdout0_26ck183 = 0.9 time = 920
.meas tran vdout0_26ck183 FIND v(dout0_26) AT=920.025n

* CHECK dout0_27 Vdout0_27ck183 = 0 time = 920
.meas tran vdout0_27ck183 FIND v(dout0_27) AT=920.025n

* CHECK dout0_28 Vdout0_28ck183 = 0 time = 920
.meas tran vdout0_28ck183 FIND v(dout0_28) AT=920.025n

* CHECK dout0_29 Vdout0_29ck183 = 0.9 time = 920
.meas tran vdout0_29ck183 FIND v(dout0_29) AT=920.025n

* CHECK dout0_30 Vdout0_30ck183 = 0 time = 920
.meas tran vdout0_30ck183 FIND v(dout0_30) AT=920.025n

* CHECK dout0_31 Vdout0_31ck183 = 0 time = 920
.meas tran vdout0_31ck183 FIND v(dout0_31) AT=920.025n

* CHECK dout0_32 Vdout0_32ck183 = 0.9 time = 920
.meas tran vdout0_32ck183 FIND v(dout0_32) AT=920.025n

* CHECK dout0_33 Vdout0_33ck183 = 0.9 time = 920
.meas tran vdout0_33ck183 FIND v(dout0_33) AT=920.025n

* CHECK dout0_34 Vdout0_34ck183 = 0.9 time = 920
.meas tran vdout0_34ck183 FIND v(dout0_34) AT=920.025n

* CHECK dout0_35 Vdout0_35ck183 = 0 time = 920
.meas tran vdout0_35ck183 FIND v(dout0_35) AT=920.025n

* CHECK dout0_36 Vdout0_36ck183 = 0 time = 920
.meas tran vdout0_36ck183 FIND v(dout0_36) AT=920.025n

* CHECK dout0_37 Vdout0_37ck183 = 0 time = 920
.meas tran vdout0_37ck183 FIND v(dout0_37) AT=920.025n

* CHECK dout0_38 Vdout0_38ck183 = 0 time = 920
.meas tran vdout0_38ck183 FIND v(dout0_38) AT=920.025n

* CHECK dout0_39 Vdout0_39ck183 = 0.9 time = 920
.meas tran vdout0_39ck183 FIND v(dout0_39) AT=920.025n

* CHECK dout0_40 Vdout0_40ck183 = 0 time = 920
.meas tran vdout0_40ck183 FIND v(dout0_40) AT=920.025n

* CHECK dout0_41 Vdout0_41ck183 = 0.9 time = 920
.meas tran vdout0_41ck183 FIND v(dout0_41) AT=920.025n

* CHECK dout0_42 Vdout0_42ck183 = 0.9 time = 920
.meas tran vdout0_42ck183 FIND v(dout0_42) AT=920.025n

* CHECK dout0_43 Vdout0_43ck183 = 0 time = 920
.meas tran vdout0_43ck183 FIND v(dout0_43) AT=920.025n

* CHECK dout0_44 Vdout0_44ck183 = 0 time = 920
.meas tran vdout0_44ck183 FIND v(dout0_44) AT=920.025n

* CHECK dout0_45 Vdout0_45ck183 = 0 time = 920
.meas tran vdout0_45ck183 FIND v(dout0_45) AT=920.025n

* CHECK dout0_46 Vdout0_46ck183 = 0.9 time = 920
.meas tran vdout0_46ck183 FIND v(dout0_46) AT=920.025n

* CHECK dout0_47 Vdout0_47ck183 = 0.9 time = 920
.meas tran vdout0_47ck183 FIND v(dout0_47) AT=920.025n

* CHECK dout0_48 Vdout0_48ck183 = 0 time = 920
.meas tran vdout0_48ck183 FIND v(dout0_48) AT=920.025n

* CHECK dout0_49 Vdout0_49ck183 = 0 time = 920
.meas tran vdout0_49ck183 FIND v(dout0_49) AT=920.025n

* CHECK dout0_50 Vdout0_50ck183 = 0.9 time = 920
.meas tran vdout0_50ck183 FIND v(dout0_50) AT=920.025n

* CHECK dout0_51 Vdout0_51ck183 = 0.9 time = 920
.meas tran vdout0_51ck183 FIND v(dout0_51) AT=920.025n

* CHECK dout0_52 Vdout0_52ck183 = 0 time = 920
.meas tran vdout0_52ck183 FIND v(dout0_52) AT=920.025n

* CHECK dout0_53 Vdout0_53ck183 = 0 time = 920
.meas tran vdout0_53ck183 FIND v(dout0_53) AT=920.025n

* CHECK dout0_54 Vdout0_54ck183 = 0.9 time = 920
.meas tran vdout0_54ck183 FIND v(dout0_54) AT=920.025n

* CHECK dout0_55 Vdout0_55ck183 = 0.9 time = 920
.meas tran vdout0_55ck183 FIND v(dout0_55) AT=920.025n

* CHECK dout0_56 Vdout0_56ck183 = 0.9 time = 920
.meas tran vdout0_56ck183 FIND v(dout0_56) AT=920.025n

* CHECK dout0_57 Vdout0_57ck183 = 0.9 time = 920
.meas tran vdout0_57ck183 FIND v(dout0_57) AT=920.025n

* CHECK dout0_58 Vdout0_58ck183 = 0.9 time = 920
.meas tran vdout0_58ck183 FIND v(dout0_58) AT=920.025n

* CHECK dout0_59 Vdout0_59ck183 = 0 time = 920
.meas tran vdout0_59ck183 FIND v(dout0_59) AT=920.025n

* CHECK dout0_60 Vdout0_60ck183 = 0 time = 920
.meas tran vdout0_60ck183 FIND v(dout0_60) AT=920.025n

* CHECK dout0_61 Vdout0_61ck183 = 0.9 time = 920
.meas tran vdout0_61ck183 FIND v(dout0_61) AT=920.025n

* CHECK dout0_62 Vdout0_62ck183 = 0 time = 920
.meas tran vdout0_62ck183 FIND v(dout0_62) AT=920.025n

* CHECK dout0_63 Vdout0_63ck183 = 0 time = 920
.meas tran vdout0_63ck183 FIND v(dout0_63) AT=920.025n

* CHECK dout0_0 Vdout0_0ck187 = 0.9 time = 940
.meas tran vdout0_0ck187 FIND v(dout0_0) AT=940.025n

* CHECK dout0_1 Vdout0_1ck187 = 0.9 time = 940
.meas tran vdout0_1ck187 FIND v(dout0_1) AT=940.025n

* CHECK dout0_2 Vdout0_2ck187 = 0.9 time = 940
.meas tran vdout0_2ck187 FIND v(dout0_2) AT=940.025n

* CHECK dout0_3 Vdout0_3ck187 = 0 time = 940
.meas tran vdout0_3ck187 FIND v(dout0_3) AT=940.025n

* CHECK dout0_4 Vdout0_4ck187 = 0.9 time = 940
.meas tran vdout0_4ck187 FIND v(dout0_4) AT=940.025n

* CHECK dout0_5 Vdout0_5ck187 = 0 time = 940
.meas tran vdout0_5ck187 FIND v(dout0_5) AT=940.025n

* CHECK dout0_6 Vdout0_6ck187 = 0 time = 940
.meas tran vdout0_6ck187 FIND v(dout0_6) AT=940.025n

* CHECK dout0_7 Vdout0_7ck187 = 0 time = 940
.meas tran vdout0_7ck187 FIND v(dout0_7) AT=940.025n

* CHECK dout0_8 Vdout0_8ck187 = 0.9 time = 940
.meas tran vdout0_8ck187 FIND v(dout0_8) AT=940.025n

* CHECK dout0_9 Vdout0_9ck187 = 0.9 time = 940
.meas tran vdout0_9ck187 FIND v(dout0_9) AT=940.025n

* CHECK dout0_10 Vdout0_10ck187 = 0.9 time = 940
.meas tran vdout0_10ck187 FIND v(dout0_10) AT=940.025n

* CHECK dout0_11 Vdout0_11ck187 = 0.9 time = 940
.meas tran vdout0_11ck187 FIND v(dout0_11) AT=940.025n

* CHECK dout0_12 Vdout0_12ck187 = 0.9 time = 940
.meas tran vdout0_12ck187 FIND v(dout0_12) AT=940.025n

* CHECK dout0_13 Vdout0_13ck187 = 0.9 time = 940
.meas tran vdout0_13ck187 FIND v(dout0_13) AT=940.025n

* CHECK dout0_14 Vdout0_14ck187 = 0.9 time = 940
.meas tran vdout0_14ck187 FIND v(dout0_14) AT=940.025n

* CHECK dout0_15 Vdout0_15ck187 = 0 time = 940
.meas tran vdout0_15ck187 FIND v(dout0_15) AT=940.025n

* CHECK dout0_16 Vdout0_16ck187 = 0.9 time = 940
.meas tran vdout0_16ck187 FIND v(dout0_16) AT=940.025n

* CHECK dout0_17 Vdout0_17ck187 = 0 time = 940
.meas tran vdout0_17ck187 FIND v(dout0_17) AT=940.025n

* CHECK dout0_18 Vdout0_18ck187 = 0 time = 940
.meas tran vdout0_18ck187 FIND v(dout0_18) AT=940.025n

* CHECK dout0_19 Vdout0_19ck187 = 0 time = 940
.meas tran vdout0_19ck187 FIND v(dout0_19) AT=940.025n

* CHECK dout0_20 Vdout0_20ck187 = 0.9 time = 940
.meas tran vdout0_20ck187 FIND v(dout0_20) AT=940.025n

* CHECK dout0_21 Vdout0_21ck187 = 0.9 time = 940
.meas tran vdout0_21ck187 FIND v(dout0_21) AT=940.025n

* CHECK dout0_22 Vdout0_22ck187 = 0.9 time = 940
.meas tran vdout0_22ck187 FIND v(dout0_22) AT=940.025n

* CHECK dout0_23 Vdout0_23ck187 = 0 time = 940
.meas tran vdout0_23ck187 FIND v(dout0_23) AT=940.025n

* CHECK dout0_24 Vdout0_24ck187 = 0.9 time = 940
.meas tran vdout0_24ck187 FIND v(dout0_24) AT=940.025n

* CHECK dout0_25 Vdout0_25ck187 = 0.9 time = 940
.meas tran vdout0_25ck187 FIND v(dout0_25) AT=940.025n

* CHECK dout0_26 Vdout0_26ck187 = 0.9 time = 940
.meas tran vdout0_26ck187 FIND v(dout0_26) AT=940.025n

* CHECK dout0_27 Vdout0_27ck187 = 0.9 time = 940
.meas tran vdout0_27ck187 FIND v(dout0_27) AT=940.025n

* CHECK dout0_28 Vdout0_28ck187 = 0.9 time = 940
.meas tran vdout0_28ck187 FIND v(dout0_28) AT=940.025n

* CHECK dout0_29 Vdout0_29ck187 = 0 time = 940
.meas tran vdout0_29ck187 FIND v(dout0_29) AT=940.025n

* CHECK dout0_30 Vdout0_30ck187 = 0 time = 940
.meas tran vdout0_30ck187 FIND v(dout0_30) AT=940.025n

* CHECK dout0_31 Vdout0_31ck187 = 0.9 time = 940
.meas tran vdout0_31ck187 FIND v(dout0_31) AT=940.025n

* CHECK dout0_32 Vdout0_32ck187 = 0 time = 940
.meas tran vdout0_32ck187 FIND v(dout0_32) AT=940.025n

* CHECK dout0_33 Vdout0_33ck187 = 0 time = 940
.meas tran vdout0_33ck187 FIND v(dout0_33) AT=940.025n

* CHECK dout0_34 Vdout0_34ck187 = 0 time = 940
.meas tran vdout0_34ck187 FIND v(dout0_34) AT=940.025n

* CHECK dout0_35 Vdout0_35ck187 = 0 time = 940
.meas tran vdout0_35ck187 FIND v(dout0_35) AT=940.025n

* CHECK dout0_36 Vdout0_36ck187 = 0 time = 940
.meas tran vdout0_36ck187 FIND v(dout0_36) AT=940.025n

* CHECK dout0_37 Vdout0_37ck187 = 0 time = 940
.meas tran vdout0_37ck187 FIND v(dout0_37) AT=940.025n

* CHECK dout0_38 Vdout0_38ck187 = 0 time = 940
.meas tran vdout0_38ck187 FIND v(dout0_38) AT=940.025n

* CHECK dout0_39 Vdout0_39ck187 = 0 time = 940
.meas tran vdout0_39ck187 FIND v(dout0_39) AT=940.025n

* CHECK dout0_40 Vdout0_40ck187 = 0.9 time = 940
.meas tran vdout0_40ck187 FIND v(dout0_40) AT=940.025n

* CHECK dout0_41 Vdout0_41ck187 = 0.9 time = 940
.meas tran vdout0_41ck187 FIND v(dout0_41) AT=940.025n

* CHECK dout0_42 Vdout0_42ck187 = 0.9 time = 940
.meas tran vdout0_42ck187 FIND v(dout0_42) AT=940.025n

* CHECK dout0_43 Vdout0_43ck187 = 0.9 time = 940
.meas tran vdout0_43ck187 FIND v(dout0_43) AT=940.025n

* CHECK dout0_44 Vdout0_44ck187 = 0.9 time = 940
.meas tran vdout0_44ck187 FIND v(dout0_44) AT=940.025n

* CHECK dout0_45 Vdout0_45ck187 = 0 time = 940
.meas tran vdout0_45ck187 FIND v(dout0_45) AT=940.025n

* CHECK dout0_46 Vdout0_46ck187 = 0.9 time = 940
.meas tran vdout0_46ck187 FIND v(dout0_46) AT=940.025n

* CHECK dout0_47 Vdout0_47ck187 = 0 time = 940
.meas tran vdout0_47ck187 FIND v(dout0_47) AT=940.025n

* CHECK dout0_48 Vdout0_48ck187 = 0 time = 940
.meas tran vdout0_48ck187 FIND v(dout0_48) AT=940.025n

* CHECK dout0_49 Vdout0_49ck187 = 0.9 time = 940
.meas tran vdout0_49ck187 FIND v(dout0_49) AT=940.025n

* CHECK dout0_50 Vdout0_50ck187 = 0 time = 940
.meas tran vdout0_50ck187 FIND v(dout0_50) AT=940.025n

* CHECK dout0_51 Vdout0_51ck187 = 0 time = 940
.meas tran vdout0_51ck187 FIND v(dout0_51) AT=940.025n

* CHECK dout0_52 Vdout0_52ck187 = 0.9 time = 940
.meas tran vdout0_52ck187 FIND v(dout0_52) AT=940.025n

* CHECK dout0_53 Vdout0_53ck187 = 0 time = 940
.meas tran vdout0_53ck187 FIND v(dout0_53) AT=940.025n

* CHECK dout0_54 Vdout0_54ck187 = 0.9 time = 940
.meas tran vdout0_54ck187 FIND v(dout0_54) AT=940.025n

* CHECK dout0_55 Vdout0_55ck187 = 0.9 time = 940
.meas tran vdout0_55ck187 FIND v(dout0_55) AT=940.025n

* CHECK dout0_56 Vdout0_56ck187 = 0.9 time = 940
.meas tran vdout0_56ck187 FIND v(dout0_56) AT=940.025n

* CHECK dout0_57 Vdout0_57ck187 = 0 time = 940
.meas tran vdout0_57ck187 FIND v(dout0_57) AT=940.025n

* CHECK dout0_58 Vdout0_58ck187 = 0 time = 940
.meas tran vdout0_58ck187 FIND v(dout0_58) AT=940.025n

* CHECK dout0_59 Vdout0_59ck187 = 0 time = 940
.meas tran vdout0_59ck187 FIND v(dout0_59) AT=940.025n

* CHECK dout0_60 Vdout0_60ck187 = 0 time = 940
.meas tran vdout0_60ck187 FIND v(dout0_60) AT=940.025n

* CHECK dout0_61 Vdout0_61ck187 = 0 time = 940
.meas tran vdout0_61ck187 FIND v(dout0_61) AT=940.025n

* CHECK dout0_62 Vdout0_62ck187 = 0 time = 940
.meas tran vdout0_62ck187 FIND v(dout0_62) AT=940.025n

* CHECK dout0_63 Vdout0_63ck187 = 0 time = 940
.meas tran vdout0_63ck187 FIND v(dout0_63) AT=940.025n

* CHECK dout0_0 Vdout0_0ck191 = 0.9 time = 960
.meas tran vdout0_0ck191 FIND v(dout0_0) AT=960.025n

* CHECK dout0_1 Vdout0_1ck191 = 0 time = 960
.meas tran vdout0_1ck191 FIND v(dout0_1) AT=960.025n

* CHECK dout0_2 Vdout0_2ck191 = 0 time = 960
.meas tran vdout0_2ck191 FIND v(dout0_2) AT=960.025n

* CHECK dout0_3 Vdout0_3ck191 = 0 time = 960
.meas tran vdout0_3ck191 FIND v(dout0_3) AT=960.025n

* CHECK dout0_4 Vdout0_4ck191 = 0 time = 960
.meas tran vdout0_4ck191 FIND v(dout0_4) AT=960.025n

* CHECK dout0_5 Vdout0_5ck191 = 0.9 time = 960
.meas tran vdout0_5ck191 FIND v(dout0_5) AT=960.025n

* CHECK dout0_6 Vdout0_6ck191 = 0.9 time = 960
.meas tran vdout0_6ck191 FIND v(dout0_6) AT=960.025n

* CHECK dout0_7 Vdout0_7ck191 = 0 time = 960
.meas tran vdout0_7ck191 FIND v(dout0_7) AT=960.025n

* CHECK dout0_8 Vdout0_8ck191 = 0.9 time = 960
.meas tran vdout0_8ck191 FIND v(dout0_8) AT=960.025n

* CHECK dout0_9 Vdout0_9ck191 = 0 time = 960
.meas tran vdout0_9ck191 FIND v(dout0_9) AT=960.025n

* CHECK dout0_10 Vdout0_10ck191 = 0 time = 960
.meas tran vdout0_10ck191 FIND v(dout0_10) AT=960.025n

* CHECK dout0_11 Vdout0_11ck191 = 0.9 time = 960
.meas tran vdout0_11ck191 FIND v(dout0_11) AT=960.025n

* CHECK dout0_12 Vdout0_12ck191 = 0.9 time = 960
.meas tran vdout0_12ck191 FIND v(dout0_12) AT=960.025n

* CHECK dout0_13 Vdout0_13ck191 = 0.9 time = 960
.meas tran vdout0_13ck191 FIND v(dout0_13) AT=960.025n

* CHECK dout0_14 Vdout0_14ck191 = 0.9 time = 960
.meas tran vdout0_14ck191 FIND v(dout0_14) AT=960.025n

* CHECK dout0_15 Vdout0_15ck191 = 0 time = 960
.meas tran vdout0_15ck191 FIND v(dout0_15) AT=960.025n

* CHECK dout0_16 Vdout0_16ck191 = 0 time = 960
.meas tran vdout0_16ck191 FIND v(dout0_16) AT=960.025n

* CHECK dout0_17 Vdout0_17ck191 = 0 time = 960
.meas tran vdout0_17ck191 FIND v(dout0_17) AT=960.025n

* CHECK dout0_18 Vdout0_18ck191 = 0.9 time = 960
.meas tran vdout0_18ck191 FIND v(dout0_18) AT=960.025n

* CHECK dout0_19 Vdout0_19ck191 = 0.9 time = 960
.meas tran vdout0_19ck191 FIND v(dout0_19) AT=960.025n

* CHECK dout0_20 Vdout0_20ck191 = 0 time = 960
.meas tran vdout0_20ck191 FIND v(dout0_20) AT=960.025n

* CHECK dout0_21 Vdout0_21ck191 = 0.9 time = 960
.meas tran vdout0_21ck191 FIND v(dout0_21) AT=960.025n

* CHECK dout0_22 Vdout0_22ck191 = 0.9 time = 960
.meas tran vdout0_22ck191 FIND v(dout0_22) AT=960.025n

* CHECK dout0_23 Vdout0_23ck191 = 0 time = 960
.meas tran vdout0_23ck191 FIND v(dout0_23) AT=960.025n

* CHECK dout0_24 Vdout0_24ck191 = 0 time = 960
.meas tran vdout0_24ck191 FIND v(dout0_24) AT=960.025n

* CHECK dout0_25 Vdout0_25ck191 = 0.9 time = 960
.meas tran vdout0_25ck191 FIND v(dout0_25) AT=960.025n

* CHECK dout0_26 Vdout0_26ck191 = 0.9 time = 960
.meas tran vdout0_26ck191 FIND v(dout0_26) AT=960.025n

* CHECK dout0_27 Vdout0_27ck191 = 0 time = 960
.meas tran vdout0_27ck191 FIND v(dout0_27) AT=960.025n

* CHECK dout0_28 Vdout0_28ck191 = 0 time = 960
.meas tran vdout0_28ck191 FIND v(dout0_28) AT=960.025n

* CHECK dout0_29 Vdout0_29ck191 = 0 time = 960
.meas tran vdout0_29ck191 FIND v(dout0_29) AT=960.025n

* CHECK dout0_30 Vdout0_30ck191 = 0.9 time = 960
.meas tran vdout0_30ck191 FIND v(dout0_30) AT=960.025n

* CHECK dout0_31 Vdout0_31ck191 = 0 time = 960
.meas tran vdout0_31ck191 FIND v(dout0_31) AT=960.025n

* CHECK dout0_32 Vdout0_32ck191 = 0 time = 960
.meas tran vdout0_32ck191 FIND v(dout0_32) AT=960.025n

* CHECK dout0_33 Vdout0_33ck191 = 0 time = 960
.meas tran vdout0_33ck191 FIND v(dout0_33) AT=960.025n

* CHECK dout0_34 Vdout0_34ck191 = 0 time = 960
.meas tran vdout0_34ck191 FIND v(dout0_34) AT=960.025n

* CHECK dout0_35 Vdout0_35ck191 = 0.9 time = 960
.meas tran vdout0_35ck191 FIND v(dout0_35) AT=960.025n

* CHECK dout0_36 Vdout0_36ck191 = 0 time = 960
.meas tran vdout0_36ck191 FIND v(dout0_36) AT=960.025n

* CHECK dout0_37 Vdout0_37ck191 = 0.9 time = 960
.meas tran vdout0_37ck191 FIND v(dout0_37) AT=960.025n

* CHECK dout0_38 Vdout0_38ck191 = 0.9 time = 960
.meas tran vdout0_38ck191 FIND v(dout0_38) AT=960.025n

* CHECK dout0_39 Vdout0_39ck191 = 0.9 time = 960
.meas tran vdout0_39ck191 FIND v(dout0_39) AT=960.025n

* CHECK dout0_40 Vdout0_40ck191 = 0.9 time = 960
.meas tran vdout0_40ck191 FIND v(dout0_40) AT=960.025n

* CHECK dout0_41 Vdout0_41ck191 = 0 time = 960
.meas tran vdout0_41ck191 FIND v(dout0_41) AT=960.025n

* CHECK dout0_42 Vdout0_42ck191 = 0.9 time = 960
.meas tran vdout0_42ck191 FIND v(dout0_42) AT=960.025n

* CHECK dout0_43 Vdout0_43ck191 = 0 time = 960
.meas tran vdout0_43ck191 FIND v(dout0_43) AT=960.025n

* CHECK dout0_44 Vdout0_44ck191 = 0.9 time = 960
.meas tran vdout0_44ck191 FIND v(dout0_44) AT=960.025n

* CHECK dout0_45 Vdout0_45ck191 = 0.9 time = 960
.meas tran vdout0_45ck191 FIND v(dout0_45) AT=960.025n

* CHECK dout0_46 Vdout0_46ck191 = 0 time = 960
.meas tran vdout0_46ck191 FIND v(dout0_46) AT=960.025n

* CHECK dout0_47 Vdout0_47ck191 = 0 time = 960
.meas tran vdout0_47ck191 FIND v(dout0_47) AT=960.025n

* CHECK dout0_48 Vdout0_48ck191 = 0 time = 960
.meas tran vdout0_48ck191 FIND v(dout0_48) AT=960.025n

* CHECK dout0_49 Vdout0_49ck191 = 0 time = 960
.meas tran vdout0_49ck191 FIND v(dout0_49) AT=960.025n

* CHECK dout0_50 Vdout0_50ck191 = 0.9 time = 960
.meas tran vdout0_50ck191 FIND v(dout0_50) AT=960.025n

* CHECK dout0_51 Vdout0_51ck191 = 0.9 time = 960
.meas tran vdout0_51ck191 FIND v(dout0_51) AT=960.025n

* CHECK dout0_52 Vdout0_52ck191 = 0 time = 960
.meas tran vdout0_52ck191 FIND v(dout0_52) AT=960.025n

* CHECK dout0_53 Vdout0_53ck191 = 0.9 time = 960
.meas tran vdout0_53ck191 FIND v(dout0_53) AT=960.025n

* CHECK dout0_54 Vdout0_54ck191 = 0 time = 960
.meas tran vdout0_54ck191 FIND v(dout0_54) AT=960.025n

* CHECK dout0_55 Vdout0_55ck191 = 0 time = 960
.meas tran vdout0_55ck191 FIND v(dout0_55) AT=960.025n

* CHECK dout0_56 Vdout0_56ck191 = 0 time = 960
.meas tran vdout0_56ck191 FIND v(dout0_56) AT=960.025n

* CHECK dout0_57 Vdout0_57ck191 = 0 time = 960
.meas tran vdout0_57ck191 FIND v(dout0_57) AT=960.025n

* CHECK dout0_58 Vdout0_58ck191 = 0 time = 960
.meas tran vdout0_58ck191 FIND v(dout0_58) AT=960.025n

* CHECK dout0_59 Vdout0_59ck191 = 0 time = 960
.meas tran vdout0_59ck191 FIND v(dout0_59) AT=960.025n

* CHECK dout0_60 Vdout0_60ck191 = 0.9 time = 960
.meas tran vdout0_60ck191 FIND v(dout0_60) AT=960.025n

* CHECK dout0_61 Vdout0_61ck191 = 0 time = 960
.meas tran vdout0_61ck191 FIND v(dout0_61) AT=960.025n

* CHECK dout0_62 Vdout0_62ck191 = 0 time = 960
.meas tran vdout0_62ck191 FIND v(dout0_62) AT=960.025n

* CHECK dout0_63 Vdout0_63ck191 = 0 time = 960
.meas tran vdout0_63ck191 FIND v(dout0_63) AT=960.025n

* CHECK dout0_0 Vdout0_0ck192 = 0 time = 965
.meas tran vdout0_0ck192 FIND v(dout0_0) AT=965.025n

* CHECK dout0_1 Vdout0_1ck192 = 0 time = 965
.meas tran vdout0_1ck192 FIND v(dout0_1) AT=965.025n

* CHECK dout0_2 Vdout0_2ck192 = 0 time = 965
.meas tran vdout0_2ck192 FIND v(dout0_2) AT=965.025n

* CHECK dout0_3 Vdout0_3ck192 = 0.9 time = 965
.meas tran vdout0_3ck192 FIND v(dout0_3) AT=965.025n

* CHECK dout0_4 Vdout0_4ck192 = 0 time = 965
.meas tran vdout0_4ck192 FIND v(dout0_4) AT=965.025n

* CHECK dout0_5 Vdout0_5ck192 = 0.9 time = 965
.meas tran vdout0_5ck192 FIND v(dout0_5) AT=965.025n

* CHECK dout0_6 Vdout0_6ck192 = 0.9 time = 965
.meas tran vdout0_6ck192 FIND v(dout0_6) AT=965.025n

* CHECK dout0_7 Vdout0_7ck192 = 0 time = 965
.meas tran vdout0_7ck192 FIND v(dout0_7) AT=965.025n

* CHECK dout0_8 Vdout0_8ck192 = 0 time = 965
.meas tran vdout0_8ck192 FIND v(dout0_8) AT=965.025n

* CHECK dout0_9 Vdout0_9ck192 = 0 time = 965
.meas tran vdout0_9ck192 FIND v(dout0_9) AT=965.025n

* CHECK dout0_10 Vdout0_10ck192 = 0.9 time = 965
.meas tran vdout0_10ck192 FIND v(dout0_10) AT=965.025n

* CHECK dout0_11 Vdout0_11ck192 = 0.9 time = 965
.meas tran vdout0_11ck192 FIND v(dout0_11) AT=965.025n

* CHECK dout0_12 Vdout0_12ck192 = 0.9 time = 965
.meas tran vdout0_12ck192 FIND v(dout0_12) AT=965.025n

* CHECK dout0_13 Vdout0_13ck192 = 0.9 time = 965
.meas tran vdout0_13ck192 FIND v(dout0_13) AT=965.025n

* CHECK dout0_14 Vdout0_14ck192 = 0 time = 965
.meas tran vdout0_14ck192 FIND v(dout0_14) AT=965.025n

* CHECK dout0_15 Vdout0_15ck192 = 0.9 time = 965
.meas tran vdout0_15ck192 FIND v(dout0_15) AT=965.025n

* CHECK dout0_16 Vdout0_16ck192 = 0 time = 965
.meas tran vdout0_16ck192 FIND v(dout0_16) AT=965.025n

* CHECK dout0_17 Vdout0_17ck192 = 0 time = 965
.meas tran vdout0_17ck192 FIND v(dout0_17) AT=965.025n

* CHECK dout0_18 Vdout0_18ck192 = 0.9 time = 965
.meas tran vdout0_18ck192 FIND v(dout0_18) AT=965.025n

* CHECK dout0_19 Vdout0_19ck192 = 0.9 time = 965
.meas tran vdout0_19ck192 FIND v(dout0_19) AT=965.025n

* CHECK dout0_20 Vdout0_20ck192 = 0 time = 965
.meas tran vdout0_20ck192 FIND v(dout0_20) AT=965.025n

* CHECK dout0_21 Vdout0_21ck192 = 0 time = 965
.meas tran vdout0_21ck192 FIND v(dout0_21) AT=965.025n

* CHECK dout0_22 Vdout0_22ck192 = 0.9 time = 965
.meas tran vdout0_22ck192 FIND v(dout0_22) AT=965.025n

* CHECK dout0_23 Vdout0_23ck192 = 0 time = 965
.meas tran vdout0_23ck192 FIND v(dout0_23) AT=965.025n

* CHECK dout0_24 Vdout0_24ck192 = 0.9 time = 965
.meas tran vdout0_24ck192 FIND v(dout0_24) AT=965.025n

* CHECK dout0_25 Vdout0_25ck192 = 0.9 time = 965
.meas tran vdout0_25ck192 FIND v(dout0_25) AT=965.025n

* CHECK dout0_26 Vdout0_26ck192 = 0 time = 965
.meas tran vdout0_26ck192 FIND v(dout0_26) AT=965.025n

* CHECK dout0_27 Vdout0_27ck192 = 0 time = 965
.meas tran vdout0_27ck192 FIND v(dout0_27) AT=965.025n

* CHECK dout0_28 Vdout0_28ck192 = 0 time = 965
.meas tran vdout0_28ck192 FIND v(dout0_28) AT=965.025n

* CHECK dout0_29 Vdout0_29ck192 = 0 time = 965
.meas tran vdout0_29ck192 FIND v(dout0_29) AT=965.025n

* CHECK dout0_30 Vdout0_30ck192 = 0 time = 965
.meas tran vdout0_30ck192 FIND v(dout0_30) AT=965.025n

* CHECK dout0_31 Vdout0_31ck192 = 0 time = 965
.meas tran vdout0_31ck192 FIND v(dout0_31) AT=965.025n

* CHECK dout0_32 Vdout0_32ck192 = 0 time = 965
.meas tran vdout0_32ck192 FIND v(dout0_32) AT=965.025n

* CHECK dout0_33 Vdout0_33ck192 = 0.9 time = 965
.meas tran vdout0_33ck192 FIND v(dout0_33) AT=965.025n

* CHECK dout0_34 Vdout0_34ck192 = 0 time = 965
.meas tran vdout0_34ck192 FIND v(dout0_34) AT=965.025n

* CHECK dout0_35 Vdout0_35ck192 = 0 time = 965
.meas tran vdout0_35ck192 FIND v(dout0_35) AT=965.025n

* CHECK dout0_36 Vdout0_36ck192 = 0 time = 965
.meas tran vdout0_36ck192 FIND v(dout0_36) AT=965.025n

* CHECK dout0_37 Vdout0_37ck192 = 0.9 time = 965
.meas tran vdout0_37ck192 FIND v(dout0_37) AT=965.025n

* CHECK dout0_38 Vdout0_38ck192 = 0 time = 965
.meas tran vdout0_38ck192 FIND v(dout0_38) AT=965.025n

* CHECK dout0_39 Vdout0_39ck192 = 0 time = 965
.meas tran vdout0_39ck192 FIND v(dout0_39) AT=965.025n

* CHECK dout0_40 Vdout0_40ck192 = 0.9 time = 965
.meas tran vdout0_40ck192 FIND v(dout0_40) AT=965.025n

* CHECK dout0_41 Vdout0_41ck192 = 0.9 time = 965
.meas tran vdout0_41ck192 FIND v(dout0_41) AT=965.025n

* CHECK dout0_42 Vdout0_42ck192 = 0 time = 965
.meas tran vdout0_42ck192 FIND v(dout0_42) AT=965.025n

* CHECK dout0_43 Vdout0_43ck192 = 0 time = 965
.meas tran vdout0_43ck192 FIND v(dout0_43) AT=965.025n

* CHECK dout0_44 Vdout0_44ck192 = 0 time = 965
.meas tran vdout0_44ck192 FIND v(dout0_44) AT=965.025n

* CHECK dout0_45 Vdout0_45ck192 = 0 time = 965
.meas tran vdout0_45ck192 FIND v(dout0_45) AT=965.025n

* CHECK dout0_46 Vdout0_46ck192 = 0 time = 965
.meas tran vdout0_46ck192 FIND v(dout0_46) AT=965.025n

* CHECK dout0_47 Vdout0_47ck192 = 0 time = 965
.meas tran vdout0_47ck192 FIND v(dout0_47) AT=965.025n

* CHECK dout0_48 Vdout0_48ck192 = 0.9 time = 965
.meas tran vdout0_48ck192 FIND v(dout0_48) AT=965.025n

* CHECK dout0_49 Vdout0_49ck192 = 0 time = 965
.meas tran vdout0_49ck192 FIND v(dout0_49) AT=965.025n

* CHECK dout0_50 Vdout0_50ck192 = 0 time = 965
.meas tran vdout0_50ck192 FIND v(dout0_50) AT=965.025n

* CHECK dout0_51 Vdout0_51ck192 = 0 time = 965
.meas tran vdout0_51ck192 FIND v(dout0_51) AT=965.025n

* CHECK dout0_52 Vdout0_52ck192 = 0.9 time = 965
.meas tran vdout0_52ck192 FIND v(dout0_52) AT=965.025n

* CHECK dout0_53 Vdout0_53ck192 = 0.9 time = 965
.meas tran vdout0_53ck192 FIND v(dout0_53) AT=965.025n

* CHECK dout0_54 Vdout0_54ck192 = 0.9 time = 965
.meas tran vdout0_54ck192 FIND v(dout0_54) AT=965.025n

* CHECK dout0_55 Vdout0_55ck192 = 0.9 time = 965
.meas tran vdout0_55ck192 FIND v(dout0_55) AT=965.025n

* CHECK dout0_56 Vdout0_56ck192 = 0.9 time = 965
.meas tran vdout0_56ck192 FIND v(dout0_56) AT=965.025n

* CHECK dout0_57 Vdout0_57ck192 = 0 time = 965
.meas tran vdout0_57ck192 FIND v(dout0_57) AT=965.025n

* CHECK dout0_58 Vdout0_58ck192 = 0 time = 965
.meas tran vdout0_58ck192 FIND v(dout0_58) AT=965.025n

* CHECK dout0_59 Vdout0_59ck192 = 0.9 time = 965
.meas tran vdout0_59ck192 FIND v(dout0_59) AT=965.025n

* CHECK dout0_60 Vdout0_60ck192 = 0.9 time = 965
.meas tran vdout0_60ck192 FIND v(dout0_60) AT=965.025n

* CHECK dout0_61 Vdout0_61ck192 = 0 time = 965
.meas tran vdout0_61ck192 FIND v(dout0_61) AT=965.025n

* CHECK dout0_62 Vdout0_62ck192 = 0 time = 965
.meas tran vdout0_62ck192 FIND v(dout0_62) AT=965.025n

* CHECK dout0_63 Vdout0_63ck192 = 0.9 time = 965
.meas tran vdout0_63ck192 FIND v(dout0_63) AT=965.025n

* CHECK dout0_0 Vdout0_0ck193 = 0 time = 970
.meas tran vdout0_0ck193 FIND v(dout0_0) AT=970.025n

* CHECK dout0_1 Vdout0_1ck193 = 0.9 time = 970
.meas tran vdout0_1ck193 FIND v(dout0_1) AT=970.025n

* CHECK dout0_2 Vdout0_2ck193 = 0.9 time = 970
.meas tran vdout0_2ck193 FIND v(dout0_2) AT=970.025n

* CHECK dout0_3 Vdout0_3ck193 = 0 time = 970
.meas tran vdout0_3ck193 FIND v(dout0_3) AT=970.025n

* CHECK dout0_4 Vdout0_4ck193 = 0.9 time = 970
.meas tran vdout0_4ck193 FIND v(dout0_4) AT=970.025n

* CHECK dout0_5 Vdout0_5ck193 = 0 time = 970
.meas tran vdout0_5ck193 FIND v(dout0_5) AT=970.025n

* CHECK dout0_6 Vdout0_6ck193 = 0 time = 970
.meas tran vdout0_6ck193 FIND v(dout0_6) AT=970.025n

* CHECK dout0_7 Vdout0_7ck193 = 0 time = 970
.meas tran vdout0_7ck193 FIND v(dout0_7) AT=970.025n

* CHECK dout0_8 Vdout0_8ck193 = 0.9 time = 970
.meas tran vdout0_8ck193 FIND v(dout0_8) AT=970.025n

* CHECK dout0_9 Vdout0_9ck193 = 0.9 time = 970
.meas tran vdout0_9ck193 FIND v(dout0_9) AT=970.025n

* CHECK dout0_10 Vdout0_10ck193 = 0 time = 970
.meas tran vdout0_10ck193 FIND v(dout0_10) AT=970.025n

* CHECK dout0_11 Vdout0_11ck193 = 0.9 time = 970
.meas tran vdout0_11ck193 FIND v(dout0_11) AT=970.025n

* CHECK dout0_12 Vdout0_12ck193 = 0.9 time = 970
.meas tran vdout0_12ck193 FIND v(dout0_12) AT=970.025n

* CHECK dout0_13 Vdout0_13ck193 = 0 time = 970
.meas tran vdout0_13ck193 FIND v(dout0_13) AT=970.025n

* CHECK dout0_14 Vdout0_14ck193 = 0 time = 970
.meas tran vdout0_14ck193 FIND v(dout0_14) AT=970.025n

* CHECK dout0_15 Vdout0_15ck193 = 0.9 time = 970
.meas tran vdout0_15ck193 FIND v(dout0_15) AT=970.025n

* CHECK dout0_16 Vdout0_16ck193 = 0 time = 970
.meas tran vdout0_16ck193 FIND v(dout0_16) AT=970.025n

* CHECK dout0_17 Vdout0_17ck193 = 0 time = 970
.meas tran vdout0_17ck193 FIND v(dout0_17) AT=970.025n

* CHECK dout0_18 Vdout0_18ck193 = 0 time = 970
.meas tran vdout0_18ck193 FIND v(dout0_18) AT=970.025n

* CHECK dout0_19 Vdout0_19ck193 = 0.9 time = 970
.meas tran vdout0_19ck193 FIND v(dout0_19) AT=970.025n

* CHECK dout0_20 Vdout0_20ck193 = 0.9 time = 970
.meas tran vdout0_20ck193 FIND v(dout0_20) AT=970.025n

* CHECK dout0_21 Vdout0_21ck193 = 0 time = 970
.meas tran vdout0_21ck193 FIND v(dout0_21) AT=970.025n

* CHECK dout0_22 Vdout0_22ck193 = 0 time = 970
.meas tran vdout0_22ck193 FIND v(dout0_22) AT=970.025n

* CHECK dout0_23 Vdout0_23ck193 = 0 time = 970
.meas tran vdout0_23ck193 FIND v(dout0_23) AT=970.025n

* CHECK dout0_24 Vdout0_24ck193 = 0.9 time = 970
.meas tran vdout0_24ck193 FIND v(dout0_24) AT=970.025n

* CHECK dout0_25 Vdout0_25ck193 = 0 time = 970
.meas tran vdout0_25ck193 FIND v(dout0_25) AT=970.025n

* CHECK dout0_26 Vdout0_26ck193 = 0.9 time = 970
.meas tran vdout0_26ck193 FIND v(dout0_26) AT=970.025n

* CHECK dout0_27 Vdout0_27ck193 = 0 time = 970
.meas tran vdout0_27ck193 FIND v(dout0_27) AT=970.025n

* CHECK dout0_28 Vdout0_28ck193 = 0 time = 970
.meas tran vdout0_28ck193 FIND v(dout0_28) AT=970.025n

* CHECK dout0_29 Vdout0_29ck193 = 0.9 time = 970
.meas tran vdout0_29ck193 FIND v(dout0_29) AT=970.025n

* CHECK dout0_30 Vdout0_30ck193 = 0 time = 970
.meas tran vdout0_30ck193 FIND v(dout0_30) AT=970.025n

* CHECK dout0_31 Vdout0_31ck193 = 0 time = 970
.meas tran vdout0_31ck193 FIND v(dout0_31) AT=970.025n

* CHECK dout0_32 Vdout0_32ck193 = 0.9 time = 970
.meas tran vdout0_32ck193 FIND v(dout0_32) AT=970.025n

* CHECK dout0_33 Vdout0_33ck193 = 0.9 time = 970
.meas tran vdout0_33ck193 FIND v(dout0_33) AT=970.025n

* CHECK dout0_34 Vdout0_34ck193 = 0.9 time = 970
.meas tran vdout0_34ck193 FIND v(dout0_34) AT=970.025n

* CHECK dout0_35 Vdout0_35ck193 = 0 time = 970
.meas tran vdout0_35ck193 FIND v(dout0_35) AT=970.025n

* CHECK dout0_36 Vdout0_36ck193 = 0 time = 970
.meas tran vdout0_36ck193 FIND v(dout0_36) AT=970.025n

* CHECK dout0_37 Vdout0_37ck193 = 0 time = 970
.meas tran vdout0_37ck193 FIND v(dout0_37) AT=970.025n

* CHECK dout0_38 Vdout0_38ck193 = 0 time = 970
.meas tran vdout0_38ck193 FIND v(dout0_38) AT=970.025n

* CHECK dout0_39 Vdout0_39ck193 = 0.9 time = 970
.meas tran vdout0_39ck193 FIND v(dout0_39) AT=970.025n

* CHECK dout0_40 Vdout0_40ck193 = 0 time = 970
.meas tran vdout0_40ck193 FIND v(dout0_40) AT=970.025n

* CHECK dout0_41 Vdout0_41ck193 = 0.9 time = 970
.meas tran vdout0_41ck193 FIND v(dout0_41) AT=970.025n

* CHECK dout0_42 Vdout0_42ck193 = 0.9 time = 970
.meas tran vdout0_42ck193 FIND v(dout0_42) AT=970.025n

* CHECK dout0_43 Vdout0_43ck193 = 0 time = 970
.meas tran vdout0_43ck193 FIND v(dout0_43) AT=970.025n

* CHECK dout0_44 Vdout0_44ck193 = 0 time = 970
.meas tran vdout0_44ck193 FIND v(dout0_44) AT=970.025n

* CHECK dout0_45 Vdout0_45ck193 = 0 time = 970
.meas tran vdout0_45ck193 FIND v(dout0_45) AT=970.025n

* CHECK dout0_46 Vdout0_46ck193 = 0.9 time = 970
.meas tran vdout0_46ck193 FIND v(dout0_46) AT=970.025n

* CHECK dout0_47 Vdout0_47ck193 = 0.9 time = 970
.meas tran vdout0_47ck193 FIND v(dout0_47) AT=970.025n

* CHECK dout0_48 Vdout0_48ck193 = 0 time = 970
.meas tran vdout0_48ck193 FIND v(dout0_48) AT=970.025n

* CHECK dout0_49 Vdout0_49ck193 = 0 time = 970
.meas tran vdout0_49ck193 FIND v(dout0_49) AT=970.025n

* CHECK dout0_50 Vdout0_50ck193 = 0.9 time = 970
.meas tran vdout0_50ck193 FIND v(dout0_50) AT=970.025n

* CHECK dout0_51 Vdout0_51ck193 = 0.9 time = 970
.meas tran vdout0_51ck193 FIND v(dout0_51) AT=970.025n

* CHECK dout0_52 Vdout0_52ck193 = 0 time = 970
.meas tran vdout0_52ck193 FIND v(dout0_52) AT=970.025n

* CHECK dout0_53 Vdout0_53ck193 = 0 time = 970
.meas tran vdout0_53ck193 FIND v(dout0_53) AT=970.025n

* CHECK dout0_54 Vdout0_54ck193 = 0.9 time = 970
.meas tran vdout0_54ck193 FIND v(dout0_54) AT=970.025n

* CHECK dout0_55 Vdout0_55ck193 = 0.9 time = 970
.meas tran vdout0_55ck193 FIND v(dout0_55) AT=970.025n

* CHECK dout0_56 Vdout0_56ck193 = 0.9 time = 970
.meas tran vdout0_56ck193 FIND v(dout0_56) AT=970.025n

* CHECK dout0_57 Vdout0_57ck193 = 0.9 time = 970
.meas tran vdout0_57ck193 FIND v(dout0_57) AT=970.025n

* CHECK dout0_58 Vdout0_58ck193 = 0.9 time = 970
.meas tran vdout0_58ck193 FIND v(dout0_58) AT=970.025n

* CHECK dout0_59 Vdout0_59ck193 = 0 time = 970
.meas tran vdout0_59ck193 FIND v(dout0_59) AT=970.025n

* CHECK dout0_60 Vdout0_60ck193 = 0 time = 970
.meas tran vdout0_60ck193 FIND v(dout0_60) AT=970.025n

* CHECK dout0_61 Vdout0_61ck193 = 0.9 time = 970
.meas tran vdout0_61ck193 FIND v(dout0_61) AT=970.025n

* CHECK dout0_62 Vdout0_62ck193 = 0 time = 970
.meas tran vdout0_62ck193 FIND v(dout0_62) AT=970.025n

* CHECK dout0_63 Vdout0_63ck193 = 0 time = 970
.meas tran vdout0_63ck193 FIND v(dout0_63) AT=970.025n

* CHECK dout0_0 Vdout0_0ck194 = 0 time = 975
.meas tran vdout0_0ck194 FIND v(dout0_0) AT=975.025n

* CHECK dout0_1 Vdout0_1ck194 = 0.9 time = 975
.meas tran vdout0_1ck194 FIND v(dout0_1) AT=975.025n

* CHECK dout0_2 Vdout0_2ck194 = 0.9 time = 975
.meas tran vdout0_2ck194 FIND v(dout0_2) AT=975.025n

* CHECK dout0_3 Vdout0_3ck194 = 0 time = 975
.meas tran vdout0_3ck194 FIND v(dout0_3) AT=975.025n

* CHECK dout0_4 Vdout0_4ck194 = 0.9 time = 975
.meas tran vdout0_4ck194 FIND v(dout0_4) AT=975.025n

* CHECK dout0_5 Vdout0_5ck194 = 0 time = 975
.meas tran vdout0_5ck194 FIND v(dout0_5) AT=975.025n

* CHECK dout0_6 Vdout0_6ck194 = 0 time = 975
.meas tran vdout0_6ck194 FIND v(dout0_6) AT=975.025n

* CHECK dout0_7 Vdout0_7ck194 = 0 time = 975
.meas tran vdout0_7ck194 FIND v(dout0_7) AT=975.025n

* CHECK dout0_8 Vdout0_8ck194 = 0.9 time = 975
.meas tran vdout0_8ck194 FIND v(dout0_8) AT=975.025n

* CHECK dout0_9 Vdout0_9ck194 = 0.9 time = 975
.meas tran vdout0_9ck194 FIND v(dout0_9) AT=975.025n

* CHECK dout0_10 Vdout0_10ck194 = 0 time = 975
.meas tran vdout0_10ck194 FIND v(dout0_10) AT=975.025n

* CHECK dout0_11 Vdout0_11ck194 = 0.9 time = 975
.meas tran vdout0_11ck194 FIND v(dout0_11) AT=975.025n

* CHECK dout0_12 Vdout0_12ck194 = 0.9 time = 975
.meas tran vdout0_12ck194 FIND v(dout0_12) AT=975.025n

* CHECK dout0_13 Vdout0_13ck194 = 0 time = 975
.meas tran vdout0_13ck194 FIND v(dout0_13) AT=975.025n

* CHECK dout0_14 Vdout0_14ck194 = 0 time = 975
.meas tran vdout0_14ck194 FIND v(dout0_14) AT=975.025n

* CHECK dout0_15 Vdout0_15ck194 = 0.9 time = 975
.meas tran vdout0_15ck194 FIND v(dout0_15) AT=975.025n

* CHECK dout0_16 Vdout0_16ck194 = 0 time = 975
.meas tran vdout0_16ck194 FIND v(dout0_16) AT=975.025n

* CHECK dout0_17 Vdout0_17ck194 = 0 time = 975
.meas tran vdout0_17ck194 FIND v(dout0_17) AT=975.025n

* CHECK dout0_18 Vdout0_18ck194 = 0 time = 975
.meas tran vdout0_18ck194 FIND v(dout0_18) AT=975.025n

* CHECK dout0_19 Vdout0_19ck194 = 0.9 time = 975
.meas tran vdout0_19ck194 FIND v(dout0_19) AT=975.025n

* CHECK dout0_20 Vdout0_20ck194 = 0.9 time = 975
.meas tran vdout0_20ck194 FIND v(dout0_20) AT=975.025n

* CHECK dout0_21 Vdout0_21ck194 = 0 time = 975
.meas tran vdout0_21ck194 FIND v(dout0_21) AT=975.025n

* CHECK dout0_22 Vdout0_22ck194 = 0 time = 975
.meas tran vdout0_22ck194 FIND v(dout0_22) AT=975.025n

* CHECK dout0_23 Vdout0_23ck194 = 0 time = 975
.meas tran vdout0_23ck194 FIND v(dout0_23) AT=975.025n

* CHECK dout0_24 Vdout0_24ck194 = 0.9 time = 975
.meas tran vdout0_24ck194 FIND v(dout0_24) AT=975.025n

* CHECK dout0_25 Vdout0_25ck194 = 0 time = 975
.meas tran vdout0_25ck194 FIND v(dout0_25) AT=975.025n

* CHECK dout0_26 Vdout0_26ck194 = 0.9 time = 975
.meas tran vdout0_26ck194 FIND v(dout0_26) AT=975.025n

* CHECK dout0_27 Vdout0_27ck194 = 0 time = 975
.meas tran vdout0_27ck194 FIND v(dout0_27) AT=975.025n

* CHECK dout0_28 Vdout0_28ck194 = 0 time = 975
.meas tran vdout0_28ck194 FIND v(dout0_28) AT=975.025n

* CHECK dout0_29 Vdout0_29ck194 = 0.9 time = 975
.meas tran vdout0_29ck194 FIND v(dout0_29) AT=975.025n

* CHECK dout0_30 Vdout0_30ck194 = 0 time = 975
.meas tran vdout0_30ck194 FIND v(dout0_30) AT=975.025n

* CHECK dout0_31 Vdout0_31ck194 = 0 time = 975
.meas tran vdout0_31ck194 FIND v(dout0_31) AT=975.025n

* CHECK dout0_32 Vdout0_32ck194 = 0.9 time = 975
.meas tran vdout0_32ck194 FIND v(dout0_32) AT=975.025n

* CHECK dout0_33 Vdout0_33ck194 = 0.9 time = 975
.meas tran vdout0_33ck194 FIND v(dout0_33) AT=975.025n

* CHECK dout0_34 Vdout0_34ck194 = 0.9 time = 975
.meas tran vdout0_34ck194 FIND v(dout0_34) AT=975.025n

* CHECK dout0_35 Vdout0_35ck194 = 0 time = 975
.meas tran vdout0_35ck194 FIND v(dout0_35) AT=975.025n

* CHECK dout0_36 Vdout0_36ck194 = 0 time = 975
.meas tran vdout0_36ck194 FIND v(dout0_36) AT=975.025n

* CHECK dout0_37 Vdout0_37ck194 = 0 time = 975
.meas tran vdout0_37ck194 FIND v(dout0_37) AT=975.025n

* CHECK dout0_38 Vdout0_38ck194 = 0 time = 975
.meas tran vdout0_38ck194 FIND v(dout0_38) AT=975.025n

* CHECK dout0_39 Vdout0_39ck194 = 0.9 time = 975
.meas tran vdout0_39ck194 FIND v(dout0_39) AT=975.025n

* CHECK dout0_40 Vdout0_40ck194 = 0 time = 975
.meas tran vdout0_40ck194 FIND v(dout0_40) AT=975.025n

* CHECK dout0_41 Vdout0_41ck194 = 0.9 time = 975
.meas tran vdout0_41ck194 FIND v(dout0_41) AT=975.025n

* CHECK dout0_42 Vdout0_42ck194 = 0.9 time = 975
.meas tran vdout0_42ck194 FIND v(dout0_42) AT=975.025n

* CHECK dout0_43 Vdout0_43ck194 = 0 time = 975
.meas tran vdout0_43ck194 FIND v(dout0_43) AT=975.025n

* CHECK dout0_44 Vdout0_44ck194 = 0 time = 975
.meas tran vdout0_44ck194 FIND v(dout0_44) AT=975.025n

* CHECK dout0_45 Vdout0_45ck194 = 0 time = 975
.meas tran vdout0_45ck194 FIND v(dout0_45) AT=975.025n

* CHECK dout0_46 Vdout0_46ck194 = 0.9 time = 975
.meas tran vdout0_46ck194 FIND v(dout0_46) AT=975.025n

* CHECK dout0_47 Vdout0_47ck194 = 0.9 time = 975
.meas tran vdout0_47ck194 FIND v(dout0_47) AT=975.025n

* CHECK dout0_48 Vdout0_48ck194 = 0 time = 975
.meas tran vdout0_48ck194 FIND v(dout0_48) AT=975.025n

* CHECK dout0_49 Vdout0_49ck194 = 0 time = 975
.meas tran vdout0_49ck194 FIND v(dout0_49) AT=975.025n

* CHECK dout0_50 Vdout0_50ck194 = 0.9 time = 975
.meas tran vdout0_50ck194 FIND v(dout0_50) AT=975.025n

* CHECK dout0_51 Vdout0_51ck194 = 0.9 time = 975
.meas tran vdout0_51ck194 FIND v(dout0_51) AT=975.025n

* CHECK dout0_52 Vdout0_52ck194 = 0 time = 975
.meas tran vdout0_52ck194 FIND v(dout0_52) AT=975.025n

* CHECK dout0_53 Vdout0_53ck194 = 0 time = 975
.meas tran vdout0_53ck194 FIND v(dout0_53) AT=975.025n

* CHECK dout0_54 Vdout0_54ck194 = 0.9 time = 975
.meas tran vdout0_54ck194 FIND v(dout0_54) AT=975.025n

* CHECK dout0_55 Vdout0_55ck194 = 0.9 time = 975
.meas tran vdout0_55ck194 FIND v(dout0_55) AT=975.025n

* CHECK dout0_56 Vdout0_56ck194 = 0.9 time = 975
.meas tran vdout0_56ck194 FIND v(dout0_56) AT=975.025n

* CHECK dout0_57 Vdout0_57ck194 = 0.9 time = 975
.meas tran vdout0_57ck194 FIND v(dout0_57) AT=975.025n

* CHECK dout0_58 Vdout0_58ck194 = 0.9 time = 975
.meas tran vdout0_58ck194 FIND v(dout0_58) AT=975.025n

* CHECK dout0_59 Vdout0_59ck194 = 0 time = 975
.meas tran vdout0_59ck194 FIND v(dout0_59) AT=975.025n

* CHECK dout0_60 Vdout0_60ck194 = 0 time = 975
.meas tran vdout0_60ck194 FIND v(dout0_60) AT=975.025n

* CHECK dout0_61 Vdout0_61ck194 = 0.9 time = 975
.meas tran vdout0_61ck194 FIND v(dout0_61) AT=975.025n

* CHECK dout0_62 Vdout0_62ck194 = 0 time = 975
.meas tran vdout0_62ck194 FIND v(dout0_62) AT=975.025n

* CHECK dout0_63 Vdout0_63ck194 = 0 time = 975
.meas tran vdout0_63ck194 FIND v(dout0_63) AT=975.025n

* CHECK dout0_0 Vdout0_0ck196 = 0 time = 985
.meas tran vdout0_0ck196 FIND v(dout0_0) AT=985.025n

* CHECK dout0_1 Vdout0_1ck196 = 0.9 time = 985
.meas tran vdout0_1ck196 FIND v(dout0_1) AT=985.025n

* CHECK dout0_2 Vdout0_2ck196 = 0.9 time = 985
.meas tran vdout0_2ck196 FIND v(dout0_2) AT=985.025n

* CHECK dout0_3 Vdout0_3ck196 = 0 time = 985
.meas tran vdout0_3ck196 FIND v(dout0_3) AT=985.025n

* CHECK dout0_4 Vdout0_4ck196 = 0.9 time = 985
.meas tran vdout0_4ck196 FIND v(dout0_4) AT=985.025n

* CHECK dout0_5 Vdout0_5ck196 = 0 time = 985
.meas tran vdout0_5ck196 FIND v(dout0_5) AT=985.025n

* CHECK dout0_6 Vdout0_6ck196 = 0 time = 985
.meas tran vdout0_6ck196 FIND v(dout0_6) AT=985.025n

* CHECK dout0_7 Vdout0_7ck196 = 0 time = 985
.meas tran vdout0_7ck196 FIND v(dout0_7) AT=985.025n

* CHECK dout0_8 Vdout0_8ck196 = 0.9 time = 985
.meas tran vdout0_8ck196 FIND v(dout0_8) AT=985.025n

* CHECK dout0_9 Vdout0_9ck196 = 0.9 time = 985
.meas tran vdout0_9ck196 FIND v(dout0_9) AT=985.025n

* CHECK dout0_10 Vdout0_10ck196 = 0 time = 985
.meas tran vdout0_10ck196 FIND v(dout0_10) AT=985.025n

* CHECK dout0_11 Vdout0_11ck196 = 0.9 time = 985
.meas tran vdout0_11ck196 FIND v(dout0_11) AT=985.025n

* CHECK dout0_12 Vdout0_12ck196 = 0.9 time = 985
.meas tran vdout0_12ck196 FIND v(dout0_12) AT=985.025n

* CHECK dout0_13 Vdout0_13ck196 = 0 time = 985
.meas tran vdout0_13ck196 FIND v(dout0_13) AT=985.025n

* CHECK dout0_14 Vdout0_14ck196 = 0 time = 985
.meas tran vdout0_14ck196 FIND v(dout0_14) AT=985.025n

* CHECK dout0_15 Vdout0_15ck196 = 0.9 time = 985
.meas tran vdout0_15ck196 FIND v(dout0_15) AT=985.025n

* CHECK dout0_16 Vdout0_16ck196 = 0 time = 985
.meas tran vdout0_16ck196 FIND v(dout0_16) AT=985.025n

* CHECK dout0_17 Vdout0_17ck196 = 0 time = 985
.meas tran vdout0_17ck196 FIND v(dout0_17) AT=985.025n

* CHECK dout0_18 Vdout0_18ck196 = 0 time = 985
.meas tran vdout0_18ck196 FIND v(dout0_18) AT=985.025n

* CHECK dout0_19 Vdout0_19ck196 = 0.9 time = 985
.meas tran vdout0_19ck196 FIND v(dout0_19) AT=985.025n

* CHECK dout0_20 Vdout0_20ck196 = 0.9 time = 985
.meas tran vdout0_20ck196 FIND v(dout0_20) AT=985.025n

* CHECK dout0_21 Vdout0_21ck196 = 0 time = 985
.meas tran vdout0_21ck196 FIND v(dout0_21) AT=985.025n

* CHECK dout0_22 Vdout0_22ck196 = 0 time = 985
.meas tran vdout0_22ck196 FIND v(dout0_22) AT=985.025n

* CHECK dout0_23 Vdout0_23ck196 = 0 time = 985
.meas tran vdout0_23ck196 FIND v(dout0_23) AT=985.025n

* CHECK dout0_24 Vdout0_24ck196 = 0.9 time = 985
.meas tran vdout0_24ck196 FIND v(dout0_24) AT=985.025n

* CHECK dout0_25 Vdout0_25ck196 = 0 time = 985
.meas tran vdout0_25ck196 FIND v(dout0_25) AT=985.025n

* CHECK dout0_26 Vdout0_26ck196 = 0.9 time = 985
.meas tran vdout0_26ck196 FIND v(dout0_26) AT=985.025n

* CHECK dout0_27 Vdout0_27ck196 = 0 time = 985
.meas tran vdout0_27ck196 FIND v(dout0_27) AT=985.025n

* CHECK dout0_28 Vdout0_28ck196 = 0 time = 985
.meas tran vdout0_28ck196 FIND v(dout0_28) AT=985.025n

* CHECK dout0_29 Vdout0_29ck196 = 0.9 time = 985
.meas tran vdout0_29ck196 FIND v(dout0_29) AT=985.025n

* CHECK dout0_30 Vdout0_30ck196 = 0 time = 985
.meas tran vdout0_30ck196 FIND v(dout0_30) AT=985.025n

* CHECK dout0_31 Vdout0_31ck196 = 0 time = 985
.meas tran vdout0_31ck196 FIND v(dout0_31) AT=985.025n

* CHECK dout0_32 Vdout0_32ck196 = 0.9 time = 985
.meas tran vdout0_32ck196 FIND v(dout0_32) AT=985.025n

* CHECK dout0_33 Vdout0_33ck196 = 0.9 time = 985
.meas tran vdout0_33ck196 FIND v(dout0_33) AT=985.025n

* CHECK dout0_34 Vdout0_34ck196 = 0.9 time = 985
.meas tran vdout0_34ck196 FIND v(dout0_34) AT=985.025n

* CHECK dout0_35 Vdout0_35ck196 = 0 time = 985
.meas tran vdout0_35ck196 FIND v(dout0_35) AT=985.025n

* CHECK dout0_36 Vdout0_36ck196 = 0 time = 985
.meas tran vdout0_36ck196 FIND v(dout0_36) AT=985.025n

* CHECK dout0_37 Vdout0_37ck196 = 0 time = 985
.meas tran vdout0_37ck196 FIND v(dout0_37) AT=985.025n

* CHECK dout0_38 Vdout0_38ck196 = 0 time = 985
.meas tran vdout0_38ck196 FIND v(dout0_38) AT=985.025n

* CHECK dout0_39 Vdout0_39ck196 = 0.9 time = 985
.meas tran vdout0_39ck196 FIND v(dout0_39) AT=985.025n

* CHECK dout0_40 Vdout0_40ck196 = 0 time = 985
.meas tran vdout0_40ck196 FIND v(dout0_40) AT=985.025n

* CHECK dout0_41 Vdout0_41ck196 = 0.9 time = 985
.meas tran vdout0_41ck196 FIND v(dout0_41) AT=985.025n

* CHECK dout0_42 Vdout0_42ck196 = 0.9 time = 985
.meas tran vdout0_42ck196 FIND v(dout0_42) AT=985.025n

* CHECK dout0_43 Vdout0_43ck196 = 0 time = 985
.meas tran vdout0_43ck196 FIND v(dout0_43) AT=985.025n

* CHECK dout0_44 Vdout0_44ck196 = 0 time = 985
.meas tran vdout0_44ck196 FIND v(dout0_44) AT=985.025n

* CHECK dout0_45 Vdout0_45ck196 = 0 time = 985
.meas tran vdout0_45ck196 FIND v(dout0_45) AT=985.025n

* CHECK dout0_46 Vdout0_46ck196 = 0.9 time = 985
.meas tran vdout0_46ck196 FIND v(dout0_46) AT=985.025n

* CHECK dout0_47 Vdout0_47ck196 = 0.9 time = 985
.meas tran vdout0_47ck196 FIND v(dout0_47) AT=985.025n

* CHECK dout0_48 Vdout0_48ck196 = 0 time = 985
.meas tran vdout0_48ck196 FIND v(dout0_48) AT=985.025n

* CHECK dout0_49 Vdout0_49ck196 = 0 time = 985
.meas tran vdout0_49ck196 FIND v(dout0_49) AT=985.025n

* CHECK dout0_50 Vdout0_50ck196 = 0.9 time = 985
.meas tran vdout0_50ck196 FIND v(dout0_50) AT=985.025n

* CHECK dout0_51 Vdout0_51ck196 = 0.9 time = 985
.meas tran vdout0_51ck196 FIND v(dout0_51) AT=985.025n

* CHECK dout0_52 Vdout0_52ck196 = 0 time = 985
.meas tran vdout0_52ck196 FIND v(dout0_52) AT=985.025n

* CHECK dout0_53 Vdout0_53ck196 = 0 time = 985
.meas tran vdout0_53ck196 FIND v(dout0_53) AT=985.025n

* CHECK dout0_54 Vdout0_54ck196 = 0.9 time = 985
.meas tran vdout0_54ck196 FIND v(dout0_54) AT=985.025n

* CHECK dout0_55 Vdout0_55ck196 = 0.9 time = 985
.meas tran vdout0_55ck196 FIND v(dout0_55) AT=985.025n

* CHECK dout0_56 Vdout0_56ck196 = 0.9 time = 985
.meas tran vdout0_56ck196 FIND v(dout0_56) AT=985.025n

* CHECK dout0_57 Vdout0_57ck196 = 0.9 time = 985
.meas tran vdout0_57ck196 FIND v(dout0_57) AT=985.025n

* CHECK dout0_58 Vdout0_58ck196 = 0.9 time = 985
.meas tran vdout0_58ck196 FIND v(dout0_58) AT=985.025n

* CHECK dout0_59 Vdout0_59ck196 = 0 time = 985
.meas tran vdout0_59ck196 FIND v(dout0_59) AT=985.025n

* CHECK dout0_60 Vdout0_60ck196 = 0 time = 985
.meas tran vdout0_60ck196 FIND v(dout0_60) AT=985.025n

* CHECK dout0_61 Vdout0_61ck196 = 0.9 time = 985
.meas tran vdout0_61ck196 FIND v(dout0_61) AT=985.025n

* CHECK dout0_62 Vdout0_62ck196 = 0 time = 985
.meas tran vdout0_62ck196 FIND v(dout0_62) AT=985.025n

* CHECK dout0_63 Vdout0_63ck196 = 0 time = 985
.meas tran vdout0_63ck196 FIND v(dout0_63) AT=985.025n

* CHECK dout0_0 Vdout0_0ck202 = 0.9 time = 1015
.meas tran vdout0_0ck202 FIND v(dout0_0) AT=1015.025n

* CHECK dout0_1 Vdout0_1ck202 = 0 time = 1015
.meas tran vdout0_1ck202 FIND v(dout0_1) AT=1015.025n

* CHECK dout0_2 Vdout0_2ck202 = 0.9 time = 1015
.meas tran vdout0_2ck202 FIND v(dout0_2) AT=1015.025n

* CHECK dout0_3 Vdout0_3ck202 = 0.9 time = 1015
.meas tran vdout0_3ck202 FIND v(dout0_3) AT=1015.025n

* CHECK dout0_4 Vdout0_4ck202 = 0.9 time = 1015
.meas tran vdout0_4ck202 FIND v(dout0_4) AT=1015.025n

* CHECK dout0_5 Vdout0_5ck202 = 0 time = 1015
.meas tran vdout0_5ck202 FIND v(dout0_5) AT=1015.025n

* CHECK dout0_6 Vdout0_6ck202 = 0.9 time = 1015
.meas tran vdout0_6ck202 FIND v(dout0_6) AT=1015.025n

* CHECK dout0_7 Vdout0_7ck202 = 0 time = 1015
.meas tran vdout0_7ck202 FIND v(dout0_7) AT=1015.025n

* CHECK dout0_8 Vdout0_8ck202 = 0.9 time = 1015
.meas tran vdout0_8ck202 FIND v(dout0_8) AT=1015.025n

* CHECK dout0_9 Vdout0_9ck202 = 0.9 time = 1015
.meas tran vdout0_9ck202 FIND v(dout0_9) AT=1015.025n

* CHECK dout0_10 Vdout0_10ck202 = 0.9 time = 1015
.meas tran vdout0_10ck202 FIND v(dout0_10) AT=1015.025n

* CHECK dout0_11 Vdout0_11ck202 = 0.9 time = 1015
.meas tran vdout0_11ck202 FIND v(dout0_11) AT=1015.025n

* CHECK dout0_12 Vdout0_12ck202 = 0.9 time = 1015
.meas tran vdout0_12ck202 FIND v(dout0_12) AT=1015.025n

* CHECK dout0_13 Vdout0_13ck202 = 0.9 time = 1015
.meas tran vdout0_13ck202 FIND v(dout0_13) AT=1015.025n

* CHECK dout0_14 Vdout0_14ck202 = 0 time = 1015
.meas tran vdout0_14ck202 FIND v(dout0_14) AT=1015.025n

* CHECK dout0_15 Vdout0_15ck202 = 0.9 time = 1015
.meas tran vdout0_15ck202 FIND v(dout0_15) AT=1015.025n

* CHECK dout0_16 Vdout0_16ck202 = 0 time = 1015
.meas tran vdout0_16ck202 FIND v(dout0_16) AT=1015.025n

* CHECK dout0_17 Vdout0_17ck202 = 0 time = 1015
.meas tran vdout0_17ck202 FIND v(dout0_17) AT=1015.025n

* CHECK dout0_18 Vdout0_18ck202 = 0 time = 1015
.meas tran vdout0_18ck202 FIND v(dout0_18) AT=1015.025n

* CHECK dout0_19 Vdout0_19ck202 = 0 time = 1015
.meas tran vdout0_19ck202 FIND v(dout0_19) AT=1015.025n

* CHECK dout0_20 Vdout0_20ck202 = 0 time = 1015
.meas tran vdout0_20ck202 FIND v(dout0_20) AT=1015.025n

* CHECK dout0_21 Vdout0_21ck202 = 0 time = 1015
.meas tran vdout0_21ck202 FIND v(dout0_21) AT=1015.025n

* CHECK dout0_22 Vdout0_22ck202 = 0.9 time = 1015
.meas tran vdout0_22ck202 FIND v(dout0_22) AT=1015.025n

* CHECK dout0_23 Vdout0_23ck202 = 0 time = 1015
.meas tran vdout0_23ck202 FIND v(dout0_23) AT=1015.025n

* CHECK dout0_24 Vdout0_24ck202 = 0 time = 1015
.meas tran vdout0_24ck202 FIND v(dout0_24) AT=1015.025n

* CHECK dout0_25 Vdout0_25ck202 = 0 time = 1015
.meas tran vdout0_25ck202 FIND v(dout0_25) AT=1015.025n

* CHECK dout0_26 Vdout0_26ck202 = 0 time = 1015
.meas tran vdout0_26ck202 FIND v(dout0_26) AT=1015.025n

* CHECK dout0_27 Vdout0_27ck202 = 0.9 time = 1015
.meas tran vdout0_27ck202 FIND v(dout0_27) AT=1015.025n

* CHECK dout0_28 Vdout0_28ck202 = 0 time = 1015
.meas tran vdout0_28ck202 FIND v(dout0_28) AT=1015.025n

* CHECK dout0_29 Vdout0_29ck202 = 0 time = 1015
.meas tran vdout0_29ck202 FIND v(dout0_29) AT=1015.025n

* CHECK dout0_30 Vdout0_30ck202 = 0 time = 1015
.meas tran vdout0_30ck202 FIND v(dout0_30) AT=1015.025n

* CHECK dout0_31 Vdout0_31ck202 = 0 time = 1015
.meas tran vdout0_31ck202 FIND v(dout0_31) AT=1015.025n

* CHECK dout0_32 Vdout0_32ck202 = 0.9 time = 1015
.meas tran vdout0_32ck202 FIND v(dout0_32) AT=1015.025n

* CHECK dout0_33 Vdout0_33ck202 = 0.9 time = 1015
.meas tran vdout0_33ck202 FIND v(dout0_33) AT=1015.025n

* CHECK dout0_34 Vdout0_34ck202 = 0 time = 1015
.meas tran vdout0_34ck202 FIND v(dout0_34) AT=1015.025n

* CHECK dout0_35 Vdout0_35ck202 = 0 time = 1015
.meas tran vdout0_35ck202 FIND v(dout0_35) AT=1015.025n

* CHECK dout0_36 Vdout0_36ck202 = 0.9 time = 1015
.meas tran vdout0_36ck202 FIND v(dout0_36) AT=1015.025n

* CHECK dout0_37 Vdout0_37ck202 = 0 time = 1015
.meas tran vdout0_37ck202 FIND v(dout0_37) AT=1015.025n

* CHECK dout0_38 Vdout0_38ck202 = 0 time = 1015
.meas tran vdout0_38ck202 FIND v(dout0_38) AT=1015.025n

* CHECK dout0_39 Vdout0_39ck202 = 0 time = 1015
.meas tran vdout0_39ck202 FIND v(dout0_39) AT=1015.025n

* CHECK dout0_40 Vdout0_40ck202 = 0.9 time = 1015
.meas tran vdout0_40ck202 FIND v(dout0_40) AT=1015.025n

* CHECK dout0_41 Vdout0_41ck202 = 0 time = 1015
.meas tran vdout0_41ck202 FIND v(dout0_41) AT=1015.025n

* CHECK dout0_42 Vdout0_42ck202 = 0 time = 1015
.meas tran vdout0_42ck202 FIND v(dout0_42) AT=1015.025n

* CHECK dout0_43 Vdout0_43ck202 = 0 time = 1015
.meas tran vdout0_43ck202 FIND v(dout0_43) AT=1015.025n

* CHECK dout0_44 Vdout0_44ck202 = 0 time = 1015
.meas tran vdout0_44ck202 FIND v(dout0_44) AT=1015.025n

* CHECK dout0_45 Vdout0_45ck202 = 0 time = 1015
.meas tran vdout0_45ck202 FIND v(dout0_45) AT=1015.025n

* CHECK dout0_46 Vdout0_46ck202 = 0.9 time = 1015
.meas tran vdout0_46ck202 FIND v(dout0_46) AT=1015.025n

* CHECK dout0_47 Vdout0_47ck202 = 0 time = 1015
.meas tran vdout0_47ck202 FIND v(dout0_47) AT=1015.025n

* CHECK dout0_48 Vdout0_48ck202 = 0.9 time = 1015
.meas tran vdout0_48ck202 FIND v(dout0_48) AT=1015.025n

* CHECK dout0_49 Vdout0_49ck202 = 0 time = 1015
.meas tran vdout0_49ck202 FIND v(dout0_49) AT=1015.025n

* CHECK dout0_50 Vdout0_50ck202 = 0 time = 1015
.meas tran vdout0_50ck202 FIND v(dout0_50) AT=1015.025n

* CHECK dout0_51 Vdout0_51ck202 = 0 time = 1015
.meas tran vdout0_51ck202 FIND v(dout0_51) AT=1015.025n

* CHECK dout0_52 Vdout0_52ck202 = 0.9 time = 1015
.meas tran vdout0_52ck202 FIND v(dout0_52) AT=1015.025n

* CHECK dout0_53 Vdout0_53ck202 = 0 time = 1015
.meas tran vdout0_53ck202 FIND v(dout0_53) AT=1015.025n

* CHECK dout0_54 Vdout0_54ck202 = 0.9 time = 1015
.meas tran vdout0_54ck202 FIND v(dout0_54) AT=1015.025n

* CHECK dout0_55 Vdout0_55ck202 = 0.9 time = 1015
.meas tran vdout0_55ck202 FIND v(dout0_55) AT=1015.025n

* CHECK dout0_56 Vdout0_56ck202 = 0 time = 1015
.meas tran vdout0_56ck202 FIND v(dout0_56) AT=1015.025n

* CHECK dout0_57 Vdout0_57ck202 = 0 time = 1015
.meas tran vdout0_57ck202 FIND v(dout0_57) AT=1015.025n

* CHECK dout0_58 Vdout0_58ck202 = 0.9 time = 1015
.meas tran vdout0_58ck202 FIND v(dout0_58) AT=1015.025n

* CHECK dout0_59 Vdout0_59ck202 = 0.9 time = 1015
.meas tran vdout0_59ck202 FIND v(dout0_59) AT=1015.025n

* CHECK dout0_60 Vdout0_60ck202 = 0.9 time = 1015
.meas tran vdout0_60ck202 FIND v(dout0_60) AT=1015.025n

* CHECK dout0_61 Vdout0_61ck202 = 0.9 time = 1015
.meas tran vdout0_61ck202 FIND v(dout0_61) AT=1015.025n

* CHECK dout0_62 Vdout0_62ck202 = 0 time = 1015
.meas tran vdout0_62ck202 FIND v(dout0_62) AT=1015.025n

* CHECK dout0_63 Vdout0_63ck202 = 0 time = 1015
.meas tran vdout0_63ck202 FIND v(dout0_63) AT=1015.025n

* CHECK dout0_0 Vdout0_0ck203 = 0.9 time = 1020
.meas tran vdout0_0ck203 FIND v(dout0_0) AT=1020.025n

* CHECK dout0_1 Vdout0_1ck203 = 0 time = 1020
.meas tran vdout0_1ck203 FIND v(dout0_1) AT=1020.025n

* CHECK dout0_2 Vdout0_2ck203 = 0 time = 1020
.meas tran vdout0_2ck203 FIND v(dout0_2) AT=1020.025n

* CHECK dout0_3 Vdout0_3ck203 = 0 time = 1020
.meas tran vdout0_3ck203 FIND v(dout0_3) AT=1020.025n

* CHECK dout0_4 Vdout0_4ck203 = 0.9 time = 1020
.meas tran vdout0_4ck203 FIND v(dout0_4) AT=1020.025n

* CHECK dout0_5 Vdout0_5ck203 = 0.9 time = 1020
.meas tran vdout0_5ck203 FIND v(dout0_5) AT=1020.025n

* CHECK dout0_6 Vdout0_6ck203 = 0 time = 1020
.meas tran vdout0_6ck203 FIND v(dout0_6) AT=1020.025n

* CHECK dout0_7 Vdout0_7ck203 = 0 time = 1020
.meas tran vdout0_7ck203 FIND v(dout0_7) AT=1020.025n

* CHECK dout0_8 Vdout0_8ck203 = 0 time = 1020
.meas tran vdout0_8ck203 FIND v(dout0_8) AT=1020.025n

* CHECK dout0_9 Vdout0_9ck203 = 0.9 time = 1020
.meas tran vdout0_9ck203 FIND v(dout0_9) AT=1020.025n

* CHECK dout0_10 Vdout0_10ck203 = 0 time = 1020
.meas tran vdout0_10ck203 FIND v(dout0_10) AT=1020.025n

* CHECK dout0_11 Vdout0_11ck203 = 0.9 time = 1020
.meas tran vdout0_11ck203 FIND v(dout0_11) AT=1020.025n

* CHECK dout0_12 Vdout0_12ck203 = 0 time = 1020
.meas tran vdout0_12ck203 FIND v(dout0_12) AT=1020.025n

* CHECK dout0_13 Vdout0_13ck203 = 0 time = 1020
.meas tran vdout0_13ck203 FIND v(dout0_13) AT=1020.025n

* CHECK dout0_14 Vdout0_14ck203 = 0 time = 1020
.meas tran vdout0_14ck203 FIND v(dout0_14) AT=1020.025n

* CHECK dout0_15 Vdout0_15ck203 = 0 time = 1020
.meas tran vdout0_15ck203 FIND v(dout0_15) AT=1020.025n

* CHECK dout0_16 Vdout0_16ck203 = 0 time = 1020
.meas tran vdout0_16ck203 FIND v(dout0_16) AT=1020.025n

* CHECK dout0_17 Vdout0_17ck203 = 0.9 time = 1020
.meas tran vdout0_17ck203 FIND v(dout0_17) AT=1020.025n

* CHECK dout0_18 Vdout0_18ck203 = 0 time = 1020
.meas tran vdout0_18ck203 FIND v(dout0_18) AT=1020.025n

* CHECK dout0_19 Vdout0_19ck203 = 0 time = 1020
.meas tran vdout0_19ck203 FIND v(dout0_19) AT=1020.025n

* CHECK dout0_20 Vdout0_20ck203 = 0 time = 1020
.meas tran vdout0_20ck203 FIND v(dout0_20) AT=1020.025n

* CHECK dout0_21 Vdout0_21ck203 = 0 time = 1020
.meas tran vdout0_21ck203 FIND v(dout0_21) AT=1020.025n

* CHECK dout0_22 Vdout0_22ck203 = 0.9 time = 1020
.meas tran vdout0_22ck203 FIND v(dout0_22) AT=1020.025n

* CHECK dout0_23 Vdout0_23ck203 = 0.9 time = 1020
.meas tran vdout0_23ck203 FIND v(dout0_23) AT=1020.025n

* CHECK dout0_24 Vdout0_24ck203 = 0.9 time = 1020
.meas tran vdout0_24ck203 FIND v(dout0_24) AT=1020.025n

* CHECK dout0_25 Vdout0_25ck203 = 0 time = 1020
.meas tran vdout0_25ck203 FIND v(dout0_25) AT=1020.025n

* CHECK dout0_26 Vdout0_26ck203 = 0.9 time = 1020
.meas tran vdout0_26ck203 FIND v(dout0_26) AT=1020.025n

* CHECK dout0_27 Vdout0_27ck203 = 0.9 time = 1020
.meas tran vdout0_27ck203 FIND v(dout0_27) AT=1020.025n

* CHECK dout0_28 Vdout0_28ck203 = 0 time = 1020
.meas tran vdout0_28ck203 FIND v(dout0_28) AT=1020.025n

* CHECK dout0_29 Vdout0_29ck203 = 0.9 time = 1020
.meas tran vdout0_29ck203 FIND v(dout0_29) AT=1020.025n

* CHECK dout0_30 Vdout0_30ck203 = 0.9 time = 1020
.meas tran vdout0_30ck203 FIND v(dout0_30) AT=1020.025n

* CHECK dout0_31 Vdout0_31ck203 = 0 time = 1020
.meas tran vdout0_31ck203 FIND v(dout0_31) AT=1020.025n

* CHECK dout0_32 Vdout0_32ck203 = 0 time = 1020
.meas tran vdout0_32ck203 FIND v(dout0_32) AT=1020.025n

* CHECK dout0_33 Vdout0_33ck203 = 0.9 time = 1020
.meas tran vdout0_33ck203 FIND v(dout0_33) AT=1020.025n

* CHECK dout0_34 Vdout0_34ck203 = 0.9 time = 1020
.meas tran vdout0_34ck203 FIND v(dout0_34) AT=1020.025n

* CHECK dout0_35 Vdout0_35ck203 = 0.9 time = 1020
.meas tran vdout0_35ck203 FIND v(dout0_35) AT=1020.025n

* CHECK dout0_36 Vdout0_36ck203 = 0.9 time = 1020
.meas tran vdout0_36ck203 FIND v(dout0_36) AT=1020.025n

* CHECK dout0_37 Vdout0_37ck203 = 0 time = 1020
.meas tran vdout0_37ck203 FIND v(dout0_37) AT=1020.025n

* CHECK dout0_38 Vdout0_38ck203 = 0.9 time = 1020
.meas tran vdout0_38ck203 FIND v(dout0_38) AT=1020.025n

* CHECK dout0_39 Vdout0_39ck203 = 0.9 time = 1020
.meas tran vdout0_39ck203 FIND v(dout0_39) AT=1020.025n

* CHECK dout0_40 Vdout0_40ck203 = 0 time = 1020
.meas tran vdout0_40ck203 FIND v(dout0_40) AT=1020.025n

* CHECK dout0_41 Vdout0_41ck203 = 0.9 time = 1020
.meas tran vdout0_41ck203 FIND v(dout0_41) AT=1020.025n

* CHECK dout0_42 Vdout0_42ck203 = 0 time = 1020
.meas tran vdout0_42ck203 FIND v(dout0_42) AT=1020.025n

* CHECK dout0_43 Vdout0_43ck203 = 0 time = 1020
.meas tran vdout0_43ck203 FIND v(dout0_43) AT=1020.025n

* CHECK dout0_44 Vdout0_44ck203 = 0.9 time = 1020
.meas tran vdout0_44ck203 FIND v(dout0_44) AT=1020.025n

* CHECK dout0_45 Vdout0_45ck203 = 0.9 time = 1020
.meas tran vdout0_45ck203 FIND v(dout0_45) AT=1020.025n

* CHECK dout0_46 Vdout0_46ck203 = 0.9 time = 1020
.meas tran vdout0_46ck203 FIND v(dout0_46) AT=1020.025n

* CHECK dout0_47 Vdout0_47ck203 = 0.9 time = 1020
.meas tran vdout0_47ck203 FIND v(dout0_47) AT=1020.025n

* CHECK dout0_48 Vdout0_48ck203 = 0 time = 1020
.meas tran vdout0_48ck203 FIND v(dout0_48) AT=1020.025n

* CHECK dout0_49 Vdout0_49ck203 = 0 time = 1020
.meas tran vdout0_49ck203 FIND v(dout0_49) AT=1020.025n

* CHECK dout0_50 Vdout0_50ck203 = 0 time = 1020
.meas tran vdout0_50ck203 FIND v(dout0_50) AT=1020.025n

* CHECK dout0_51 Vdout0_51ck203 = 0.9 time = 1020
.meas tran vdout0_51ck203 FIND v(dout0_51) AT=1020.025n

* CHECK dout0_52 Vdout0_52ck203 = 0 time = 1020
.meas tran vdout0_52ck203 FIND v(dout0_52) AT=1020.025n

* CHECK dout0_53 Vdout0_53ck203 = 0.9 time = 1020
.meas tran vdout0_53ck203 FIND v(dout0_53) AT=1020.025n

* CHECK dout0_54 Vdout0_54ck203 = 0.9 time = 1020
.meas tran vdout0_54ck203 FIND v(dout0_54) AT=1020.025n

* CHECK dout0_55 Vdout0_55ck203 = 0 time = 1020
.meas tran vdout0_55ck203 FIND v(dout0_55) AT=1020.025n

* CHECK dout0_56 Vdout0_56ck203 = 0.9 time = 1020
.meas tran vdout0_56ck203 FIND v(dout0_56) AT=1020.025n

* CHECK dout0_57 Vdout0_57ck203 = 0 time = 1020
.meas tran vdout0_57ck203 FIND v(dout0_57) AT=1020.025n

* CHECK dout0_58 Vdout0_58ck203 = 0.9 time = 1020
.meas tran vdout0_58ck203 FIND v(dout0_58) AT=1020.025n

* CHECK dout0_59 Vdout0_59ck203 = 0.9 time = 1020
.meas tran vdout0_59ck203 FIND v(dout0_59) AT=1020.025n

* CHECK dout0_60 Vdout0_60ck203 = 0.9 time = 1020
.meas tran vdout0_60ck203 FIND v(dout0_60) AT=1020.025n

* CHECK dout0_61 Vdout0_61ck203 = 0.9 time = 1020
.meas tran vdout0_61ck203 FIND v(dout0_61) AT=1020.025n

* CHECK dout0_62 Vdout0_62ck203 = 0.9 time = 1020
.meas tran vdout0_62ck203 FIND v(dout0_62) AT=1020.025n

* CHECK dout0_63 Vdout0_63ck203 = 0.9 time = 1020
.meas tran vdout0_63ck203 FIND v(dout0_63) AT=1020.025n

* CHECK dout0_0 Vdout0_0ck204 = 0.9 time = 1025
.meas tran vdout0_0ck204 FIND v(dout0_0) AT=1025.025n

* CHECK dout0_1 Vdout0_1ck204 = 0.9 time = 1025
.meas tran vdout0_1ck204 FIND v(dout0_1) AT=1025.025n

* CHECK dout0_2 Vdout0_2ck204 = 0.9 time = 1025
.meas tran vdout0_2ck204 FIND v(dout0_2) AT=1025.025n

* CHECK dout0_3 Vdout0_3ck204 = 0 time = 1025
.meas tran vdout0_3ck204 FIND v(dout0_3) AT=1025.025n

* CHECK dout0_4 Vdout0_4ck204 = 0 time = 1025
.meas tran vdout0_4ck204 FIND v(dout0_4) AT=1025.025n

* CHECK dout0_5 Vdout0_5ck204 = 0.9 time = 1025
.meas tran vdout0_5ck204 FIND v(dout0_5) AT=1025.025n

* CHECK dout0_6 Vdout0_6ck204 = 0.9 time = 1025
.meas tran vdout0_6ck204 FIND v(dout0_6) AT=1025.025n

* CHECK dout0_7 Vdout0_7ck204 = 0 time = 1025
.meas tran vdout0_7ck204 FIND v(dout0_7) AT=1025.025n

* CHECK dout0_8 Vdout0_8ck204 = 0 time = 1025
.meas tran vdout0_8ck204 FIND v(dout0_8) AT=1025.025n

* CHECK dout0_9 Vdout0_9ck204 = 0.9 time = 1025
.meas tran vdout0_9ck204 FIND v(dout0_9) AT=1025.025n

* CHECK dout0_10 Vdout0_10ck204 = 0.9 time = 1025
.meas tran vdout0_10ck204 FIND v(dout0_10) AT=1025.025n

* CHECK dout0_11 Vdout0_11ck204 = 0 time = 1025
.meas tran vdout0_11ck204 FIND v(dout0_11) AT=1025.025n

* CHECK dout0_12 Vdout0_12ck204 = 0 time = 1025
.meas tran vdout0_12ck204 FIND v(dout0_12) AT=1025.025n

* CHECK dout0_13 Vdout0_13ck204 = 0.9 time = 1025
.meas tran vdout0_13ck204 FIND v(dout0_13) AT=1025.025n

* CHECK dout0_14 Vdout0_14ck204 = 0.9 time = 1025
.meas tran vdout0_14ck204 FIND v(dout0_14) AT=1025.025n

* CHECK dout0_15 Vdout0_15ck204 = 0.9 time = 1025
.meas tran vdout0_15ck204 FIND v(dout0_15) AT=1025.025n

* CHECK dout0_16 Vdout0_16ck204 = 0 time = 1025
.meas tran vdout0_16ck204 FIND v(dout0_16) AT=1025.025n

* CHECK dout0_17 Vdout0_17ck204 = 0.9 time = 1025
.meas tran vdout0_17ck204 FIND v(dout0_17) AT=1025.025n

* CHECK dout0_18 Vdout0_18ck204 = 0 time = 1025
.meas tran vdout0_18ck204 FIND v(dout0_18) AT=1025.025n

* CHECK dout0_19 Vdout0_19ck204 = 0 time = 1025
.meas tran vdout0_19ck204 FIND v(dout0_19) AT=1025.025n

* CHECK dout0_20 Vdout0_20ck204 = 0 time = 1025
.meas tran vdout0_20ck204 FIND v(dout0_20) AT=1025.025n

* CHECK dout0_21 Vdout0_21ck204 = 0.9 time = 1025
.meas tran vdout0_21ck204 FIND v(dout0_21) AT=1025.025n

* CHECK dout0_22 Vdout0_22ck204 = 0.9 time = 1025
.meas tran vdout0_22ck204 FIND v(dout0_22) AT=1025.025n

* CHECK dout0_23 Vdout0_23ck204 = 0 time = 1025
.meas tran vdout0_23ck204 FIND v(dout0_23) AT=1025.025n

* CHECK dout0_24 Vdout0_24ck204 = 0 time = 1025
.meas tran vdout0_24ck204 FIND v(dout0_24) AT=1025.025n

* CHECK dout0_25 Vdout0_25ck204 = 0 time = 1025
.meas tran vdout0_25ck204 FIND v(dout0_25) AT=1025.025n

* CHECK dout0_26 Vdout0_26ck204 = 0 time = 1025
.meas tran vdout0_26ck204 FIND v(dout0_26) AT=1025.025n

* CHECK dout0_27 Vdout0_27ck204 = 0.9 time = 1025
.meas tran vdout0_27ck204 FIND v(dout0_27) AT=1025.025n

* CHECK dout0_28 Vdout0_28ck204 = 0 time = 1025
.meas tran vdout0_28ck204 FIND v(dout0_28) AT=1025.025n

* CHECK dout0_29 Vdout0_29ck204 = 0 time = 1025
.meas tran vdout0_29ck204 FIND v(dout0_29) AT=1025.025n

* CHECK dout0_30 Vdout0_30ck204 = 0 time = 1025
.meas tran vdout0_30ck204 FIND v(dout0_30) AT=1025.025n

* CHECK dout0_31 Vdout0_31ck204 = 0.9 time = 1025
.meas tran vdout0_31ck204 FIND v(dout0_31) AT=1025.025n

* CHECK dout0_32 Vdout0_32ck204 = 0.9 time = 1025
.meas tran vdout0_32ck204 FIND v(dout0_32) AT=1025.025n

* CHECK dout0_33 Vdout0_33ck204 = 0 time = 1025
.meas tran vdout0_33ck204 FIND v(dout0_33) AT=1025.025n

* CHECK dout0_34 Vdout0_34ck204 = 0.9 time = 1025
.meas tran vdout0_34ck204 FIND v(dout0_34) AT=1025.025n

* CHECK dout0_35 Vdout0_35ck204 = 0.9 time = 1025
.meas tran vdout0_35ck204 FIND v(dout0_35) AT=1025.025n

* CHECK dout0_36 Vdout0_36ck204 = 0.9 time = 1025
.meas tran vdout0_36ck204 FIND v(dout0_36) AT=1025.025n

* CHECK dout0_37 Vdout0_37ck204 = 0 time = 1025
.meas tran vdout0_37ck204 FIND v(dout0_37) AT=1025.025n

* CHECK dout0_38 Vdout0_38ck204 = 0 time = 1025
.meas tran vdout0_38ck204 FIND v(dout0_38) AT=1025.025n

* CHECK dout0_39 Vdout0_39ck204 = 0 time = 1025
.meas tran vdout0_39ck204 FIND v(dout0_39) AT=1025.025n

* CHECK dout0_40 Vdout0_40ck204 = 0.9 time = 1025
.meas tran vdout0_40ck204 FIND v(dout0_40) AT=1025.025n

* CHECK dout0_41 Vdout0_41ck204 = 0 time = 1025
.meas tran vdout0_41ck204 FIND v(dout0_41) AT=1025.025n

* CHECK dout0_42 Vdout0_42ck204 = 0.9 time = 1025
.meas tran vdout0_42ck204 FIND v(dout0_42) AT=1025.025n

* CHECK dout0_43 Vdout0_43ck204 = 0 time = 1025
.meas tran vdout0_43ck204 FIND v(dout0_43) AT=1025.025n

* CHECK dout0_44 Vdout0_44ck204 = 0 time = 1025
.meas tran vdout0_44ck204 FIND v(dout0_44) AT=1025.025n

* CHECK dout0_45 Vdout0_45ck204 = 0 time = 1025
.meas tran vdout0_45ck204 FIND v(dout0_45) AT=1025.025n

* CHECK dout0_46 Vdout0_46ck204 = 0.9 time = 1025
.meas tran vdout0_46ck204 FIND v(dout0_46) AT=1025.025n

* CHECK dout0_47 Vdout0_47ck204 = 0.9 time = 1025
.meas tran vdout0_47ck204 FIND v(dout0_47) AT=1025.025n

* CHECK dout0_48 Vdout0_48ck204 = 0.9 time = 1025
.meas tran vdout0_48ck204 FIND v(dout0_48) AT=1025.025n

* CHECK dout0_49 Vdout0_49ck204 = 0.9 time = 1025
.meas tran vdout0_49ck204 FIND v(dout0_49) AT=1025.025n

* CHECK dout0_50 Vdout0_50ck204 = 0.9 time = 1025
.meas tran vdout0_50ck204 FIND v(dout0_50) AT=1025.025n

* CHECK dout0_51 Vdout0_51ck204 = 0 time = 1025
.meas tran vdout0_51ck204 FIND v(dout0_51) AT=1025.025n

* CHECK dout0_52 Vdout0_52ck204 = 0 time = 1025
.meas tran vdout0_52ck204 FIND v(dout0_52) AT=1025.025n

* CHECK dout0_53 Vdout0_53ck204 = 0.9 time = 1025
.meas tran vdout0_53ck204 FIND v(dout0_53) AT=1025.025n

* CHECK dout0_54 Vdout0_54ck204 = 0.9 time = 1025
.meas tran vdout0_54ck204 FIND v(dout0_54) AT=1025.025n

* CHECK dout0_55 Vdout0_55ck204 = 0.9 time = 1025
.meas tran vdout0_55ck204 FIND v(dout0_55) AT=1025.025n

* CHECK dout0_56 Vdout0_56ck204 = 0.9 time = 1025
.meas tran vdout0_56ck204 FIND v(dout0_56) AT=1025.025n

* CHECK dout0_57 Vdout0_57ck204 = 0.9 time = 1025
.meas tran vdout0_57ck204 FIND v(dout0_57) AT=1025.025n

* CHECK dout0_58 Vdout0_58ck204 = 0 time = 1025
.meas tran vdout0_58ck204 FIND v(dout0_58) AT=1025.025n

* CHECK dout0_59 Vdout0_59ck204 = 0.9 time = 1025
.meas tran vdout0_59ck204 FIND v(dout0_59) AT=1025.025n

* CHECK dout0_60 Vdout0_60ck204 = 0.9 time = 1025
.meas tran vdout0_60ck204 FIND v(dout0_60) AT=1025.025n

* CHECK dout0_61 Vdout0_61ck204 = 0 time = 1025
.meas tran vdout0_61ck204 FIND v(dout0_61) AT=1025.025n

* CHECK dout0_62 Vdout0_62ck204 = 0 time = 1025
.meas tran vdout0_62ck204 FIND v(dout0_62) AT=1025.025n

* CHECK dout0_63 Vdout0_63ck204 = 0.9 time = 1025
.meas tran vdout0_63ck204 FIND v(dout0_63) AT=1025.025n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
