* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "freepdk45_sram_1w1r_32x72.sp"

* Global Power Supplies
Vvdd vdd 0 0.9

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xfreepdk45_sram_1w1r_32x72 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 din0_40 din0_41 din0_42 din0_43 din0_44 din0_45 din0_46 din0_47 din0_48 din0_49 din0_50 din0_51 din0_52 din0_53 din0_54 din0_55 din0_56 din0_57 din0_58 din0_59 din0_60 din0_61 din0_62 din0_63 din0_64 din0_65 din0_66 din0_67 din0_68 din0_69 din0_70 din0_71 a0_0 a0_1 a0_2 a0_3 a0_4 a1_0 a1_1 a1_2 a1_3 a1_4 CSB0 CSB1 clk0 clk1 dout1_0 dout1_1 dout1_2 dout1_3 dout1_4 dout1_5 dout1_6 dout1_7 dout1_8 dout1_9 dout1_10 dout1_11 dout1_12 dout1_13 dout1_14 dout1_15 dout1_16 dout1_17 dout1_18 dout1_19 dout1_20 dout1_21 dout1_22 dout1_23 dout1_24 dout1_25 dout1_26 dout1_27 dout1_28 dout1_29 dout1_30 dout1_31 dout1_32 dout1_33 dout1_34 dout1_35 dout1_36 dout1_37 dout1_38 dout1_39 dout1_40 dout1_41 dout1_42 dout1_43 dout1_44 dout1_45 dout1_46 dout1_47 dout1_48 dout1_49 dout1_50 dout1_51 dout1_52 dout1_53 dout1_54 dout1_55 dout1_56 dout1_57 dout1_58 dout1_59 dout1_60 dout1_61 dout1_62 dout1_63 dout1_64 dout1_65 dout1_66 dout1_67 dout1_68 dout1_69 dout1_70 dout1_71 vdd gnd freepdk45_sram_1w1r_32x72

* SRAM output loads
CD10 dout1_0  0 0.8364f
CD11 dout1_1  0 0.8364f
CD12 dout1_2  0 0.8364f
CD13 dout1_3  0 0.8364f
CD14 dout1_4  0 0.8364f
CD15 dout1_5  0 0.8364f
CD16 dout1_6  0 0.8364f
CD17 dout1_7  0 0.8364f
CD18 dout1_8  0 0.8364f
CD19 dout1_9  0 0.8364f
CD110 dout1_10  0 0.8364f
CD111 dout1_11  0 0.8364f
CD112 dout1_12  0 0.8364f
CD113 dout1_13  0 0.8364f
CD114 dout1_14  0 0.8364f
CD115 dout1_15  0 0.8364f
CD116 dout1_16  0 0.8364f
CD117 dout1_17  0 0.8364f
CD118 dout1_18  0 0.8364f
CD119 dout1_19  0 0.8364f
CD120 dout1_20  0 0.8364f
CD121 dout1_21  0 0.8364f
CD122 dout1_22  0 0.8364f
CD123 dout1_23  0 0.8364f
CD124 dout1_24  0 0.8364f
CD125 dout1_25  0 0.8364f
CD126 dout1_26  0 0.8364f
CD127 dout1_27  0 0.8364f
CD128 dout1_28  0 0.8364f
CD129 dout1_29  0 0.8364f
CD130 dout1_30  0 0.8364f
CD131 dout1_31  0 0.8364f
CD132 dout1_32  0 0.8364f
CD133 dout1_33  0 0.8364f
CD134 dout1_34  0 0.8364f
CD135 dout1_35  0 0.8364f
CD136 dout1_36  0 0.8364f
CD137 dout1_37  0 0.8364f
CD138 dout1_38  0 0.8364f
CD139 dout1_39  0 0.8364f
CD140 dout1_40  0 0.8364f
CD141 dout1_41  0 0.8364f
CD142 dout1_42  0 0.8364f
CD143 dout1_43  0 0.8364f
CD144 dout1_44  0 0.8364f
CD145 dout1_45  0 0.8364f
CD146 dout1_46  0 0.8364f
CD147 dout1_47  0 0.8364f
CD148 dout1_48  0 0.8364f
CD149 dout1_49  0 0.8364f
CD150 dout1_50  0 0.8364f
CD151 dout1_51  0 0.8364f
CD152 dout1_52  0 0.8364f
CD153 dout1_53  0 0.8364f
CD154 dout1_54  0 0.8364f
CD155 dout1_55  0 0.8364f
CD156 dout1_56  0 0.8364f
CD157 dout1_57  0 0.8364f
CD158 dout1_58  0 0.8364f
CD159 dout1_59  0 0.8364f
CD160 dout1_60  0 0.8364f
CD161 dout1_61  0 0.8364f
CD162 dout1_62  0 0.8364f
CD163 dout1_63  0 0.8364f
CD164 dout1_64  0 0.8364f
CD165 dout1_65  0 0.8364f
CD166 dout1_66  0 0.8364f
CD167 dout1_67  0 0.8364f
CD168 dout1_68  0 0.8364f
CD169 dout1_69  0 0.8364f
CD170 dout1_70  0 0.8364f
CD171 dout1_71  0 0.8364f

* Important signals for debug
* bl:	xfreepdk45_sram_1w1r_32x72.xbank0.bl_1_0
* br:	xfreepdk45_sram_1w1r_32x72.xbank0.br_1_0
* s_en:	xfreepdk45_sram_1w1r_32x72.s_en
* q:	xfreepdk45_sram_1w1r_32x72.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xfreepdk45_sram_1w1r_32x72.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 011100000001101000001011001101010001000111110010010011001001000110010011  to  address 11110 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 111001001000101000101000101010000111000111100101000101000110100001100110  to  address 00000 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 010001100001111111111100111001001010100110000110011110000100100101110010  to  address 00000 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 010001100001111111111100111001001010100110000110011110000100100101110010 from address 00000 (from port 1) during cycle 4 (20ns - 25ns)
*	Writing 011010101011110000010000000111000001110000011100010100111101000101110101  to  address 11110 (from port 0) during cycle 5 (25ns - 30ns)
*	Reading 011010101011110000010000000111000001110000011100010100111101000101110101 from address 11110 (from port 1) during cycle 6 (30ns - 35ns)
*	Writing 110011010111111000001101010110001111010000011110010010100101101000100011  to  address 00000 (from port 0) during cycle 7 (35ns - 40ns)
*	Writing 010010111101110110110001000000111100111100010111110110010011010010111111  to  address 00000 (from port 0) during cycle 8 (40ns - 45ns)
*	Writing 010111111100111101111110110010101000001001011001010000010001000101010100  to  address 00000 (from port 0) during cycle 10 (50ns - 55ns)
*	Reading 011010101011110000010000000111000001110000011100010100111101000101110101 from address 11110 (from port 1) during cycle 14 (70ns - 75ns)
*	Writing 011011100001110111100111101110001001111001001101000010000010010101111111  to  address 11110 (from port 0) during cycle 15 (75ns - 80ns)
*	Writing 011111011010001101011011100000100000010000011101010100100110110101111111  to  address 00000 (from port 0) during cycle 16 (80ns - 85ns)
*	Reading 011011100001110111100111101110001001111001001101000010000010010101111111 from address 11110 (from port 1) during cycle 16 (80ns - 85ns)
*	Writing 100000011000001000100100111001111110100110100111111100011100110011111100  to  address 00000 (from port 0) during cycle 17 (85ns - 90ns)
*	Reading 100000011000001000100100111001111110100110100111111100011100110011111100 from address 00000 (from port 1) during cycle 20 (100ns - 105ns)
*	Writing 101111000101111111011110000010100111101001011011010001001110000100100110  to  address 11110 (from port 0) during cycle 21 (105ns - 110ns)
*	Reading 101111000101111111011110000010100111101001011011010001001110000100100110 from address 11110 (from port 1) during cycle 22 (110ns - 115ns)
*	Writing 011111111111010111101101011001000100011111110101001101000000001101011001  to  address 11110 (from port 0) during cycle 23 (115ns - 120ns)
*	Reading 100000011000001000100100111001111110100110100111111100011100110011111100 from address 00000 (from port 1) during cycle 23 (115ns - 120ns)
*	Reading 011111111111010111101101011001000100011111110101001101000000001101011001 from address 11110 (from port 1) during cycle 25 (125ns - 130ns)
*	Writing 101011100001011000110001111010101011000111010001101110100101010010110010  to  address 00000 (from port 0) during cycle 27 (135ns - 140ns)
*	Reading 011111111111010111101101011001000100011111110101001101000000001101011001 from address 11110 (from port 1) during cycle 27 (135ns - 140ns)
*	Writing 000001111000011111011100001010110101000100101111001110011011010100111101  to  address 00000 (from port 0) during cycle 28 (140ns - 145ns)
*	Reading 000001111000011111011100001010110101000100101111001110011011010100111101 from address 00000 (from port 1) during cycle 29 (145ns - 150ns)
*	Writing 100001110001010000001101000111110010010010100110000101100100011110100001  to  address 11110 (from port 0) during cycle 31 (155ns - 160ns)
*	Reading 000001111000011111011100001010110101000100101111001110011011010100111101 from address 00000 (from port 1) during cycle 32 (160ns - 165ns)
*	Writing 110010000100110000110111000100001000100011111001101110001010101110000110  to  address 11110 (from port 0) during cycle 33 (165ns - 170ns)
*	Writing 101101110001111010110110001101011111011100100111100011110011011000010111  to  address 00000 (from port 0) during cycle 36 (180ns - 185ns)
*	Writing 001100110111110110001110001101001100011111111001111010000110000110010000  to  address 00000 (from port 0) during cycle 37 (185ns - 190ns)
*	Writing 010101001110111001010101111111110111010110100011101000011100000010111111  to  address 11110 (from port 0) during cycle 39 (195ns - 200ns)
*	Writing 000111000000100001010110100010010101000011001110001111000001011011001101  to  address 11110 (from port 0) during cycle 40 (200ns - 205ns)
*	Writing 101000011011110001111101110001011110000000110001110111111010111111010000  to  address 11110 (from port 0) during cycle 41 (205ns - 210ns)
*	Reading 001100110111110110001110001101001100011111111001111010000110000110010000 from address 00000 (from port 1) during cycle 41 (205ns - 210ns)
*	Reading 001100110111110110001110001101001100011111111001111010000110000110010000 from address 00000 (from port 1) during cycle 42 (210ns - 215ns)
*	Reading 001100110111110110001110001101001100011111111001111010000110000110010000 from address 00000 (from port 1) during cycle 43 (215ns - 220ns)
*	Reading 001100110111110110001110001101001100011111111001111010000110000110010000 from address 00000 (from port 1) during cycle 44 (220ns - 225ns)
*	Reading 001100110111110110001110001101001100011111111001111010000110000110010000 from address 00000 (from port 1) during cycle 45 (225ns - 230ns)
*	Writing 001011011000101010100010010110011100001000100001011000001110001111100110  to  address 00000 (from port 0) during cycle 46 (230ns - 235ns)
*	Writing 000001101100001000100001001101011010101001101101101100101001100010111001  to  address 11110 (from port 0) during cycle 48 (240ns - 245ns)
*	Writing 001010100001110111000000111001110000000011111111010100101011001101100001  to  address 11110 (from port 0) during cycle 49 (245ns - 250ns)
*	Reading 001011011000101010100010010110011100001000100001011000001110001111100110 from address 00000 (from port 1) during cycle 50 (250ns - 255ns)
*	Reading 001010100001110111000000111001110000000011111111010100101011001101100001 from address 11110 (from port 1) during cycle 51 (255ns - 260ns)
*	Writing 010011111101100111101000010011111100110010010100011010001000000101110000  to  address 11110 (from port 0) during cycle 52 (260ns - 265ns)
*	Writing 111011001011111010011100111100000011000011000100001001101011110100001101  to  address 00000 (from port 0) during cycle 56 (280ns - 285ns)
*	Writing 111010010001000011001011011011010000111001001101101011000110110100111101  to  address 00000 (from port 0) during cycle 57 (285ns - 290ns)
*	Reading 010011111101100111101000010011111100110010010100011010001000000101110000 from address 11110 (from port 1) during cycle 57 (285ns - 290ns)
*	Reading 111010010001000011001011011011010000111001001101101011000110110100111101 from address 00000 (from port 1) during cycle 58 (290ns - 295ns)
*	Reading 010011111101100111101000010011111100110010010100011010001000000101110000 from address 11110 (from port 1) during cycle 59 (295ns - 300ns)
*	Writing 001101000111100111111101000001000001001001000111101001001000011101010000  to  address 11110 (from port 0) during cycle 60 (300ns - 305ns)
*	Reading 111010010001000011001011011011010000111001001101101011000110110100111101 from address 00000 (from port 1) during cycle 60 (300ns - 305ns)
*	Writing 111110010000010001010110100110100001111110010111011000110011100011000111  to  address 11110 (from port 0) during cycle 62 (310ns - 315ns)
*	Writing 111000101101011000100011111101101011101100010111101000111001000001010111  to  address 00000 (from port 0) during cycle 63 (315ns - 320ns)
*	Writing 000100110110000000001100001100001101010100100010010010010100000010001110  to  address 11110 (from port 0) during cycle 64 (320ns - 325ns)
*	Writing 110111001001100001111001100101101010000110001101110010110110001100110110  to  address 11110 (from port 0) during cycle 66 (330ns - 335ns)
*	Writing 000110110110001101011110110110110011110010001111111000010110111010101000  to  address 11110 (from port 0) during cycle 67 (335ns - 340ns)
*	Writing 101100011110011111000100110011001110111100011001001001011000000001101101  to  address 11110 (from port 0) during cycle 68 (340ns - 345ns)
*	Reading 101100011110011111000100110011001110111100011001001001011000000001101101 from address 11110 (from port 1) during cycle 69 (345ns - 350ns)
*	Writing 011001001001000100010000101000111100000000011100100101001010100110111111  to  address 00000 (from port 0) during cycle 70 (350ns - 355ns)
*	Writing 001001100011101000101111100001101000111111110110110110110010101111110110  to  address 00000 (from port 0) during cycle 71 (355ns - 360ns)
*	Writing 110010000001010100010110010100001011100010100100011110001101110100010011  to  address 11110 (from port 0) during cycle 72 (360ns - 365ns)
*	Writing 100110000000000000000110010110101100011100110000100001010111110011101110  to  address 11110 (from port 0) during cycle 73 (365ns - 370ns)
*	Reading 001001100011101000101111100001101000111111110110110110110010101111110110 from address 00000 (from port 1) during cycle 73 (365ns - 370ns)
*	Writing 010001001101010101100110110010000101010110001011011100011011001110100100  to  address 11110 (from port 0) during cycle 75 (375ns - 380ns)
*	Writing 110010111000111010000110101000000110111110111010000110011110110010110001  to  address 11110 (from port 0) during cycle 76 (380ns - 385ns)
*	Reading 001001100011101000101111100001101000111111110110110110110010101111110110 from address 00000 (from port 1) during cycle 76 (380ns - 385ns)
*	Reading 110010111000111010000110101000000110111110111010000110011110110010110001 from address 11110 (from port 1) during cycle 77 (385ns - 390ns)
*	Reading 001001100011101000101111100001101000111111110110110110110010101111110110 from address 00000 (from port 1) during cycle 80 (400ns - 405ns)
*	Writing 000000100111010001010000111010111110001011100010000011001100000111011001  to  address 00000 (from port 0) during cycle 81 (405ns - 410ns)
*	Writing 101101000100110111010010001011100010011001101001000000010110111011010110  to  address 00000 (from port 0) during cycle 82 (410ns - 415ns)
*	Reading 101101000100110111010010001011100010011001101001000000010110111011010110 from address 00000 (from port 1) during cycle 83 (415ns - 420ns)
*	Writing 111011010100100001011111101110000010100110111111100001111011111101101011  to  address 11110 (from port 0) during cycle 85 (425ns - 430ns)
*	Writing 010011010011011101011111001111101100111010001001010111100000101010000111  to  address 00000 (from port 0) during cycle 86 (430ns - 435ns)
*	Writing 110101100101110001010001111001010110101110001101110100110100001111010001  to  address 11110 (from port 0) during cycle 87 (435ns - 440ns)
*	Writing 011001010011000110011000011111011111011110111111010001000000100011001101  to  address 00000 (from port 0) during cycle 88 (440ns - 445ns)
*	Reading 110101100101110001010001111001010110101110001101110100110100001111010001 from address 11110 (from port 1) during cycle 88 (440ns - 445ns)
*	Writing 001101100111011011100100000001100010100000001010001011010101001011000000  to  address 11110 (from port 0) during cycle 90 (450ns - 455ns)
*	Writing 101111010110100101110111100001001101000101001100101011101101010010110110  to  address 00000 (from port 0) during cycle 91 (455ns - 460ns)
*	Reading 101111010110100101110111100001001101000101001100101011101101010010110110 from address 00000 (from port 1) during cycle 92 (460ns - 465ns)
*	Writing 000111101101001101001011111011001110111110001101110101101001110101100011  to  address 00000 (from port 0) during cycle 93 (465ns - 470ns)
*	Reading 001101100111011011100100000001100010100000001010001011010101001011000000 from address 11110 (from port 1) during cycle 93 (465ns - 470ns)
*	Writing 111001001100110101100100111111110000101101010001101010000101101101110101  to  address 00000 (from port 0) during cycle 94 (470ns - 475ns)
*	Writing 011010100100010010010101100010001010001011111001101011001010001001100110  to  address 00000 (from port 0) during cycle 97 (485ns - 490ns)
*	Reading 001101100111011011100100000001100010100000001010001011010101001011000000 from address 11110 (from port 1) during cycle 97 (485ns - 490ns)
*	Writing 011100011001011110000100100111010000111010100111100010101110111011110100  to  address 00000 (from port 0) during cycle 98 (490ns - 495ns)
*	Reading 001101100111011011100100000001100010100000001010001011010101001011000000 from address 11110 (from port 1) during cycle 98 (490ns - 495ns)
*	Writing 101001010011111000000100001100000001111001100000100011000110011101111101  to  address 00000 (from port 0) during cycle 99 (495ns - 500ns)
*	Writing 110011110000011110101100001111000001000100000110101100010001101011000111  to  address 11110 (from port 0) during cycle 100 (500ns - 505ns)
*	Reading 101001010011111000000100001100000001111001100000100011000110011101111101 from address 00000 (from port 1) during cycle 100 (500ns - 505ns)
*	Writing 111111110011001111111101101010001000001011001100101110001101110111111111  to  address 00000 (from port 0) during cycle 102 (510ns - 515ns)
*	Reading 110011110000011110101100001111000001000100000110101100010001101011000111 from address 11110 (from port 1) during cycle 102 (510ns - 515ns)
*	Reading 110011110000011110101100001111000001000100000110101100010001101011000111 from address 11110 (from port 1) during cycle 103 (515ns - 520ns)
*	Writing 010110000011110110111110001010100111001110101010111111000000010111001011  to  address 00000 (from port 0) during cycle 104 (520ns - 525ns)
*	Reading 110011110000011110101100001111000001000100000110101100010001101011000111 from address 11110 (from port 1) during cycle 104 (520ns - 525ns)
*	Writing 011010100001110010110001101010101001110000001101000010101101001011110001  to  address 00000 (from port 0) during cycle 105 (525ns - 530ns)
*	Reading 011010100001110010110001101010101001110000001101000010101101001011110001 from address 00000 (from port 1) during cycle 106 (530ns - 535ns)
*	Writing 111001111111001000100111101000000010000111011110000001111111100010001101  to  address 11110 (from port 0) during cycle 107 (535ns - 540ns)
*	Reading 011010100001110010110001101010101001110000001101000010101101001011110001 from address 00000 (from port 1) during cycle 107 (535ns - 540ns)
*	Writing 101101111000000000000010001011101110110110110010000001111010001001011001  to  address 00000 (from port 0) during cycle 108 (540ns - 545ns)
*	Reading 111001111111001000100111101000000010000111011110000001111111100010001101 from address 11110 (from port 1) during cycle 108 (540ns - 545ns)
*	Writing 110010001010010101100001111101011110110100111100010010101101001011111000  to  address 00000 (from port 0) during cycle 109 (545ns - 550ns)
*	Writing 001100110100010001000001010111000100011000011011010001011011101011110010  to  address 00000 (from port 0) during cycle 110 (550ns - 555ns)
*	Reading 111001111111001000100111101000000010000111011110000001111111100010001101 from address 11110 (from port 1) during cycle 110 (550ns - 555ns)
*	Reading 001100110100010001000001010111000100011000011011010001011011101011110010 from address 00000 (from port 1) during cycle 111 (555ns - 560ns)
*	Writing 111001110110000001100100000000101010111010001110111000010010010010100100  to  address 00000 (from port 0) during cycle 112 (560ns - 565ns)
*	Writing 110111110110011101111001111110011101110110110100100110110011000011101101  to  address 00000 (from port 0) during cycle 114 (570ns - 575ns)
*	Reading 111001111111001000100111101000000010000111011110000001111111100010001101 from address 11110 (from port 1) during cycle 114 (570ns - 575ns)
*	Reading 110111110110011101111001111110011101110110110100100110110011000011101101 from address 00000 (from port 1) during cycle 115 (575ns - 580ns)
*	Reading 110111110110011101111001111110011101110110110100100110110011000011101101 from address 00000 (from port 1) during cycle 116 (580ns - 585ns)
*	Reading 111001111111001000100111101000000010000111011110000001111111100010001101 from address 11110 (from port 1) during cycle 117 (585ns - 590ns)
*	Writing 100010101101001010000001010100001101101001101001010110110011010011110001  to  address 11110 (from port 0) during cycle 118 (590ns - 595ns)
*	Writing 110011110000001000001110000110101100100010011100010000100110000100011001  to  address 11110 (from port 0) during cycle 119 (595ns - 600ns)
*	Writing 011010010011011010010000011110101110011010010001101010001101100000100011  to  address 00000 (from port 0) during cycle 120 (600ns - 605ns)
*	Writing 001010110101011101001001110001011111000111010101000001100000100011101010  to  address 11110 (from port 0) during cycle 122 (610ns - 615ns)
*	Reading 011010010011011010010000011110101110011010010001101010001101100000100011 from address 00000 (from port 1) during cycle 122 (610ns - 615ns)
*	Writing 100010100100001010000100011001101001110000011111101001000111111001110110  to  address 00000 (from port 0) during cycle 123 (615ns - 620ns)
*	Writing 111110001100000100010110001000001010111111000001111111111101110100100100  to  address 11110 (from port 0) during cycle 124 (620ns - 625ns)
*	Writing 101011101011001001111001010000010001001100000101101111110011010110101000  to  address 11110 (from port 0) during cycle 125 (625ns - 630ns)
*	Reading 101011101011001001111001010000010001001100000101101111110011010110101000 from address 11110 (from port 1) during cycle 127 (635ns - 640ns)
*	Writing 010010010100100010110001001101111000101110100011011010011011111000110101  to  address 00000 (from port 0) during cycle 128 (640ns - 645ns)
*	Reading 010010010100100010110001001101111000101110100011011010011011111000110101 from address 00000 (from port 1) during cycle 130 (650ns - 655ns)
*	Writing 011111001111010001101111010110100111111110011000001100101001110111010000  to  address 00000 (from port 0) during cycle 132 (660ns - 665ns)
*	Writing 000101000011110011010010001000000101110001100100110111111101110101111011  to  address 11110 (from port 0) during cycle 133 (665ns - 670ns)
*	Writing 100111101011011011101001101000000111001101000010011111110011101111101101  to  address 11110 (from port 0) during cycle 134 (670ns - 675ns)
*	Writing 110111000101011001010111100001011101111111110000000110001101011110000001  to  address 11110 (from port 0) during cycle 135 (675ns - 680ns)
*	Writing 111001110100000110011001111100010010111001101001010100001000111110010000  to  address 00000 (from port 0) during cycle 136 (680ns - 685ns)
*	Reading 110111000101011001010111100001011101111111110000000110001101011110000001 from address 11110 (from port 1) during cycle 137 (685ns - 690ns)
*	Reading 111001110100000110011001111100010010111001101001010100001000111110010000 from address 00000 (from port 1) during cycle 138 (690ns - 695ns)
*	Reading 110111000101011001010111100001011101111111110000000110001101011110000001 from address 11110 (from port 1) during cycle 140 (700ns - 705ns)
*	Writing 000111110011100010111000110100110111011100011000101100000011110111101000  to  address 11110 (from port 0) during cycle 141 (705ns - 710ns)
*	Writing 101000001000010010111100011000101101001110100100011110000010110000011101  to  address 11110 (from port 0) during cycle 143 (715ns - 720ns)
*	Writing 101101011111101000011110110011100010011100001010101101111011000110110110  to  address 00000 (from port 0) during cycle 144 (720ns - 725ns)
*	Writing 110010000010010101010100110001011100100001100000111001100011011101111101  to  address 11110 (from port 0) during cycle 145 (725ns - 730ns)
*	Reading 101101011111101000011110110011100010011100001010101101111011000110110110 from address 00000 (from port 1) during cycle 145 (725ns - 730ns)
*	Reading 110010000010010101010100110001011100100001100000111001100011011101111101 from address 11110 (from port 1) during cycle 146 (730ns - 735ns)
*	Writing 111001000110110100001101000010111101010011100101111000111000011011111011  to  address 11110 (from port 0) during cycle 147 (735ns - 740ns)
*	Reading 101101011111101000011110110011100010011100001010101101111011000110110110 from address 00000 (from port 1) during cycle 147 (735ns - 740ns)
*	Writing 001011001101110111111111110111010111101100010000101000001100011111100111  to  address 11110 (from port 0) during cycle 149 (745ns - 750ns)
*	Writing 000111010110101010101001000110111100011111101000011111111000100010100000  to  address 11110 (from port 0) during cycle 150 (750ns - 755ns)
*	Reading 101101011111101000011110110011100010011100001010101101111011000110110110 from address 00000 (from port 1) during cycle 150 (750ns - 755ns)
*	Writing 011011100100110011000010110001001001011110010011000010000001000100011110  to  address 11110 (from port 0) during cycle 152 (760ns - 765ns)
*	Writing 001010110101101100101000110001101011011000011011110000011111100011011101  to  address 00000 (from port 0) during cycle 155 (775ns - 780ns)
*	Reading 011011100100110011000010110001001001011110010011000010000001000100011110 from address 11110 (from port 1) during cycle 155 (775ns - 780ns)
*	Writing 011010001101001110010001001010011010011110101101010101101111100011101111  to  address 00000 (from port 0) during cycle 156 (780ns - 785ns)
*	Reading 011011100100110011000010110001001001011110010011000010000001000100011110 from address 11110 (from port 1) during cycle 156 (780ns - 785ns)
*	Writing 111000101111011000000001001001010011011111111100000110110110101010110100  to  address 00000 (from port 0) during cycle 158 (790ns - 795ns)
*	Reading 011011100100110011000010110001001001011110010011000010000001000100011110 from address 11110 (from port 1) during cycle 158 (790ns - 795ns)
*	Writing 110111000001001010110001010010101110110001111101111000001001111010100000  to  address 00000 (from port 0) during cycle 159 (795ns - 800ns)
*	Writing 000111011000001010000011110010110111000101101011001001000101101110111111  to  address 00000 (from port 0) during cycle 160 (800ns - 805ns)
*	Writing 011110001011111000111111000101111000010000101000111000110010011011011111  to  address 00000 (from port 0) during cycle 162 (810ns - 815ns)
*	Writing 111001001011010000111011111110011101110100110000001110010101000111010010  to  address 00000 (from port 0) during cycle 163 (815ns - 820ns)
*	Reading 011011100100110011000010110001001001011110010011000010000001000100011110 from address 11110 (from port 1) during cycle 163 (815ns - 820ns)
*	Reading 011011100100110011000010110001001001011110010011000010000001000100011110 from address 11110 (from port 1) during cycle 164 (820ns - 825ns)
*	Writing 110101101010011111010000100100101101111111100000111010011111011010101100  to  address 00000 (from port 0) during cycle 165 (825ns - 830ns)
*	Reading 011011100100110011000010110001001001011110010011000010000001000100011110 from address 11110 (from port 1) during cycle 166 (830ns - 835ns)
*	Reading 110101101010011111010000100100101101111111100000111010011111011010101100 from address 00000 (from port 1) during cycle 167 (835ns - 840ns)
*	Writing 001011100100000001100010010010101110100011000000010010000011101000111101  to  address 11110 (from port 0) during cycle 168 (840ns - 845ns)
*	Writing 011101011001111011111111110001100100001010000011101110000010010110100011  to  address 00000 (from port 0) during cycle 170 (850ns - 855ns)
*	Writing 001101111110110011110100000110101111000100000000000101101000000010100111  to  address 00000 (from port 0) during cycle 171 (855ns - 860ns)
*	Reading 001101111110110011110100000110101111000100000000000101101000000010100111 from address 00000 (from port 1) during cycle 173 (865ns - 870ns)
*	Writing 101110110011101001111111010101111000000110110011001011111001111100100101  to  address 00000 (from port 0) during cycle 174 (870ns - 875ns)
*	Writing 001010001000111011101001111010000010110100011001000001100010011001001000  to  address 00000 (from port 0) during cycle 175 (875ns - 880ns)
*	Reading 001011100100000001100010010010101110100011000000010010000011101000111101 from address 11110 (from port 1) during cycle 175 (875ns - 880ns)
*	Reading 001010001000111011101001111010000010110100011001000001100010011001001000 from address 00000 (from port 1) during cycle 176 (880ns - 885ns)
*	Writing 010011000001000101101111110100111101111100101001010011111111001001101010  to  address 11110 (from port 0) during cycle 178 (890ns - 895ns)
*	Writing 000111100101010110100001100011111100110000110000110001001101001100011010  to  address 11110 (from port 0) during cycle 179 (895ns - 900ns)
*	Reading 001010001000111011101001111010000010110100011001000001100010011001001000 from address 00000 (from port 1) during cycle 179 (895ns - 900ns)
*	Writing 000101101101111011000111011100111000010111010111111111110111101011110100  to  address 11110 (from port 0) during cycle 181 (905ns - 910ns)
*	Writing 101110011011001100100010101111011101010001101000110000101010001111101100  to  address 11110 (from port 0) during cycle 182 (910ns - 915ns)
*	Writing 011101110000101010010111001010001010011000000010110110110001001110111100  to  address 00000 (from port 0) during cycle 183 (915ns - 920ns)
*	Reading 101110011011001100100010101111011101010001101000110000101010001111101100 from address 11110 (from port 1) during cycle 183 (915ns - 920ns)
*	Writing 111110011010011100111111100111011000000001100000111011011110010011001010  to  address 11110 (from port 0) during cycle 184 (920ns - 925ns)
*	Writing 010101011001001110000010000011101000010110001110101001100011010101110111  to  address 11110 (from port 0) during cycle 185 (925ns - 930ns)
*	Writing 010000100101110110101010010011001110111111100110100000101110011010010000  to  address 11110 (from port 0) during cycle 187 (935ns - 940ns)
*	Writing 111011000100111100100011010001101001010100010000010111101110101010110101  to  address 11110 (from port 0) during cycle 188 (940ns - 945ns)
*	Writing 000100011101011000100001000000000011111111111111010111111111100111101011  to  address 00000 (from port 0) during cycle 189 (945ns - 950ns)
*	Reading 000100011101011000100001000000000011111111111111010111111111100111101011 from address 00000 (from port 1) during cycle 190 (950ns - 955ns)
*	Reading 000100011101011000100001000000000011111111111111010111111111100111101011 from address 00000 (from port 1) during cycle 191 (955ns - 960ns)
*	Reading 111011000100111100100011010001101001010100010000010111101110101010110101 from address 11110 (from port 1) during cycle 192 (960ns - 965ns)
*	Writing 100100001001100110111011010111011101111110111001100010011101111101001101  to  address 11110 (from port 0) during cycle 193 (965ns - 970ns)
*	Reading 100100001001100110111011010111011101111110111001100010011101111101001101 from address 11110 (from port 1) during cycle 194 (970ns - 975ns)
*	Reading 100100001001100110111011010111011101111110111001100010011101111101001101 from address 11110 (from port 1) during cycle 195 (975ns - 980ns)
*	Writing 000000101111000000010001111101011111100100011001000101000010011101011111  to  address 00000 (from port 0) during cycle 197 (985ns - 990ns)
*	Writing 011001001000001010001111110010010111011100101010110111110011101111101010  to  address 00000 (from port 0) during cycle 198 (990ns - 995ns)
*	Reading 100100001001100110111011010111011101111110111001100010011101111101001101 from address 11110 (from port 1) during cycle 198 (990ns - 995ns)
*	Reading 011001001000001010001111110010010111011100101010110111110011101111101010 from address 00000 (from port 1) during cycle 200 (1000ns - 1005ns)
*	Reading 100100001001100110111011010111011101111110111001100010011101111101001101 from address 11110 (from port 1) during cycle 201 (1005ns - 1010ns)
*	Reading 100100001001100110111011010111011101111110111001100010011101111101001101 from address 11110 (from port 1) during cycle 203 (1015ns - 1020ns)
*	Writing 110101100010111100111111000010100111000000011101010010001111001110111010  to  address 11110 (from port 0) during cycle 204 (1020ns - 1025ns)
*	Reading 011001001000001010001111110010010111011100101010110111110011101111101010 from address 00000 (from port 1) during cycle 204 (1020ns - 1025ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 0), (440, 1), (445, 1), (450, 0), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 1), (360, 0), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 1), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 1), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 1), (605, 1), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 1), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 1), (605, 1), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 1), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 0), (805, 0), (810, 1), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 1), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 0), (605, 0), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 0), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 0), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 0), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 1), (360, 0), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 0), (600, 1), (605, 1), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 1), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 0), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 1), (860, 1), (865, 1), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 1), (445, 1), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_40  din0_40  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 1), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_41  din0_41  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 1), (345, 1), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 0), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_42  din0_42  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 1), (860, 1), (865, 1), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_43  din0_43  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_44  din0_44  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_45  din0_45  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_46  din0_46  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_47  din0_47  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_48  din0_48  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_49  din0_49  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_50  din0_50  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_51  din0_51  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 1), (355, 0), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_52  din0_52  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_53  din0_53  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_54  din0_54  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 0), (600, 1), (605, 1), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_55  din0_55  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 1), (365, 0), (370, 0), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 0), (440, 1), (445, 1), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_56  din0_56  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 1), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_57  din0_57  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 1), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_58  din0_58  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 0), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_59  din0_59  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_60  din0_60  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 1), (540, 0), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_61  din0_61  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_62  din0_62  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_63  din0_63  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 0), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_64  din0_64  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 0), (450, 1), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_65  din0_65  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 1), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_66  din0_66  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_67  din0_67  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_68  din0_68  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_69  din0_69  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 0), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_70  din0_70  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_71  din0_71  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Va0_4  a0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va1_0  a1_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va1_1  a1_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va1_2  a1_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va1_3  a1_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va1_4  a1_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 0), (30, 1), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 0), (160, 1), (165, 0), (170, 1), (175, 1), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 0), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 0), (460, 1), (465, 0), (470, 0), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 0), (515, 1), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 0), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 0), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )
* (time, data): [(0, 1), (5, 1), (10, 1), (15, 1), (20, 0), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 0), (115, 0), (120, 1), (125, 0), (130, 1), (135, 0), (140, 1), (145, 0), (150, 1), (155, 1), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 1)]
VCSB1 CSB1 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)
* PULSE: period=5
Vclk1 clk1 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout1_0 Vdout1_0ck4 = 0 time = 25
.meas tran vdout1_0ck4 FIND v(dout1_0) AT=25.025n

* CHECK dout1_1 Vdout1_1ck4 = 0.9 time = 25
.meas tran vdout1_1ck4 FIND v(dout1_1) AT=25.025n

* CHECK dout1_2 Vdout1_2ck4 = 0 time = 25
.meas tran vdout1_2ck4 FIND v(dout1_2) AT=25.025n

* CHECK dout1_3 Vdout1_3ck4 = 0 time = 25
.meas tran vdout1_3ck4 FIND v(dout1_3) AT=25.025n

* CHECK dout1_4 Vdout1_4ck4 = 0.9 time = 25
.meas tran vdout1_4ck4 FIND v(dout1_4) AT=25.025n

* CHECK dout1_5 Vdout1_5ck4 = 0.9 time = 25
.meas tran vdout1_5ck4 FIND v(dout1_5) AT=25.025n

* CHECK dout1_6 Vdout1_6ck4 = 0.9 time = 25
.meas tran vdout1_6ck4 FIND v(dout1_6) AT=25.025n

* CHECK dout1_7 Vdout1_7ck4 = 0 time = 25
.meas tran vdout1_7ck4 FIND v(dout1_7) AT=25.025n

* CHECK dout1_8 Vdout1_8ck4 = 0.9 time = 25
.meas tran vdout1_8ck4 FIND v(dout1_8) AT=25.025n

* CHECK dout1_9 Vdout1_9ck4 = 0 time = 25
.meas tran vdout1_9ck4 FIND v(dout1_9) AT=25.025n

* CHECK dout1_10 Vdout1_10ck4 = 0 time = 25
.meas tran vdout1_10ck4 FIND v(dout1_10) AT=25.025n

* CHECK dout1_11 Vdout1_11ck4 = 0.9 time = 25
.meas tran vdout1_11ck4 FIND v(dout1_11) AT=25.025n

* CHECK dout1_12 Vdout1_12ck4 = 0 time = 25
.meas tran vdout1_12ck4 FIND v(dout1_12) AT=25.025n

* CHECK dout1_13 Vdout1_13ck4 = 0 time = 25
.meas tran vdout1_13ck4 FIND v(dout1_13) AT=25.025n

* CHECK dout1_14 Vdout1_14ck4 = 0.9 time = 25
.meas tran vdout1_14ck4 FIND v(dout1_14) AT=25.025n

* CHECK dout1_15 Vdout1_15ck4 = 0 time = 25
.meas tran vdout1_15ck4 FIND v(dout1_15) AT=25.025n

* CHECK dout1_16 Vdout1_16ck4 = 0 time = 25
.meas tran vdout1_16ck4 FIND v(dout1_16) AT=25.025n

* CHECK dout1_17 Vdout1_17ck4 = 0 time = 25
.meas tran vdout1_17ck4 FIND v(dout1_17) AT=25.025n

* CHECK dout1_18 Vdout1_18ck4 = 0 time = 25
.meas tran vdout1_18ck4 FIND v(dout1_18) AT=25.025n

* CHECK dout1_19 Vdout1_19ck4 = 0.9 time = 25
.meas tran vdout1_19ck4 FIND v(dout1_19) AT=25.025n

* CHECK dout1_20 Vdout1_20ck4 = 0.9 time = 25
.meas tran vdout1_20ck4 FIND v(dout1_20) AT=25.025n

* CHECK dout1_21 Vdout1_21ck4 = 0.9 time = 25
.meas tran vdout1_21ck4 FIND v(dout1_21) AT=25.025n

* CHECK dout1_22 Vdout1_22ck4 = 0.9 time = 25
.meas tran vdout1_22ck4 FIND v(dout1_22) AT=25.025n

* CHECK dout1_23 Vdout1_23ck4 = 0 time = 25
.meas tran vdout1_23ck4 FIND v(dout1_23) AT=25.025n

* CHECK dout1_24 Vdout1_24ck4 = 0 time = 25
.meas tran vdout1_24ck4 FIND v(dout1_24) AT=25.025n

* CHECK dout1_25 Vdout1_25ck4 = 0.9 time = 25
.meas tran vdout1_25ck4 FIND v(dout1_25) AT=25.025n

* CHECK dout1_26 Vdout1_26ck4 = 0.9 time = 25
.meas tran vdout1_26ck4 FIND v(dout1_26) AT=25.025n

* CHECK dout1_27 Vdout1_27ck4 = 0 time = 25
.meas tran vdout1_27ck4 FIND v(dout1_27) AT=25.025n

* CHECK dout1_28 Vdout1_28ck4 = 0 time = 25
.meas tran vdout1_28ck4 FIND v(dout1_28) AT=25.025n

* CHECK dout1_29 Vdout1_29ck4 = 0 time = 25
.meas tran vdout1_29ck4 FIND v(dout1_29) AT=25.025n

* CHECK dout1_30 Vdout1_30ck4 = 0 time = 25
.meas tran vdout1_30ck4 FIND v(dout1_30) AT=25.025n

* CHECK dout1_31 Vdout1_31ck4 = 0.9 time = 25
.meas tran vdout1_31ck4 FIND v(dout1_31) AT=25.025n

* CHECK dout1_32 Vdout1_32ck4 = 0.9 time = 25
.meas tran vdout1_32ck4 FIND v(dout1_32) AT=25.025n

* CHECK dout1_33 Vdout1_33ck4 = 0 time = 25
.meas tran vdout1_33ck4 FIND v(dout1_33) AT=25.025n

* CHECK dout1_34 Vdout1_34ck4 = 0 time = 25
.meas tran vdout1_34ck4 FIND v(dout1_34) AT=25.025n

* CHECK dout1_35 Vdout1_35ck4 = 0.9 time = 25
.meas tran vdout1_35ck4 FIND v(dout1_35) AT=25.025n

* CHECK dout1_36 Vdout1_36ck4 = 0 time = 25
.meas tran vdout1_36ck4 FIND v(dout1_36) AT=25.025n

* CHECK dout1_37 Vdout1_37ck4 = 0.9 time = 25
.meas tran vdout1_37ck4 FIND v(dout1_37) AT=25.025n

* CHECK dout1_38 Vdout1_38ck4 = 0 time = 25
.meas tran vdout1_38ck4 FIND v(dout1_38) AT=25.025n

* CHECK dout1_39 Vdout1_39ck4 = 0.9 time = 25
.meas tran vdout1_39ck4 FIND v(dout1_39) AT=25.025n

* CHECK dout1_40 Vdout1_40ck4 = 0 time = 25
.meas tran vdout1_40ck4 FIND v(dout1_40) AT=25.025n

* CHECK dout1_41 Vdout1_41ck4 = 0 time = 25
.meas tran vdout1_41ck4 FIND v(dout1_41) AT=25.025n

* CHECK dout1_42 Vdout1_42ck4 = 0.9 time = 25
.meas tran vdout1_42ck4 FIND v(dout1_42) AT=25.025n

* CHECK dout1_43 Vdout1_43ck4 = 0 time = 25
.meas tran vdout1_43ck4 FIND v(dout1_43) AT=25.025n

* CHECK dout1_44 Vdout1_44ck4 = 0 time = 25
.meas tran vdout1_44ck4 FIND v(dout1_44) AT=25.025n

* CHECK dout1_45 Vdout1_45ck4 = 0.9 time = 25
.meas tran vdout1_45ck4 FIND v(dout1_45) AT=25.025n

* CHECK dout1_46 Vdout1_46ck4 = 0.9 time = 25
.meas tran vdout1_46ck4 FIND v(dout1_46) AT=25.025n

* CHECK dout1_47 Vdout1_47ck4 = 0.9 time = 25
.meas tran vdout1_47ck4 FIND v(dout1_47) AT=25.025n

* CHECK dout1_48 Vdout1_48ck4 = 0 time = 25
.meas tran vdout1_48ck4 FIND v(dout1_48) AT=25.025n

* CHECK dout1_49 Vdout1_49ck4 = 0 time = 25
.meas tran vdout1_49ck4 FIND v(dout1_49) AT=25.025n

* CHECK dout1_50 Vdout1_50ck4 = 0.9 time = 25
.meas tran vdout1_50ck4 FIND v(dout1_50) AT=25.025n

* CHECK dout1_51 Vdout1_51ck4 = 0.9 time = 25
.meas tran vdout1_51ck4 FIND v(dout1_51) AT=25.025n

* CHECK dout1_52 Vdout1_52ck4 = 0.9 time = 25
.meas tran vdout1_52ck4 FIND v(dout1_52) AT=25.025n

* CHECK dout1_53 Vdout1_53ck4 = 0.9 time = 25
.meas tran vdout1_53ck4 FIND v(dout1_53) AT=25.025n

* CHECK dout1_54 Vdout1_54ck4 = 0.9 time = 25
.meas tran vdout1_54ck4 FIND v(dout1_54) AT=25.025n

* CHECK dout1_55 Vdout1_55ck4 = 0.9 time = 25
.meas tran vdout1_55ck4 FIND v(dout1_55) AT=25.025n

* CHECK dout1_56 Vdout1_56ck4 = 0.9 time = 25
.meas tran vdout1_56ck4 FIND v(dout1_56) AT=25.025n

* CHECK dout1_57 Vdout1_57ck4 = 0.9 time = 25
.meas tran vdout1_57ck4 FIND v(dout1_57) AT=25.025n

* CHECK dout1_58 Vdout1_58ck4 = 0.9 time = 25
.meas tran vdout1_58ck4 FIND v(dout1_58) AT=25.025n

* CHECK dout1_59 Vdout1_59ck4 = 0.9 time = 25
.meas tran vdout1_59ck4 FIND v(dout1_59) AT=25.025n

* CHECK dout1_60 Vdout1_60ck4 = 0.9 time = 25
.meas tran vdout1_60ck4 FIND v(dout1_60) AT=25.025n

* CHECK dout1_61 Vdout1_61ck4 = 0 time = 25
.meas tran vdout1_61ck4 FIND v(dout1_61) AT=25.025n

* CHECK dout1_62 Vdout1_62ck4 = 0 time = 25
.meas tran vdout1_62ck4 FIND v(dout1_62) AT=25.025n

* CHECK dout1_63 Vdout1_63ck4 = 0 time = 25
.meas tran vdout1_63ck4 FIND v(dout1_63) AT=25.025n

* CHECK dout1_64 Vdout1_64ck4 = 0 time = 25
.meas tran vdout1_64ck4 FIND v(dout1_64) AT=25.025n

* CHECK dout1_65 Vdout1_65ck4 = 0.9 time = 25
.meas tran vdout1_65ck4 FIND v(dout1_65) AT=25.025n

* CHECK dout1_66 Vdout1_66ck4 = 0.9 time = 25
.meas tran vdout1_66ck4 FIND v(dout1_66) AT=25.025n

* CHECK dout1_67 Vdout1_67ck4 = 0 time = 25
.meas tran vdout1_67ck4 FIND v(dout1_67) AT=25.025n

* CHECK dout1_68 Vdout1_68ck4 = 0 time = 25
.meas tran vdout1_68ck4 FIND v(dout1_68) AT=25.025n

* CHECK dout1_69 Vdout1_69ck4 = 0 time = 25
.meas tran vdout1_69ck4 FIND v(dout1_69) AT=25.025n

* CHECK dout1_70 Vdout1_70ck4 = 0.9 time = 25
.meas tran vdout1_70ck4 FIND v(dout1_70) AT=25.025n

* CHECK dout1_71 Vdout1_71ck4 = 0 time = 25
.meas tran vdout1_71ck4 FIND v(dout1_71) AT=25.025n

* CHECK dout1_0 Vdout1_0ck6 = 0.9 time = 35
.meas tran vdout1_0ck6 FIND v(dout1_0) AT=35.025n

* CHECK dout1_1 Vdout1_1ck6 = 0 time = 35
.meas tran vdout1_1ck6 FIND v(dout1_1) AT=35.025n

* CHECK dout1_2 Vdout1_2ck6 = 0.9 time = 35
.meas tran vdout1_2ck6 FIND v(dout1_2) AT=35.025n

* CHECK dout1_3 Vdout1_3ck6 = 0 time = 35
.meas tran vdout1_3ck6 FIND v(dout1_3) AT=35.025n

* CHECK dout1_4 Vdout1_4ck6 = 0.9 time = 35
.meas tran vdout1_4ck6 FIND v(dout1_4) AT=35.025n

* CHECK dout1_5 Vdout1_5ck6 = 0.9 time = 35
.meas tran vdout1_5ck6 FIND v(dout1_5) AT=35.025n

* CHECK dout1_6 Vdout1_6ck6 = 0.9 time = 35
.meas tran vdout1_6ck6 FIND v(dout1_6) AT=35.025n

* CHECK dout1_7 Vdout1_7ck6 = 0 time = 35
.meas tran vdout1_7ck6 FIND v(dout1_7) AT=35.025n

* CHECK dout1_8 Vdout1_8ck6 = 0.9 time = 35
.meas tran vdout1_8ck6 FIND v(dout1_8) AT=35.025n

* CHECK dout1_9 Vdout1_9ck6 = 0 time = 35
.meas tran vdout1_9ck6 FIND v(dout1_9) AT=35.025n

* CHECK dout1_10 Vdout1_10ck6 = 0 time = 35
.meas tran vdout1_10ck6 FIND v(dout1_10) AT=35.025n

* CHECK dout1_11 Vdout1_11ck6 = 0 time = 35
.meas tran vdout1_11ck6 FIND v(dout1_11) AT=35.025n

* CHECK dout1_12 Vdout1_12ck6 = 0.9 time = 35
.meas tran vdout1_12ck6 FIND v(dout1_12) AT=35.025n

* CHECK dout1_13 Vdout1_13ck6 = 0 time = 35
.meas tran vdout1_13ck6 FIND v(dout1_13) AT=35.025n

* CHECK dout1_14 Vdout1_14ck6 = 0.9 time = 35
.meas tran vdout1_14ck6 FIND v(dout1_14) AT=35.025n

* CHECK dout1_15 Vdout1_15ck6 = 0.9 time = 35
.meas tran vdout1_15ck6 FIND v(dout1_15) AT=35.025n

* CHECK dout1_16 Vdout1_16ck6 = 0.9 time = 35
.meas tran vdout1_16ck6 FIND v(dout1_16) AT=35.025n

* CHECK dout1_17 Vdout1_17ck6 = 0.9 time = 35
.meas tran vdout1_17ck6 FIND v(dout1_17) AT=35.025n

* CHECK dout1_18 Vdout1_18ck6 = 0 time = 35
.meas tran vdout1_18ck6 FIND v(dout1_18) AT=35.025n

* CHECK dout1_19 Vdout1_19ck6 = 0 time = 35
.meas tran vdout1_19ck6 FIND v(dout1_19) AT=35.025n

* CHECK dout1_20 Vdout1_20ck6 = 0.9 time = 35
.meas tran vdout1_20ck6 FIND v(dout1_20) AT=35.025n

* CHECK dout1_21 Vdout1_21ck6 = 0 time = 35
.meas tran vdout1_21ck6 FIND v(dout1_21) AT=35.025n

* CHECK dout1_22 Vdout1_22ck6 = 0.9 time = 35
.meas tran vdout1_22ck6 FIND v(dout1_22) AT=35.025n

* CHECK dout1_23 Vdout1_23ck6 = 0 time = 35
.meas tran vdout1_23ck6 FIND v(dout1_23) AT=35.025n

* CHECK dout1_24 Vdout1_24ck6 = 0 time = 35
.meas tran vdout1_24ck6 FIND v(dout1_24) AT=35.025n

* CHECK dout1_25 Vdout1_25ck6 = 0 time = 35
.meas tran vdout1_25ck6 FIND v(dout1_25) AT=35.025n

* CHECK dout1_26 Vdout1_26ck6 = 0.9 time = 35
.meas tran vdout1_26ck6 FIND v(dout1_26) AT=35.025n

* CHECK dout1_27 Vdout1_27ck6 = 0.9 time = 35
.meas tran vdout1_27ck6 FIND v(dout1_27) AT=35.025n

* CHECK dout1_28 Vdout1_28ck6 = 0.9 time = 35
.meas tran vdout1_28ck6 FIND v(dout1_28) AT=35.025n

* CHECK dout1_29 Vdout1_29ck6 = 0 time = 35
.meas tran vdout1_29ck6 FIND v(dout1_29) AT=35.025n

* CHECK dout1_30 Vdout1_30ck6 = 0 time = 35
.meas tran vdout1_30ck6 FIND v(dout1_30) AT=35.025n

* CHECK dout1_31 Vdout1_31ck6 = 0 time = 35
.meas tran vdout1_31ck6 FIND v(dout1_31) AT=35.025n

* CHECK dout1_32 Vdout1_32ck6 = 0 time = 35
.meas tran vdout1_32ck6 FIND v(dout1_32) AT=35.025n

* CHECK dout1_33 Vdout1_33ck6 = 0 time = 35
.meas tran vdout1_33ck6 FIND v(dout1_33) AT=35.025n

* CHECK dout1_34 Vdout1_34ck6 = 0.9 time = 35
.meas tran vdout1_34ck6 FIND v(dout1_34) AT=35.025n

* CHECK dout1_35 Vdout1_35ck6 = 0.9 time = 35
.meas tran vdout1_35ck6 FIND v(dout1_35) AT=35.025n

* CHECK dout1_36 Vdout1_36ck6 = 0.9 time = 35
.meas tran vdout1_36ck6 FIND v(dout1_36) AT=35.025n

* CHECK dout1_37 Vdout1_37ck6 = 0 time = 35
.meas tran vdout1_37ck6 FIND v(dout1_37) AT=35.025n

* CHECK dout1_38 Vdout1_38ck6 = 0 time = 35
.meas tran vdout1_38ck6 FIND v(dout1_38) AT=35.025n

* CHECK dout1_39 Vdout1_39ck6 = 0 time = 35
.meas tran vdout1_39ck6 FIND v(dout1_39) AT=35.025n

* CHECK dout1_40 Vdout1_40ck6 = 0 time = 35
.meas tran vdout1_40ck6 FIND v(dout1_40) AT=35.025n

* CHECK dout1_41 Vdout1_41ck6 = 0 time = 35
.meas tran vdout1_41ck6 FIND v(dout1_41) AT=35.025n

* CHECK dout1_42 Vdout1_42ck6 = 0.9 time = 35
.meas tran vdout1_42ck6 FIND v(dout1_42) AT=35.025n

* CHECK dout1_43 Vdout1_43ck6 = 0.9 time = 35
.meas tran vdout1_43ck6 FIND v(dout1_43) AT=35.025n

* CHECK dout1_44 Vdout1_44ck6 = 0.9 time = 35
.meas tran vdout1_44ck6 FIND v(dout1_44) AT=35.025n

* CHECK dout1_45 Vdout1_45ck6 = 0 time = 35
.meas tran vdout1_45ck6 FIND v(dout1_45) AT=35.025n

* CHECK dout1_46 Vdout1_46ck6 = 0 time = 35
.meas tran vdout1_46ck6 FIND v(dout1_46) AT=35.025n

* CHECK dout1_47 Vdout1_47ck6 = 0 time = 35
.meas tran vdout1_47ck6 FIND v(dout1_47) AT=35.025n

* CHECK dout1_48 Vdout1_48ck6 = 0 time = 35
.meas tran vdout1_48ck6 FIND v(dout1_48) AT=35.025n

* CHECK dout1_49 Vdout1_49ck6 = 0 time = 35
.meas tran vdout1_49ck6 FIND v(dout1_49) AT=35.025n

* CHECK dout1_50 Vdout1_50ck6 = 0 time = 35
.meas tran vdout1_50ck6 FIND v(dout1_50) AT=35.025n

* CHECK dout1_51 Vdout1_51ck6 = 0 time = 35
.meas tran vdout1_51ck6 FIND v(dout1_51) AT=35.025n

* CHECK dout1_52 Vdout1_52ck6 = 0.9 time = 35
.meas tran vdout1_52ck6 FIND v(dout1_52) AT=35.025n

* CHECK dout1_53 Vdout1_53ck6 = 0 time = 35
.meas tran vdout1_53ck6 FIND v(dout1_53) AT=35.025n

* CHECK dout1_54 Vdout1_54ck6 = 0 time = 35
.meas tran vdout1_54ck6 FIND v(dout1_54) AT=35.025n

* CHECK dout1_55 Vdout1_55ck6 = 0 time = 35
.meas tran vdout1_55ck6 FIND v(dout1_55) AT=35.025n

* CHECK dout1_56 Vdout1_56ck6 = 0 time = 35
.meas tran vdout1_56ck6 FIND v(dout1_56) AT=35.025n

* CHECK dout1_57 Vdout1_57ck6 = 0 time = 35
.meas tran vdout1_57ck6 FIND v(dout1_57) AT=35.025n

* CHECK dout1_58 Vdout1_58ck6 = 0.9 time = 35
.meas tran vdout1_58ck6 FIND v(dout1_58) AT=35.025n

* CHECK dout1_59 Vdout1_59ck6 = 0.9 time = 35
.meas tran vdout1_59ck6 FIND v(dout1_59) AT=35.025n

* CHECK dout1_60 Vdout1_60ck6 = 0.9 time = 35
.meas tran vdout1_60ck6 FIND v(dout1_60) AT=35.025n

* CHECK dout1_61 Vdout1_61ck6 = 0.9 time = 35
.meas tran vdout1_61ck6 FIND v(dout1_61) AT=35.025n

* CHECK dout1_62 Vdout1_62ck6 = 0 time = 35
.meas tran vdout1_62ck6 FIND v(dout1_62) AT=35.025n

* CHECK dout1_63 Vdout1_63ck6 = 0.9 time = 35
.meas tran vdout1_63ck6 FIND v(dout1_63) AT=35.025n

* CHECK dout1_64 Vdout1_64ck6 = 0 time = 35
.meas tran vdout1_64ck6 FIND v(dout1_64) AT=35.025n

* CHECK dout1_65 Vdout1_65ck6 = 0.9 time = 35
.meas tran vdout1_65ck6 FIND v(dout1_65) AT=35.025n

* CHECK dout1_66 Vdout1_66ck6 = 0 time = 35
.meas tran vdout1_66ck6 FIND v(dout1_66) AT=35.025n

* CHECK dout1_67 Vdout1_67ck6 = 0.9 time = 35
.meas tran vdout1_67ck6 FIND v(dout1_67) AT=35.025n

* CHECK dout1_68 Vdout1_68ck6 = 0 time = 35
.meas tran vdout1_68ck6 FIND v(dout1_68) AT=35.025n

* CHECK dout1_69 Vdout1_69ck6 = 0.9 time = 35
.meas tran vdout1_69ck6 FIND v(dout1_69) AT=35.025n

* CHECK dout1_70 Vdout1_70ck6 = 0.9 time = 35
.meas tran vdout1_70ck6 FIND v(dout1_70) AT=35.025n

* CHECK dout1_71 Vdout1_71ck6 = 0 time = 35
.meas tran vdout1_71ck6 FIND v(dout1_71) AT=35.025n

* CHECK dout1_0 Vdout1_0ck14 = 0.9 time = 75
.meas tran vdout1_0ck14 FIND v(dout1_0) AT=75.025n

* CHECK dout1_1 Vdout1_1ck14 = 0 time = 75
.meas tran vdout1_1ck14 FIND v(dout1_1) AT=75.025n

* CHECK dout1_2 Vdout1_2ck14 = 0.9 time = 75
.meas tran vdout1_2ck14 FIND v(dout1_2) AT=75.025n

* CHECK dout1_3 Vdout1_3ck14 = 0 time = 75
.meas tran vdout1_3ck14 FIND v(dout1_3) AT=75.025n

* CHECK dout1_4 Vdout1_4ck14 = 0.9 time = 75
.meas tran vdout1_4ck14 FIND v(dout1_4) AT=75.025n

* CHECK dout1_5 Vdout1_5ck14 = 0.9 time = 75
.meas tran vdout1_5ck14 FIND v(dout1_5) AT=75.025n

* CHECK dout1_6 Vdout1_6ck14 = 0.9 time = 75
.meas tran vdout1_6ck14 FIND v(dout1_6) AT=75.025n

* CHECK dout1_7 Vdout1_7ck14 = 0 time = 75
.meas tran vdout1_7ck14 FIND v(dout1_7) AT=75.025n

* CHECK dout1_8 Vdout1_8ck14 = 0.9 time = 75
.meas tran vdout1_8ck14 FIND v(dout1_8) AT=75.025n

* CHECK dout1_9 Vdout1_9ck14 = 0 time = 75
.meas tran vdout1_9ck14 FIND v(dout1_9) AT=75.025n

* CHECK dout1_10 Vdout1_10ck14 = 0 time = 75
.meas tran vdout1_10ck14 FIND v(dout1_10) AT=75.025n

* CHECK dout1_11 Vdout1_11ck14 = 0 time = 75
.meas tran vdout1_11ck14 FIND v(dout1_11) AT=75.025n

* CHECK dout1_12 Vdout1_12ck14 = 0.9 time = 75
.meas tran vdout1_12ck14 FIND v(dout1_12) AT=75.025n

* CHECK dout1_13 Vdout1_13ck14 = 0 time = 75
.meas tran vdout1_13ck14 FIND v(dout1_13) AT=75.025n

* CHECK dout1_14 Vdout1_14ck14 = 0.9 time = 75
.meas tran vdout1_14ck14 FIND v(dout1_14) AT=75.025n

* CHECK dout1_15 Vdout1_15ck14 = 0.9 time = 75
.meas tran vdout1_15ck14 FIND v(dout1_15) AT=75.025n

* CHECK dout1_16 Vdout1_16ck14 = 0.9 time = 75
.meas tran vdout1_16ck14 FIND v(dout1_16) AT=75.025n

* CHECK dout1_17 Vdout1_17ck14 = 0.9 time = 75
.meas tran vdout1_17ck14 FIND v(dout1_17) AT=75.025n

* CHECK dout1_18 Vdout1_18ck14 = 0 time = 75
.meas tran vdout1_18ck14 FIND v(dout1_18) AT=75.025n

* CHECK dout1_19 Vdout1_19ck14 = 0 time = 75
.meas tran vdout1_19ck14 FIND v(dout1_19) AT=75.025n

* CHECK dout1_20 Vdout1_20ck14 = 0.9 time = 75
.meas tran vdout1_20ck14 FIND v(dout1_20) AT=75.025n

* CHECK dout1_21 Vdout1_21ck14 = 0 time = 75
.meas tran vdout1_21ck14 FIND v(dout1_21) AT=75.025n

* CHECK dout1_22 Vdout1_22ck14 = 0.9 time = 75
.meas tran vdout1_22ck14 FIND v(dout1_22) AT=75.025n

* CHECK dout1_23 Vdout1_23ck14 = 0 time = 75
.meas tran vdout1_23ck14 FIND v(dout1_23) AT=75.025n

* CHECK dout1_24 Vdout1_24ck14 = 0 time = 75
.meas tran vdout1_24ck14 FIND v(dout1_24) AT=75.025n

* CHECK dout1_25 Vdout1_25ck14 = 0 time = 75
.meas tran vdout1_25ck14 FIND v(dout1_25) AT=75.025n

* CHECK dout1_26 Vdout1_26ck14 = 0.9 time = 75
.meas tran vdout1_26ck14 FIND v(dout1_26) AT=75.025n

* CHECK dout1_27 Vdout1_27ck14 = 0.9 time = 75
.meas tran vdout1_27ck14 FIND v(dout1_27) AT=75.025n

* CHECK dout1_28 Vdout1_28ck14 = 0.9 time = 75
.meas tran vdout1_28ck14 FIND v(dout1_28) AT=75.025n

* CHECK dout1_29 Vdout1_29ck14 = 0 time = 75
.meas tran vdout1_29ck14 FIND v(dout1_29) AT=75.025n

* CHECK dout1_30 Vdout1_30ck14 = 0 time = 75
.meas tran vdout1_30ck14 FIND v(dout1_30) AT=75.025n

* CHECK dout1_31 Vdout1_31ck14 = 0 time = 75
.meas tran vdout1_31ck14 FIND v(dout1_31) AT=75.025n

* CHECK dout1_32 Vdout1_32ck14 = 0 time = 75
.meas tran vdout1_32ck14 FIND v(dout1_32) AT=75.025n

* CHECK dout1_33 Vdout1_33ck14 = 0 time = 75
.meas tran vdout1_33ck14 FIND v(dout1_33) AT=75.025n

* CHECK dout1_34 Vdout1_34ck14 = 0.9 time = 75
.meas tran vdout1_34ck14 FIND v(dout1_34) AT=75.025n

* CHECK dout1_35 Vdout1_35ck14 = 0.9 time = 75
.meas tran vdout1_35ck14 FIND v(dout1_35) AT=75.025n

* CHECK dout1_36 Vdout1_36ck14 = 0.9 time = 75
.meas tran vdout1_36ck14 FIND v(dout1_36) AT=75.025n

* CHECK dout1_37 Vdout1_37ck14 = 0 time = 75
.meas tran vdout1_37ck14 FIND v(dout1_37) AT=75.025n

* CHECK dout1_38 Vdout1_38ck14 = 0 time = 75
.meas tran vdout1_38ck14 FIND v(dout1_38) AT=75.025n

* CHECK dout1_39 Vdout1_39ck14 = 0 time = 75
.meas tran vdout1_39ck14 FIND v(dout1_39) AT=75.025n

* CHECK dout1_40 Vdout1_40ck14 = 0 time = 75
.meas tran vdout1_40ck14 FIND v(dout1_40) AT=75.025n

* CHECK dout1_41 Vdout1_41ck14 = 0 time = 75
.meas tran vdout1_41ck14 FIND v(dout1_41) AT=75.025n

* CHECK dout1_42 Vdout1_42ck14 = 0.9 time = 75
.meas tran vdout1_42ck14 FIND v(dout1_42) AT=75.025n

* CHECK dout1_43 Vdout1_43ck14 = 0.9 time = 75
.meas tran vdout1_43ck14 FIND v(dout1_43) AT=75.025n

* CHECK dout1_44 Vdout1_44ck14 = 0.9 time = 75
.meas tran vdout1_44ck14 FIND v(dout1_44) AT=75.025n

* CHECK dout1_45 Vdout1_45ck14 = 0 time = 75
.meas tran vdout1_45ck14 FIND v(dout1_45) AT=75.025n

* CHECK dout1_46 Vdout1_46ck14 = 0 time = 75
.meas tran vdout1_46ck14 FIND v(dout1_46) AT=75.025n

* CHECK dout1_47 Vdout1_47ck14 = 0 time = 75
.meas tran vdout1_47ck14 FIND v(dout1_47) AT=75.025n

* CHECK dout1_48 Vdout1_48ck14 = 0 time = 75
.meas tran vdout1_48ck14 FIND v(dout1_48) AT=75.025n

* CHECK dout1_49 Vdout1_49ck14 = 0 time = 75
.meas tran vdout1_49ck14 FIND v(dout1_49) AT=75.025n

* CHECK dout1_50 Vdout1_50ck14 = 0 time = 75
.meas tran vdout1_50ck14 FIND v(dout1_50) AT=75.025n

* CHECK dout1_51 Vdout1_51ck14 = 0 time = 75
.meas tran vdout1_51ck14 FIND v(dout1_51) AT=75.025n

* CHECK dout1_52 Vdout1_52ck14 = 0.9 time = 75
.meas tran vdout1_52ck14 FIND v(dout1_52) AT=75.025n

* CHECK dout1_53 Vdout1_53ck14 = 0 time = 75
.meas tran vdout1_53ck14 FIND v(dout1_53) AT=75.025n

* CHECK dout1_54 Vdout1_54ck14 = 0 time = 75
.meas tran vdout1_54ck14 FIND v(dout1_54) AT=75.025n

* CHECK dout1_55 Vdout1_55ck14 = 0 time = 75
.meas tran vdout1_55ck14 FIND v(dout1_55) AT=75.025n

* CHECK dout1_56 Vdout1_56ck14 = 0 time = 75
.meas tran vdout1_56ck14 FIND v(dout1_56) AT=75.025n

* CHECK dout1_57 Vdout1_57ck14 = 0 time = 75
.meas tran vdout1_57ck14 FIND v(dout1_57) AT=75.025n

* CHECK dout1_58 Vdout1_58ck14 = 0.9 time = 75
.meas tran vdout1_58ck14 FIND v(dout1_58) AT=75.025n

* CHECK dout1_59 Vdout1_59ck14 = 0.9 time = 75
.meas tran vdout1_59ck14 FIND v(dout1_59) AT=75.025n

* CHECK dout1_60 Vdout1_60ck14 = 0.9 time = 75
.meas tran vdout1_60ck14 FIND v(dout1_60) AT=75.025n

* CHECK dout1_61 Vdout1_61ck14 = 0.9 time = 75
.meas tran vdout1_61ck14 FIND v(dout1_61) AT=75.025n

* CHECK dout1_62 Vdout1_62ck14 = 0 time = 75
.meas tran vdout1_62ck14 FIND v(dout1_62) AT=75.025n

* CHECK dout1_63 Vdout1_63ck14 = 0.9 time = 75
.meas tran vdout1_63ck14 FIND v(dout1_63) AT=75.025n

* CHECK dout1_64 Vdout1_64ck14 = 0 time = 75
.meas tran vdout1_64ck14 FIND v(dout1_64) AT=75.025n

* CHECK dout1_65 Vdout1_65ck14 = 0.9 time = 75
.meas tran vdout1_65ck14 FIND v(dout1_65) AT=75.025n

* CHECK dout1_66 Vdout1_66ck14 = 0 time = 75
.meas tran vdout1_66ck14 FIND v(dout1_66) AT=75.025n

* CHECK dout1_67 Vdout1_67ck14 = 0.9 time = 75
.meas tran vdout1_67ck14 FIND v(dout1_67) AT=75.025n

* CHECK dout1_68 Vdout1_68ck14 = 0 time = 75
.meas tran vdout1_68ck14 FIND v(dout1_68) AT=75.025n

* CHECK dout1_69 Vdout1_69ck14 = 0.9 time = 75
.meas tran vdout1_69ck14 FIND v(dout1_69) AT=75.025n

* CHECK dout1_70 Vdout1_70ck14 = 0.9 time = 75
.meas tran vdout1_70ck14 FIND v(dout1_70) AT=75.025n

* CHECK dout1_71 Vdout1_71ck14 = 0 time = 75
.meas tran vdout1_71ck14 FIND v(dout1_71) AT=75.025n

* CHECK dout1_0 Vdout1_0ck16 = 0.9 time = 85
.meas tran vdout1_0ck16 FIND v(dout1_0) AT=85.025n

* CHECK dout1_1 Vdout1_1ck16 = 0.9 time = 85
.meas tran vdout1_1ck16 FIND v(dout1_1) AT=85.025n

* CHECK dout1_2 Vdout1_2ck16 = 0.9 time = 85
.meas tran vdout1_2ck16 FIND v(dout1_2) AT=85.025n

* CHECK dout1_3 Vdout1_3ck16 = 0.9 time = 85
.meas tran vdout1_3ck16 FIND v(dout1_3) AT=85.025n

* CHECK dout1_4 Vdout1_4ck16 = 0.9 time = 85
.meas tran vdout1_4ck16 FIND v(dout1_4) AT=85.025n

* CHECK dout1_5 Vdout1_5ck16 = 0.9 time = 85
.meas tran vdout1_5ck16 FIND v(dout1_5) AT=85.025n

* CHECK dout1_6 Vdout1_6ck16 = 0.9 time = 85
.meas tran vdout1_6ck16 FIND v(dout1_6) AT=85.025n

* CHECK dout1_7 Vdout1_7ck16 = 0 time = 85
.meas tran vdout1_7ck16 FIND v(dout1_7) AT=85.025n

* CHECK dout1_8 Vdout1_8ck16 = 0.9 time = 85
.meas tran vdout1_8ck16 FIND v(dout1_8) AT=85.025n

* CHECK dout1_9 Vdout1_9ck16 = 0 time = 85
.meas tran vdout1_9ck16 FIND v(dout1_9) AT=85.025n

* CHECK dout1_10 Vdout1_10ck16 = 0.9 time = 85
.meas tran vdout1_10ck16 FIND v(dout1_10) AT=85.025n

* CHECK dout1_11 Vdout1_11ck16 = 0 time = 85
.meas tran vdout1_11ck16 FIND v(dout1_11) AT=85.025n

* CHECK dout1_12 Vdout1_12ck16 = 0 time = 85
.meas tran vdout1_12ck16 FIND v(dout1_12) AT=85.025n

* CHECK dout1_13 Vdout1_13ck16 = 0.9 time = 85
.meas tran vdout1_13ck16 FIND v(dout1_13) AT=85.025n

* CHECK dout1_14 Vdout1_14ck16 = 0 time = 85
.meas tran vdout1_14ck16 FIND v(dout1_14) AT=85.025n

* CHECK dout1_15 Vdout1_15ck16 = 0 time = 85
.meas tran vdout1_15ck16 FIND v(dout1_15) AT=85.025n

* CHECK dout1_16 Vdout1_16ck16 = 0 time = 85
.meas tran vdout1_16ck16 FIND v(dout1_16) AT=85.025n

* CHECK dout1_17 Vdout1_17ck16 = 0 time = 85
.meas tran vdout1_17ck16 FIND v(dout1_17) AT=85.025n

* CHECK dout1_18 Vdout1_18ck16 = 0 time = 85
.meas tran vdout1_18ck16 FIND v(dout1_18) AT=85.025n

* CHECK dout1_19 Vdout1_19ck16 = 0.9 time = 85
.meas tran vdout1_19ck16 FIND v(dout1_19) AT=85.025n

* CHECK dout1_20 Vdout1_20ck16 = 0 time = 85
.meas tran vdout1_20ck16 FIND v(dout1_20) AT=85.025n

* CHECK dout1_21 Vdout1_21ck16 = 0 time = 85
.meas tran vdout1_21ck16 FIND v(dout1_21) AT=85.025n

* CHECK dout1_22 Vdout1_22ck16 = 0 time = 85
.meas tran vdout1_22ck16 FIND v(dout1_22) AT=85.025n

* CHECK dout1_23 Vdout1_23ck16 = 0 time = 85
.meas tran vdout1_23ck16 FIND v(dout1_23) AT=85.025n

* CHECK dout1_24 Vdout1_24ck16 = 0.9 time = 85
.meas tran vdout1_24ck16 FIND v(dout1_24) AT=85.025n

* CHECK dout1_25 Vdout1_25ck16 = 0 time = 85
.meas tran vdout1_25ck16 FIND v(dout1_25) AT=85.025n

* CHECK dout1_26 Vdout1_26ck16 = 0.9 time = 85
.meas tran vdout1_26ck16 FIND v(dout1_26) AT=85.025n

* CHECK dout1_27 Vdout1_27ck16 = 0.9 time = 85
.meas tran vdout1_27ck16 FIND v(dout1_27) AT=85.025n

* CHECK dout1_28 Vdout1_28ck16 = 0 time = 85
.meas tran vdout1_28ck16 FIND v(dout1_28) AT=85.025n

* CHECK dout1_29 Vdout1_29ck16 = 0 time = 85
.meas tran vdout1_29ck16 FIND v(dout1_29) AT=85.025n

* CHECK dout1_30 Vdout1_30ck16 = 0.9 time = 85
.meas tran vdout1_30ck16 FIND v(dout1_30) AT=85.025n

* CHECK dout1_31 Vdout1_31ck16 = 0 time = 85
.meas tran vdout1_31ck16 FIND v(dout1_31) AT=85.025n

* CHECK dout1_32 Vdout1_32ck16 = 0 time = 85
.meas tran vdout1_32ck16 FIND v(dout1_32) AT=85.025n

* CHECK dout1_33 Vdout1_33ck16 = 0.9 time = 85
.meas tran vdout1_33ck16 FIND v(dout1_33) AT=85.025n

* CHECK dout1_34 Vdout1_34ck16 = 0.9 time = 85
.meas tran vdout1_34ck16 FIND v(dout1_34) AT=85.025n

* CHECK dout1_35 Vdout1_35ck16 = 0.9 time = 85
.meas tran vdout1_35ck16 FIND v(dout1_35) AT=85.025n

* CHECK dout1_36 Vdout1_36ck16 = 0.9 time = 85
.meas tran vdout1_36ck16 FIND v(dout1_36) AT=85.025n

* CHECK dout1_37 Vdout1_37ck16 = 0 time = 85
.meas tran vdout1_37ck16 FIND v(dout1_37) AT=85.025n

* CHECK dout1_38 Vdout1_38ck16 = 0 time = 85
.meas tran vdout1_38ck16 FIND v(dout1_38) AT=85.025n

* CHECK dout1_39 Vdout1_39ck16 = 0.9 time = 85
.meas tran vdout1_39ck16 FIND v(dout1_39) AT=85.025n

* CHECK dout1_40 Vdout1_40ck16 = 0 time = 85
.meas tran vdout1_40ck16 FIND v(dout1_40) AT=85.025n

* CHECK dout1_41 Vdout1_41ck16 = 0 time = 85
.meas tran vdout1_41ck16 FIND v(dout1_41) AT=85.025n

* CHECK dout1_42 Vdout1_42ck16 = 0 time = 85
.meas tran vdout1_42ck16 FIND v(dout1_42) AT=85.025n

* CHECK dout1_43 Vdout1_43ck16 = 0.9 time = 85
.meas tran vdout1_43ck16 FIND v(dout1_43) AT=85.025n

* CHECK dout1_44 Vdout1_44ck16 = 0.9 time = 85
.meas tran vdout1_44ck16 FIND v(dout1_44) AT=85.025n

* CHECK dout1_45 Vdout1_45ck16 = 0.9 time = 85
.meas tran vdout1_45ck16 FIND v(dout1_45) AT=85.025n

* CHECK dout1_46 Vdout1_46ck16 = 0 time = 85
.meas tran vdout1_46ck16 FIND v(dout1_46) AT=85.025n

* CHECK dout1_47 Vdout1_47ck16 = 0.9 time = 85
.meas tran vdout1_47ck16 FIND v(dout1_47) AT=85.025n

* CHECK dout1_48 Vdout1_48ck16 = 0.9 time = 85
.meas tran vdout1_48ck16 FIND v(dout1_48) AT=85.025n

* CHECK dout1_49 Vdout1_49ck16 = 0.9 time = 85
.meas tran vdout1_49ck16 FIND v(dout1_49) AT=85.025n

* CHECK dout1_50 Vdout1_50ck16 = 0.9 time = 85
.meas tran vdout1_50ck16 FIND v(dout1_50) AT=85.025n

* CHECK dout1_51 Vdout1_51ck16 = 0 time = 85
.meas tran vdout1_51ck16 FIND v(dout1_51) AT=85.025n

* CHECK dout1_52 Vdout1_52ck16 = 0 time = 85
.meas tran vdout1_52ck16 FIND v(dout1_52) AT=85.025n

* CHECK dout1_53 Vdout1_53ck16 = 0.9 time = 85
.meas tran vdout1_53ck16 FIND v(dout1_53) AT=85.025n

* CHECK dout1_54 Vdout1_54ck16 = 0.9 time = 85
.meas tran vdout1_54ck16 FIND v(dout1_54) AT=85.025n

* CHECK dout1_55 Vdout1_55ck16 = 0.9 time = 85
.meas tran vdout1_55ck16 FIND v(dout1_55) AT=85.025n

* CHECK dout1_56 Vdout1_56ck16 = 0.9 time = 85
.meas tran vdout1_56ck16 FIND v(dout1_56) AT=85.025n

* CHECK dout1_57 Vdout1_57ck16 = 0 time = 85
.meas tran vdout1_57ck16 FIND v(dout1_57) AT=85.025n

* CHECK dout1_58 Vdout1_58ck16 = 0.9 time = 85
.meas tran vdout1_58ck16 FIND v(dout1_58) AT=85.025n

* CHECK dout1_59 Vdout1_59ck16 = 0.9 time = 85
.meas tran vdout1_59ck16 FIND v(dout1_59) AT=85.025n

* CHECK dout1_60 Vdout1_60ck16 = 0.9 time = 85
.meas tran vdout1_60ck16 FIND v(dout1_60) AT=85.025n

* CHECK dout1_61 Vdout1_61ck16 = 0 time = 85
.meas tran vdout1_61ck16 FIND v(dout1_61) AT=85.025n

* CHECK dout1_62 Vdout1_62ck16 = 0 time = 85
.meas tran vdout1_62ck16 FIND v(dout1_62) AT=85.025n

* CHECK dout1_63 Vdout1_63ck16 = 0 time = 85
.meas tran vdout1_63ck16 FIND v(dout1_63) AT=85.025n

* CHECK dout1_64 Vdout1_64ck16 = 0 time = 85
.meas tran vdout1_64ck16 FIND v(dout1_64) AT=85.025n

* CHECK dout1_65 Vdout1_65ck16 = 0.9 time = 85
.meas tran vdout1_65ck16 FIND v(dout1_65) AT=85.025n

* CHECK dout1_66 Vdout1_66ck16 = 0.9 time = 85
.meas tran vdout1_66ck16 FIND v(dout1_66) AT=85.025n

* CHECK dout1_67 Vdout1_67ck16 = 0.9 time = 85
.meas tran vdout1_67ck16 FIND v(dout1_67) AT=85.025n

* CHECK dout1_68 Vdout1_68ck16 = 0 time = 85
.meas tran vdout1_68ck16 FIND v(dout1_68) AT=85.025n

* CHECK dout1_69 Vdout1_69ck16 = 0.9 time = 85
.meas tran vdout1_69ck16 FIND v(dout1_69) AT=85.025n

* CHECK dout1_70 Vdout1_70ck16 = 0.9 time = 85
.meas tran vdout1_70ck16 FIND v(dout1_70) AT=85.025n

* CHECK dout1_71 Vdout1_71ck16 = 0 time = 85
.meas tran vdout1_71ck16 FIND v(dout1_71) AT=85.025n

* CHECK dout1_0 Vdout1_0ck20 = 0 time = 105
.meas tran vdout1_0ck20 FIND v(dout1_0) AT=105.025n

* CHECK dout1_1 Vdout1_1ck20 = 0 time = 105
.meas tran vdout1_1ck20 FIND v(dout1_1) AT=105.025n

* CHECK dout1_2 Vdout1_2ck20 = 0.9 time = 105
.meas tran vdout1_2ck20 FIND v(dout1_2) AT=105.025n

* CHECK dout1_3 Vdout1_3ck20 = 0.9 time = 105
.meas tran vdout1_3ck20 FIND v(dout1_3) AT=105.025n

* CHECK dout1_4 Vdout1_4ck20 = 0.9 time = 105
.meas tran vdout1_4ck20 FIND v(dout1_4) AT=105.025n

* CHECK dout1_5 Vdout1_5ck20 = 0.9 time = 105
.meas tran vdout1_5ck20 FIND v(dout1_5) AT=105.025n

* CHECK dout1_6 Vdout1_6ck20 = 0.9 time = 105
.meas tran vdout1_6ck20 FIND v(dout1_6) AT=105.025n

* CHECK dout1_7 Vdout1_7ck20 = 0.9 time = 105
.meas tran vdout1_7ck20 FIND v(dout1_7) AT=105.025n

* CHECK dout1_8 Vdout1_8ck20 = 0 time = 105
.meas tran vdout1_8ck20 FIND v(dout1_8) AT=105.025n

* CHECK dout1_9 Vdout1_9ck20 = 0 time = 105
.meas tran vdout1_9ck20 FIND v(dout1_9) AT=105.025n

* CHECK dout1_10 Vdout1_10ck20 = 0.9 time = 105
.meas tran vdout1_10ck20 FIND v(dout1_10) AT=105.025n

* CHECK dout1_11 Vdout1_11ck20 = 0.9 time = 105
.meas tran vdout1_11ck20 FIND v(dout1_11) AT=105.025n

* CHECK dout1_12 Vdout1_12ck20 = 0 time = 105
.meas tran vdout1_12ck20 FIND v(dout1_12) AT=105.025n

* CHECK dout1_13 Vdout1_13ck20 = 0 time = 105
.meas tran vdout1_13ck20 FIND v(dout1_13) AT=105.025n

* CHECK dout1_14 Vdout1_14ck20 = 0.9 time = 105
.meas tran vdout1_14ck20 FIND v(dout1_14) AT=105.025n

* CHECK dout1_15 Vdout1_15ck20 = 0.9 time = 105
.meas tran vdout1_15ck20 FIND v(dout1_15) AT=105.025n

* CHECK dout1_16 Vdout1_16ck20 = 0.9 time = 105
.meas tran vdout1_16ck20 FIND v(dout1_16) AT=105.025n

* CHECK dout1_17 Vdout1_17ck20 = 0 time = 105
.meas tran vdout1_17ck20 FIND v(dout1_17) AT=105.025n

* CHECK dout1_18 Vdout1_18ck20 = 0 time = 105
.meas tran vdout1_18ck20 FIND v(dout1_18) AT=105.025n

* CHECK dout1_19 Vdout1_19ck20 = 0 time = 105
.meas tran vdout1_19ck20 FIND v(dout1_19) AT=105.025n

* CHECK dout1_20 Vdout1_20ck20 = 0.9 time = 105
.meas tran vdout1_20ck20 FIND v(dout1_20) AT=105.025n

* CHECK dout1_21 Vdout1_21ck20 = 0.9 time = 105
.meas tran vdout1_21ck20 FIND v(dout1_21) AT=105.025n

* CHECK dout1_22 Vdout1_22ck20 = 0.9 time = 105
.meas tran vdout1_22ck20 FIND v(dout1_22) AT=105.025n

* CHECK dout1_23 Vdout1_23ck20 = 0.9 time = 105
.meas tran vdout1_23ck20 FIND v(dout1_23) AT=105.025n

* CHECK dout1_24 Vdout1_24ck20 = 0.9 time = 105
.meas tran vdout1_24ck20 FIND v(dout1_24) AT=105.025n

* CHECK dout1_25 Vdout1_25ck20 = 0.9 time = 105
.meas tran vdout1_25ck20 FIND v(dout1_25) AT=105.025n

* CHECK dout1_26 Vdout1_26ck20 = 0.9 time = 105
.meas tran vdout1_26ck20 FIND v(dout1_26) AT=105.025n

* CHECK dout1_27 Vdout1_27ck20 = 0 time = 105
.meas tran vdout1_27ck20 FIND v(dout1_27) AT=105.025n

* CHECK dout1_28 Vdout1_28ck20 = 0 time = 105
.meas tran vdout1_28ck20 FIND v(dout1_28) AT=105.025n

* CHECK dout1_29 Vdout1_29ck20 = 0.9 time = 105
.meas tran vdout1_29ck20 FIND v(dout1_29) AT=105.025n

* CHECK dout1_30 Vdout1_30ck20 = 0 time = 105
.meas tran vdout1_30ck20 FIND v(dout1_30) AT=105.025n

* CHECK dout1_31 Vdout1_31ck20 = 0.9 time = 105
.meas tran vdout1_31ck20 FIND v(dout1_31) AT=105.025n

* CHECK dout1_32 Vdout1_32ck20 = 0.9 time = 105
.meas tran vdout1_32ck20 FIND v(dout1_32) AT=105.025n

* CHECK dout1_33 Vdout1_33ck20 = 0 time = 105
.meas tran vdout1_33ck20 FIND v(dout1_33) AT=105.025n

* CHECK dout1_34 Vdout1_34ck20 = 0 time = 105
.meas tran vdout1_34ck20 FIND v(dout1_34) AT=105.025n

* CHECK dout1_35 Vdout1_35ck20 = 0.9 time = 105
.meas tran vdout1_35ck20 FIND v(dout1_35) AT=105.025n

* CHECK dout1_36 Vdout1_36ck20 = 0 time = 105
.meas tran vdout1_36ck20 FIND v(dout1_36) AT=105.025n

* CHECK dout1_37 Vdout1_37ck20 = 0.9 time = 105
.meas tran vdout1_37ck20 FIND v(dout1_37) AT=105.025n

* CHECK dout1_38 Vdout1_38ck20 = 0.9 time = 105
.meas tran vdout1_38ck20 FIND v(dout1_38) AT=105.025n

* CHECK dout1_39 Vdout1_39ck20 = 0.9 time = 105
.meas tran vdout1_39ck20 FIND v(dout1_39) AT=105.025n

* CHECK dout1_40 Vdout1_40ck20 = 0.9 time = 105
.meas tran vdout1_40ck20 FIND v(dout1_40) AT=105.025n

* CHECK dout1_41 Vdout1_41ck20 = 0.9 time = 105
.meas tran vdout1_41ck20 FIND v(dout1_41) AT=105.025n

* CHECK dout1_42 Vdout1_42ck20 = 0.9 time = 105
.meas tran vdout1_42ck20 FIND v(dout1_42) AT=105.025n

* CHECK dout1_43 Vdout1_43ck20 = 0 time = 105
.meas tran vdout1_43ck20 FIND v(dout1_43) AT=105.025n

* CHECK dout1_44 Vdout1_44ck20 = 0 time = 105
.meas tran vdout1_44ck20 FIND v(dout1_44) AT=105.025n

* CHECK dout1_45 Vdout1_45ck20 = 0.9 time = 105
.meas tran vdout1_45ck20 FIND v(dout1_45) AT=105.025n

* CHECK dout1_46 Vdout1_46ck20 = 0.9 time = 105
.meas tran vdout1_46ck20 FIND v(dout1_46) AT=105.025n

* CHECK dout1_47 Vdout1_47ck20 = 0.9 time = 105
.meas tran vdout1_47ck20 FIND v(dout1_47) AT=105.025n

* CHECK dout1_48 Vdout1_48ck20 = 0 time = 105
.meas tran vdout1_48ck20 FIND v(dout1_48) AT=105.025n

* CHECK dout1_49 Vdout1_49ck20 = 0 time = 105
.meas tran vdout1_49ck20 FIND v(dout1_49) AT=105.025n

* CHECK dout1_50 Vdout1_50ck20 = 0.9 time = 105
.meas tran vdout1_50ck20 FIND v(dout1_50) AT=105.025n

* CHECK dout1_51 Vdout1_51ck20 = 0 time = 105
.meas tran vdout1_51ck20 FIND v(dout1_51) AT=105.025n

* CHECK dout1_52 Vdout1_52ck20 = 0 time = 105
.meas tran vdout1_52ck20 FIND v(dout1_52) AT=105.025n

* CHECK dout1_53 Vdout1_53ck20 = 0.9 time = 105
.meas tran vdout1_53ck20 FIND v(dout1_53) AT=105.025n

* CHECK dout1_54 Vdout1_54ck20 = 0 time = 105
.meas tran vdout1_54ck20 FIND v(dout1_54) AT=105.025n

* CHECK dout1_55 Vdout1_55ck20 = 0 time = 105
.meas tran vdout1_55ck20 FIND v(dout1_55) AT=105.025n

* CHECK dout1_56 Vdout1_56ck20 = 0 time = 105
.meas tran vdout1_56ck20 FIND v(dout1_56) AT=105.025n

* CHECK dout1_57 Vdout1_57ck20 = 0.9 time = 105
.meas tran vdout1_57ck20 FIND v(dout1_57) AT=105.025n

* CHECK dout1_58 Vdout1_58ck20 = 0 time = 105
.meas tran vdout1_58ck20 FIND v(dout1_58) AT=105.025n

* CHECK dout1_59 Vdout1_59ck20 = 0 time = 105
.meas tran vdout1_59ck20 FIND v(dout1_59) AT=105.025n

* CHECK dout1_60 Vdout1_60ck20 = 0 time = 105
.meas tran vdout1_60ck20 FIND v(dout1_60) AT=105.025n

* CHECK dout1_61 Vdout1_61ck20 = 0 time = 105
.meas tran vdout1_61ck20 FIND v(dout1_61) AT=105.025n

* CHECK dout1_62 Vdout1_62ck20 = 0 time = 105
.meas tran vdout1_62ck20 FIND v(dout1_62) AT=105.025n

* CHECK dout1_63 Vdout1_63ck20 = 0.9 time = 105
.meas tran vdout1_63ck20 FIND v(dout1_63) AT=105.025n

* CHECK dout1_64 Vdout1_64ck20 = 0.9 time = 105
.meas tran vdout1_64ck20 FIND v(dout1_64) AT=105.025n

* CHECK dout1_65 Vdout1_65ck20 = 0 time = 105
.meas tran vdout1_65ck20 FIND v(dout1_65) AT=105.025n

* CHECK dout1_66 Vdout1_66ck20 = 0 time = 105
.meas tran vdout1_66ck20 FIND v(dout1_66) AT=105.025n

* CHECK dout1_67 Vdout1_67ck20 = 0 time = 105
.meas tran vdout1_67ck20 FIND v(dout1_67) AT=105.025n

* CHECK dout1_68 Vdout1_68ck20 = 0 time = 105
.meas tran vdout1_68ck20 FIND v(dout1_68) AT=105.025n

* CHECK dout1_69 Vdout1_69ck20 = 0 time = 105
.meas tran vdout1_69ck20 FIND v(dout1_69) AT=105.025n

* CHECK dout1_70 Vdout1_70ck20 = 0 time = 105
.meas tran vdout1_70ck20 FIND v(dout1_70) AT=105.025n

* CHECK dout1_71 Vdout1_71ck20 = 0.9 time = 105
.meas tran vdout1_71ck20 FIND v(dout1_71) AT=105.025n

* CHECK dout1_0 Vdout1_0ck22 = 0 time = 115
.meas tran vdout1_0ck22 FIND v(dout1_0) AT=115.025n

* CHECK dout1_1 Vdout1_1ck22 = 0.9 time = 115
.meas tran vdout1_1ck22 FIND v(dout1_1) AT=115.025n

* CHECK dout1_2 Vdout1_2ck22 = 0.9 time = 115
.meas tran vdout1_2ck22 FIND v(dout1_2) AT=115.025n

* CHECK dout1_3 Vdout1_3ck22 = 0 time = 115
.meas tran vdout1_3ck22 FIND v(dout1_3) AT=115.025n

* CHECK dout1_4 Vdout1_4ck22 = 0 time = 115
.meas tran vdout1_4ck22 FIND v(dout1_4) AT=115.025n

* CHECK dout1_5 Vdout1_5ck22 = 0.9 time = 115
.meas tran vdout1_5ck22 FIND v(dout1_5) AT=115.025n

* CHECK dout1_6 Vdout1_6ck22 = 0 time = 115
.meas tran vdout1_6ck22 FIND v(dout1_6) AT=115.025n

* CHECK dout1_7 Vdout1_7ck22 = 0 time = 115
.meas tran vdout1_7ck22 FIND v(dout1_7) AT=115.025n

* CHECK dout1_8 Vdout1_8ck22 = 0.9 time = 115
.meas tran vdout1_8ck22 FIND v(dout1_8) AT=115.025n

* CHECK dout1_9 Vdout1_9ck22 = 0 time = 115
.meas tran vdout1_9ck22 FIND v(dout1_9) AT=115.025n

* CHECK dout1_10 Vdout1_10ck22 = 0 time = 115
.meas tran vdout1_10ck22 FIND v(dout1_10) AT=115.025n

* CHECK dout1_11 Vdout1_11ck22 = 0 time = 115
.meas tran vdout1_11ck22 FIND v(dout1_11) AT=115.025n

* CHECK dout1_12 Vdout1_12ck22 = 0 time = 115
.meas tran vdout1_12ck22 FIND v(dout1_12) AT=115.025n

* CHECK dout1_13 Vdout1_13ck22 = 0.9 time = 115
.meas tran vdout1_13ck22 FIND v(dout1_13) AT=115.025n

* CHECK dout1_14 Vdout1_14ck22 = 0.9 time = 115
.meas tran vdout1_14ck22 FIND v(dout1_14) AT=115.025n

* CHECK dout1_15 Vdout1_15ck22 = 0.9 time = 115
.meas tran vdout1_15ck22 FIND v(dout1_15) AT=115.025n

* CHECK dout1_16 Vdout1_16ck22 = 0 time = 115
.meas tran vdout1_16ck22 FIND v(dout1_16) AT=115.025n

* CHECK dout1_17 Vdout1_17ck22 = 0 time = 115
.meas tran vdout1_17ck22 FIND v(dout1_17) AT=115.025n

* CHECK dout1_18 Vdout1_18ck22 = 0.9 time = 115
.meas tran vdout1_18ck22 FIND v(dout1_18) AT=115.025n

* CHECK dout1_19 Vdout1_19ck22 = 0 time = 115
.meas tran vdout1_19ck22 FIND v(dout1_19) AT=115.025n

* CHECK dout1_20 Vdout1_20ck22 = 0 time = 115
.meas tran vdout1_20ck22 FIND v(dout1_20) AT=115.025n

* CHECK dout1_21 Vdout1_21ck22 = 0 time = 115
.meas tran vdout1_21ck22 FIND v(dout1_21) AT=115.025n

* CHECK dout1_22 Vdout1_22ck22 = 0.9 time = 115
.meas tran vdout1_22ck22 FIND v(dout1_22) AT=115.025n

* CHECK dout1_23 Vdout1_23ck22 = 0 time = 115
.meas tran vdout1_23ck22 FIND v(dout1_23) AT=115.025n

* CHECK dout1_24 Vdout1_24ck22 = 0.9 time = 115
.meas tran vdout1_24ck22 FIND v(dout1_24) AT=115.025n

* CHECK dout1_25 Vdout1_25ck22 = 0.9 time = 115
.meas tran vdout1_25ck22 FIND v(dout1_25) AT=115.025n

* CHECK dout1_26 Vdout1_26ck22 = 0 time = 115
.meas tran vdout1_26ck22 FIND v(dout1_26) AT=115.025n

* CHECK dout1_27 Vdout1_27ck22 = 0.9 time = 115
.meas tran vdout1_27ck22 FIND v(dout1_27) AT=115.025n

* CHECK dout1_28 Vdout1_28ck22 = 0.9 time = 115
.meas tran vdout1_28ck22 FIND v(dout1_28) AT=115.025n

* CHECK dout1_29 Vdout1_29ck22 = 0 time = 115
.meas tran vdout1_29ck22 FIND v(dout1_29) AT=115.025n

* CHECK dout1_30 Vdout1_30ck22 = 0.9 time = 115
.meas tran vdout1_30ck22 FIND v(dout1_30) AT=115.025n

* CHECK dout1_31 Vdout1_31ck22 = 0 time = 115
.meas tran vdout1_31ck22 FIND v(dout1_31) AT=115.025n

* CHECK dout1_32 Vdout1_32ck22 = 0 time = 115
.meas tran vdout1_32ck22 FIND v(dout1_32) AT=115.025n

* CHECK dout1_33 Vdout1_33ck22 = 0.9 time = 115
.meas tran vdout1_33ck22 FIND v(dout1_33) AT=115.025n

* CHECK dout1_34 Vdout1_34ck22 = 0 time = 115
.meas tran vdout1_34ck22 FIND v(dout1_34) AT=115.025n

* CHECK dout1_35 Vdout1_35ck22 = 0.9 time = 115
.meas tran vdout1_35ck22 FIND v(dout1_35) AT=115.025n

* CHECK dout1_36 Vdout1_36ck22 = 0.9 time = 115
.meas tran vdout1_36ck22 FIND v(dout1_36) AT=115.025n

* CHECK dout1_37 Vdout1_37ck22 = 0.9 time = 115
.meas tran vdout1_37ck22 FIND v(dout1_37) AT=115.025n

* CHECK dout1_38 Vdout1_38ck22 = 0.9 time = 115
.meas tran vdout1_38ck22 FIND v(dout1_38) AT=115.025n

* CHECK dout1_39 Vdout1_39ck22 = 0 time = 115
.meas tran vdout1_39ck22 FIND v(dout1_39) AT=115.025n

* CHECK dout1_40 Vdout1_40ck22 = 0 time = 115
.meas tran vdout1_40ck22 FIND v(dout1_40) AT=115.025n

* CHECK dout1_41 Vdout1_41ck22 = 0.9 time = 115
.meas tran vdout1_41ck22 FIND v(dout1_41) AT=115.025n

* CHECK dout1_42 Vdout1_42ck22 = 0 time = 115
.meas tran vdout1_42ck22 FIND v(dout1_42) AT=115.025n

* CHECK dout1_43 Vdout1_43ck22 = 0.9 time = 115
.meas tran vdout1_43ck22 FIND v(dout1_43) AT=115.025n

* CHECK dout1_44 Vdout1_44ck22 = 0 time = 115
.meas tran vdout1_44ck22 FIND v(dout1_44) AT=115.025n

* CHECK dout1_45 Vdout1_45ck22 = 0 time = 115
.meas tran vdout1_45ck22 FIND v(dout1_45) AT=115.025n

* CHECK dout1_46 Vdout1_46ck22 = 0 time = 115
.meas tran vdout1_46ck22 FIND v(dout1_46) AT=115.025n

* CHECK dout1_47 Vdout1_47ck22 = 0 time = 115
.meas tran vdout1_47ck22 FIND v(dout1_47) AT=115.025n

* CHECK dout1_48 Vdout1_48ck22 = 0 time = 115
.meas tran vdout1_48ck22 FIND v(dout1_48) AT=115.025n

* CHECK dout1_49 Vdout1_49ck22 = 0.9 time = 115
.meas tran vdout1_49ck22 FIND v(dout1_49) AT=115.025n

* CHECK dout1_50 Vdout1_50ck22 = 0.9 time = 115
.meas tran vdout1_50ck22 FIND v(dout1_50) AT=115.025n

* CHECK dout1_51 Vdout1_51ck22 = 0.9 time = 115
.meas tran vdout1_51ck22 FIND v(dout1_51) AT=115.025n

* CHECK dout1_52 Vdout1_52ck22 = 0.9 time = 115
.meas tran vdout1_52ck22 FIND v(dout1_52) AT=115.025n

* CHECK dout1_53 Vdout1_53ck22 = 0 time = 115
.meas tran vdout1_53ck22 FIND v(dout1_53) AT=115.025n

* CHECK dout1_54 Vdout1_54ck22 = 0.9 time = 115
.meas tran vdout1_54ck22 FIND v(dout1_54) AT=115.025n

* CHECK dout1_55 Vdout1_55ck22 = 0.9 time = 115
.meas tran vdout1_55ck22 FIND v(dout1_55) AT=115.025n

* CHECK dout1_56 Vdout1_56ck22 = 0.9 time = 115
.meas tran vdout1_56ck22 FIND v(dout1_56) AT=115.025n

* CHECK dout1_57 Vdout1_57ck22 = 0.9 time = 115
.meas tran vdout1_57ck22 FIND v(dout1_57) AT=115.025n

* CHECK dout1_58 Vdout1_58ck22 = 0.9 time = 115
.meas tran vdout1_58ck22 FIND v(dout1_58) AT=115.025n

* CHECK dout1_59 Vdout1_59ck22 = 0.9 time = 115
.meas tran vdout1_59ck22 FIND v(dout1_59) AT=115.025n

* CHECK dout1_60 Vdout1_60ck22 = 0.9 time = 115
.meas tran vdout1_60ck22 FIND v(dout1_60) AT=115.025n

* CHECK dout1_61 Vdout1_61ck22 = 0 time = 115
.meas tran vdout1_61ck22 FIND v(dout1_61) AT=115.025n

* CHECK dout1_62 Vdout1_62ck22 = 0.9 time = 115
.meas tran vdout1_62ck22 FIND v(dout1_62) AT=115.025n

* CHECK dout1_63 Vdout1_63ck22 = 0 time = 115
.meas tran vdout1_63ck22 FIND v(dout1_63) AT=115.025n

* CHECK dout1_64 Vdout1_64ck22 = 0 time = 115
.meas tran vdout1_64ck22 FIND v(dout1_64) AT=115.025n

* CHECK dout1_65 Vdout1_65ck22 = 0 time = 115
.meas tran vdout1_65ck22 FIND v(dout1_65) AT=115.025n

* CHECK dout1_66 Vdout1_66ck22 = 0.9 time = 115
.meas tran vdout1_66ck22 FIND v(dout1_66) AT=115.025n

* CHECK dout1_67 Vdout1_67ck22 = 0.9 time = 115
.meas tran vdout1_67ck22 FIND v(dout1_67) AT=115.025n

* CHECK dout1_68 Vdout1_68ck22 = 0.9 time = 115
.meas tran vdout1_68ck22 FIND v(dout1_68) AT=115.025n

* CHECK dout1_69 Vdout1_69ck22 = 0.9 time = 115
.meas tran vdout1_69ck22 FIND v(dout1_69) AT=115.025n

* CHECK dout1_70 Vdout1_70ck22 = 0 time = 115
.meas tran vdout1_70ck22 FIND v(dout1_70) AT=115.025n

* CHECK dout1_71 Vdout1_71ck22 = 0.9 time = 115
.meas tran vdout1_71ck22 FIND v(dout1_71) AT=115.025n

* CHECK dout1_0 Vdout1_0ck23 = 0 time = 120
.meas tran vdout1_0ck23 FIND v(dout1_0) AT=120.025n

* CHECK dout1_1 Vdout1_1ck23 = 0 time = 120
.meas tran vdout1_1ck23 FIND v(dout1_1) AT=120.025n

* CHECK dout1_2 Vdout1_2ck23 = 0.9 time = 120
.meas tran vdout1_2ck23 FIND v(dout1_2) AT=120.025n

* CHECK dout1_3 Vdout1_3ck23 = 0.9 time = 120
.meas tran vdout1_3ck23 FIND v(dout1_3) AT=120.025n

* CHECK dout1_4 Vdout1_4ck23 = 0.9 time = 120
.meas tran vdout1_4ck23 FIND v(dout1_4) AT=120.025n

* CHECK dout1_5 Vdout1_5ck23 = 0.9 time = 120
.meas tran vdout1_5ck23 FIND v(dout1_5) AT=120.025n

* CHECK dout1_6 Vdout1_6ck23 = 0.9 time = 120
.meas tran vdout1_6ck23 FIND v(dout1_6) AT=120.025n

* CHECK dout1_7 Vdout1_7ck23 = 0.9 time = 120
.meas tran vdout1_7ck23 FIND v(dout1_7) AT=120.025n

* CHECK dout1_8 Vdout1_8ck23 = 0 time = 120
.meas tran vdout1_8ck23 FIND v(dout1_8) AT=120.025n

* CHECK dout1_9 Vdout1_9ck23 = 0 time = 120
.meas tran vdout1_9ck23 FIND v(dout1_9) AT=120.025n

* CHECK dout1_10 Vdout1_10ck23 = 0.9 time = 120
.meas tran vdout1_10ck23 FIND v(dout1_10) AT=120.025n

* CHECK dout1_11 Vdout1_11ck23 = 0.9 time = 120
.meas tran vdout1_11ck23 FIND v(dout1_11) AT=120.025n

* CHECK dout1_12 Vdout1_12ck23 = 0 time = 120
.meas tran vdout1_12ck23 FIND v(dout1_12) AT=120.025n

* CHECK dout1_13 Vdout1_13ck23 = 0 time = 120
.meas tran vdout1_13ck23 FIND v(dout1_13) AT=120.025n

* CHECK dout1_14 Vdout1_14ck23 = 0.9 time = 120
.meas tran vdout1_14ck23 FIND v(dout1_14) AT=120.025n

* CHECK dout1_15 Vdout1_15ck23 = 0.9 time = 120
.meas tran vdout1_15ck23 FIND v(dout1_15) AT=120.025n

* CHECK dout1_16 Vdout1_16ck23 = 0.9 time = 120
.meas tran vdout1_16ck23 FIND v(dout1_16) AT=120.025n

* CHECK dout1_17 Vdout1_17ck23 = 0 time = 120
.meas tran vdout1_17ck23 FIND v(dout1_17) AT=120.025n

* CHECK dout1_18 Vdout1_18ck23 = 0 time = 120
.meas tran vdout1_18ck23 FIND v(dout1_18) AT=120.025n

* CHECK dout1_19 Vdout1_19ck23 = 0 time = 120
.meas tran vdout1_19ck23 FIND v(dout1_19) AT=120.025n

* CHECK dout1_20 Vdout1_20ck23 = 0.9 time = 120
.meas tran vdout1_20ck23 FIND v(dout1_20) AT=120.025n

* CHECK dout1_21 Vdout1_21ck23 = 0.9 time = 120
.meas tran vdout1_21ck23 FIND v(dout1_21) AT=120.025n

* CHECK dout1_22 Vdout1_22ck23 = 0.9 time = 120
.meas tran vdout1_22ck23 FIND v(dout1_22) AT=120.025n

* CHECK dout1_23 Vdout1_23ck23 = 0.9 time = 120
.meas tran vdout1_23ck23 FIND v(dout1_23) AT=120.025n

* CHECK dout1_24 Vdout1_24ck23 = 0.9 time = 120
.meas tran vdout1_24ck23 FIND v(dout1_24) AT=120.025n

* CHECK dout1_25 Vdout1_25ck23 = 0.9 time = 120
.meas tran vdout1_25ck23 FIND v(dout1_25) AT=120.025n

* CHECK dout1_26 Vdout1_26ck23 = 0.9 time = 120
.meas tran vdout1_26ck23 FIND v(dout1_26) AT=120.025n

* CHECK dout1_27 Vdout1_27ck23 = 0 time = 120
.meas tran vdout1_27ck23 FIND v(dout1_27) AT=120.025n

* CHECK dout1_28 Vdout1_28ck23 = 0 time = 120
.meas tran vdout1_28ck23 FIND v(dout1_28) AT=120.025n

* CHECK dout1_29 Vdout1_29ck23 = 0.9 time = 120
.meas tran vdout1_29ck23 FIND v(dout1_29) AT=120.025n

* CHECK dout1_30 Vdout1_30ck23 = 0 time = 120
.meas tran vdout1_30ck23 FIND v(dout1_30) AT=120.025n

* CHECK dout1_31 Vdout1_31ck23 = 0.9 time = 120
.meas tran vdout1_31ck23 FIND v(dout1_31) AT=120.025n

* CHECK dout1_32 Vdout1_32ck23 = 0.9 time = 120
.meas tran vdout1_32ck23 FIND v(dout1_32) AT=120.025n

* CHECK dout1_33 Vdout1_33ck23 = 0 time = 120
.meas tran vdout1_33ck23 FIND v(dout1_33) AT=120.025n

* CHECK dout1_34 Vdout1_34ck23 = 0 time = 120
.meas tran vdout1_34ck23 FIND v(dout1_34) AT=120.025n

* CHECK dout1_35 Vdout1_35ck23 = 0.9 time = 120
.meas tran vdout1_35ck23 FIND v(dout1_35) AT=120.025n

* CHECK dout1_36 Vdout1_36ck23 = 0 time = 120
.meas tran vdout1_36ck23 FIND v(dout1_36) AT=120.025n

* CHECK dout1_37 Vdout1_37ck23 = 0.9 time = 120
.meas tran vdout1_37ck23 FIND v(dout1_37) AT=120.025n

* CHECK dout1_38 Vdout1_38ck23 = 0.9 time = 120
.meas tran vdout1_38ck23 FIND v(dout1_38) AT=120.025n

* CHECK dout1_39 Vdout1_39ck23 = 0.9 time = 120
.meas tran vdout1_39ck23 FIND v(dout1_39) AT=120.025n

* CHECK dout1_40 Vdout1_40ck23 = 0.9 time = 120
.meas tran vdout1_40ck23 FIND v(dout1_40) AT=120.025n

* CHECK dout1_41 Vdout1_41ck23 = 0.9 time = 120
.meas tran vdout1_41ck23 FIND v(dout1_41) AT=120.025n

* CHECK dout1_42 Vdout1_42ck23 = 0.9 time = 120
.meas tran vdout1_42ck23 FIND v(dout1_42) AT=120.025n

* CHECK dout1_43 Vdout1_43ck23 = 0 time = 120
.meas tran vdout1_43ck23 FIND v(dout1_43) AT=120.025n

* CHECK dout1_44 Vdout1_44ck23 = 0 time = 120
.meas tran vdout1_44ck23 FIND v(dout1_44) AT=120.025n

* CHECK dout1_45 Vdout1_45ck23 = 0.9 time = 120
.meas tran vdout1_45ck23 FIND v(dout1_45) AT=120.025n

* CHECK dout1_46 Vdout1_46ck23 = 0.9 time = 120
.meas tran vdout1_46ck23 FIND v(dout1_46) AT=120.025n

* CHECK dout1_47 Vdout1_47ck23 = 0.9 time = 120
.meas tran vdout1_47ck23 FIND v(dout1_47) AT=120.025n

* CHECK dout1_48 Vdout1_48ck23 = 0 time = 120
.meas tran vdout1_48ck23 FIND v(dout1_48) AT=120.025n

* CHECK dout1_49 Vdout1_49ck23 = 0 time = 120
.meas tran vdout1_49ck23 FIND v(dout1_49) AT=120.025n

* CHECK dout1_50 Vdout1_50ck23 = 0.9 time = 120
.meas tran vdout1_50ck23 FIND v(dout1_50) AT=120.025n

* CHECK dout1_51 Vdout1_51ck23 = 0 time = 120
.meas tran vdout1_51ck23 FIND v(dout1_51) AT=120.025n

* CHECK dout1_52 Vdout1_52ck23 = 0 time = 120
.meas tran vdout1_52ck23 FIND v(dout1_52) AT=120.025n

* CHECK dout1_53 Vdout1_53ck23 = 0.9 time = 120
.meas tran vdout1_53ck23 FIND v(dout1_53) AT=120.025n

* CHECK dout1_54 Vdout1_54ck23 = 0 time = 120
.meas tran vdout1_54ck23 FIND v(dout1_54) AT=120.025n

* CHECK dout1_55 Vdout1_55ck23 = 0 time = 120
.meas tran vdout1_55ck23 FIND v(dout1_55) AT=120.025n

* CHECK dout1_56 Vdout1_56ck23 = 0 time = 120
.meas tran vdout1_56ck23 FIND v(dout1_56) AT=120.025n

* CHECK dout1_57 Vdout1_57ck23 = 0.9 time = 120
.meas tran vdout1_57ck23 FIND v(dout1_57) AT=120.025n

* CHECK dout1_58 Vdout1_58ck23 = 0 time = 120
.meas tran vdout1_58ck23 FIND v(dout1_58) AT=120.025n

* CHECK dout1_59 Vdout1_59ck23 = 0 time = 120
.meas tran vdout1_59ck23 FIND v(dout1_59) AT=120.025n

* CHECK dout1_60 Vdout1_60ck23 = 0 time = 120
.meas tran vdout1_60ck23 FIND v(dout1_60) AT=120.025n

* CHECK dout1_61 Vdout1_61ck23 = 0 time = 120
.meas tran vdout1_61ck23 FIND v(dout1_61) AT=120.025n

* CHECK dout1_62 Vdout1_62ck23 = 0 time = 120
.meas tran vdout1_62ck23 FIND v(dout1_62) AT=120.025n

* CHECK dout1_63 Vdout1_63ck23 = 0.9 time = 120
.meas tran vdout1_63ck23 FIND v(dout1_63) AT=120.025n

* CHECK dout1_64 Vdout1_64ck23 = 0.9 time = 120
.meas tran vdout1_64ck23 FIND v(dout1_64) AT=120.025n

* CHECK dout1_65 Vdout1_65ck23 = 0 time = 120
.meas tran vdout1_65ck23 FIND v(dout1_65) AT=120.025n

* CHECK dout1_66 Vdout1_66ck23 = 0 time = 120
.meas tran vdout1_66ck23 FIND v(dout1_66) AT=120.025n

* CHECK dout1_67 Vdout1_67ck23 = 0 time = 120
.meas tran vdout1_67ck23 FIND v(dout1_67) AT=120.025n

* CHECK dout1_68 Vdout1_68ck23 = 0 time = 120
.meas tran vdout1_68ck23 FIND v(dout1_68) AT=120.025n

* CHECK dout1_69 Vdout1_69ck23 = 0 time = 120
.meas tran vdout1_69ck23 FIND v(dout1_69) AT=120.025n

* CHECK dout1_70 Vdout1_70ck23 = 0 time = 120
.meas tran vdout1_70ck23 FIND v(dout1_70) AT=120.025n

* CHECK dout1_71 Vdout1_71ck23 = 0.9 time = 120
.meas tran vdout1_71ck23 FIND v(dout1_71) AT=120.025n

* CHECK dout1_0 Vdout1_0ck25 = 0.9 time = 130
.meas tran vdout1_0ck25 FIND v(dout1_0) AT=130.025n

* CHECK dout1_1 Vdout1_1ck25 = 0 time = 130
.meas tran vdout1_1ck25 FIND v(dout1_1) AT=130.025n

* CHECK dout1_2 Vdout1_2ck25 = 0 time = 130
.meas tran vdout1_2ck25 FIND v(dout1_2) AT=130.025n

* CHECK dout1_3 Vdout1_3ck25 = 0.9 time = 130
.meas tran vdout1_3ck25 FIND v(dout1_3) AT=130.025n

* CHECK dout1_4 Vdout1_4ck25 = 0.9 time = 130
.meas tran vdout1_4ck25 FIND v(dout1_4) AT=130.025n

* CHECK dout1_5 Vdout1_5ck25 = 0 time = 130
.meas tran vdout1_5ck25 FIND v(dout1_5) AT=130.025n

* CHECK dout1_6 Vdout1_6ck25 = 0.9 time = 130
.meas tran vdout1_6ck25 FIND v(dout1_6) AT=130.025n

* CHECK dout1_7 Vdout1_7ck25 = 0 time = 130
.meas tran vdout1_7ck25 FIND v(dout1_7) AT=130.025n

* CHECK dout1_8 Vdout1_8ck25 = 0.9 time = 130
.meas tran vdout1_8ck25 FIND v(dout1_8) AT=130.025n

* CHECK dout1_9 Vdout1_9ck25 = 0.9 time = 130
.meas tran vdout1_9ck25 FIND v(dout1_9) AT=130.025n

* CHECK dout1_10 Vdout1_10ck25 = 0 time = 130
.meas tran vdout1_10ck25 FIND v(dout1_10) AT=130.025n

* CHECK dout1_11 Vdout1_11ck25 = 0 time = 130
.meas tran vdout1_11ck25 FIND v(dout1_11) AT=130.025n

* CHECK dout1_12 Vdout1_12ck25 = 0 time = 130
.meas tran vdout1_12ck25 FIND v(dout1_12) AT=130.025n

* CHECK dout1_13 Vdout1_13ck25 = 0 time = 130
.meas tran vdout1_13ck25 FIND v(dout1_13) AT=130.025n

* CHECK dout1_14 Vdout1_14ck25 = 0 time = 130
.meas tran vdout1_14ck25 FIND v(dout1_14) AT=130.025n

* CHECK dout1_15 Vdout1_15ck25 = 0 time = 130
.meas tran vdout1_15ck25 FIND v(dout1_15) AT=130.025n

* CHECK dout1_16 Vdout1_16ck25 = 0 time = 130
.meas tran vdout1_16ck25 FIND v(dout1_16) AT=130.025n

* CHECK dout1_17 Vdout1_17ck25 = 0 time = 130
.meas tran vdout1_17ck25 FIND v(dout1_17) AT=130.025n

* CHECK dout1_18 Vdout1_18ck25 = 0.9 time = 130
.meas tran vdout1_18ck25 FIND v(dout1_18) AT=130.025n

* CHECK dout1_19 Vdout1_19ck25 = 0 time = 130
.meas tran vdout1_19ck25 FIND v(dout1_19) AT=130.025n

* CHECK dout1_20 Vdout1_20ck25 = 0.9 time = 130
.meas tran vdout1_20ck25 FIND v(dout1_20) AT=130.025n

* CHECK dout1_21 Vdout1_21ck25 = 0.9 time = 130
.meas tran vdout1_21ck25 FIND v(dout1_21) AT=130.025n

* CHECK dout1_22 Vdout1_22ck25 = 0 time = 130
.meas tran vdout1_22ck25 FIND v(dout1_22) AT=130.025n

* CHECK dout1_23 Vdout1_23ck25 = 0 time = 130
.meas tran vdout1_23ck25 FIND v(dout1_23) AT=130.025n

* CHECK dout1_24 Vdout1_24ck25 = 0.9 time = 130
.meas tran vdout1_24ck25 FIND v(dout1_24) AT=130.025n

* CHECK dout1_25 Vdout1_25ck25 = 0 time = 130
.meas tran vdout1_25ck25 FIND v(dout1_25) AT=130.025n

* CHECK dout1_26 Vdout1_26ck25 = 0.9 time = 130
.meas tran vdout1_26ck25 FIND v(dout1_26) AT=130.025n

* CHECK dout1_27 Vdout1_27ck25 = 0 time = 130
.meas tran vdout1_27ck25 FIND v(dout1_27) AT=130.025n

* CHECK dout1_28 Vdout1_28ck25 = 0.9 time = 130
.meas tran vdout1_28ck25 FIND v(dout1_28) AT=130.025n

* CHECK dout1_29 Vdout1_29ck25 = 0.9 time = 130
.meas tran vdout1_29ck25 FIND v(dout1_29) AT=130.025n

* CHECK dout1_30 Vdout1_30ck25 = 0.9 time = 130
.meas tran vdout1_30ck25 FIND v(dout1_30) AT=130.025n

* CHECK dout1_31 Vdout1_31ck25 = 0.9 time = 130
.meas tran vdout1_31ck25 FIND v(dout1_31) AT=130.025n

* CHECK dout1_32 Vdout1_32ck25 = 0.9 time = 130
.meas tran vdout1_32ck25 FIND v(dout1_32) AT=130.025n

* CHECK dout1_33 Vdout1_33ck25 = 0.9 time = 130
.meas tran vdout1_33ck25 FIND v(dout1_33) AT=130.025n

* CHECK dout1_34 Vdout1_34ck25 = 0.9 time = 130
.meas tran vdout1_34ck25 FIND v(dout1_34) AT=130.025n

* CHECK dout1_35 Vdout1_35ck25 = 0 time = 130
.meas tran vdout1_35ck25 FIND v(dout1_35) AT=130.025n

* CHECK dout1_36 Vdout1_36ck25 = 0 time = 130
.meas tran vdout1_36ck25 FIND v(dout1_36) AT=130.025n

* CHECK dout1_37 Vdout1_37ck25 = 0 time = 130
.meas tran vdout1_37ck25 FIND v(dout1_37) AT=130.025n

* CHECK dout1_38 Vdout1_38ck25 = 0.9 time = 130
.meas tran vdout1_38ck25 FIND v(dout1_38) AT=130.025n

* CHECK dout1_39 Vdout1_39ck25 = 0 time = 130
.meas tran vdout1_39ck25 FIND v(dout1_39) AT=130.025n

* CHECK dout1_40 Vdout1_40ck25 = 0 time = 130
.meas tran vdout1_40ck25 FIND v(dout1_40) AT=130.025n

* CHECK dout1_41 Vdout1_41ck25 = 0 time = 130
.meas tran vdout1_41ck25 FIND v(dout1_41) AT=130.025n

* CHECK dout1_42 Vdout1_42ck25 = 0.9 time = 130
.meas tran vdout1_42ck25 FIND v(dout1_42) AT=130.025n

* CHECK dout1_43 Vdout1_43ck25 = 0 time = 130
.meas tran vdout1_43ck25 FIND v(dout1_43) AT=130.025n

* CHECK dout1_44 Vdout1_44ck25 = 0 time = 130
.meas tran vdout1_44ck25 FIND v(dout1_44) AT=130.025n

* CHECK dout1_45 Vdout1_45ck25 = 0.9 time = 130
.meas tran vdout1_45ck25 FIND v(dout1_45) AT=130.025n

* CHECK dout1_46 Vdout1_46ck25 = 0.9 time = 130
.meas tran vdout1_46ck25 FIND v(dout1_46) AT=130.025n

* CHECK dout1_47 Vdout1_47ck25 = 0 time = 130
.meas tran vdout1_47ck25 FIND v(dout1_47) AT=130.025n

* CHECK dout1_48 Vdout1_48ck25 = 0.9 time = 130
.meas tran vdout1_48ck25 FIND v(dout1_48) AT=130.025n

* CHECK dout1_49 Vdout1_49ck25 = 0 time = 130
.meas tran vdout1_49ck25 FIND v(dout1_49) AT=130.025n

* CHECK dout1_50 Vdout1_50ck25 = 0.9 time = 130
.meas tran vdout1_50ck25 FIND v(dout1_50) AT=130.025n

* CHECK dout1_51 Vdout1_51ck25 = 0.9 time = 130
.meas tran vdout1_51ck25 FIND v(dout1_51) AT=130.025n

* CHECK dout1_52 Vdout1_52ck25 = 0 time = 130
.meas tran vdout1_52ck25 FIND v(dout1_52) AT=130.025n

* CHECK dout1_53 Vdout1_53ck25 = 0.9 time = 130
.meas tran vdout1_53ck25 FIND v(dout1_53) AT=130.025n

* CHECK dout1_54 Vdout1_54ck25 = 0.9 time = 130
.meas tran vdout1_54ck25 FIND v(dout1_54) AT=130.025n

* CHECK dout1_55 Vdout1_55ck25 = 0.9 time = 130
.meas tran vdout1_55ck25 FIND v(dout1_55) AT=130.025n

* CHECK dout1_56 Vdout1_56ck25 = 0.9 time = 130
.meas tran vdout1_56ck25 FIND v(dout1_56) AT=130.025n

* CHECK dout1_57 Vdout1_57ck25 = 0 time = 130
.meas tran vdout1_57ck25 FIND v(dout1_57) AT=130.025n

* CHECK dout1_58 Vdout1_58ck25 = 0.9 time = 130
.meas tran vdout1_58ck25 FIND v(dout1_58) AT=130.025n

* CHECK dout1_59 Vdout1_59ck25 = 0 time = 130
.meas tran vdout1_59ck25 FIND v(dout1_59) AT=130.025n

* CHECK dout1_60 Vdout1_60ck25 = 0.9 time = 130
.meas tran vdout1_60ck25 FIND v(dout1_60) AT=130.025n

* CHECK dout1_61 Vdout1_61ck25 = 0.9 time = 130
.meas tran vdout1_61ck25 FIND v(dout1_61) AT=130.025n

* CHECK dout1_62 Vdout1_62ck25 = 0.9 time = 130
.meas tran vdout1_62ck25 FIND v(dout1_62) AT=130.025n

* CHECK dout1_63 Vdout1_63ck25 = 0.9 time = 130
.meas tran vdout1_63ck25 FIND v(dout1_63) AT=130.025n

* CHECK dout1_64 Vdout1_64ck25 = 0.9 time = 130
.meas tran vdout1_64ck25 FIND v(dout1_64) AT=130.025n

* CHECK dout1_65 Vdout1_65ck25 = 0.9 time = 130
.meas tran vdout1_65ck25 FIND v(dout1_65) AT=130.025n

* CHECK dout1_66 Vdout1_66ck25 = 0.9 time = 130
.meas tran vdout1_66ck25 FIND v(dout1_66) AT=130.025n

* CHECK dout1_67 Vdout1_67ck25 = 0.9 time = 130
.meas tran vdout1_67ck25 FIND v(dout1_67) AT=130.025n

* CHECK dout1_68 Vdout1_68ck25 = 0.9 time = 130
.meas tran vdout1_68ck25 FIND v(dout1_68) AT=130.025n

* CHECK dout1_69 Vdout1_69ck25 = 0.9 time = 130
.meas tran vdout1_69ck25 FIND v(dout1_69) AT=130.025n

* CHECK dout1_70 Vdout1_70ck25 = 0.9 time = 130
.meas tran vdout1_70ck25 FIND v(dout1_70) AT=130.025n

* CHECK dout1_71 Vdout1_71ck25 = 0 time = 130
.meas tran vdout1_71ck25 FIND v(dout1_71) AT=130.025n

* CHECK dout1_0 Vdout1_0ck27 = 0.9 time = 140
.meas tran vdout1_0ck27 FIND v(dout1_0) AT=140.025n

* CHECK dout1_1 Vdout1_1ck27 = 0 time = 140
.meas tran vdout1_1ck27 FIND v(dout1_1) AT=140.025n

* CHECK dout1_2 Vdout1_2ck27 = 0 time = 140
.meas tran vdout1_2ck27 FIND v(dout1_2) AT=140.025n

* CHECK dout1_3 Vdout1_3ck27 = 0.9 time = 140
.meas tran vdout1_3ck27 FIND v(dout1_3) AT=140.025n

* CHECK dout1_4 Vdout1_4ck27 = 0.9 time = 140
.meas tran vdout1_4ck27 FIND v(dout1_4) AT=140.025n

* CHECK dout1_5 Vdout1_5ck27 = 0 time = 140
.meas tran vdout1_5ck27 FIND v(dout1_5) AT=140.025n

* CHECK dout1_6 Vdout1_6ck27 = 0.9 time = 140
.meas tran vdout1_6ck27 FIND v(dout1_6) AT=140.025n

* CHECK dout1_7 Vdout1_7ck27 = 0 time = 140
.meas tran vdout1_7ck27 FIND v(dout1_7) AT=140.025n

* CHECK dout1_8 Vdout1_8ck27 = 0.9 time = 140
.meas tran vdout1_8ck27 FIND v(dout1_8) AT=140.025n

* CHECK dout1_9 Vdout1_9ck27 = 0.9 time = 140
.meas tran vdout1_9ck27 FIND v(dout1_9) AT=140.025n

* CHECK dout1_10 Vdout1_10ck27 = 0 time = 140
.meas tran vdout1_10ck27 FIND v(dout1_10) AT=140.025n

* CHECK dout1_11 Vdout1_11ck27 = 0 time = 140
.meas tran vdout1_11ck27 FIND v(dout1_11) AT=140.025n

* CHECK dout1_12 Vdout1_12ck27 = 0 time = 140
.meas tran vdout1_12ck27 FIND v(dout1_12) AT=140.025n

* CHECK dout1_13 Vdout1_13ck27 = 0 time = 140
.meas tran vdout1_13ck27 FIND v(dout1_13) AT=140.025n

* CHECK dout1_14 Vdout1_14ck27 = 0 time = 140
.meas tran vdout1_14ck27 FIND v(dout1_14) AT=140.025n

* CHECK dout1_15 Vdout1_15ck27 = 0 time = 140
.meas tran vdout1_15ck27 FIND v(dout1_15) AT=140.025n

* CHECK dout1_16 Vdout1_16ck27 = 0 time = 140
.meas tran vdout1_16ck27 FIND v(dout1_16) AT=140.025n

* CHECK dout1_17 Vdout1_17ck27 = 0 time = 140
.meas tran vdout1_17ck27 FIND v(dout1_17) AT=140.025n

* CHECK dout1_18 Vdout1_18ck27 = 0.9 time = 140
.meas tran vdout1_18ck27 FIND v(dout1_18) AT=140.025n

* CHECK dout1_19 Vdout1_19ck27 = 0 time = 140
.meas tran vdout1_19ck27 FIND v(dout1_19) AT=140.025n

* CHECK dout1_20 Vdout1_20ck27 = 0.9 time = 140
.meas tran vdout1_20ck27 FIND v(dout1_20) AT=140.025n

* CHECK dout1_21 Vdout1_21ck27 = 0.9 time = 140
.meas tran vdout1_21ck27 FIND v(dout1_21) AT=140.025n

* CHECK dout1_22 Vdout1_22ck27 = 0 time = 140
.meas tran vdout1_22ck27 FIND v(dout1_22) AT=140.025n

* CHECK dout1_23 Vdout1_23ck27 = 0 time = 140
.meas tran vdout1_23ck27 FIND v(dout1_23) AT=140.025n

* CHECK dout1_24 Vdout1_24ck27 = 0.9 time = 140
.meas tran vdout1_24ck27 FIND v(dout1_24) AT=140.025n

* CHECK dout1_25 Vdout1_25ck27 = 0 time = 140
.meas tran vdout1_25ck27 FIND v(dout1_25) AT=140.025n

* CHECK dout1_26 Vdout1_26ck27 = 0.9 time = 140
.meas tran vdout1_26ck27 FIND v(dout1_26) AT=140.025n

* CHECK dout1_27 Vdout1_27ck27 = 0 time = 140
.meas tran vdout1_27ck27 FIND v(dout1_27) AT=140.025n

* CHECK dout1_28 Vdout1_28ck27 = 0.9 time = 140
.meas tran vdout1_28ck27 FIND v(dout1_28) AT=140.025n

* CHECK dout1_29 Vdout1_29ck27 = 0.9 time = 140
.meas tran vdout1_29ck27 FIND v(dout1_29) AT=140.025n

* CHECK dout1_30 Vdout1_30ck27 = 0.9 time = 140
.meas tran vdout1_30ck27 FIND v(dout1_30) AT=140.025n

* CHECK dout1_31 Vdout1_31ck27 = 0.9 time = 140
.meas tran vdout1_31ck27 FIND v(dout1_31) AT=140.025n

* CHECK dout1_32 Vdout1_32ck27 = 0.9 time = 140
.meas tran vdout1_32ck27 FIND v(dout1_32) AT=140.025n

* CHECK dout1_33 Vdout1_33ck27 = 0.9 time = 140
.meas tran vdout1_33ck27 FIND v(dout1_33) AT=140.025n

* CHECK dout1_34 Vdout1_34ck27 = 0.9 time = 140
.meas tran vdout1_34ck27 FIND v(dout1_34) AT=140.025n

* CHECK dout1_35 Vdout1_35ck27 = 0 time = 140
.meas tran vdout1_35ck27 FIND v(dout1_35) AT=140.025n

* CHECK dout1_36 Vdout1_36ck27 = 0 time = 140
.meas tran vdout1_36ck27 FIND v(dout1_36) AT=140.025n

* CHECK dout1_37 Vdout1_37ck27 = 0 time = 140
.meas tran vdout1_37ck27 FIND v(dout1_37) AT=140.025n

* CHECK dout1_38 Vdout1_38ck27 = 0.9 time = 140
.meas tran vdout1_38ck27 FIND v(dout1_38) AT=140.025n

* CHECK dout1_39 Vdout1_39ck27 = 0 time = 140
.meas tran vdout1_39ck27 FIND v(dout1_39) AT=140.025n

* CHECK dout1_40 Vdout1_40ck27 = 0 time = 140
.meas tran vdout1_40ck27 FIND v(dout1_40) AT=140.025n

* CHECK dout1_41 Vdout1_41ck27 = 0 time = 140
.meas tran vdout1_41ck27 FIND v(dout1_41) AT=140.025n

* CHECK dout1_42 Vdout1_42ck27 = 0.9 time = 140
.meas tran vdout1_42ck27 FIND v(dout1_42) AT=140.025n

* CHECK dout1_43 Vdout1_43ck27 = 0 time = 140
.meas tran vdout1_43ck27 FIND v(dout1_43) AT=140.025n

* CHECK dout1_44 Vdout1_44ck27 = 0 time = 140
.meas tran vdout1_44ck27 FIND v(dout1_44) AT=140.025n

* CHECK dout1_45 Vdout1_45ck27 = 0.9 time = 140
.meas tran vdout1_45ck27 FIND v(dout1_45) AT=140.025n

* CHECK dout1_46 Vdout1_46ck27 = 0.9 time = 140
.meas tran vdout1_46ck27 FIND v(dout1_46) AT=140.025n

* CHECK dout1_47 Vdout1_47ck27 = 0 time = 140
.meas tran vdout1_47ck27 FIND v(dout1_47) AT=140.025n

* CHECK dout1_48 Vdout1_48ck27 = 0.9 time = 140
.meas tran vdout1_48ck27 FIND v(dout1_48) AT=140.025n

* CHECK dout1_49 Vdout1_49ck27 = 0 time = 140
.meas tran vdout1_49ck27 FIND v(dout1_49) AT=140.025n

* CHECK dout1_50 Vdout1_50ck27 = 0.9 time = 140
.meas tran vdout1_50ck27 FIND v(dout1_50) AT=140.025n

* CHECK dout1_51 Vdout1_51ck27 = 0.9 time = 140
.meas tran vdout1_51ck27 FIND v(dout1_51) AT=140.025n

* CHECK dout1_52 Vdout1_52ck27 = 0 time = 140
.meas tran vdout1_52ck27 FIND v(dout1_52) AT=140.025n

* CHECK dout1_53 Vdout1_53ck27 = 0.9 time = 140
.meas tran vdout1_53ck27 FIND v(dout1_53) AT=140.025n

* CHECK dout1_54 Vdout1_54ck27 = 0.9 time = 140
.meas tran vdout1_54ck27 FIND v(dout1_54) AT=140.025n

* CHECK dout1_55 Vdout1_55ck27 = 0.9 time = 140
.meas tran vdout1_55ck27 FIND v(dout1_55) AT=140.025n

* CHECK dout1_56 Vdout1_56ck27 = 0.9 time = 140
.meas tran vdout1_56ck27 FIND v(dout1_56) AT=140.025n

* CHECK dout1_57 Vdout1_57ck27 = 0 time = 140
.meas tran vdout1_57ck27 FIND v(dout1_57) AT=140.025n

* CHECK dout1_58 Vdout1_58ck27 = 0.9 time = 140
.meas tran vdout1_58ck27 FIND v(dout1_58) AT=140.025n

* CHECK dout1_59 Vdout1_59ck27 = 0 time = 140
.meas tran vdout1_59ck27 FIND v(dout1_59) AT=140.025n

* CHECK dout1_60 Vdout1_60ck27 = 0.9 time = 140
.meas tran vdout1_60ck27 FIND v(dout1_60) AT=140.025n

* CHECK dout1_61 Vdout1_61ck27 = 0.9 time = 140
.meas tran vdout1_61ck27 FIND v(dout1_61) AT=140.025n

* CHECK dout1_62 Vdout1_62ck27 = 0.9 time = 140
.meas tran vdout1_62ck27 FIND v(dout1_62) AT=140.025n

* CHECK dout1_63 Vdout1_63ck27 = 0.9 time = 140
.meas tran vdout1_63ck27 FIND v(dout1_63) AT=140.025n

* CHECK dout1_64 Vdout1_64ck27 = 0.9 time = 140
.meas tran vdout1_64ck27 FIND v(dout1_64) AT=140.025n

* CHECK dout1_65 Vdout1_65ck27 = 0.9 time = 140
.meas tran vdout1_65ck27 FIND v(dout1_65) AT=140.025n

* CHECK dout1_66 Vdout1_66ck27 = 0.9 time = 140
.meas tran vdout1_66ck27 FIND v(dout1_66) AT=140.025n

* CHECK dout1_67 Vdout1_67ck27 = 0.9 time = 140
.meas tran vdout1_67ck27 FIND v(dout1_67) AT=140.025n

* CHECK dout1_68 Vdout1_68ck27 = 0.9 time = 140
.meas tran vdout1_68ck27 FIND v(dout1_68) AT=140.025n

* CHECK dout1_69 Vdout1_69ck27 = 0.9 time = 140
.meas tran vdout1_69ck27 FIND v(dout1_69) AT=140.025n

* CHECK dout1_70 Vdout1_70ck27 = 0.9 time = 140
.meas tran vdout1_70ck27 FIND v(dout1_70) AT=140.025n

* CHECK dout1_71 Vdout1_71ck27 = 0 time = 140
.meas tran vdout1_71ck27 FIND v(dout1_71) AT=140.025n

* CHECK dout1_0 Vdout1_0ck29 = 0.9 time = 150
.meas tran vdout1_0ck29 FIND v(dout1_0) AT=150.025n

* CHECK dout1_1 Vdout1_1ck29 = 0 time = 150
.meas tran vdout1_1ck29 FIND v(dout1_1) AT=150.025n

* CHECK dout1_2 Vdout1_2ck29 = 0.9 time = 150
.meas tran vdout1_2ck29 FIND v(dout1_2) AT=150.025n

* CHECK dout1_3 Vdout1_3ck29 = 0.9 time = 150
.meas tran vdout1_3ck29 FIND v(dout1_3) AT=150.025n

* CHECK dout1_4 Vdout1_4ck29 = 0.9 time = 150
.meas tran vdout1_4ck29 FIND v(dout1_4) AT=150.025n

* CHECK dout1_5 Vdout1_5ck29 = 0.9 time = 150
.meas tran vdout1_5ck29 FIND v(dout1_5) AT=150.025n

* CHECK dout1_6 Vdout1_6ck29 = 0 time = 150
.meas tran vdout1_6ck29 FIND v(dout1_6) AT=150.025n

* CHECK dout1_7 Vdout1_7ck29 = 0 time = 150
.meas tran vdout1_7ck29 FIND v(dout1_7) AT=150.025n

* CHECK dout1_8 Vdout1_8ck29 = 0.9 time = 150
.meas tran vdout1_8ck29 FIND v(dout1_8) AT=150.025n

* CHECK dout1_9 Vdout1_9ck29 = 0 time = 150
.meas tran vdout1_9ck29 FIND v(dout1_9) AT=150.025n

* CHECK dout1_10 Vdout1_10ck29 = 0.9 time = 150
.meas tran vdout1_10ck29 FIND v(dout1_10) AT=150.025n

* CHECK dout1_11 Vdout1_11ck29 = 0 time = 150
.meas tran vdout1_11ck29 FIND v(dout1_11) AT=150.025n

* CHECK dout1_12 Vdout1_12ck29 = 0.9 time = 150
.meas tran vdout1_12ck29 FIND v(dout1_12) AT=150.025n

* CHECK dout1_13 Vdout1_13ck29 = 0.9 time = 150
.meas tran vdout1_13ck29 FIND v(dout1_13) AT=150.025n

* CHECK dout1_14 Vdout1_14ck29 = 0 time = 150
.meas tran vdout1_14ck29 FIND v(dout1_14) AT=150.025n

* CHECK dout1_15 Vdout1_15ck29 = 0.9 time = 150
.meas tran vdout1_15ck29 FIND v(dout1_15) AT=150.025n

* CHECK dout1_16 Vdout1_16ck29 = 0.9 time = 150
.meas tran vdout1_16ck29 FIND v(dout1_16) AT=150.025n

* CHECK dout1_17 Vdout1_17ck29 = 0 time = 150
.meas tran vdout1_17ck29 FIND v(dout1_17) AT=150.025n

* CHECK dout1_18 Vdout1_18ck29 = 0 time = 150
.meas tran vdout1_18ck29 FIND v(dout1_18) AT=150.025n

* CHECK dout1_19 Vdout1_19ck29 = 0.9 time = 150
.meas tran vdout1_19ck29 FIND v(dout1_19) AT=150.025n

* CHECK dout1_20 Vdout1_20ck29 = 0.9 time = 150
.meas tran vdout1_20ck29 FIND v(dout1_20) AT=150.025n

* CHECK dout1_21 Vdout1_21ck29 = 0.9 time = 150
.meas tran vdout1_21ck29 FIND v(dout1_21) AT=150.025n

* CHECK dout1_22 Vdout1_22ck29 = 0 time = 150
.meas tran vdout1_22ck29 FIND v(dout1_22) AT=150.025n

* CHECK dout1_23 Vdout1_23ck29 = 0 time = 150
.meas tran vdout1_23ck29 FIND v(dout1_23) AT=150.025n

* CHECK dout1_24 Vdout1_24ck29 = 0.9 time = 150
.meas tran vdout1_24ck29 FIND v(dout1_24) AT=150.025n

* CHECK dout1_25 Vdout1_25ck29 = 0.9 time = 150
.meas tran vdout1_25ck29 FIND v(dout1_25) AT=150.025n

* CHECK dout1_26 Vdout1_26ck29 = 0.9 time = 150
.meas tran vdout1_26ck29 FIND v(dout1_26) AT=150.025n

* CHECK dout1_27 Vdout1_27ck29 = 0.9 time = 150
.meas tran vdout1_27ck29 FIND v(dout1_27) AT=150.025n

* CHECK dout1_28 Vdout1_28ck29 = 0 time = 150
.meas tran vdout1_28ck29 FIND v(dout1_28) AT=150.025n

* CHECK dout1_29 Vdout1_29ck29 = 0.9 time = 150
.meas tran vdout1_29ck29 FIND v(dout1_29) AT=150.025n

* CHECK dout1_30 Vdout1_30ck29 = 0 time = 150
.meas tran vdout1_30ck29 FIND v(dout1_30) AT=150.025n

* CHECK dout1_31 Vdout1_31ck29 = 0 time = 150
.meas tran vdout1_31ck29 FIND v(dout1_31) AT=150.025n

* CHECK dout1_32 Vdout1_32ck29 = 0.9 time = 150
.meas tran vdout1_32ck29 FIND v(dout1_32) AT=150.025n

* CHECK dout1_33 Vdout1_33ck29 = 0 time = 150
.meas tran vdout1_33ck29 FIND v(dout1_33) AT=150.025n

* CHECK dout1_34 Vdout1_34ck29 = 0 time = 150
.meas tran vdout1_34ck29 FIND v(dout1_34) AT=150.025n

* CHECK dout1_35 Vdout1_35ck29 = 0 time = 150
.meas tran vdout1_35ck29 FIND v(dout1_35) AT=150.025n

* CHECK dout1_36 Vdout1_36ck29 = 0.9 time = 150
.meas tran vdout1_36ck29 FIND v(dout1_36) AT=150.025n

* CHECK dout1_37 Vdout1_37ck29 = 0 time = 150
.meas tran vdout1_37ck29 FIND v(dout1_37) AT=150.025n

* CHECK dout1_38 Vdout1_38ck29 = 0.9 time = 150
.meas tran vdout1_38ck29 FIND v(dout1_38) AT=150.025n

* CHECK dout1_39 Vdout1_39ck29 = 0 time = 150
.meas tran vdout1_39ck29 FIND v(dout1_39) AT=150.025n

* CHECK dout1_40 Vdout1_40ck29 = 0.9 time = 150
.meas tran vdout1_40ck29 FIND v(dout1_40) AT=150.025n

* CHECK dout1_41 Vdout1_41ck29 = 0.9 time = 150
.meas tran vdout1_41ck29 FIND v(dout1_41) AT=150.025n

* CHECK dout1_42 Vdout1_42ck29 = 0 time = 150
.meas tran vdout1_42ck29 FIND v(dout1_42) AT=150.025n

* CHECK dout1_43 Vdout1_43ck29 = 0.9 time = 150
.meas tran vdout1_43ck29 FIND v(dout1_43) AT=150.025n

* CHECK dout1_44 Vdout1_44ck29 = 0 time = 150
.meas tran vdout1_44ck29 FIND v(dout1_44) AT=150.025n

* CHECK dout1_45 Vdout1_45ck29 = 0.9 time = 150
.meas tran vdout1_45ck29 FIND v(dout1_45) AT=150.025n

* CHECK dout1_46 Vdout1_46ck29 = 0 time = 150
.meas tran vdout1_46ck29 FIND v(dout1_46) AT=150.025n

* CHECK dout1_47 Vdout1_47ck29 = 0 time = 150
.meas tran vdout1_47ck29 FIND v(dout1_47) AT=150.025n

* CHECK dout1_48 Vdout1_48ck29 = 0 time = 150
.meas tran vdout1_48ck29 FIND v(dout1_48) AT=150.025n

* CHECK dout1_49 Vdout1_49ck29 = 0 time = 150
.meas tran vdout1_49ck29 FIND v(dout1_49) AT=150.025n

* CHECK dout1_50 Vdout1_50ck29 = 0.9 time = 150
.meas tran vdout1_50ck29 FIND v(dout1_50) AT=150.025n

* CHECK dout1_51 Vdout1_51ck29 = 0.9 time = 150
.meas tran vdout1_51ck29 FIND v(dout1_51) AT=150.025n

* CHECK dout1_52 Vdout1_52ck29 = 0.9 time = 150
.meas tran vdout1_52ck29 FIND v(dout1_52) AT=150.025n

* CHECK dout1_53 Vdout1_53ck29 = 0 time = 150
.meas tran vdout1_53ck29 FIND v(dout1_53) AT=150.025n

* CHECK dout1_54 Vdout1_54ck29 = 0.9 time = 150
.meas tran vdout1_54ck29 FIND v(dout1_54) AT=150.025n

* CHECK dout1_55 Vdout1_55ck29 = 0.9 time = 150
.meas tran vdout1_55ck29 FIND v(dout1_55) AT=150.025n

* CHECK dout1_56 Vdout1_56ck29 = 0.9 time = 150
.meas tran vdout1_56ck29 FIND v(dout1_56) AT=150.025n

* CHECK dout1_57 Vdout1_57ck29 = 0.9 time = 150
.meas tran vdout1_57ck29 FIND v(dout1_57) AT=150.025n

* CHECK dout1_58 Vdout1_58ck29 = 0.9 time = 150
.meas tran vdout1_58ck29 FIND v(dout1_58) AT=150.025n

* CHECK dout1_59 Vdout1_59ck29 = 0 time = 150
.meas tran vdout1_59ck29 FIND v(dout1_59) AT=150.025n

* CHECK dout1_60 Vdout1_60ck29 = 0 time = 150
.meas tran vdout1_60ck29 FIND v(dout1_60) AT=150.025n

* CHECK dout1_61 Vdout1_61ck29 = 0 time = 150
.meas tran vdout1_61ck29 FIND v(dout1_61) AT=150.025n

* CHECK dout1_62 Vdout1_62ck29 = 0 time = 150
.meas tran vdout1_62ck29 FIND v(dout1_62) AT=150.025n

* CHECK dout1_63 Vdout1_63ck29 = 0.9 time = 150
.meas tran vdout1_63ck29 FIND v(dout1_63) AT=150.025n

* CHECK dout1_64 Vdout1_64ck29 = 0.9 time = 150
.meas tran vdout1_64ck29 FIND v(dout1_64) AT=150.025n

* CHECK dout1_65 Vdout1_65ck29 = 0.9 time = 150
.meas tran vdout1_65ck29 FIND v(dout1_65) AT=150.025n

* CHECK dout1_66 Vdout1_66ck29 = 0.9 time = 150
.meas tran vdout1_66ck29 FIND v(dout1_66) AT=150.025n

* CHECK dout1_67 Vdout1_67ck29 = 0 time = 150
.meas tran vdout1_67ck29 FIND v(dout1_67) AT=150.025n

* CHECK dout1_68 Vdout1_68ck29 = 0 time = 150
.meas tran vdout1_68ck29 FIND v(dout1_68) AT=150.025n

* CHECK dout1_69 Vdout1_69ck29 = 0 time = 150
.meas tran vdout1_69ck29 FIND v(dout1_69) AT=150.025n

* CHECK dout1_70 Vdout1_70ck29 = 0 time = 150
.meas tran vdout1_70ck29 FIND v(dout1_70) AT=150.025n

* CHECK dout1_71 Vdout1_71ck29 = 0 time = 150
.meas tran vdout1_71ck29 FIND v(dout1_71) AT=150.025n

* CHECK dout1_0 Vdout1_0ck32 = 0.9 time = 165
.meas tran vdout1_0ck32 FIND v(dout1_0) AT=165.025n

* CHECK dout1_1 Vdout1_1ck32 = 0 time = 165
.meas tran vdout1_1ck32 FIND v(dout1_1) AT=165.025n

* CHECK dout1_2 Vdout1_2ck32 = 0.9 time = 165
.meas tran vdout1_2ck32 FIND v(dout1_2) AT=165.025n

* CHECK dout1_3 Vdout1_3ck32 = 0.9 time = 165
.meas tran vdout1_3ck32 FIND v(dout1_3) AT=165.025n

* CHECK dout1_4 Vdout1_4ck32 = 0.9 time = 165
.meas tran vdout1_4ck32 FIND v(dout1_4) AT=165.025n

* CHECK dout1_5 Vdout1_5ck32 = 0.9 time = 165
.meas tran vdout1_5ck32 FIND v(dout1_5) AT=165.025n

* CHECK dout1_6 Vdout1_6ck32 = 0 time = 165
.meas tran vdout1_6ck32 FIND v(dout1_6) AT=165.025n

* CHECK dout1_7 Vdout1_7ck32 = 0 time = 165
.meas tran vdout1_7ck32 FIND v(dout1_7) AT=165.025n

* CHECK dout1_8 Vdout1_8ck32 = 0.9 time = 165
.meas tran vdout1_8ck32 FIND v(dout1_8) AT=165.025n

* CHECK dout1_9 Vdout1_9ck32 = 0 time = 165
.meas tran vdout1_9ck32 FIND v(dout1_9) AT=165.025n

* CHECK dout1_10 Vdout1_10ck32 = 0.9 time = 165
.meas tran vdout1_10ck32 FIND v(dout1_10) AT=165.025n

* CHECK dout1_11 Vdout1_11ck32 = 0 time = 165
.meas tran vdout1_11ck32 FIND v(dout1_11) AT=165.025n

* CHECK dout1_12 Vdout1_12ck32 = 0.9 time = 165
.meas tran vdout1_12ck32 FIND v(dout1_12) AT=165.025n

* CHECK dout1_13 Vdout1_13ck32 = 0.9 time = 165
.meas tran vdout1_13ck32 FIND v(dout1_13) AT=165.025n

* CHECK dout1_14 Vdout1_14ck32 = 0 time = 165
.meas tran vdout1_14ck32 FIND v(dout1_14) AT=165.025n

* CHECK dout1_15 Vdout1_15ck32 = 0.9 time = 165
.meas tran vdout1_15ck32 FIND v(dout1_15) AT=165.025n

* CHECK dout1_16 Vdout1_16ck32 = 0.9 time = 165
.meas tran vdout1_16ck32 FIND v(dout1_16) AT=165.025n

* CHECK dout1_17 Vdout1_17ck32 = 0 time = 165
.meas tran vdout1_17ck32 FIND v(dout1_17) AT=165.025n

* CHECK dout1_18 Vdout1_18ck32 = 0 time = 165
.meas tran vdout1_18ck32 FIND v(dout1_18) AT=165.025n

* CHECK dout1_19 Vdout1_19ck32 = 0.9 time = 165
.meas tran vdout1_19ck32 FIND v(dout1_19) AT=165.025n

* CHECK dout1_20 Vdout1_20ck32 = 0.9 time = 165
.meas tran vdout1_20ck32 FIND v(dout1_20) AT=165.025n

* CHECK dout1_21 Vdout1_21ck32 = 0.9 time = 165
.meas tran vdout1_21ck32 FIND v(dout1_21) AT=165.025n

* CHECK dout1_22 Vdout1_22ck32 = 0 time = 165
.meas tran vdout1_22ck32 FIND v(dout1_22) AT=165.025n

* CHECK dout1_23 Vdout1_23ck32 = 0 time = 165
.meas tran vdout1_23ck32 FIND v(dout1_23) AT=165.025n

* CHECK dout1_24 Vdout1_24ck32 = 0.9 time = 165
.meas tran vdout1_24ck32 FIND v(dout1_24) AT=165.025n

* CHECK dout1_25 Vdout1_25ck32 = 0.9 time = 165
.meas tran vdout1_25ck32 FIND v(dout1_25) AT=165.025n

* CHECK dout1_26 Vdout1_26ck32 = 0.9 time = 165
.meas tran vdout1_26ck32 FIND v(dout1_26) AT=165.025n

* CHECK dout1_27 Vdout1_27ck32 = 0.9 time = 165
.meas tran vdout1_27ck32 FIND v(dout1_27) AT=165.025n

* CHECK dout1_28 Vdout1_28ck32 = 0 time = 165
.meas tran vdout1_28ck32 FIND v(dout1_28) AT=165.025n

* CHECK dout1_29 Vdout1_29ck32 = 0.9 time = 165
.meas tran vdout1_29ck32 FIND v(dout1_29) AT=165.025n

* CHECK dout1_30 Vdout1_30ck32 = 0 time = 165
.meas tran vdout1_30ck32 FIND v(dout1_30) AT=165.025n

* CHECK dout1_31 Vdout1_31ck32 = 0 time = 165
.meas tran vdout1_31ck32 FIND v(dout1_31) AT=165.025n

* CHECK dout1_32 Vdout1_32ck32 = 0.9 time = 165
.meas tran vdout1_32ck32 FIND v(dout1_32) AT=165.025n

* CHECK dout1_33 Vdout1_33ck32 = 0 time = 165
.meas tran vdout1_33ck32 FIND v(dout1_33) AT=165.025n

* CHECK dout1_34 Vdout1_34ck32 = 0 time = 165
.meas tran vdout1_34ck32 FIND v(dout1_34) AT=165.025n

* CHECK dout1_35 Vdout1_35ck32 = 0 time = 165
.meas tran vdout1_35ck32 FIND v(dout1_35) AT=165.025n

* CHECK dout1_36 Vdout1_36ck32 = 0.9 time = 165
.meas tran vdout1_36ck32 FIND v(dout1_36) AT=165.025n

* CHECK dout1_37 Vdout1_37ck32 = 0 time = 165
.meas tran vdout1_37ck32 FIND v(dout1_37) AT=165.025n

* CHECK dout1_38 Vdout1_38ck32 = 0.9 time = 165
.meas tran vdout1_38ck32 FIND v(dout1_38) AT=165.025n

* CHECK dout1_39 Vdout1_39ck32 = 0 time = 165
.meas tran vdout1_39ck32 FIND v(dout1_39) AT=165.025n

* CHECK dout1_40 Vdout1_40ck32 = 0.9 time = 165
.meas tran vdout1_40ck32 FIND v(dout1_40) AT=165.025n

* CHECK dout1_41 Vdout1_41ck32 = 0.9 time = 165
.meas tran vdout1_41ck32 FIND v(dout1_41) AT=165.025n

* CHECK dout1_42 Vdout1_42ck32 = 0 time = 165
.meas tran vdout1_42ck32 FIND v(dout1_42) AT=165.025n

* CHECK dout1_43 Vdout1_43ck32 = 0.9 time = 165
.meas tran vdout1_43ck32 FIND v(dout1_43) AT=165.025n

* CHECK dout1_44 Vdout1_44ck32 = 0 time = 165
.meas tran vdout1_44ck32 FIND v(dout1_44) AT=165.025n

* CHECK dout1_45 Vdout1_45ck32 = 0.9 time = 165
.meas tran vdout1_45ck32 FIND v(dout1_45) AT=165.025n

* CHECK dout1_46 Vdout1_46ck32 = 0 time = 165
.meas tran vdout1_46ck32 FIND v(dout1_46) AT=165.025n

* CHECK dout1_47 Vdout1_47ck32 = 0 time = 165
.meas tran vdout1_47ck32 FIND v(dout1_47) AT=165.025n

* CHECK dout1_48 Vdout1_48ck32 = 0 time = 165
.meas tran vdout1_48ck32 FIND v(dout1_48) AT=165.025n

* CHECK dout1_49 Vdout1_49ck32 = 0 time = 165
.meas tran vdout1_49ck32 FIND v(dout1_49) AT=165.025n

* CHECK dout1_50 Vdout1_50ck32 = 0.9 time = 165
.meas tran vdout1_50ck32 FIND v(dout1_50) AT=165.025n

* CHECK dout1_51 Vdout1_51ck32 = 0.9 time = 165
.meas tran vdout1_51ck32 FIND v(dout1_51) AT=165.025n

* CHECK dout1_52 Vdout1_52ck32 = 0.9 time = 165
.meas tran vdout1_52ck32 FIND v(dout1_52) AT=165.025n

* CHECK dout1_53 Vdout1_53ck32 = 0 time = 165
.meas tran vdout1_53ck32 FIND v(dout1_53) AT=165.025n

* CHECK dout1_54 Vdout1_54ck32 = 0.9 time = 165
.meas tran vdout1_54ck32 FIND v(dout1_54) AT=165.025n

* CHECK dout1_55 Vdout1_55ck32 = 0.9 time = 165
.meas tran vdout1_55ck32 FIND v(dout1_55) AT=165.025n

* CHECK dout1_56 Vdout1_56ck32 = 0.9 time = 165
.meas tran vdout1_56ck32 FIND v(dout1_56) AT=165.025n

* CHECK dout1_57 Vdout1_57ck32 = 0.9 time = 165
.meas tran vdout1_57ck32 FIND v(dout1_57) AT=165.025n

* CHECK dout1_58 Vdout1_58ck32 = 0.9 time = 165
.meas tran vdout1_58ck32 FIND v(dout1_58) AT=165.025n

* CHECK dout1_59 Vdout1_59ck32 = 0 time = 165
.meas tran vdout1_59ck32 FIND v(dout1_59) AT=165.025n

* CHECK dout1_60 Vdout1_60ck32 = 0 time = 165
.meas tran vdout1_60ck32 FIND v(dout1_60) AT=165.025n

* CHECK dout1_61 Vdout1_61ck32 = 0 time = 165
.meas tran vdout1_61ck32 FIND v(dout1_61) AT=165.025n

* CHECK dout1_62 Vdout1_62ck32 = 0 time = 165
.meas tran vdout1_62ck32 FIND v(dout1_62) AT=165.025n

* CHECK dout1_63 Vdout1_63ck32 = 0.9 time = 165
.meas tran vdout1_63ck32 FIND v(dout1_63) AT=165.025n

* CHECK dout1_64 Vdout1_64ck32 = 0.9 time = 165
.meas tran vdout1_64ck32 FIND v(dout1_64) AT=165.025n

* CHECK dout1_65 Vdout1_65ck32 = 0.9 time = 165
.meas tran vdout1_65ck32 FIND v(dout1_65) AT=165.025n

* CHECK dout1_66 Vdout1_66ck32 = 0.9 time = 165
.meas tran vdout1_66ck32 FIND v(dout1_66) AT=165.025n

* CHECK dout1_67 Vdout1_67ck32 = 0 time = 165
.meas tran vdout1_67ck32 FIND v(dout1_67) AT=165.025n

* CHECK dout1_68 Vdout1_68ck32 = 0 time = 165
.meas tran vdout1_68ck32 FIND v(dout1_68) AT=165.025n

* CHECK dout1_69 Vdout1_69ck32 = 0 time = 165
.meas tran vdout1_69ck32 FIND v(dout1_69) AT=165.025n

* CHECK dout1_70 Vdout1_70ck32 = 0 time = 165
.meas tran vdout1_70ck32 FIND v(dout1_70) AT=165.025n

* CHECK dout1_71 Vdout1_71ck32 = 0 time = 165
.meas tran vdout1_71ck32 FIND v(dout1_71) AT=165.025n

* CHECK dout1_0 Vdout1_0ck41 = 0 time = 210
.meas tran vdout1_0ck41 FIND v(dout1_0) AT=210.025n

* CHECK dout1_1 Vdout1_1ck41 = 0 time = 210
.meas tran vdout1_1ck41 FIND v(dout1_1) AT=210.025n

* CHECK dout1_2 Vdout1_2ck41 = 0 time = 210
.meas tran vdout1_2ck41 FIND v(dout1_2) AT=210.025n

* CHECK dout1_3 Vdout1_3ck41 = 0 time = 210
.meas tran vdout1_3ck41 FIND v(dout1_3) AT=210.025n

* CHECK dout1_4 Vdout1_4ck41 = 0.9 time = 210
.meas tran vdout1_4ck41 FIND v(dout1_4) AT=210.025n

* CHECK dout1_5 Vdout1_5ck41 = 0 time = 210
.meas tran vdout1_5ck41 FIND v(dout1_5) AT=210.025n

* CHECK dout1_6 Vdout1_6ck41 = 0 time = 210
.meas tran vdout1_6ck41 FIND v(dout1_6) AT=210.025n

* CHECK dout1_7 Vdout1_7ck41 = 0.9 time = 210
.meas tran vdout1_7ck41 FIND v(dout1_7) AT=210.025n

* CHECK dout1_8 Vdout1_8ck41 = 0.9 time = 210
.meas tran vdout1_8ck41 FIND v(dout1_8) AT=210.025n

* CHECK dout1_9 Vdout1_9ck41 = 0 time = 210
.meas tran vdout1_9ck41 FIND v(dout1_9) AT=210.025n

* CHECK dout1_10 Vdout1_10ck41 = 0 time = 210
.meas tran vdout1_10ck41 FIND v(dout1_10) AT=210.025n

* CHECK dout1_11 Vdout1_11ck41 = 0 time = 210
.meas tran vdout1_11ck41 FIND v(dout1_11) AT=210.025n

* CHECK dout1_12 Vdout1_12ck41 = 0 time = 210
.meas tran vdout1_12ck41 FIND v(dout1_12) AT=210.025n

* CHECK dout1_13 Vdout1_13ck41 = 0.9 time = 210
.meas tran vdout1_13ck41 FIND v(dout1_13) AT=210.025n

* CHECK dout1_14 Vdout1_14ck41 = 0.9 time = 210
.meas tran vdout1_14ck41 FIND v(dout1_14) AT=210.025n

* CHECK dout1_15 Vdout1_15ck41 = 0 time = 210
.meas tran vdout1_15ck41 FIND v(dout1_15) AT=210.025n

* CHECK dout1_16 Vdout1_16ck41 = 0 time = 210
.meas tran vdout1_16ck41 FIND v(dout1_16) AT=210.025n

* CHECK dout1_17 Vdout1_17ck41 = 0 time = 210
.meas tran vdout1_17ck41 FIND v(dout1_17) AT=210.025n

* CHECK dout1_18 Vdout1_18ck41 = 0 time = 210
.meas tran vdout1_18ck41 FIND v(dout1_18) AT=210.025n

* CHECK dout1_19 Vdout1_19ck41 = 0.9 time = 210
.meas tran vdout1_19ck41 FIND v(dout1_19) AT=210.025n

* CHECK dout1_20 Vdout1_20ck41 = 0 time = 210
.meas tran vdout1_20ck41 FIND v(dout1_20) AT=210.025n

* CHECK dout1_21 Vdout1_21ck41 = 0.9 time = 210
.meas tran vdout1_21ck41 FIND v(dout1_21) AT=210.025n

* CHECK dout1_22 Vdout1_22ck41 = 0.9 time = 210
.meas tran vdout1_22ck41 FIND v(dout1_22) AT=210.025n

* CHECK dout1_23 Vdout1_23ck41 = 0.9 time = 210
.meas tran vdout1_23ck41 FIND v(dout1_23) AT=210.025n

* CHECK dout1_24 Vdout1_24ck41 = 0.9 time = 210
.meas tran vdout1_24ck41 FIND v(dout1_24) AT=210.025n

* CHECK dout1_25 Vdout1_25ck41 = 0 time = 210
.meas tran vdout1_25ck41 FIND v(dout1_25) AT=210.025n

* CHECK dout1_26 Vdout1_26ck41 = 0 time = 210
.meas tran vdout1_26ck41 FIND v(dout1_26) AT=210.025n

* CHECK dout1_27 Vdout1_27ck41 = 0.9 time = 210
.meas tran vdout1_27ck41 FIND v(dout1_27) AT=210.025n

* CHECK dout1_28 Vdout1_28ck41 = 0.9 time = 210
.meas tran vdout1_28ck41 FIND v(dout1_28) AT=210.025n

* CHECK dout1_29 Vdout1_29ck41 = 0.9 time = 210
.meas tran vdout1_29ck41 FIND v(dout1_29) AT=210.025n

* CHECK dout1_30 Vdout1_30ck41 = 0.9 time = 210
.meas tran vdout1_30ck41 FIND v(dout1_30) AT=210.025n

* CHECK dout1_31 Vdout1_31ck41 = 0.9 time = 210
.meas tran vdout1_31ck41 FIND v(dout1_31) AT=210.025n

* CHECK dout1_32 Vdout1_32ck41 = 0.9 time = 210
.meas tran vdout1_32ck41 FIND v(dout1_32) AT=210.025n

* CHECK dout1_33 Vdout1_33ck41 = 0.9 time = 210
.meas tran vdout1_33ck41 FIND v(dout1_33) AT=210.025n

* CHECK dout1_34 Vdout1_34ck41 = 0.9 time = 210
.meas tran vdout1_34ck41 FIND v(dout1_34) AT=210.025n

* CHECK dout1_35 Vdout1_35ck41 = 0 time = 210
.meas tran vdout1_35ck41 FIND v(dout1_35) AT=210.025n

* CHECK dout1_36 Vdout1_36ck41 = 0 time = 210
.meas tran vdout1_36ck41 FIND v(dout1_36) AT=210.025n

* CHECK dout1_37 Vdout1_37ck41 = 0 time = 210
.meas tran vdout1_37ck41 FIND v(dout1_37) AT=210.025n

* CHECK dout1_38 Vdout1_38ck41 = 0.9 time = 210
.meas tran vdout1_38ck41 FIND v(dout1_38) AT=210.025n

* CHECK dout1_39 Vdout1_39ck41 = 0.9 time = 210
.meas tran vdout1_39ck41 FIND v(dout1_39) AT=210.025n

* CHECK dout1_40 Vdout1_40ck41 = 0 time = 210
.meas tran vdout1_40ck41 FIND v(dout1_40) AT=210.025n

* CHECK dout1_41 Vdout1_41ck41 = 0 time = 210
.meas tran vdout1_41ck41 FIND v(dout1_41) AT=210.025n

* CHECK dout1_42 Vdout1_42ck41 = 0.9 time = 210
.meas tran vdout1_42ck41 FIND v(dout1_42) AT=210.025n

* CHECK dout1_43 Vdout1_43ck41 = 0 time = 210
.meas tran vdout1_43ck41 FIND v(dout1_43) AT=210.025n

* CHECK dout1_44 Vdout1_44ck41 = 0.9 time = 210
.meas tran vdout1_44ck41 FIND v(dout1_44) AT=210.025n

* CHECK dout1_45 Vdout1_45ck41 = 0.9 time = 210
.meas tran vdout1_45ck41 FIND v(dout1_45) AT=210.025n

* CHECK dout1_46 Vdout1_46ck41 = 0 time = 210
.meas tran vdout1_46ck41 FIND v(dout1_46) AT=210.025n

* CHECK dout1_47 Vdout1_47ck41 = 0 time = 210
.meas tran vdout1_47ck41 FIND v(dout1_47) AT=210.025n

* CHECK dout1_48 Vdout1_48ck41 = 0 time = 210
.meas tran vdout1_48ck41 FIND v(dout1_48) AT=210.025n

* CHECK dout1_49 Vdout1_49ck41 = 0.9 time = 210
.meas tran vdout1_49ck41 FIND v(dout1_49) AT=210.025n

* CHECK dout1_50 Vdout1_50ck41 = 0.9 time = 210
.meas tran vdout1_50ck41 FIND v(dout1_50) AT=210.025n

* CHECK dout1_51 Vdout1_51ck41 = 0.9 time = 210
.meas tran vdout1_51ck41 FIND v(dout1_51) AT=210.025n

* CHECK dout1_52 Vdout1_52ck41 = 0 time = 210
.meas tran vdout1_52ck41 FIND v(dout1_52) AT=210.025n

* CHECK dout1_53 Vdout1_53ck41 = 0 time = 210
.meas tran vdout1_53ck41 FIND v(dout1_53) AT=210.025n

* CHECK dout1_54 Vdout1_54ck41 = 0 time = 210
.meas tran vdout1_54ck41 FIND v(dout1_54) AT=210.025n

* CHECK dout1_55 Vdout1_55ck41 = 0.9 time = 210
.meas tran vdout1_55ck41 FIND v(dout1_55) AT=210.025n

* CHECK dout1_56 Vdout1_56ck41 = 0.9 time = 210
.meas tran vdout1_56ck41 FIND v(dout1_56) AT=210.025n

* CHECK dout1_57 Vdout1_57ck41 = 0 time = 210
.meas tran vdout1_57ck41 FIND v(dout1_57) AT=210.025n

* CHECK dout1_58 Vdout1_58ck41 = 0.9 time = 210
.meas tran vdout1_58ck41 FIND v(dout1_58) AT=210.025n

* CHECK dout1_59 Vdout1_59ck41 = 0.9 time = 210
.meas tran vdout1_59ck41 FIND v(dout1_59) AT=210.025n

* CHECK dout1_60 Vdout1_60ck41 = 0.9 time = 210
.meas tran vdout1_60ck41 FIND v(dout1_60) AT=210.025n

* CHECK dout1_61 Vdout1_61ck41 = 0.9 time = 210
.meas tran vdout1_61ck41 FIND v(dout1_61) AT=210.025n

* CHECK dout1_62 Vdout1_62ck41 = 0.9 time = 210
.meas tran vdout1_62ck41 FIND v(dout1_62) AT=210.025n

* CHECK dout1_63 Vdout1_63ck41 = 0 time = 210
.meas tran vdout1_63ck41 FIND v(dout1_63) AT=210.025n

* CHECK dout1_64 Vdout1_64ck41 = 0.9 time = 210
.meas tran vdout1_64ck41 FIND v(dout1_64) AT=210.025n

* CHECK dout1_65 Vdout1_65ck41 = 0.9 time = 210
.meas tran vdout1_65ck41 FIND v(dout1_65) AT=210.025n

* CHECK dout1_66 Vdout1_66ck41 = 0 time = 210
.meas tran vdout1_66ck41 FIND v(dout1_66) AT=210.025n

* CHECK dout1_67 Vdout1_67ck41 = 0 time = 210
.meas tran vdout1_67ck41 FIND v(dout1_67) AT=210.025n

* CHECK dout1_68 Vdout1_68ck41 = 0.9 time = 210
.meas tran vdout1_68ck41 FIND v(dout1_68) AT=210.025n

* CHECK dout1_69 Vdout1_69ck41 = 0.9 time = 210
.meas tran vdout1_69ck41 FIND v(dout1_69) AT=210.025n

* CHECK dout1_70 Vdout1_70ck41 = 0 time = 210
.meas tran vdout1_70ck41 FIND v(dout1_70) AT=210.025n

* CHECK dout1_71 Vdout1_71ck41 = 0 time = 210
.meas tran vdout1_71ck41 FIND v(dout1_71) AT=210.025n

* CHECK dout1_0 Vdout1_0ck42 = 0 time = 215
.meas tran vdout1_0ck42 FIND v(dout1_0) AT=215.025n

* CHECK dout1_1 Vdout1_1ck42 = 0 time = 215
.meas tran vdout1_1ck42 FIND v(dout1_1) AT=215.025n

* CHECK dout1_2 Vdout1_2ck42 = 0 time = 215
.meas tran vdout1_2ck42 FIND v(dout1_2) AT=215.025n

* CHECK dout1_3 Vdout1_3ck42 = 0 time = 215
.meas tran vdout1_3ck42 FIND v(dout1_3) AT=215.025n

* CHECK dout1_4 Vdout1_4ck42 = 0.9 time = 215
.meas tran vdout1_4ck42 FIND v(dout1_4) AT=215.025n

* CHECK dout1_5 Vdout1_5ck42 = 0 time = 215
.meas tran vdout1_5ck42 FIND v(dout1_5) AT=215.025n

* CHECK dout1_6 Vdout1_6ck42 = 0 time = 215
.meas tran vdout1_6ck42 FIND v(dout1_6) AT=215.025n

* CHECK dout1_7 Vdout1_7ck42 = 0.9 time = 215
.meas tran vdout1_7ck42 FIND v(dout1_7) AT=215.025n

* CHECK dout1_8 Vdout1_8ck42 = 0.9 time = 215
.meas tran vdout1_8ck42 FIND v(dout1_8) AT=215.025n

* CHECK dout1_9 Vdout1_9ck42 = 0 time = 215
.meas tran vdout1_9ck42 FIND v(dout1_9) AT=215.025n

* CHECK dout1_10 Vdout1_10ck42 = 0 time = 215
.meas tran vdout1_10ck42 FIND v(dout1_10) AT=215.025n

* CHECK dout1_11 Vdout1_11ck42 = 0 time = 215
.meas tran vdout1_11ck42 FIND v(dout1_11) AT=215.025n

* CHECK dout1_12 Vdout1_12ck42 = 0 time = 215
.meas tran vdout1_12ck42 FIND v(dout1_12) AT=215.025n

* CHECK dout1_13 Vdout1_13ck42 = 0.9 time = 215
.meas tran vdout1_13ck42 FIND v(dout1_13) AT=215.025n

* CHECK dout1_14 Vdout1_14ck42 = 0.9 time = 215
.meas tran vdout1_14ck42 FIND v(dout1_14) AT=215.025n

* CHECK dout1_15 Vdout1_15ck42 = 0 time = 215
.meas tran vdout1_15ck42 FIND v(dout1_15) AT=215.025n

* CHECK dout1_16 Vdout1_16ck42 = 0 time = 215
.meas tran vdout1_16ck42 FIND v(dout1_16) AT=215.025n

* CHECK dout1_17 Vdout1_17ck42 = 0 time = 215
.meas tran vdout1_17ck42 FIND v(dout1_17) AT=215.025n

* CHECK dout1_18 Vdout1_18ck42 = 0 time = 215
.meas tran vdout1_18ck42 FIND v(dout1_18) AT=215.025n

* CHECK dout1_19 Vdout1_19ck42 = 0.9 time = 215
.meas tran vdout1_19ck42 FIND v(dout1_19) AT=215.025n

* CHECK dout1_20 Vdout1_20ck42 = 0 time = 215
.meas tran vdout1_20ck42 FIND v(dout1_20) AT=215.025n

* CHECK dout1_21 Vdout1_21ck42 = 0.9 time = 215
.meas tran vdout1_21ck42 FIND v(dout1_21) AT=215.025n

* CHECK dout1_22 Vdout1_22ck42 = 0.9 time = 215
.meas tran vdout1_22ck42 FIND v(dout1_22) AT=215.025n

* CHECK dout1_23 Vdout1_23ck42 = 0.9 time = 215
.meas tran vdout1_23ck42 FIND v(dout1_23) AT=215.025n

* CHECK dout1_24 Vdout1_24ck42 = 0.9 time = 215
.meas tran vdout1_24ck42 FIND v(dout1_24) AT=215.025n

* CHECK dout1_25 Vdout1_25ck42 = 0 time = 215
.meas tran vdout1_25ck42 FIND v(dout1_25) AT=215.025n

* CHECK dout1_26 Vdout1_26ck42 = 0 time = 215
.meas tran vdout1_26ck42 FIND v(dout1_26) AT=215.025n

* CHECK dout1_27 Vdout1_27ck42 = 0.9 time = 215
.meas tran vdout1_27ck42 FIND v(dout1_27) AT=215.025n

* CHECK dout1_28 Vdout1_28ck42 = 0.9 time = 215
.meas tran vdout1_28ck42 FIND v(dout1_28) AT=215.025n

* CHECK dout1_29 Vdout1_29ck42 = 0.9 time = 215
.meas tran vdout1_29ck42 FIND v(dout1_29) AT=215.025n

* CHECK dout1_30 Vdout1_30ck42 = 0.9 time = 215
.meas tran vdout1_30ck42 FIND v(dout1_30) AT=215.025n

* CHECK dout1_31 Vdout1_31ck42 = 0.9 time = 215
.meas tran vdout1_31ck42 FIND v(dout1_31) AT=215.025n

* CHECK dout1_32 Vdout1_32ck42 = 0.9 time = 215
.meas tran vdout1_32ck42 FIND v(dout1_32) AT=215.025n

* CHECK dout1_33 Vdout1_33ck42 = 0.9 time = 215
.meas tran vdout1_33ck42 FIND v(dout1_33) AT=215.025n

* CHECK dout1_34 Vdout1_34ck42 = 0.9 time = 215
.meas tran vdout1_34ck42 FIND v(dout1_34) AT=215.025n

* CHECK dout1_35 Vdout1_35ck42 = 0 time = 215
.meas tran vdout1_35ck42 FIND v(dout1_35) AT=215.025n

* CHECK dout1_36 Vdout1_36ck42 = 0 time = 215
.meas tran vdout1_36ck42 FIND v(dout1_36) AT=215.025n

* CHECK dout1_37 Vdout1_37ck42 = 0 time = 215
.meas tran vdout1_37ck42 FIND v(dout1_37) AT=215.025n

* CHECK dout1_38 Vdout1_38ck42 = 0.9 time = 215
.meas tran vdout1_38ck42 FIND v(dout1_38) AT=215.025n

* CHECK dout1_39 Vdout1_39ck42 = 0.9 time = 215
.meas tran vdout1_39ck42 FIND v(dout1_39) AT=215.025n

* CHECK dout1_40 Vdout1_40ck42 = 0 time = 215
.meas tran vdout1_40ck42 FIND v(dout1_40) AT=215.025n

* CHECK dout1_41 Vdout1_41ck42 = 0 time = 215
.meas tran vdout1_41ck42 FIND v(dout1_41) AT=215.025n

* CHECK dout1_42 Vdout1_42ck42 = 0.9 time = 215
.meas tran vdout1_42ck42 FIND v(dout1_42) AT=215.025n

* CHECK dout1_43 Vdout1_43ck42 = 0 time = 215
.meas tran vdout1_43ck42 FIND v(dout1_43) AT=215.025n

* CHECK dout1_44 Vdout1_44ck42 = 0.9 time = 215
.meas tran vdout1_44ck42 FIND v(dout1_44) AT=215.025n

* CHECK dout1_45 Vdout1_45ck42 = 0.9 time = 215
.meas tran vdout1_45ck42 FIND v(dout1_45) AT=215.025n

* CHECK dout1_46 Vdout1_46ck42 = 0 time = 215
.meas tran vdout1_46ck42 FIND v(dout1_46) AT=215.025n

* CHECK dout1_47 Vdout1_47ck42 = 0 time = 215
.meas tran vdout1_47ck42 FIND v(dout1_47) AT=215.025n

* CHECK dout1_48 Vdout1_48ck42 = 0 time = 215
.meas tran vdout1_48ck42 FIND v(dout1_48) AT=215.025n

* CHECK dout1_49 Vdout1_49ck42 = 0.9 time = 215
.meas tran vdout1_49ck42 FIND v(dout1_49) AT=215.025n

* CHECK dout1_50 Vdout1_50ck42 = 0.9 time = 215
.meas tran vdout1_50ck42 FIND v(dout1_50) AT=215.025n

* CHECK dout1_51 Vdout1_51ck42 = 0.9 time = 215
.meas tran vdout1_51ck42 FIND v(dout1_51) AT=215.025n

* CHECK dout1_52 Vdout1_52ck42 = 0 time = 215
.meas tran vdout1_52ck42 FIND v(dout1_52) AT=215.025n

* CHECK dout1_53 Vdout1_53ck42 = 0 time = 215
.meas tran vdout1_53ck42 FIND v(dout1_53) AT=215.025n

* CHECK dout1_54 Vdout1_54ck42 = 0 time = 215
.meas tran vdout1_54ck42 FIND v(dout1_54) AT=215.025n

* CHECK dout1_55 Vdout1_55ck42 = 0.9 time = 215
.meas tran vdout1_55ck42 FIND v(dout1_55) AT=215.025n

* CHECK dout1_56 Vdout1_56ck42 = 0.9 time = 215
.meas tran vdout1_56ck42 FIND v(dout1_56) AT=215.025n

* CHECK dout1_57 Vdout1_57ck42 = 0 time = 215
.meas tran vdout1_57ck42 FIND v(dout1_57) AT=215.025n

* CHECK dout1_58 Vdout1_58ck42 = 0.9 time = 215
.meas tran vdout1_58ck42 FIND v(dout1_58) AT=215.025n

* CHECK dout1_59 Vdout1_59ck42 = 0.9 time = 215
.meas tran vdout1_59ck42 FIND v(dout1_59) AT=215.025n

* CHECK dout1_60 Vdout1_60ck42 = 0.9 time = 215
.meas tran vdout1_60ck42 FIND v(dout1_60) AT=215.025n

* CHECK dout1_61 Vdout1_61ck42 = 0.9 time = 215
.meas tran vdout1_61ck42 FIND v(dout1_61) AT=215.025n

* CHECK dout1_62 Vdout1_62ck42 = 0.9 time = 215
.meas tran vdout1_62ck42 FIND v(dout1_62) AT=215.025n

* CHECK dout1_63 Vdout1_63ck42 = 0 time = 215
.meas tran vdout1_63ck42 FIND v(dout1_63) AT=215.025n

* CHECK dout1_64 Vdout1_64ck42 = 0.9 time = 215
.meas tran vdout1_64ck42 FIND v(dout1_64) AT=215.025n

* CHECK dout1_65 Vdout1_65ck42 = 0.9 time = 215
.meas tran vdout1_65ck42 FIND v(dout1_65) AT=215.025n

* CHECK dout1_66 Vdout1_66ck42 = 0 time = 215
.meas tran vdout1_66ck42 FIND v(dout1_66) AT=215.025n

* CHECK dout1_67 Vdout1_67ck42 = 0 time = 215
.meas tran vdout1_67ck42 FIND v(dout1_67) AT=215.025n

* CHECK dout1_68 Vdout1_68ck42 = 0.9 time = 215
.meas tran vdout1_68ck42 FIND v(dout1_68) AT=215.025n

* CHECK dout1_69 Vdout1_69ck42 = 0.9 time = 215
.meas tran vdout1_69ck42 FIND v(dout1_69) AT=215.025n

* CHECK dout1_70 Vdout1_70ck42 = 0 time = 215
.meas tran vdout1_70ck42 FIND v(dout1_70) AT=215.025n

* CHECK dout1_71 Vdout1_71ck42 = 0 time = 215
.meas tran vdout1_71ck42 FIND v(dout1_71) AT=215.025n

* CHECK dout1_0 Vdout1_0ck43 = 0 time = 220
.meas tran vdout1_0ck43 FIND v(dout1_0) AT=220.025n

* CHECK dout1_1 Vdout1_1ck43 = 0 time = 220
.meas tran vdout1_1ck43 FIND v(dout1_1) AT=220.025n

* CHECK dout1_2 Vdout1_2ck43 = 0 time = 220
.meas tran vdout1_2ck43 FIND v(dout1_2) AT=220.025n

* CHECK dout1_3 Vdout1_3ck43 = 0 time = 220
.meas tran vdout1_3ck43 FIND v(dout1_3) AT=220.025n

* CHECK dout1_4 Vdout1_4ck43 = 0.9 time = 220
.meas tran vdout1_4ck43 FIND v(dout1_4) AT=220.025n

* CHECK dout1_5 Vdout1_5ck43 = 0 time = 220
.meas tran vdout1_5ck43 FIND v(dout1_5) AT=220.025n

* CHECK dout1_6 Vdout1_6ck43 = 0 time = 220
.meas tran vdout1_6ck43 FIND v(dout1_6) AT=220.025n

* CHECK dout1_7 Vdout1_7ck43 = 0.9 time = 220
.meas tran vdout1_7ck43 FIND v(dout1_7) AT=220.025n

* CHECK dout1_8 Vdout1_8ck43 = 0.9 time = 220
.meas tran vdout1_8ck43 FIND v(dout1_8) AT=220.025n

* CHECK dout1_9 Vdout1_9ck43 = 0 time = 220
.meas tran vdout1_9ck43 FIND v(dout1_9) AT=220.025n

* CHECK dout1_10 Vdout1_10ck43 = 0 time = 220
.meas tran vdout1_10ck43 FIND v(dout1_10) AT=220.025n

* CHECK dout1_11 Vdout1_11ck43 = 0 time = 220
.meas tran vdout1_11ck43 FIND v(dout1_11) AT=220.025n

* CHECK dout1_12 Vdout1_12ck43 = 0 time = 220
.meas tran vdout1_12ck43 FIND v(dout1_12) AT=220.025n

* CHECK dout1_13 Vdout1_13ck43 = 0.9 time = 220
.meas tran vdout1_13ck43 FIND v(dout1_13) AT=220.025n

* CHECK dout1_14 Vdout1_14ck43 = 0.9 time = 220
.meas tran vdout1_14ck43 FIND v(dout1_14) AT=220.025n

* CHECK dout1_15 Vdout1_15ck43 = 0 time = 220
.meas tran vdout1_15ck43 FIND v(dout1_15) AT=220.025n

* CHECK dout1_16 Vdout1_16ck43 = 0 time = 220
.meas tran vdout1_16ck43 FIND v(dout1_16) AT=220.025n

* CHECK dout1_17 Vdout1_17ck43 = 0 time = 220
.meas tran vdout1_17ck43 FIND v(dout1_17) AT=220.025n

* CHECK dout1_18 Vdout1_18ck43 = 0 time = 220
.meas tran vdout1_18ck43 FIND v(dout1_18) AT=220.025n

* CHECK dout1_19 Vdout1_19ck43 = 0.9 time = 220
.meas tran vdout1_19ck43 FIND v(dout1_19) AT=220.025n

* CHECK dout1_20 Vdout1_20ck43 = 0 time = 220
.meas tran vdout1_20ck43 FIND v(dout1_20) AT=220.025n

* CHECK dout1_21 Vdout1_21ck43 = 0.9 time = 220
.meas tran vdout1_21ck43 FIND v(dout1_21) AT=220.025n

* CHECK dout1_22 Vdout1_22ck43 = 0.9 time = 220
.meas tran vdout1_22ck43 FIND v(dout1_22) AT=220.025n

* CHECK dout1_23 Vdout1_23ck43 = 0.9 time = 220
.meas tran vdout1_23ck43 FIND v(dout1_23) AT=220.025n

* CHECK dout1_24 Vdout1_24ck43 = 0.9 time = 220
.meas tran vdout1_24ck43 FIND v(dout1_24) AT=220.025n

* CHECK dout1_25 Vdout1_25ck43 = 0 time = 220
.meas tran vdout1_25ck43 FIND v(dout1_25) AT=220.025n

* CHECK dout1_26 Vdout1_26ck43 = 0 time = 220
.meas tran vdout1_26ck43 FIND v(dout1_26) AT=220.025n

* CHECK dout1_27 Vdout1_27ck43 = 0.9 time = 220
.meas tran vdout1_27ck43 FIND v(dout1_27) AT=220.025n

* CHECK dout1_28 Vdout1_28ck43 = 0.9 time = 220
.meas tran vdout1_28ck43 FIND v(dout1_28) AT=220.025n

* CHECK dout1_29 Vdout1_29ck43 = 0.9 time = 220
.meas tran vdout1_29ck43 FIND v(dout1_29) AT=220.025n

* CHECK dout1_30 Vdout1_30ck43 = 0.9 time = 220
.meas tran vdout1_30ck43 FIND v(dout1_30) AT=220.025n

* CHECK dout1_31 Vdout1_31ck43 = 0.9 time = 220
.meas tran vdout1_31ck43 FIND v(dout1_31) AT=220.025n

* CHECK dout1_32 Vdout1_32ck43 = 0.9 time = 220
.meas tran vdout1_32ck43 FIND v(dout1_32) AT=220.025n

* CHECK dout1_33 Vdout1_33ck43 = 0.9 time = 220
.meas tran vdout1_33ck43 FIND v(dout1_33) AT=220.025n

* CHECK dout1_34 Vdout1_34ck43 = 0.9 time = 220
.meas tran vdout1_34ck43 FIND v(dout1_34) AT=220.025n

* CHECK dout1_35 Vdout1_35ck43 = 0 time = 220
.meas tran vdout1_35ck43 FIND v(dout1_35) AT=220.025n

* CHECK dout1_36 Vdout1_36ck43 = 0 time = 220
.meas tran vdout1_36ck43 FIND v(dout1_36) AT=220.025n

* CHECK dout1_37 Vdout1_37ck43 = 0 time = 220
.meas tran vdout1_37ck43 FIND v(dout1_37) AT=220.025n

* CHECK dout1_38 Vdout1_38ck43 = 0.9 time = 220
.meas tran vdout1_38ck43 FIND v(dout1_38) AT=220.025n

* CHECK dout1_39 Vdout1_39ck43 = 0.9 time = 220
.meas tran vdout1_39ck43 FIND v(dout1_39) AT=220.025n

* CHECK dout1_40 Vdout1_40ck43 = 0 time = 220
.meas tran vdout1_40ck43 FIND v(dout1_40) AT=220.025n

* CHECK dout1_41 Vdout1_41ck43 = 0 time = 220
.meas tran vdout1_41ck43 FIND v(dout1_41) AT=220.025n

* CHECK dout1_42 Vdout1_42ck43 = 0.9 time = 220
.meas tran vdout1_42ck43 FIND v(dout1_42) AT=220.025n

* CHECK dout1_43 Vdout1_43ck43 = 0 time = 220
.meas tran vdout1_43ck43 FIND v(dout1_43) AT=220.025n

* CHECK dout1_44 Vdout1_44ck43 = 0.9 time = 220
.meas tran vdout1_44ck43 FIND v(dout1_44) AT=220.025n

* CHECK dout1_45 Vdout1_45ck43 = 0.9 time = 220
.meas tran vdout1_45ck43 FIND v(dout1_45) AT=220.025n

* CHECK dout1_46 Vdout1_46ck43 = 0 time = 220
.meas tran vdout1_46ck43 FIND v(dout1_46) AT=220.025n

* CHECK dout1_47 Vdout1_47ck43 = 0 time = 220
.meas tran vdout1_47ck43 FIND v(dout1_47) AT=220.025n

* CHECK dout1_48 Vdout1_48ck43 = 0 time = 220
.meas tran vdout1_48ck43 FIND v(dout1_48) AT=220.025n

* CHECK dout1_49 Vdout1_49ck43 = 0.9 time = 220
.meas tran vdout1_49ck43 FIND v(dout1_49) AT=220.025n

* CHECK dout1_50 Vdout1_50ck43 = 0.9 time = 220
.meas tran vdout1_50ck43 FIND v(dout1_50) AT=220.025n

* CHECK dout1_51 Vdout1_51ck43 = 0.9 time = 220
.meas tran vdout1_51ck43 FIND v(dout1_51) AT=220.025n

* CHECK dout1_52 Vdout1_52ck43 = 0 time = 220
.meas tran vdout1_52ck43 FIND v(dout1_52) AT=220.025n

* CHECK dout1_53 Vdout1_53ck43 = 0 time = 220
.meas tran vdout1_53ck43 FIND v(dout1_53) AT=220.025n

* CHECK dout1_54 Vdout1_54ck43 = 0 time = 220
.meas tran vdout1_54ck43 FIND v(dout1_54) AT=220.025n

* CHECK dout1_55 Vdout1_55ck43 = 0.9 time = 220
.meas tran vdout1_55ck43 FIND v(dout1_55) AT=220.025n

* CHECK dout1_56 Vdout1_56ck43 = 0.9 time = 220
.meas tran vdout1_56ck43 FIND v(dout1_56) AT=220.025n

* CHECK dout1_57 Vdout1_57ck43 = 0 time = 220
.meas tran vdout1_57ck43 FIND v(dout1_57) AT=220.025n

* CHECK dout1_58 Vdout1_58ck43 = 0.9 time = 220
.meas tran vdout1_58ck43 FIND v(dout1_58) AT=220.025n

* CHECK dout1_59 Vdout1_59ck43 = 0.9 time = 220
.meas tran vdout1_59ck43 FIND v(dout1_59) AT=220.025n

* CHECK dout1_60 Vdout1_60ck43 = 0.9 time = 220
.meas tran vdout1_60ck43 FIND v(dout1_60) AT=220.025n

* CHECK dout1_61 Vdout1_61ck43 = 0.9 time = 220
.meas tran vdout1_61ck43 FIND v(dout1_61) AT=220.025n

* CHECK dout1_62 Vdout1_62ck43 = 0.9 time = 220
.meas tran vdout1_62ck43 FIND v(dout1_62) AT=220.025n

* CHECK dout1_63 Vdout1_63ck43 = 0 time = 220
.meas tran vdout1_63ck43 FIND v(dout1_63) AT=220.025n

* CHECK dout1_64 Vdout1_64ck43 = 0.9 time = 220
.meas tran vdout1_64ck43 FIND v(dout1_64) AT=220.025n

* CHECK dout1_65 Vdout1_65ck43 = 0.9 time = 220
.meas tran vdout1_65ck43 FIND v(dout1_65) AT=220.025n

* CHECK dout1_66 Vdout1_66ck43 = 0 time = 220
.meas tran vdout1_66ck43 FIND v(dout1_66) AT=220.025n

* CHECK dout1_67 Vdout1_67ck43 = 0 time = 220
.meas tran vdout1_67ck43 FIND v(dout1_67) AT=220.025n

* CHECK dout1_68 Vdout1_68ck43 = 0.9 time = 220
.meas tran vdout1_68ck43 FIND v(dout1_68) AT=220.025n

* CHECK dout1_69 Vdout1_69ck43 = 0.9 time = 220
.meas tran vdout1_69ck43 FIND v(dout1_69) AT=220.025n

* CHECK dout1_70 Vdout1_70ck43 = 0 time = 220
.meas tran vdout1_70ck43 FIND v(dout1_70) AT=220.025n

* CHECK dout1_71 Vdout1_71ck43 = 0 time = 220
.meas tran vdout1_71ck43 FIND v(dout1_71) AT=220.025n

* CHECK dout1_0 Vdout1_0ck44 = 0 time = 225
.meas tran vdout1_0ck44 FIND v(dout1_0) AT=225.025n

* CHECK dout1_1 Vdout1_1ck44 = 0 time = 225
.meas tran vdout1_1ck44 FIND v(dout1_1) AT=225.025n

* CHECK dout1_2 Vdout1_2ck44 = 0 time = 225
.meas tran vdout1_2ck44 FIND v(dout1_2) AT=225.025n

* CHECK dout1_3 Vdout1_3ck44 = 0 time = 225
.meas tran vdout1_3ck44 FIND v(dout1_3) AT=225.025n

* CHECK dout1_4 Vdout1_4ck44 = 0.9 time = 225
.meas tran vdout1_4ck44 FIND v(dout1_4) AT=225.025n

* CHECK dout1_5 Vdout1_5ck44 = 0 time = 225
.meas tran vdout1_5ck44 FIND v(dout1_5) AT=225.025n

* CHECK dout1_6 Vdout1_6ck44 = 0 time = 225
.meas tran vdout1_6ck44 FIND v(dout1_6) AT=225.025n

* CHECK dout1_7 Vdout1_7ck44 = 0.9 time = 225
.meas tran vdout1_7ck44 FIND v(dout1_7) AT=225.025n

* CHECK dout1_8 Vdout1_8ck44 = 0.9 time = 225
.meas tran vdout1_8ck44 FIND v(dout1_8) AT=225.025n

* CHECK dout1_9 Vdout1_9ck44 = 0 time = 225
.meas tran vdout1_9ck44 FIND v(dout1_9) AT=225.025n

* CHECK dout1_10 Vdout1_10ck44 = 0 time = 225
.meas tran vdout1_10ck44 FIND v(dout1_10) AT=225.025n

* CHECK dout1_11 Vdout1_11ck44 = 0 time = 225
.meas tran vdout1_11ck44 FIND v(dout1_11) AT=225.025n

* CHECK dout1_12 Vdout1_12ck44 = 0 time = 225
.meas tran vdout1_12ck44 FIND v(dout1_12) AT=225.025n

* CHECK dout1_13 Vdout1_13ck44 = 0.9 time = 225
.meas tran vdout1_13ck44 FIND v(dout1_13) AT=225.025n

* CHECK dout1_14 Vdout1_14ck44 = 0.9 time = 225
.meas tran vdout1_14ck44 FIND v(dout1_14) AT=225.025n

* CHECK dout1_15 Vdout1_15ck44 = 0 time = 225
.meas tran vdout1_15ck44 FIND v(dout1_15) AT=225.025n

* CHECK dout1_16 Vdout1_16ck44 = 0 time = 225
.meas tran vdout1_16ck44 FIND v(dout1_16) AT=225.025n

* CHECK dout1_17 Vdout1_17ck44 = 0 time = 225
.meas tran vdout1_17ck44 FIND v(dout1_17) AT=225.025n

* CHECK dout1_18 Vdout1_18ck44 = 0 time = 225
.meas tran vdout1_18ck44 FIND v(dout1_18) AT=225.025n

* CHECK dout1_19 Vdout1_19ck44 = 0.9 time = 225
.meas tran vdout1_19ck44 FIND v(dout1_19) AT=225.025n

* CHECK dout1_20 Vdout1_20ck44 = 0 time = 225
.meas tran vdout1_20ck44 FIND v(dout1_20) AT=225.025n

* CHECK dout1_21 Vdout1_21ck44 = 0.9 time = 225
.meas tran vdout1_21ck44 FIND v(dout1_21) AT=225.025n

* CHECK dout1_22 Vdout1_22ck44 = 0.9 time = 225
.meas tran vdout1_22ck44 FIND v(dout1_22) AT=225.025n

* CHECK dout1_23 Vdout1_23ck44 = 0.9 time = 225
.meas tran vdout1_23ck44 FIND v(dout1_23) AT=225.025n

* CHECK dout1_24 Vdout1_24ck44 = 0.9 time = 225
.meas tran vdout1_24ck44 FIND v(dout1_24) AT=225.025n

* CHECK dout1_25 Vdout1_25ck44 = 0 time = 225
.meas tran vdout1_25ck44 FIND v(dout1_25) AT=225.025n

* CHECK dout1_26 Vdout1_26ck44 = 0 time = 225
.meas tran vdout1_26ck44 FIND v(dout1_26) AT=225.025n

* CHECK dout1_27 Vdout1_27ck44 = 0.9 time = 225
.meas tran vdout1_27ck44 FIND v(dout1_27) AT=225.025n

* CHECK dout1_28 Vdout1_28ck44 = 0.9 time = 225
.meas tran vdout1_28ck44 FIND v(dout1_28) AT=225.025n

* CHECK dout1_29 Vdout1_29ck44 = 0.9 time = 225
.meas tran vdout1_29ck44 FIND v(dout1_29) AT=225.025n

* CHECK dout1_30 Vdout1_30ck44 = 0.9 time = 225
.meas tran vdout1_30ck44 FIND v(dout1_30) AT=225.025n

* CHECK dout1_31 Vdout1_31ck44 = 0.9 time = 225
.meas tran vdout1_31ck44 FIND v(dout1_31) AT=225.025n

* CHECK dout1_32 Vdout1_32ck44 = 0.9 time = 225
.meas tran vdout1_32ck44 FIND v(dout1_32) AT=225.025n

* CHECK dout1_33 Vdout1_33ck44 = 0.9 time = 225
.meas tran vdout1_33ck44 FIND v(dout1_33) AT=225.025n

* CHECK dout1_34 Vdout1_34ck44 = 0.9 time = 225
.meas tran vdout1_34ck44 FIND v(dout1_34) AT=225.025n

* CHECK dout1_35 Vdout1_35ck44 = 0 time = 225
.meas tran vdout1_35ck44 FIND v(dout1_35) AT=225.025n

* CHECK dout1_36 Vdout1_36ck44 = 0 time = 225
.meas tran vdout1_36ck44 FIND v(dout1_36) AT=225.025n

* CHECK dout1_37 Vdout1_37ck44 = 0 time = 225
.meas tran vdout1_37ck44 FIND v(dout1_37) AT=225.025n

* CHECK dout1_38 Vdout1_38ck44 = 0.9 time = 225
.meas tran vdout1_38ck44 FIND v(dout1_38) AT=225.025n

* CHECK dout1_39 Vdout1_39ck44 = 0.9 time = 225
.meas tran vdout1_39ck44 FIND v(dout1_39) AT=225.025n

* CHECK dout1_40 Vdout1_40ck44 = 0 time = 225
.meas tran vdout1_40ck44 FIND v(dout1_40) AT=225.025n

* CHECK dout1_41 Vdout1_41ck44 = 0 time = 225
.meas tran vdout1_41ck44 FIND v(dout1_41) AT=225.025n

* CHECK dout1_42 Vdout1_42ck44 = 0.9 time = 225
.meas tran vdout1_42ck44 FIND v(dout1_42) AT=225.025n

* CHECK dout1_43 Vdout1_43ck44 = 0 time = 225
.meas tran vdout1_43ck44 FIND v(dout1_43) AT=225.025n

* CHECK dout1_44 Vdout1_44ck44 = 0.9 time = 225
.meas tran vdout1_44ck44 FIND v(dout1_44) AT=225.025n

* CHECK dout1_45 Vdout1_45ck44 = 0.9 time = 225
.meas tran vdout1_45ck44 FIND v(dout1_45) AT=225.025n

* CHECK dout1_46 Vdout1_46ck44 = 0 time = 225
.meas tran vdout1_46ck44 FIND v(dout1_46) AT=225.025n

* CHECK dout1_47 Vdout1_47ck44 = 0 time = 225
.meas tran vdout1_47ck44 FIND v(dout1_47) AT=225.025n

* CHECK dout1_48 Vdout1_48ck44 = 0 time = 225
.meas tran vdout1_48ck44 FIND v(dout1_48) AT=225.025n

* CHECK dout1_49 Vdout1_49ck44 = 0.9 time = 225
.meas tran vdout1_49ck44 FIND v(dout1_49) AT=225.025n

* CHECK dout1_50 Vdout1_50ck44 = 0.9 time = 225
.meas tran vdout1_50ck44 FIND v(dout1_50) AT=225.025n

* CHECK dout1_51 Vdout1_51ck44 = 0.9 time = 225
.meas tran vdout1_51ck44 FIND v(dout1_51) AT=225.025n

* CHECK dout1_52 Vdout1_52ck44 = 0 time = 225
.meas tran vdout1_52ck44 FIND v(dout1_52) AT=225.025n

* CHECK dout1_53 Vdout1_53ck44 = 0 time = 225
.meas tran vdout1_53ck44 FIND v(dout1_53) AT=225.025n

* CHECK dout1_54 Vdout1_54ck44 = 0 time = 225
.meas tran vdout1_54ck44 FIND v(dout1_54) AT=225.025n

* CHECK dout1_55 Vdout1_55ck44 = 0.9 time = 225
.meas tran vdout1_55ck44 FIND v(dout1_55) AT=225.025n

* CHECK dout1_56 Vdout1_56ck44 = 0.9 time = 225
.meas tran vdout1_56ck44 FIND v(dout1_56) AT=225.025n

* CHECK dout1_57 Vdout1_57ck44 = 0 time = 225
.meas tran vdout1_57ck44 FIND v(dout1_57) AT=225.025n

* CHECK dout1_58 Vdout1_58ck44 = 0.9 time = 225
.meas tran vdout1_58ck44 FIND v(dout1_58) AT=225.025n

* CHECK dout1_59 Vdout1_59ck44 = 0.9 time = 225
.meas tran vdout1_59ck44 FIND v(dout1_59) AT=225.025n

* CHECK dout1_60 Vdout1_60ck44 = 0.9 time = 225
.meas tran vdout1_60ck44 FIND v(dout1_60) AT=225.025n

* CHECK dout1_61 Vdout1_61ck44 = 0.9 time = 225
.meas tran vdout1_61ck44 FIND v(dout1_61) AT=225.025n

* CHECK dout1_62 Vdout1_62ck44 = 0.9 time = 225
.meas tran vdout1_62ck44 FIND v(dout1_62) AT=225.025n

* CHECK dout1_63 Vdout1_63ck44 = 0 time = 225
.meas tran vdout1_63ck44 FIND v(dout1_63) AT=225.025n

* CHECK dout1_64 Vdout1_64ck44 = 0.9 time = 225
.meas tran vdout1_64ck44 FIND v(dout1_64) AT=225.025n

* CHECK dout1_65 Vdout1_65ck44 = 0.9 time = 225
.meas tran vdout1_65ck44 FIND v(dout1_65) AT=225.025n

* CHECK dout1_66 Vdout1_66ck44 = 0 time = 225
.meas tran vdout1_66ck44 FIND v(dout1_66) AT=225.025n

* CHECK dout1_67 Vdout1_67ck44 = 0 time = 225
.meas tran vdout1_67ck44 FIND v(dout1_67) AT=225.025n

* CHECK dout1_68 Vdout1_68ck44 = 0.9 time = 225
.meas tran vdout1_68ck44 FIND v(dout1_68) AT=225.025n

* CHECK dout1_69 Vdout1_69ck44 = 0.9 time = 225
.meas tran vdout1_69ck44 FIND v(dout1_69) AT=225.025n

* CHECK dout1_70 Vdout1_70ck44 = 0 time = 225
.meas tran vdout1_70ck44 FIND v(dout1_70) AT=225.025n

* CHECK dout1_71 Vdout1_71ck44 = 0 time = 225
.meas tran vdout1_71ck44 FIND v(dout1_71) AT=225.025n

* CHECK dout1_0 Vdout1_0ck45 = 0 time = 230
.meas tran vdout1_0ck45 FIND v(dout1_0) AT=230.025n

* CHECK dout1_1 Vdout1_1ck45 = 0 time = 230
.meas tran vdout1_1ck45 FIND v(dout1_1) AT=230.025n

* CHECK dout1_2 Vdout1_2ck45 = 0 time = 230
.meas tran vdout1_2ck45 FIND v(dout1_2) AT=230.025n

* CHECK dout1_3 Vdout1_3ck45 = 0 time = 230
.meas tran vdout1_3ck45 FIND v(dout1_3) AT=230.025n

* CHECK dout1_4 Vdout1_4ck45 = 0.9 time = 230
.meas tran vdout1_4ck45 FIND v(dout1_4) AT=230.025n

* CHECK dout1_5 Vdout1_5ck45 = 0 time = 230
.meas tran vdout1_5ck45 FIND v(dout1_5) AT=230.025n

* CHECK dout1_6 Vdout1_6ck45 = 0 time = 230
.meas tran vdout1_6ck45 FIND v(dout1_6) AT=230.025n

* CHECK dout1_7 Vdout1_7ck45 = 0.9 time = 230
.meas tran vdout1_7ck45 FIND v(dout1_7) AT=230.025n

* CHECK dout1_8 Vdout1_8ck45 = 0.9 time = 230
.meas tran vdout1_8ck45 FIND v(dout1_8) AT=230.025n

* CHECK dout1_9 Vdout1_9ck45 = 0 time = 230
.meas tran vdout1_9ck45 FIND v(dout1_9) AT=230.025n

* CHECK dout1_10 Vdout1_10ck45 = 0 time = 230
.meas tran vdout1_10ck45 FIND v(dout1_10) AT=230.025n

* CHECK dout1_11 Vdout1_11ck45 = 0 time = 230
.meas tran vdout1_11ck45 FIND v(dout1_11) AT=230.025n

* CHECK dout1_12 Vdout1_12ck45 = 0 time = 230
.meas tran vdout1_12ck45 FIND v(dout1_12) AT=230.025n

* CHECK dout1_13 Vdout1_13ck45 = 0.9 time = 230
.meas tran vdout1_13ck45 FIND v(dout1_13) AT=230.025n

* CHECK dout1_14 Vdout1_14ck45 = 0.9 time = 230
.meas tran vdout1_14ck45 FIND v(dout1_14) AT=230.025n

* CHECK dout1_15 Vdout1_15ck45 = 0 time = 230
.meas tran vdout1_15ck45 FIND v(dout1_15) AT=230.025n

* CHECK dout1_16 Vdout1_16ck45 = 0 time = 230
.meas tran vdout1_16ck45 FIND v(dout1_16) AT=230.025n

* CHECK dout1_17 Vdout1_17ck45 = 0 time = 230
.meas tran vdout1_17ck45 FIND v(dout1_17) AT=230.025n

* CHECK dout1_18 Vdout1_18ck45 = 0 time = 230
.meas tran vdout1_18ck45 FIND v(dout1_18) AT=230.025n

* CHECK dout1_19 Vdout1_19ck45 = 0.9 time = 230
.meas tran vdout1_19ck45 FIND v(dout1_19) AT=230.025n

* CHECK dout1_20 Vdout1_20ck45 = 0 time = 230
.meas tran vdout1_20ck45 FIND v(dout1_20) AT=230.025n

* CHECK dout1_21 Vdout1_21ck45 = 0.9 time = 230
.meas tran vdout1_21ck45 FIND v(dout1_21) AT=230.025n

* CHECK dout1_22 Vdout1_22ck45 = 0.9 time = 230
.meas tran vdout1_22ck45 FIND v(dout1_22) AT=230.025n

* CHECK dout1_23 Vdout1_23ck45 = 0.9 time = 230
.meas tran vdout1_23ck45 FIND v(dout1_23) AT=230.025n

* CHECK dout1_24 Vdout1_24ck45 = 0.9 time = 230
.meas tran vdout1_24ck45 FIND v(dout1_24) AT=230.025n

* CHECK dout1_25 Vdout1_25ck45 = 0 time = 230
.meas tran vdout1_25ck45 FIND v(dout1_25) AT=230.025n

* CHECK dout1_26 Vdout1_26ck45 = 0 time = 230
.meas tran vdout1_26ck45 FIND v(dout1_26) AT=230.025n

* CHECK dout1_27 Vdout1_27ck45 = 0.9 time = 230
.meas tran vdout1_27ck45 FIND v(dout1_27) AT=230.025n

* CHECK dout1_28 Vdout1_28ck45 = 0.9 time = 230
.meas tran vdout1_28ck45 FIND v(dout1_28) AT=230.025n

* CHECK dout1_29 Vdout1_29ck45 = 0.9 time = 230
.meas tran vdout1_29ck45 FIND v(dout1_29) AT=230.025n

* CHECK dout1_30 Vdout1_30ck45 = 0.9 time = 230
.meas tran vdout1_30ck45 FIND v(dout1_30) AT=230.025n

* CHECK dout1_31 Vdout1_31ck45 = 0.9 time = 230
.meas tran vdout1_31ck45 FIND v(dout1_31) AT=230.025n

* CHECK dout1_32 Vdout1_32ck45 = 0.9 time = 230
.meas tran vdout1_32ck45 FIND v(dout1_32) AT=230.025n

* CHECK dout1_33 Vdout1_33ck45 = 0.9 time = 230
.meas tran vdout1_33ck45 FIND v(dout1_33) AT=230.025n

* CHECK dout1_34 Vdout1_34ck45 = 0.9 time = 230
.meas tran vdout1_34ck45 FIND v(dout1_34) AT=230.025n

* CHECK dout1_35 Vdout1_35ck45 = 0 time = 230
.meas tran vdout1_35ck45 FIND v(dout1_35) AT=230.025n

* CHECK dout1_36 Vdout1_36ck45 = 0 time = 230
.meas tran vdout1_36ck45 FIND v(dout1_36) AT=230.025n

* CHECK dout1_37 Vdout1_37ck45 = 0 time = 230
.meas tran vdout1_37ck45 FIND v(dout1_37) AT=230.025n

* CHECK dout1_38 Vdout1_38ck45 = 0.9 time = 230
.meas tran vdout1_38ck45 FIND v(dout1_38) AT=230.025n

* CHECK dout1_39 Vdout1_39ck45 = 0.9 time = 230
.meas tran vdout1_39ck45 FIND v(dout1_39) AT=230.025n

* CHECK dout1_40 Vdout1_40ck45 = 0 time = 230
.meas tran vdout1_40ck45 FIND v(dout1_40) AT=230.025n

* CHECK dout1_41 Vdout1_41ck45 = 0 time = 230
.meas tran vdout1_41ck45 FIND v(dout1_41) AT=230.025n

* CHECK dout1_42 Vdout1_42ck45 = 0.9 time = 230
.meas tran vdout1_42ck45 FIND v(dout1_42) AT=230.025n

* CHECK dout1_43 Vdout1_43ck45 = 0 time = 230
.meas tran vdout1_43ck45 FIND v(dout1_43) AT=230.025n

* CHECK dout1_44 Vdout1_44ck45 = 0.9 time = 230
.meas tran vdout1_44ck45 FIND v(dout1_44) AT=230.025n

* CHECK dout1_45 Vdout1_45ck45 = 0.9 time = 230
.meas tran vdout1_45ck45 FIND v(dout1_45) AT=230.025n

* CHECK dout1_46 Vdout1_46ck45 = 0 time = 230
.meas tran vdout1_46ck45 FIND v(dout1_46) AT=230.025n

* CHECK dout1_47 Vdout1_47ck45 = 0 time = 230
.meas tran vdout1_47ck45 FIND v(dout1_47) AT=230.025n

* CHECK dout1_48 Vdout1_48ck45 = 0 time = 230
.meas tran vdout1_48ck45 FIND v(dout1_48) AT=230.025n

* CHECK dout1_49 Vdout1_49ck45 = 0.9 time = 230
.meas tran vdout1_49ck45 FIND v(dout1_49) AT=230.025n

* CHECK dout1_50 Vdout1_50ck45 = 0.9 time = 230
.meas tran vdout1_50ck45 FIND v(dout1_50) AT=230.025n

* CHECK dout1_51 Vdout1_51ck45 = 0.9 time = 230
.meas tran vdout1_51ck45 FIND v(dout1_51) AT=230.025n

* CHECK dout1_52 Vdout1_52ck45 = 0 time = 230
.meas tran vdout1_52ck45 FIND v(dout1_52) AT=230.025n

* CHECK dout1_53 Vdout1_53ck45 = 0 time = 230
.meas tran vdout1_53ck45 FIND v(dout1_53) AT=230.025n

* CHECK dout1_54 Vdout1_54ck45 = 0 time = 230
.meas tran vdout1_54ck45 FIND v(dout1_54) AT=230.025n

* CHECK dout1_55 Vdout1_55ck45 = 0.9 time = 230
.meas tran vdout1_55ck45 FIND v(dout1_55) AT=230.025n

* CHECK dout1_56 Vdout1_56ck45 = 0.9 time = 230
.meas tran vdout1_56ck45 FIND v(dout1_56) AT=230.025n

* CHECK dout1_57 Vdout1_57ck45 = 0 time = 230
.meas tran vdout1_57ck45 FIND v(dout1_57) AT=230.025n

* CHECK dout1_58 Vdout1_58ck45 = 0.9 time = 230
.meas tran vdout1_58ck45 FIND v(dout1_58) AT=230.025n

* CHECK dout1_59 Vdout1_59ck45 = 0.9 time = 230
.meas tran vdout1_59ck45 FIND v(dout1_59) AT=230.025n

* CHECK dout1_60 Vdout1_60ck45 = 0.9 time = 230
.meas tran vdout1_60ck45 FIND v(dout1_60) AT=230.025n

* CHECK dout1_61 Vdout1_61ck45 = 0.9 time = 230
.meas tran vdout1_61ck45 FIND v(dout1_61) AT=230.025n

* CHECK dout1_62 Vdout1_62ck45 = 0.9 time = 230
.meas tran vdout1_62ck45 FIND v(dout1_62) AT=230.025n

* CHECK dout1_63 Vdout1_63ck45 = 0 time = 230
.meas tran vdout1_63ck45 FIND v(dout1_63) AT=230.025n

* CHECK dout1_64 Vdout1_64ck45 = 0.9 time = 230
.meas tran vdout1_64ck45 FIND v(dout1_64) AT=230.025n

* CHECK dout1_65 Vdout1_65ck45 = 0.9 time = 230
.meas tran vdout1_65ck45 FIND v(dout1_65) AT=230.025n

* CHECK dout1_66 Vdout1_66ck45 = 0 time = 230
.meas tran vdout1_66ck45 FIND v(dout1_66) AT=230.025n

* CHECK dout1_67 Vdout1_67ck45 = 0 time = 230
.meas tran vdout1_67ck45 FIND v(dout1_67) AT=230.025n

* CHECK dout1_68 Vdout1_68ck45 = 0.9 time = 230
.meas tran vdout1_68ck45 FIND v(dout1_68) AT=230.025n

* CHECK dout1_69 Vdout1_69ck45 = 0.9 time = 230
.meas tran vdout1_69ck45 FIND v(dout1_69) AT=230.025n

* CHECK dout1_70 Vdout1_70ck45 = 0 time = 230
.meas tran vdout1_70ck45 FIND v(dout1_70) AT=230.025n

* CHECK dout1_71 Vdout1_71ck45 = 0 time = 230
.meas tran vdout1_71ck45 FIND v(dout1_71) AT=230.025n

* CHECK dout1_0 Vdout1_0ck50 = 0 time = 255
.meas tran vdout1_0ck50 FIND v(dout1_0) AT=255.025n

* CHECK dout1_1 Vdout1_1ck50 = 0.9 time = 255
.meas tran vdout1_1ck50 FIND v(dout1_1) AT=255.025n

* CHECK dout1_2 Vdout1_2ck50 = 0.9 time = 255
.meas tran vdout1_2ck50 FIND v(dout1_2) AT=255.025n

* CHECK dout1_3 Vdout1_3ck50 = 0 time = 255
.meas tran vdout1_3ck50 FIND v(dout1_3) AT=255.025n

* CHECK dout1_4 Vdout1_4ck50 = 0 time = 255
.meas tran vdout1_4ck50 FIND v(dout1_4) AT=255.025n

* CHECK dout1_5 Vdout1_5ck50 = 0.9 time = 255
.meas tran vdout1_5ck50 FIND v(dout1_5) AT=255.025n

* CHECK dout1_6 Vdout1_6ck50 = 0.9 time = 255
.meas tran vdout1_6ck50 FIND v(dout1_6) AT=255.025n

* CHECK dout1_7 Vdout1_7ck50 = 0.9 time = 255
.meas tran vdout1_7ck50 FIND v(dout1_7) AT=255.025n

* CHECK dout1_8 Vdout1_8ck50 = 0.9 time = 255
.meas tran vdout1_8ck50 FIND v(dout1_8) AT=255.025n

* CHECK dout1_9 Vdout1_9ck50 = 0.9 time = 255
.meas tran vdout1_9ck50 FIND v(dout1_9) AT=255.025n

* CHECK dout1_10 Vdout1_10ck50 = 0 time = 255
.meas tran vdout1_10ck50 FIND v(dout1_10) AT=255.025n

* CHECK dout1_11 Vdout1_11ck50 = 0 time = 255
.meas tran vdout1_11ck50 FIND v(dout1_11) AT=255.025n

* CHECK dout1_12 Vdout1_12ck50 = 0 time = 255
.meas tran vdout1_12ck50 FIND v(dout1_12) AT=255.025n

* CHECK dout1_13 Vdout1_13ck50 = 0.9 time = 255
.meas tran vdout1_13ck50 FIND v(dout1_13) AT=255.025n

* CHECK dout1_14 Vdout1_14ck50 = 0.9 time = 255
.meas tran vdout1_14ck50 FIND v(dout1_14) AT=255.025n

* CHECK dout1_15 Vdout1_15ck50 = 0.9 time = 255
.meas tran vdout1_15ck50 FIND v(dout1_15) AT=255.025n

* CHECK dout1_16 Vdout1_16ck50 = 0 time = 255
.meas tran vdout1_16ck50 FIND v(dout1_16) AT=255.025n

* CHECK dout1_17 Vdout1_17ck50 = 0 time = 255
.meas tran vdout1_17ck50 FIND v(dout1_17) AT=255.025n

* CHECK dout1_18 Vdout1_18ck50 = 0 time = 255
.meas tran vdout1_18ck50 FIND v(dout1_18) AT=255.025n

* CHECK dout1_19 Vdout1_19ck50 = 0 time = 255
.meas tran vdout1_19ck50 FIND v(dout1_19) AT=255.025n

* CHECK dout1_20 Vdout1_20ck50 = 0 time = 255
.meas tran vdout1_20ck50 FIND v(dout1_20) AT=255.025n

* CHECK dout1_21 Vdout1_21ck50 = 0.9 time = 255
.meas tran vdout1_21ck50 FIND v(dout1_21) AT=255.025n

* CHECK dout1_22 Vdout1_22ck50 = 0.9 time = 255
.meas tran vdout1_22ck50 FIND v(dout1_22) AT=255.025n

* CHECK dout1_23 Vdout1_23ck50 = 0 time = 255
.meas tran vdout1_23ck50 FIND v(dout1_23) AT=255.025n

* CHECK dout1_24 Vdout1_24ck50 = 0.9 time = 255
.meas tran vdout1_24ck50 FIND v(dout1_24) AT=255.025n

* CHECK dout1_25 Vdout1_25ck50 = 0 time = 255
.meas tran vdout1_25ck50 FIND v(dout1_25) AT=255.025n

* CHECK dout1_26 Vdout1_26ck50 = 0 time = 255
.meas tran vdout1_26ck50 FIND v(dout1_26) AT=255.025n

* CHECK dout1_27 Vdout1_27ck50 = 0 time = 255
.meas tran vdout1_27ck50 FIND v(dout1_27) AT=255.025n

* CHECK dout1_28 Vdout1_28ck50 = 0 time = 255
.meas tran vdout1_28ck50 FIND v(dout1_28) AT=255.025n

* CHECK dout1_29 Vdout1_29ck50 = 0.9 time = 255
.meas tran vdout1_29ck50 FIND v(dout1_29) AT=255.025n

* CHECK dout1_30 Vdout1_30ck50 = 0 time = 255
.meas tran vdout1_30ck50 FIND v(dout1_30) AT=255.025n

* CHECK dout1_31 Vdout1_31ck50 = 0 time = 255
.meas tran vdout1_31ck50 FIND v(dout1_31) AT=255.025n

* CHECK dout1_32 Vdout1_32ck50 = 0 time = 255
.meas tran vdout1_32ck50 FIND v(dout1_32) AT=255.025n

* CHECK dout1_33 Vdout1_33ck50 = 0.9 time = 255
.meas tran vdout1_33ck50 FIND v(dout1_33) AT=255.025n

* CHECK dout1_34 Vdout1_34ck50 = 0 time = 255
.meas tran vdout1_34ck50 FIND v(dout1_34) AT=255.025n

* CHECK dout1_35 Vdout1_35ck50 = 0 time = 255
.meas tran vdout1_35ck50 FIND v(dout1_35) AT=255.025n

* CHECK dout1_36 Vdout1_36ck50 = 0 time = 255
.meas tran vdout1_36ck50 FIND v(dout1_36) AT=255.025n

* CHECK dout1_37 Vdout1_37ck50 = 0 time = 255
.meas tran vdout1_37ck50 FIND v(dout1_37) AT=255.025n

* CHECK dout1_38 Vdout1_38ck50 = 0.9 time = 255
.meas tran vdout1_38ck50 FIND v(dout1_38) AT=255.025n

* CHECK dout1_39 Vdout1_39ck50 = 0.9 time = 255
.meas tran vdout1_39ck50 FIND v(dout1_39) AT=255.025n

* CHECK dout1_40 Vdout1_40ck50 = 0.9 time = 255
.meas tran vdout1_40ck50 FIND v(dout1_40) AT=255.025n

* CHECK dout1_41 Vdout1_41ck50 = 0 time = 255
.meas tran vdout1_41ck50 FIND v(dout1_41) AT=255.025n

* CHECK dout1_42 Vdout1_42ck50 = 0 time = 255
.meas tran vdout1_42ck50 FIND v(dout1_42) AT=255.025n

* CHECK dout1_43 Vdout1_43ck50 = 0.9 time = 255
.meas tran vdout1_43ck50 FIND v(dout1_43) AT=255.025n

* CHECK dout1_44 Vdout1_44ck50 = 0.9 time = 255
.meas tran vdout1_44ck50 FIND v(dout1_44) AT=255.025n

* CHECK dout1_45 Vdout1_45ck50 = 0 time = 255
.meas tran vdout1_45ck50 FIND v(dout1_45) AT=255.025n

* CHECK dout1_46 Vdout1_46ck50 = 0.9 time = 255
.meas tran vdout1_46ck50 FIND v(dout1_46) AT=255.025n

* CHECK dout1_47 Vdout1_47ck50 = 0 time = 255
.meas tran vdout1_47ck50 FIND v(dout1_47) AT=255.025n

* CHECK dout1_48 Vdout1_48ck50 = 0 time = 255
.meas tran vdout1_48ck50 FIND v(dout1_48) AT=255.025n

* CHECK dout1_49 Vdout1_49ck50 = 0.9 time = 255
.meas tran vdout1_49ck50 FIND v(dout1_49) AT=255.025n

* CHECK dout1_50 Vdout1_50ck50 = 0 time = 255
.meas tran vdout1_50ck50 FIND v(dout1_50) AT=255.025n

* CHECK dout1_51 Vdout1_51ck50 = 0 time = 255
.meas tran vdout1_51ck50 FIND v(dout1_51) AT=255.025n

* CHECK dout1_52 Vdout1_52ck50 = 0 time = 255
.meas tran vdout1_52ck50 FIND v(dout1_52) AT=255.025n

* CHECK dout1_53 Vdout1_53ck50 = 0.9 time = 255
.meas tran vdout1_53ck50 FIND v(dout1_53) AT=255.025n

* CHECK dout1_54 Vdout1_54ck50 = 0 time = 255
.meas tran vdout1_54ck50 FIND v(dout1_54) AT=255.025n

* CHECK dout1_55 Vdout1_55ck50 = 0.9 time = 255
.meas tran vdout1_55ck50 FIND v(dout1_55) AT=255.025n

* CHECK dout1_56 Vdout1_56ck50 = 0 time = 255
.meas tran vdout1_56ck50 FIND v(dout1_56) AT=255.025n

* CHECK dout1_57 Vdout1_57ck50 = 0.9 time = 255
.meas tran vdout1_57ck50 FIND v(dout1_57) AT=255.025n

* CHECK dout1_58 Vdout1_58ck50 = 0 time = 255
.meas tran vdout1_58ck50 FIND v(dout1_58) AT=255.025n

* CHECK dout1_59 Vdout1_59ck50 = 0.9 time = 255
.meas tran vdout1_59ck50 FIND v(dout1_59) AT=255.025n

* CHECK dout1_60 Vdout1_60ck50 = 0 time = 255
.meas tran vdout1_60ck50 FIND v(dout1_60) AT=255.025n

* CHECK dout1_61 Vdout1_61ck50 = 0 time = 255
.meas tran vdout1_61ck50 FIND v(dout1_61) AT=255.025n

* CHECK dout1_62 Vdout1_62ck50 = 0 time = 255
.meas tran vdout1_62ck50 FIND v(dout1_62) AT=255.025n

* CHECK dout1_63 Vdout1_63ck50 = 0.9 time = 255
.meas tran vdout1_63ck50 FIND v(dout1_63) AT=255.025n

* CHECK dout1_64 Vdout1_64ck50 = 0.9 time = 255
.meas tran vdout1_64ck50 FIND v(dout1_64) AT=255.025n

* CHECK dout1_65 Vdout1_65ck50 = 0 time = 255
.meas tran vdout1_65ck50 FIND v(dout1_65) AT=255.025n

* CHECK dout1_66 Vdout1_66ck50 = 0.9 time = 255
.meas tran vdout1_66ck50 FIND v(dout1_66) AT=255.025n

* CHECK dout1_67 Vdout1_67ck50 = 0.9 time = 255
.meas tran vdout1_67ck50 FIND v(dout1_67) AT=255.025n

* CHECK dout1_68 Vdout1_68ck50 = 0 time = 255
.meas tran vdout1_68ck50 FIND v(dout1_68) AT=255.025n

* CHECK dout1_69 Vdout1_69ck50 = 0.9 time = 255
.meas tran vdout1_69ck50 FIND v(dout1_69) AT=255.025n

* CHECK dout1_70 Vdout1_70ck50 = 0 time = 255
.meas tran vdout1_70ck50 FIND v(dout1_70) AT=255.025n

* CHECK dout1_71 Vdout1_71ck50 = 0 time = 255
.meas tran vdout1_71ck50 FIND v(dout1_71) AT=255.025n

* CHECK dout1_0 Vdout1_0ck51 = 0.9 time = 260
.meas tran vdout1_0ck51 FIND v(dout1_0) AT=260.025n

* CHECK dout1_1 Vdout1_1ck51 = 0 time = 260
.meas tran vdout1_1ck51 FIND v(dout1_1) AT=260.025n

* CHECK dout1_2 Vdout1_2ck51 = 0 time = 260
.meas tran vdout1_2ck51 FIND v(dout1_2) AT=260.025n

* CHECK dout1_3 Vdout1_3ck51 = 0 time = 260
.meas tran vdout1_3ck51 FIND v(dout1_3) AT=260.025n

* CHECK dout1_4 Vdout1_4ck51 = 0 time = 260
.meas tran vdout1_4ck51 FIND v(dout1_4) AT=260.025n

* CHECK dout1_5 Vdout1_5ck51 = 0.9 time = 260
.meas tran vdout1_5ck51 FIND v(dout1_5) AT=260.025n

* CHECK dout1_6 Vdout1_6ck51 = 0.9 time = 260
.meas tran vdout1_6ck51 FIND v(dout1_6) AT=260.025n

* CHECK dout1_7 Vdout1_7ck51 = 0 time = 260
.meas tran vdout1_7ck51 FIND v(dout1_7) AT=260.025n

* CHECK dout1_8 Vdout1_8ck51 = 0.9 time = 260
.meas tran vdout1_8ck51 FIND v(dout1_8) AT=260.025n

* CHECK dout1_9 Vdout1_9ck51 = 0.9 time = 260
.meas tran vdout1_9ck51 FIND v(dout1_9) AT=260.025n

* CHECK dout1_10 Vdout1_10ck51 = 0 time = 260
.meas tran vdout1_10ck51 FIND v(dout1_10) AT=260.025n

* CHECK dout1_11 Vdout1_11ck51 = 0 time = 260
.meas tran vdout1_11ck51 FIND v(dout1_11) AT=260.025n

* CHECK dout1_12 Vdout1_12ck51 = 0.9 time = 260
.meas tran vdout1_12ck51 FIND v(dout1_12) AT=260.025n

* CHECK dout1_13 Vdout1_13ck51 = 0.9 time = 260
.meas tran vdout1_13ck51 FIND v(dout1_13) AT=260.025n

* CHECK dout1_14 Vdout1_14ck51 = 0 time = 260
.meas tran vdout1_14ck51 FIND v(dout1_14) AT=260.025n

* CHECK dout1_15 Vdout1_15ck51 = 0.9 time = 260
.meas tran vdout1_15ck51 FIND v(dout1_15) AT=260.025n

* CHECK dout1_16 Vdout1_16ck51 = 0 time = 260
.meas tran vdout1_16ck51 FIND v(dout1_16) AT=260.025n

* CHECK dout1_17 Vdout1_17ck51 = 0.9 time = 260
.meas tran vdout1_17ck51 FIND v(dout1_17) AT=260.025n

* CHECK dout1_18 Vdout1_18ck51 = 0 time = 260
.meas tran vdout1_18ck51 FIND v(dout1_18) AT=260.025n

* CHECK dout1_19 Vdout1_19ck51 = 0 time = 260
.meas tran vdout1_19ck51 FIND v(dout1_19) AT=260.025n

* CHECK dout1_20 Vdout1_20ck51 = 0.9 time = 260
.meas tran vdout1_20ck51 FIND v(dout1_20) AT=260.025n

* CHECK dout1_21 Vdout1_21ck51 = 0 time = 260
.meas tran vdout1_21ck51 FIND v(dout1_21) AT=260.025n

* CHECK dout1_22 Vdout1_22ck51 = 0.9 time = 260
.meas tran vdout1_22ck51 FIND v(dout1_22) AT=260.025n

* CHECK dout1_23 Vdout1_23ck51 = 0 time = 260
.meas tran vdout1_23ck51 FIND v(dout1_23) AT=260.025n

* CHECK dout1_24 Vdout1_24ck51 = 0.9 time = 260
.meas tran vdout1_24ck51 FIND v(dout1_24) AT=260.025n

* CHECK dout1_25 Vdout1_25ck51 = 0.9 time = 260
.meas tran vdout1_25ck51 FIND v(dout1_25) AT=260.025n

* CHECK dout1_26 Vdout1_26ck51 = 0.9 time = 260
.meas tran vdout1_26ck51 FIND v(dout1_26) AT=260.025n

* CHECK dout1_27 Vdout1_27ck51 = 0.9 time = 260
.meas tran vdout1_27ck51 FIND v(dout1_27) AT=260.025n

* CHECK dout1_28 Vdout1_28ck51 = 0.9 time = 260
.meas tran vdout1_28ck51 FIND v(dout1_28) AT=260.025n

* CHECK dout1_29 Vdout1_29ck51 = 0.9 time = 260
.meas tran vdout1_29ck51 FIND v(dout1_29) AT=260.025n

* CHECK dout1_30 Vdout1_30ck51 = 0.9 time = 260
.meas tran vdout1_30ck51 FIND v(dout1_30) AT=260.025n

* CHECK dout1_31 Vdout1_31ck51 = 0.9 time = 260
.meas tran vdout1_31ck51 FIND v(dout1_31) AT=260.025n

* CHECK dout1_32 Vdout1_32ck51 = 0 time = 260
.meas tran vdout1_32ck51 FIND v(dout1_32) AT=260.025n

* CHECK dout1_33 Vdout1_33ck51 = 0 time = 260
.meas tran vdout1_33ck51 FIND v(dout1_33) AT=260.025n

* CHECK dout1_34 Vdout1_34ck51 = 0 time = 260
.meas tran vdout1_34ck51 FIND v(dout1_34) AT=260.025n

* CHECK dout1_35 Vdout1_35ck51 = 0 time = 260
.meas tran vdout1_35ck51 FIND v(dout1_35) AT=260.025n

* CHECK dout1_36 Vdout1_36ck51 = 0 time = 260
.meas tran vdout1_36ck51 FIND v(dout1_36) AT=260.025n

* CHECK dout1_37 Vdout1_37ck51 = 0 time = 260
.meas tran vdout1_37ck51 FIND v(dout1_37) AT=260.025n

* CHECK dout1_38 Vdout1_38ck51 = 0 time = 260
.meas tran vdout1_38ck51 FIND v(dout1_38) AT=260.025n

* CHECK dout1_39 Vdout1_39ck51 = 0 time = 260
.meas tran vdout1_39ck51 FIND v(dout1_39) AT=260.025n

* CHECK dout1_40 Vdout1_40ck51 = 0.9 time = 260
.meas tran vdout1_40ck51 FIND v(dout1_40) AT=260.025n

* CHECK dout1_41 Vdout1_41ck51 = 0.9 time = 260
.meas tran vdout1_41ck51 FIND v(dout1_41) AT=260.025n

* CHECK dout1_42 Vdout1_42ck51 = 0.9 time = 260
.meas tran vdout1_42ck51 FIND v(dout1_42) AT=260.025n

* CHECK dout1_43 Vdout1_43ck51 = 0 time = 260
.meas tran vdout1_43ck51 FIND v(dout1_43) AT=260.025n

* CHECK dout1_44 Vdout1_44ck51 = 0 time = 260
.meas tran vdout1_44ck51 FIND v(dout1_44) AT=260.025n

* CHECK dout1_45 Vdout1_45ck51 = 0.9 time = 260
.meas tran vdout1_45ck51 FIND v(dout1_45) AT=260.025n

* CHECK dout1_46 Vdout1_46ck51 = 0.9 time = 260
.meas tran vdout1_46ck51 FIND v(dout1_46) AT=260.025n

* CHECK dout1_47 Vdout1_47ck51 = 0.9 time = 260
.meas tran vdout1_47ck51 FIND v(dout1_47) AT=260.025n

* CHECK dout1_48 Vdout1_48ck51 = 0 time = 260
.meas tran vdout1_48ck51 FIND v(dout1_48) AT=260.025n

* CHECK dout1_49 Vdout1_49ck51 = 0 time = 260
.meas tran vdout1_49ck51 FIND v(dout1_49) AT=260.025n

* CHECK dout1_50 Vdout1_50ck51 = 0 time = 260
.meas tran vdout1_50ck51 FIND v(dout1_50) AT=260.025n

* CHECK dout1_51 Vdout1_51ck51 = 0 time = 260
.meas tran vdout1_51ck51 FIND v(dout1_51) AT=260.025n

* CHECK dout1_52 Vdout1_52ck51 = 0 time = 260
.meas tran vdout1_52ck51 FIND v(dout1_52) AT=260.025n

* CHECK dout1_53 Vdout1_53ck51 = 0 time = 260
.meas tran vdout1_53ck51 FIND v(dout1_53) AT=260.025n

* CHECK dout1_54 Vdout1_54ck51 = 0.9 time = 260
.meas tran vdout1_54ck51 FIND v(dout1_54) AT=260.025n

* CHECK dout1_55 Vdout1_55ck51 = 0.9 time = 260
.meas tran vdout1_55ck51 FIND v(dout1_55) AT=260.025n

* CHECK dout1_56 Vdout1_56ck51 = 0.9 time = 260
.meas tran vdout1_56ck51 FIND v(dout1_56) AT=260.025n

* CHECK dout1_57 Vdout1_57ck51 = 0 time = 260
.meas tran vdout1_57ck51 FIND v(dout1_57) AT=260.025n

* CHECK dout1_58 Vdout1_58ck51 = 0.9 time = 260
.meas tran vdout1_58ck51 FIND v(dout1_58) AT=260.025n

* CHECK dout1_59 Vdout1_59ck51 = 0.9 time = 260
.meas tran vdout1_59ck51 FIND v(dout1_59) AT=260.025n

* CHECK dout1_60 Vdout1_60ck51 = 0.9 time = 260
.meas tran vdout1_60ck51 FIND v(dout1_60) AT=260.025n

* CHECK dout1_61 Vdout1_61ck51 = 0 time = 260
.meas tran vdout1_61ck51 FIND v(dout1_61) AT=260.025n

* CHECK dout1_62 Vdout1_62ck51 = 0 time = 260
.meas tran vdout1_62ck51 FIND v(dout1_62) AT=260.025n

* CHECK dout1_63 Vdout1_63ck51 = 0 time = 260
.meas tran vdout1_63ck51 FIND v(dout1_63) AT=260.025n

* CHECK dout1_64 Vdout1_64ck51 = 0 time = 260
.meas tran vdout1_64ck51 FIND v(dout1_64) AT=260.025n

* CHECK dout1_65 Vdout1_65ck51 = 0.9 time = 260
.meas tran vdout1_65ck51 FIND v(dout1_65) AT=260.025n

* CHECK dout1_66 Vdout1_66ck51 = 0 time = 260
.meas tran vdout1_66ck51 FIND v(dout1_66) AT=260.025n

* CHECK dout1_67 Vdout1_67ck51 = 0.9 time = 260
.meas tran vdout1_67ck51 FIND v(dout1_67) AT=260.025n

* CHECK dout1_68 Vdout1_68ck51 = 0 time = 260
.meas tran vdout1_68ck51 FIND v(dout1_68) AT=260.025n

* CHECK dout1_69 Vdout1_69ck51 = 0.9 time = 260
.meas tran vdout1_69ck51 FIND v(dout1_69) AT=260.025n

* CHECK dout1_70 Vdout1_70ck51 = 0 time = 260
.meas tran vdout1_70ck51 FIND v(dout1_70) AT=260.025n

* CHECK dout1_71 Vdout1_71ck51 = 0 time = 260
.meas tran vdout1_71ck51 FIND v(dout1_71) AT=260.025n

* CHECK dout1_0 Vdout1_0ck57 = 0 time = 290
.meas tran vdout1_0ck57 FIND v(dout1_0) AT=290.025n

* CHECK dout1_1 Vdout1_1ck57 = 0 time = 290
.meas tran vdout1_1ck57 FIND v(dout1_1) AT=290.025n

* CHECK dout1_2 Vdout1_2ck57 = 0 time = 290
.meas tran vdout1_2ck57 FIND v(dout1_2) AT=290.025n

* CHECK dout1_3 Vdout1_3ck57 = 0 time = 290
.meas tran vdout1_3ck57 FIND v(dout1_3) AT=290.025n

* CHECK dout1_4 Vdout1_4ck57 = 0.9 time = 290
.meas tran vdout1_4ck57 FIND v(dout1_4) AT=290.025n

* CHECK dout1_5 Vdout1_5ck57 = 0.9 time = 290
.meas tran vdout1_5ck57 FIND v(dout1_5) AT=290.025n

* CHECK dout1_6 Vdout1_6ck57 = 0.9 time = 290
.meas tran vdout1_6ck57 FIND v(dout1_6) AT=290.025n

* CHECK dout1_7 Vdout1_7ck57 = 0 time = 290
.meas tran vdout1_7ck57 FIND v(dout1_7) AT=290.025n

* CHECK dout1_8 Vdout1_8ck57 = 0.9 time = 290
.meas tran vdout1_8ck57 FIND v(dout1_8) AT=290.025n

* CHECK dout1_9 Vdout1_9ck57 = 0 time = 290
.meas tran vdout1_9ck57 FIND v(dout1_9) AT=290.025n

* CHECK dout1_10 Vdout1_10ck57 = 0 time = 290
.meas tran vdout1_10ck57 FIND v(dout1_10) AT=290.025n

* CHECK dout1_11 Vdout1_11ck57 = 0 time = 290
.meas tran vdout1_11ck57 FIND v(dout1_11) AT=290.025n

* CHECK dout1_12 Vdout1_12ck57 = 0 time = 290
.meas tran vdout1_12ck57 FIND v(dout1_12) AT=290.025n

* CHECK dout1_13 Vdout1_13ck57 = 0 time = 290
.meas tran vdout1_13ck57 FIND v(dout1_13) AT=290.025n

* CHECK dout1_14 Vdout1_14ck57 = 0 time = 290
.meas tran vdout1_14ck57 FIND v(dout1_14) AT=290.025n

* CHECK dout1_15 Vdout1_15ck57 = 0.9 time = 290
.meas tran vdout1_15ck57 FIND v(dout1_15) AT=290.025n

* CHECK dout1_16 Vdout1_16ck57 = 0 time = 290
.meas tran vdout1_16ck57 FIND v(dout1_16) AT=290.025n

* CHECK dout1_17 Vdout1_17ck57 = 0 time = 290
.meas tran vdout1_17ck57 FIND v(dout1_17) AT=290.025n

* CHECK dout1_18 Vdout1_18ck57 = 0 time = 290
.meas tran vdout1_18ck57 FIND v(dout1_18) AT=290.025n

* CHECK dout1_19 Vdout1_19ck57 = 0.9 time = 290
.meas tran vdout1_19ck57 FIND v(dout1_19) AT=290.025n

* CHECK dout1_20 Vdout1_20ck57 = 0 time = 290
.meas tran vdout1_20ck57 FIND v(dout1_20) AT=290.025n

* CHECK dout1_21 Vdout1_21ck57 = 0.9 time = 290
.meas tran vdout1_21ck57 FIND v(dout1_21) AT=290.025n

* CHECK dout1_22 Vdout1_22ck57 = 0.9 time = 290
.meas tran vdout1_22ck57 FIND v(dout1_22) AT=290.025n

* CHECK dout1_23 Vdout1_23ck57 = 0 time = 290
.meas tran vdout1_23ck57 FIND v(dout1_23) AT=290.025n

* CHECK dout1_24 Vdout1_24ck57 = 0 time = 290
.meas tran vdout1_24ck57 FIND v(dout1_24) AT=290.025n

* CHECK dout1_25 Vdout1_25ck57 = 0 time = 290
.meas tran vdout1_25ck57 FIND v(dout1_25) AT=290.025n

* CHECK dout1_26 Vdout1_26ck57 = 0.9 time = 290
.meas tran vdout1_26ck57 FIND v(dout1_26) AT=290.025n

* CHECK dout1_27 Vdout1_27ck57 = 0 time = 290
.meas tran vdout1_27ck57 FIND v(dout1_27) AT=290.025n

* CHECK dout1_28 Vdout1_28ck57 = 0.9 time = 290
.meas tran vdout1_28ck57 FIND v(dout1_28) AT=290.025n

* CHECK dout1_29 Vdout1_29ck57 = 0 time = 290
.meas tran vdout1_29ck57 FIND v(dout1_29) AT=290.025n

* CHECK dout1_30 Vdout1_30ck57 = 0 time = 290
.meas tran vdout1_30ck57 FIND v(dout1_30) AT=290.025n

* CHECK dout1_31 Vdout1_31ck57 = 0.9 time = 290
.meas tran vdout1_31ck57 FIND v(dout1_31) AT=290.025n

* CHECK dout1_32 Vdout1_32ck57 = 0 time = 290
.meas tran vdout1_32ck57 FIND v(dout1_32) AT=290.025n

* CHECK dout1_33 Vdout1_33ck57 = 0 time = 290
.meas tran vdout1_33ck57 FIND v(dout1_33) AT=290.025n

* CHECK dout1_34 Vdout1_34ck57 = 0.9 time = 290
.meas tran vdout1_34ck57 FIND v(dout1_34) AT=290.025n

* CHECK dout1_35 Vdout1_35ck57 = 0.9 time = 290
.meas tran vdout1_35ck57 FIND v(dout1_35) AT=290.025n

* CHECK dout1_36 Vdout1_36ck57 = 0 time = 290
.meas tran vdout1_36ck57 FIND v(dout1_36) AT=290.025n

* CHECK dout1_37 Vdout1_37ck57 = 0 time = 290
.meas tran vdout1_37ck57 FIND v(dout1_37) AT=290.025n

* CHECK dout1_38 Vdout1_38ck57 = 0.9 time = 290
.meas tran vdout1_38ck57 FIND v(dout1_38) AT=290.025n

* CHECK dout1_39 Vdout1_39ck57 = 0.9 time = 290
.meas tran vdout1_39ck57 FIND v(dout1_39) AT=290.025n

* CHECK dout1_40 Vdout1_40ck57 = 0.9 time = 290
.meas tran vdout1_40ck57 FIND v(dout1_40) AT=290.025n

* CHECK dout1_41 Vdout1_41ck57 = 0.9 time = 290
.meas tran vdout1_41ck57 FIND v(dout1_41) AT=290.025n

* CHECK dout1_42 Vdout1_42ck57 = 0.9 time = 290
.meas tran vdout1_42ck57 FIND v(dout1_42) AT=290.025n

* CHECK dout1_43 Vdout1_43ck57 = 0.9 time = 290
.meas tran vdout1_43ck57 FIND v(dout1_43) AT=290.025n

* CHECK dout1_44 Vdout1_44ck57 = 0 time = 290
.meas tran vdout1_44ck57 FIND v(dout1_44) AT=290.025n

* CHECK dout1_45 Vdout1_45ck57 = 0 time = 290
.meas tran vdout1_45ck57 FIND v(dout1_45) AT=290.025n

* CHECK dout1_46 Vdout1_46ck57 = 0.9 time = 290
.meas tran vdout1_46ck57 FIND v(dout1_46) AT=290.025n

* CHECK dout1_47 Vdout1_47ck57 = 0 time = 290
.meas tran vdout1_47ck57 FIND v(dout1_47) AT=290.025n

* CHECK dout1_48 Vdout1_48ck57 = 0 time = 290
.meas tran vdout1_48ck57 FIND v(dout1_48) AT=290.025n

* CHECK dout1_49 Vdout1_49ck57 = 0 time = 290
.meas tran vdout1_49ck57 FIND v(dout1_49) AT=290.025n

* CHECK dout1_50 Vdout1_50ck57 = 0 time = 290
.meas tran vdout1_50ck57 FIND v(dout1_50) AT=290.025n

* CHECK dout1_51 Vdout1_51ck57 = 0.9 time = 290
.meas tran vdout1_51ck57 FIND v(dout1_51) AT=290.025n

* CHECK dout1_52 Vdout1_52ck57 = 0 time = 290
.meas tran vdout1_52ck57 FIND v(dout1_52) AT=290.025n

* CHECK dout1_53 Vdout1_53ck57 = 0.9 time = 290
.meas tran vdout1_53ck57 FIND v(dout1_53) AT=290.025n

* CHECK dout1_54 Vdout1_54ck57 = 0.9 time = 290
.meas tran vdout1_54ck57 FIND v(dout1_54) AT=290.025n

* CHECK dout1_55 Vdout1_55ck57 = 0.9 time = 290
.meas tran vdout1_55ck57 FIND v(dout1_55) AT=290.025n

* CHECK dout1_56 Vdout1_56ck57 = 0.9 time = 290
.meas tran vdout1_56ck57 FIND v(dout1_56) AT=290.025n

* CHECK dout1_57 Vdout1_57ck57 = 0 time = 290
.meas tran vdout1_57ck57 FIND v(dout1_57) AT=290.025n

* CHECK dout1_58 Vdout1_58ck57 = 0 time = 290
.meas tran vdout1_58ck57 FIND v(dout1_58) AT=290.025n

* CHECK dout1_59 Vdout1_59ck57 = 0.9 time = 290
.meas tran vdout1_59ck57 FIND v(dout1_59) AT=290.025n

* CHECK dout1_60 Vdout1_60ck57 = 0.9 time = 290
.meas tran vdout1_60ck57 FIND v(dout1_60) AT=290.025n

* CHECK dout1_61 Vdout1_61ck57 = 0 time = 290
.meas tran vdout1_61ck57 FIND v(dout1_61) AT=290.025n

* CHECK dout1_62 Vdout1_62ck57 = 0.9 time = 290
.meas tran vdout1_62ck57 FIND v(dout1_62) AT=290.025n

* CHECK dout1_63 Vdout1_63ck57 = 0.9 time = 290
.meas tran vdout1_63ck57 FIND v(dout1_63) AT=290.025n

* CHECK dout1_64 Vdout1_64ck57 = 0.9 time = 290
.meas tran vdout1_64ck57 FIND v(dout1_64) AT=290.025n

* CHECK dout1_65 Vdout1_65ck57 = 0.9 time = 290
.meas tran vdout1_65ck57 FIND v(dout1_65) AT=290.025n

* CHECK dout1_66 Vdout1_66ck57 = 0.9 time = 290
.meas tran vdout1_66ck57 FIND v(dout1_66) AT=290.025n

* CHECK dout1_67 Vdout1_67ck57 = 0.9 time = 290
.meas tran vdout1_67ck57 FIND v(dout1_67) AT=290.025n

* CHECK dout1_68 Vdout1_68ck57 = 0 time = 290
.meas tran vdout1_68ck57 FIND v(dout1_68) AT=290.025n

* CHECK dout1_69 Vdout1_69ck57 = 0 time = 290
.meas tran vdout1_69ck57 FIND v(dout1_69) AT=290.025n

* CHECK dout1_70 Vdout1_70ck57 = 0.9 time = 290
.meas tran vdout1_70ck57 FIND v(dout1_70) AT=290.025n

* CHECK dout1_71 Vdout1_71ck57 = 0 time = 290
.meas tran vdout1_71ck57 FIND v(dout1_71) AT=290.025n

* CHECK dout1_0 Vdout1_0ck58 = 0.9 time = 295
.meas tran vdout1_0ck58 FIND v(dout1_0) AT=295.025n

* CHECK dout1_1 Vdout1_1ck58 = 0 time = 295
.meas tran vdout1_1ck58 FIND v(dout1_1) AT=295.025n

* CHECK dout1_2 Vdout1_2ck58 = 0.9 time = 295
.meas tran vdout1_2ck58 FIND v(dout1_2) AT=295.025n

* CHECK dout1_3 Vdout1_3ck58 = 0.9 time = 295
.meas tran vdout1_3ck58 FIND v(dout1_3) AT=295.025n

* CHECK dout1_4 Vdout1_4ck58 = 0.9 time = 295
.meas tran vdout1_4ck58 FIND v(dout1_4) AT=295.025n

* CHECK dout1_5 Vdout1_5ck58 = 0.9 time = 295
.meas tran vdout1_5ck58 FIND v(dout1_5) AT=295.025n

* CHECK dout1_6 Vdout1_6ck58 = 0 time = 295
.meas tran vdout1_6ck58 FIND v(dout1_6) AT=295.025n

* CHECK dout1_7 Vdout1_7ck58 = 0 time = 295
.meas tran vdout1_7ck58 FIND v(dout1_7) AT=295.025n

* CHECK dout1_8 Vdout1_8ck58 = 0.9 time = 295
.meas tran vdout1_8ck58 FIND v(dout1_8) AT=295.025n

* CHECK dout1_9 Vdout1_9ck58 = 0 time = 295
.meas tran vdout1_9ck58 FIND v(dout1_9) AT=295.025n

* CHECK dout1_10 Vdout1_10ck58 = 0.9 time = 295
.meas tran vdout1_10ck58 FIND v(dout1_10) AT=295.025n

* CHECK dout1_11 Vdout1_11ck58 = 0.9 time = 295
.meas tran vdout1_11ck58 FIND v(dout1_11) AT=295.025n

* CHECK dout1_12 Vdout1_12ck58 = 0 time = 295
.meas tran vdout1_12ck58 FIND v(dout1_12) AT=295.025n

* CHECK dout1_13 Vdout1_13ck58 = 0.9 time = 295
.meas tran vdout1_13ck58 FIND v(dout1_13) AT=295.025n

* CHECK dout1_14 Vdout1_14ck58 = 0.9 time = 295
.meas tran vdout1_14ck58 FIND v(dout1_14) AT=295.025n

* CHECK dout1_15 Vdout1_15ck58 = 0 time = 295
.meas tran vdout1_15ck58 FIND v(dout1_15) AT=295.025n

* CHECK dout1_16 Vdout1_16ck58 = 0 time = 295
.meas tran vdout1_16ck58 FIND v(dout1_16) AT=295.025n

* CHECK dout1_17 Vdout1_17ck58 = 0 time = 295
.meas tran vdout1_17ck58 FIND v(dout1_17) AT=295.025n

* CHECK dout1_18 Vdout1_18ck58 = 0.9 time = 295
.meas tran vdout1_18ck58 FIND v(dout1_18) AT=295.025n

* CHECK dout1_19 Vdout1_19ck58 = 0.9 time = 295
.meas tran vdout1_19ck58 FIND v(dout1_19) AT=295.025n

* CHECK dout1_20 Vdout1_20ck58 = 0 time = 295
.meas tran vdout1_20ck58 FIND v(dout1_20) AT=295.025n

* CHECK dout1_21 Vdout1_21ck58 = 0.9 time = 295
.meas tran vdout1_21ck58 FIND v(dout1_21) AT=295.025n

* CHECK dout1_22 Vdout1_22ck58 = 0 time = 295
.meas tran vdout1_22ck58 FIND v(dout1_22) AT=295.025n

* CHECK dout1_23 Vdout1_23ck58 = 0.9 time = 295
.meas tran vdout1_23ck58 FIND v(dout1_23) AT=295.025n

* CHECK dout1_24 Vdout1_24ck58 = 0.9 time = 295
.meas tran vdout1_24ck58 FIND v(dout1_24) AT=295.025n

* CHECK dout1_25 Vdout1_25ck58 = 0 time = 295
.meas tran vdout1_25ck58 FIND v(dout1_25) AT=295.025n

* CHECK dout1_26 Vdout1_26ck58 = 0.9 time = 295
.meas tran vdout1_26ck58 FIND v(dout1_26) AT=295.025n

* CHECK dout1_27 Vdout1_27ck58 = 0.9 time = 295
.meas tran vdout1_27ck58 FIND v(dout1_27) AT=295.025n

* CHECK dout1_28 Vdout1_28ck58 = 0 time = 295
.meas tran vdout1_28ck58 FIND v(dout1_28) AT=295.025n

* CHECK dout1_29 Vdout1_29ck58 = 0 time = 295
.meas tran vdout1_29ck58 FIND v(dout1_29) AT=295.025n

* CHECK dout1_30 Vdout1_30ck58 = 0.9 time = 295
.meas tran vdout1_30ck58 FIND v(dout1_30) AT=295.025n

* CHECK dout1_31 Vdout1_31ck58 = 0 time = 295
.meas tran vdout1_31ck58 FIND v(dout1_31) AT=295.025n

* CHECK dout1_32 Vdout1_32ck58 = 0 time = 295
.meas tran vdout1_32ck58 FIND v(dout1_32) AT=295.025n

* CHECK dout1_33 Vdout1_33ck58 = 0.9 time = 295
.meas tran vdout1_33ck58 FIND v(dout1_33) AT=295.025n

* CHECK dout1_34 Vdout1_34ck58 = 0.9 time = 295
.meas tran vdout1_34ck58 FIND v(dout1_34) AT=295.025n

* CHECK dout1_35 Vdout1_35ck58 = 0.9 time = 295
.meas tran vdout1_35ck58 FIND v(dout1_35) AT=295.025n

* CHECK dout1_36 Vdout1_36ck58 = 0 time = 295
.meas tran vdout1_36ck58 FIND v(dout1_36) AT=295.025n

* CHECK dout1_37 Vdout1_37ck58 = 0 time = 295
.meas tran vdout1_37ck58 FIND v(dout1_37) AT=295.025n

* CHECK dout1_38 Vdout1_38ck58 = 0 time = 295
.meas tran vdout1_38ck58 FIND v(dout1_38) AT=295.025n

* CHECK dout1_39 Vdout1_39ck58 = 0 time = 295
.meas tran vdout1_39ck58 FIND v(dout1_39) AT=295.025n

* CHECK dout1_40 Vdout1_40ck58 = 0.9 time = 295
.meas tran vdout1_40ck58 FIND v(dout1_40) AT=295.025n

* CHECK dout1_41 Vdout1_41ck58 = 0 time = 295
.meas tran vdout1_41ck58 FIND v(dout1_41) AT=295.025n

* CHECK dout1_42 Vdout1_42ck58 = 0.9 time = 295
.meas tran vdout1_42ck58 FIND v(dout1_42) AT=295.025n

* CHECK dout1_43 Vdout1_43ck58 = 0.9 time = 295
.meas tran vdout1_43ck58 FIND v(dout1_43) AT=295.025n

* CHECK dout1_44 Vdout1_44ck58 = 0 time = 295
.meas tran vdout1_44ck58 FIND v(dout1_44) AT=295.025n

* CHECK dout1_45 Vdout1_45ck58 = 0.9 time = 295
.meas tran vdout1_45ck58 FIND v(dout1_45) AT=295.025n

* CHECK dout1_46 Vdout1_46ck58 = 0.9 time = 295
.meas tran vdout1_46ck58 FIND v(dout1_46) AT=295.025n

* CHECK dout1_47 Vdout1_47ck58 = 0 time = 295
.meas tran vdout1_47ck58 FIND v(dout1_47) AT=295.025n

* CHECK dout1_48 Vdout1_48ck58 = 0.9 time = 295
.meas tran vdout1_48ck58 FIND v(dout1_48) AT=295.025n

* CHECK dout1_49 Vdout1_49ck58 = 0.9 time = 295
.meas tran vdout1_49ck58 FIND v(dout1_49) AT=295.025n

* CHECK dout1_50 Vdout1_50ck58 = 0 time = 295
.meas tran vdout1_50ck58 FIND v(dout1_50) AT=295.025n

* CHECK dout1_51 Vdout1_51ck58 = 0.9 time = 295
.meas tran vdout1_51ck58 FIND v(dout1_51) AT=295.025n

* CHECK dout1_52 Vdout1_52ck58 = 0 time = 295
.meas tran vdout1_52ck58 FIND v(dout1_52) AT=295.025n

* CHECK dout1_53 Vdout1_53ck58 = 0 time = 295
.meas tran vdout1_53ck58 FIND v(dout1_53) AT=295.025n

* CHECK dout1_54 Vdout1_54ck58 = 0.9 time = 295
.meas tran vdout1_54ck58 FIND v(dout1_54) AT=295.025n

* CHECK dout1_55 Vdout1_55ck58 = 0.9 time = 295
.meas tran vdout1_55ck58 FIND v(dout1_55) AT=295.025n

* CHECK dout1_56 Vdout1_56ck58 = 0 time = 295
.meas tran vdout1_56ck58 FIND v(dout1_56) AT=295.025n

* CHECK dout1_57 Vdout1_57ck58 = 0 time = 295
.meas tran vdout1_57ck58 FIND v(dout1_57) AT=295.025n

* CHECK dout1_58 Vdout1_58ck58 = 0 time = 295
.meas tran vdout1_58ck58 FIND v(dout1_58) AT=295.025n

* CHECK dout1_59 Vdout1_59ck58 = 0 time = 295
.meas tran vdout1_59ck58 FIND v(dout1_59) AT=295.025n

* CHECK dout1_60 Vdout1_60ck58 = 0.9 time = 295
.meas tran vdout1_60ck58 FIND v(dout1_60) AT=295.025n

* CHECK dout1_61 Vdout1_61ck58 = 0 time = 295
.meas tran vdout1_61ck58 FIND v(dout1_61) AT=295.025n

* CHECK dout1_62 Vdout1_62ck58 = 0 time = 295
.meas tran vdout1_62ck58 FIND v(dout1_62) AT=295.025n

* CHECK dout1_63 Vdout1_63ck58 = 0 time = 295
.meas tran vdout1_63ck58 FIND v(dout1_63) AT=295.025n

* CHECK dout1_64 Vdout1_64ck58 = 0.9 time = 295
.meas tran vdout1_64ck58 FIND v(dout1_64) AT=295.025n

* CHECK dout1_65 Vdout1_65ck58 = 0 time = 295
.meas tran vdout1_65ck58 FIND v(dout1_65) AT=295.025n

* CHECK dout1_66 Vdout1_66ck58 = 0 time = 295
.meas tran vdout1_66ck58 FIND v(dout1_66) AT=295.025n

* CHECK dout1_67 Vdout1_67ck58 = 0.9 time = 295
.meas tran vdout1_67ck58 FIND v(dout1_67) AT=295.025n

* CHECK dout1_68 Vdout1_68ck58 = 0 time = 295
.meas tran vdout1_68ck58 FIND v(dout1_68) AT=295.025n

* CHECK dout1_69 Vdout1_69ck58 = 0.9 time = 295
.meas tran vdout1_69ck58 FIND v(dout1_69) AT=295.025n

* CHECK dout1_70 Vdout1_70ck58 = 0.9 time = 295
.meas tran vdout1_70ck58 FIND v(dout1_70) AT=295.025n

* CHECK dout1_71 Vdout1_71ck58 = 0.9 time = 295
.meas tran vdout1_71ck58 FIND v(dout1_71) AT=295.025n

* CHECK dout1_0 Vdout1_0ck59 = 0 time = 300
.meas tran vdout1_0ck59 FIND v(dout1_0) AT=300.025n

* CHECK dout1_1 Vdout1_1ck59 = 0 time = 300
.meas tran vdout1_1ck59 FIND v(dout1_1) AT=300.025n

* CHECK dout1_2 Vdout1_2ck59 = 0 time = 300
.meas tran vdout1_2ck59 FIND v(dout1_2) AT=300.025n

* CHECK dout1_3 Vdout1_3ck59 = 0 time = 300
.meas tran vdout1_3ck59 FIND v(dout1_3) AT=300.025n

* CHECK dout1_4 Vdout1_4ck59 = 0.9 time = 300
.meas tran vdout1_4ck59 FIND v(dout1_4) AT=300.025n

* CHECK dout1_5 Vdout1_5ck59 = 0.9 time = 300
.meas tran vdout1_5ck59 FIND v(dout1_5) AT=300.025n

* CHECK dout1_6 Vdout1_6ck59 = 0.9 time = 300
.meas tran vdout1_6ck59 FIND v(dout1_6) AT=300.025n

* CHECK dout1_7 Vdout1_7ck59 = 0 time = 300
.meas tran vdout1_7ck59 FIND v(dout1_7) AT=300.025n

* CHECK dout1_8 Vdout1_8ck59 = 0.9 time = 300
.meas tran vdout1_8ck59 FIND v(dout1_8) AT=300.025n

* CHECK dout1_9 Vdout1_9ck59 = 0 time = 300
.meas tran vdout1_9ck59 FIND v(dout1_9) AT=300.025n

* CHECK dout1_10 Vdout1_10ck59 = 0 time = 300
.meas tran vdout1_10ck59 FIND v(dout1_10) AT=300.025n

* CHECK dout1_11 Vdout1_11ck59 = 0 time = 300
.meas tran vdout1_11ck59 FIND v(dout1_11) AT=300.025n

* CHECK dout1_12 Vdout1_12ck59 = 0 time = 300
.meas tran vdout1_12ck59 FIND v(dout1_12) AT=300.025n

* CHECK dout1_13 Vdout1_13ck59 = 0 time = 300
.meas tran vdout1_13ck59 FIND v(dout1_13) AT=300.025n

* CHECK dout1_14 Vdout1_14ck59 = 0 time = 300
.meas tran vdout1_14ck59 FIND v(dout1_14) AT=300.025n

* CHECK dout1_15 Vdout1_15ck59 = 0.9 time = 300
.meas tran vdout1_15ck59 FIND v(dout1_15) AT=300.025n

* CHECK dout1_16 Vdout1_16ck59 = 0 time = 300
.meas tran vdout1_16ck59 FIND v(dout1_16) AT=300.025n

* CHECK dout1_17 Vdout1_17ck59 = 0 time = 300
.meas tran vdout1_17ck59 FIND v(dout1_17) AT=300.025n

* CHECK dout1_18 Vdout1_18ck59 = 0 time = 300
.meas tran vdout1_18ck59 FIND v(dout1_18) AT=300.025n

* CHECK dout1_19 Vdout1_19ck59 = 0.9 time = 300
.meas tran vdout1_19ck59 FIND v(dout1_19) AT=300.025n

* CHECK dout1_20 Vdout1_20ck59 = 0 time = 300
.meas tran vdout1_20ck59 FIND v(dout1_20) AT=300.025n

* CHECK dout1_21 Vdout1_21ck59 = 0.9 time = 300
.meas tran vdout1_21ck59 FIND v(dout1_21) AT=300.025n

* CHECK dout1_22 Vdout1_22ck59 = 0.9 time = 300
.meas tran vdout1_22ck59 FIND v(dout1_22) AT=300.025n

* CHECK dout1_23 Vdout1_23ck59 = 0 time = 300
.meas tran vdout1_23ck59 FIND v(dout1_23) AT=300.025n

* CHECK dout1_24 Vdout1_24ck59 = 0 time = 300
.meas tran vdout1_24ck59 FIND v(dout1_24) AT=300.025n

* CHECK dout1_25 Vdout1_25ck59 = 0 time = 300
.meas tran vdout1_25ck59 FIND v(dout1_25) AT=300.025n

* CHECK dout1_26 Vdout1_26ck59 = 0.9 time = 300
.meas tran vdout1_26ck59 FIND v(dout1_26) AT=300.025n

* CHECK dout1_27 Vdout1_27ck59 = 0 time = 300
.meas tran vdout1_27ck59 FIND v(dout1_27) AT=300.025n

* CHECK dout1_28 Vdout1_28ck59 = 0.9 time = 300
.meas tran vdout1_28ck59 FIND v(dout1_28) AT=300.025n

* CHECK dout1_29 Vdout1_29ck59 = 0 time = 300
.meas tran vdout1_29ck59 FIND v(dout1_29) AT=300.025n

* CHECK dout1_30 Vdout1_30ck59 = 0 time = 300
.meas tran vdout1_30ck59 FIND v(dout1_30) AT=300.025n

* CHECK dout1_31 Vdout1_31ck59 = 0.9 time = 300
.meas tran vdout1_31ck59 FIND v(dout1_31) AT=300.025n

* CHECK dout1_32 Vdout1_32ck59 = 0 time = 300
.meas tran vdout1_32ck59 FIND v(dout1_32) AT=300.025n

* CHECK dout1_33 Vdout1_33ck59 = 0 time = 300
.meas tran vdout1_33ck59 FIND v(dout1_33) AT=300.025n

* CHECK dout1_34 Vdout1_34ck59 = 0.9 time = 300
.meas tran vdout1_34ck59 FIND v(dout1_34) AT=300.025n

* CHECK dout1_35 Vdout1_35ck59 = 0.9 time = 300
.meas tran vdout1_35ck59 FIND v(dout1_35) AT=300.025n

* CHECK dout1_36 Vdout1_36ck59 = 0 time = 300
.meas tran vdout1_36ck59 FIND v(dout1_36) AT=300.025n

* CHECK dout1_37 Vdout1_37ck59 = 0 time = 300
.meas tran vdout1_37ck59 FIND v(dout1_37) AT=300.025n

* CHECK dout1_38 Vdout1_38ck59 = 0.9 time = 300
.meas tran vdout1_38ck59 FIND v(dout1_38) AT=300.025n

* CHECK dout1_39 Vdout1_39ck59 = 0.9 time = 300
.meas tran vdout1_39ck59 FIND v(dout1_39) AT=300.025n

* CHECK dout1_40 Vdout1_40ck59 = 0.9 time = 300
.meas tran vdout1_40ck59 FIND v(dout1_40) AT=300.025n

* CHECK dout1_41 Vdout1_41ck59 = 0.9 time = 300
.meas tran vdout1_41ck59 FIND v(dout1_41) AT=300.025n

* CHECK dout1_42 Vdout1_42ck59 = 0.9 time = 300
.meas tran vdout1_42ck59 FIND v(dout1_42) AT=300.025n

* CHECK dout1_43 Vdout1_43ck59 = 0.9 time = 300
.meas tran vdout1_43ck59 FIND v(dout1_43) AT=300.025n

* CHECK dout1_44 Vdout1_44ck59 = 0 time = 300
.meas tran vdout1_44ck59 FIND v(dout1_44) AT=300.025n

* CHECK dout1_45 Vdout1_45ck59 = 0 time = 300
.meas tran vdout1_45ck59 FIND v(dout1_45) AT=300.025n

* CHECK dout1_46 Vdout1_46ck59 = 0.9 time = 300
.meas tran vdout1_46ck59 FIND v(dout1_46) AT=300.025n

* CHECK dout1_47 Vdout1_47ck59 = 0 time = 300
.meas tran vdout1_47ck59 FIND v(dout1_47) AT=300.025n

* CHECK dout1_48 Vdout1_48ck59 = 0 time = 300
.meas tran vdout1_48ck59 FIND v(dout1_48) AT=300.025n

* CHECK dout1_49 Vdout1_49ck59 = 0 time = 300
.meas tran vdout1_49ck59 FIND v(dout1_49) AT=300.025n

* CHECK dout1_50 Vdout1_50ck59 = 0 time = 300
.meas tran vdout1_50ck59 FIND v(dout1_50) AT=300.025n

* CHECK dout1_51 Vdout1_51ck59 = 0.9 time = 300
.meas tran vdout1_51ck59 FIND v(dout1_51) AT=300.025n

* CHECK dout1_52 Vdout1_52ck59 = 0 time = 300
.meas tran vdout1_52ck59 FIND v(dout1_52) AT=300.025n

* CHECK dout1_53 Vdout1_53ck59 = 0.9 time = 300
.meas tran vdout1_53ck59 FIND v(dout1_53) AT=300.025n

* CHECK dout1_54 Vdout1_54ck59 = 0.9 time = 300
.meas tran vdout1_54ck59 FIND v(dout1_54) AT=300.025n

* CHECK dout1_55 Vdout1_55ck59 = 0.9 time = 300
.meas tran vdout1_55ck59 FIND v(dout1_55) AT=300.025n

* CHECK dout1_56 Vdout1_56ck59 = 0.9 time = 300
.meas tran vdout1_56ck59 FIND v(dout1_56) AT=300.025n

* CHECK dout1_57 Vdout1_57ck59 = 0 time = 300
.meas tran vdout1_57ck59 FIND v(dout1_57) AT=300.025n

* CHECK dout1_58 Vdout1_58ck59 = 0 time = 300
.meas tran vdout1_58ck59 FIND v(dout1_58) AT=300.025n

* CHECK dout1_59 Vdout1_59ck59 = 0.9 time = 300
.meas tran vdout1_59ck59 FIND v(dout1_59) AT=300.025n

* CHECK dout1_60 Vdout1_60ck59 = 0.9 time = 300
.meas tran vdout1_60ck59 FIND v(dout1_60) AT=300.025n

* CHECK dout1_61 Vdout1_61ck59 = 0 time = 300
.meas tran vdout1_61ck59 FIND v(dout1_61) AT=300.025n

* CHECK dout1_62 Vdout1_62ck59 = 0.9 time = 300
.meas tran vdout1_62ck59 FIND v(dout1_62) AT=300.025n

* CHECK dout1_63 Vdout1_63ck59 = 0.9 time = 300
.meas tran vdout1_63ck59 FIND v(dout1_63) AT=300.025n

* CHECK dout1_64 Vdout1_64ck59 = 0.9 time = 300
.meas tran vdout1_64ck59 FIND v(dout1_64) AT=300.025n

* CHECK dout1_65 Vdout1_65ck59 = 0.9 time = 300
.meas tran vdout1_65ck59 FIND v(dout1_65) AT=300.025n

* CHECK dout1_66 Vdout1_66ck59 = 0.9 time = 300
.meas tran vdout1_66ck59 FIND v(dout1_66) AT=300.025n

* CHECK dout1_67 Vdout1_67ck59 = 0.9 time = 300
.meas tran vdout1_67ck59 FIND v(dout1_67) AT=300.025n

* CHECK dout1_68 Vdout1_68ck59 = 0 time = 300
.meas tran vdout1_68ck59 FIND v(dout1_68) AT=300.025n

* CHECK dout1_69 Vdout1_69ck59 = 0 time = 300
.meas tran vdout1_69ck59 FIND v(dout1_69) AT=300.025n

* CHECK dout1_70 Vdout1_70ck59 = 0.9 time = 300
.meas tran vdout1_70ck59 FIND v(dout1_70) AT=300.025n

* CHECK dout1_71 Vdout1_71ck59 = 0 time = 300
.meas tran vdout1_71ck59 FIND v(dout1_71) AT=300.025n

* CHECK dout1_0 Vdout1_0ck60 = 0.9 time = 305
.meas tran vdout1_0ck60 FIND v(dout1_0) AT=305.025n

* CHECK dout1_1 Vdout1_1ck60 = 0 time = 305
.meas tran vdout1_1ck60 FIND v(dout1_1) AT=305.025n

* CHECK dout1_2 Vdout1_2ck60 = 0.9 time = 305
.meas tran vdout1_2ck60 FIND v(dout1_2) AT=305.025n

* CHECK dout1_3 Vdout1_3ck60 = 0.9 time = 305
.meas tran vdout1_3ck60 FIND v(dout1_3) AT=305.025n

* CHECK dout1_4 Vdout1_4ck60 = 0.9 time = 305
.meas tran vdout1_4ck60 FIND v(dout1_4) AT=305.025n

* CHECK dout1_5 Vdout1_5ck60 = 0.9 time = 305
.meas tran vdout1_5ck60 FIND v(dout1_5) AT=305.025n

* CHECK dout1_6 Vdout1_6ck60 = 0 time = 305
.meas tran vdout1_6ck60 FIND v(dout1_6) AT=305.025n

* CHECK dout1_7 Vdout1_7ck60 = 0 time = 305
.meas tran vdout1_7ck60 FIND v(dout1_7) AT=305.025n

* CHECK dout1_8 Vdout1_8ck60 = 0.9 time = 305
.meas tran vdout1_8ck60 FIND v(dout1_8) AT=305.025n

* CHECK dout1_9 Vdout1_9ck60 = 0 time = 305
.meas tran vdout1_9ck60 FIND v(dout1_9) AT=305.025n

* CHECK dout1_10 Vdout1_10ck60 = 0.9 time = 305
.meas tran vdout1_10ck60 FIND v(dout1_10) AT=305.025n

* CHECK dout1_11 Vdout1_11ck60 = 0.9 time = 305
.meas tran vdout1_11ck60 FIND v(dout1_11) AT=305.025n

* CHECK dout1_12 Vdout1_12ck60 = 0 time = 305
.meas tran vdout1_12ck60 FIND v(dout1_12) AT=305.025n

* CHECK dout1_13 Vdout1_13ck60 = 0.9 time = 305
.meas tran vdout1_13ck60 FIND v(dout1_13) AT=305.025n

* CHECK dout1_14 Vdout1_14ck60 = 0.9 time = 305
.meas tran vdout1_14ck60 FIND v(dout1_14) AT=305.025n

* CHECK dout1_15 Vdout1_15ck60 = 0 time = 305
.meas tran vdout1_15ck60 FIND v(dout1_15) AT=305.025n

* CHECK dout1_16 Vdout1_16ck60 = 0 time = 305
.meas tran vdout1_16ck60 FIND v(dout1_16) AT=305.025n

* CHECK dout1_17 Vdout1_17ck60 = 0 time = 305
.meas tran vdout1_17ck60 FIND v(dout1_17) AT=305.025n

* CHECK dout1_18 Vdout1_18ck60 = 0.9 time = 305
.meas tran vdout1_18ck60 FIND v(dout1_18) AT=305.025n

* CHECK dout1_19 Vdout1_19ck60 = 0.9 time = 305
.meas tran vdout1_19ck60 FIND v(dout1_19) AT=305.025n

* CHECK dout1_20 Vdout1_20ck60 = 0 time = 305
.meas tran vdout1_20ck60 FIND v(dout1_20) AT=305.025n

* CHECK dout1_21 Vdout1_21ck60 = 0.9 time = 305
.meas tran vdout1_21ck60 FIND v(dout1_21) AT=305.025n

* CHECK dout1_22 Vdout1_22ck60 = 0 time = 305
.meas tran vdout1_22ck60 FIND v(dout1_22) AT=305.025n

* CHECK dout1_23 Vdout1_23ck60 = 0.9 time = 305
.meas tran vdout1_23ck60 FIND v(dout1_23) AT=305.025n

* CHECK dout1_24 Vdout1_24ck60 = 0.9 time = 305
.meas tran vdout1_24ck60 FIND v(dout1_24) AT=305.025n

* CHECK dout1_25 Vdout1_25ck60 = 0 time = 305
.meas tran vdout1_25ck60 FIND v(dout1_25) AT=305.025n

* CHECK dout1_26 Vdout1_26ck60 = 0.9 time = 305
.meas tran vdout1_26ck60 FIND v(dout1_26) AT=305.025n

* CHECK dout1_27 Vdout1_27ck60 = 0.9 time = 305
.meas tran vdout1_27ck60 FIND v(dout1_27) AT=305.025n

* CHECK dout1_28 Vdout1_28ck60 = 0 time = 305
.meas tran vdout1_28ck60 FIND v(dout1_28) AT=305.025n

* CHECK dout1_29 Vdout1_29ck60 = 0 time = 305
.meas tran vdout1_29ck60 FIND v(dout1_29) AT=305.025n

* CHECK dout1_30 Vdout1_30ck60 = 0.9 time = 305
.meas tran vdout1_30ck60 FIND v(dout1_30) AT=305.025n

* CHECK dout1_31 Vdout1_31ck60 = 0 time = 305
.meas tran vdout1_31ck60 FIND v(dout1_31) AT=305.025n

* CHECK dout1_32 Vdout1_32ck60 = 0 time = 305
.meas tran vdout1_32ck60 FIND v(dout1_32) AT=305.025n

* CHECK dout1_33 Vdout1_33ck60 = 0.9 time = 305
.meas tran vdout1_33ck60 FIND v(dout1_33) AT=305.025n

* CHECK dout1_34 Vdout1_34ck60 = 0.9 time = 305
.meas tran vdout1_34ck60 FIND v(dout1_34) AT=305.025n

* CHECK dout1_35 Vdout1_35ck60 = 0.9 time = 305
.meas tran vdout1_35ck60 FIND v(dout1_35) AT=305.025n

* CHECK dout1_36 Vdout1_36ck60 = 0 time = 305
.meas tran vdout1_36ck60 FIND v(dout1_36) AT=305.025n

* CHECK dout1_37 Vdout1_37ck60 = 0 time = 305
.meas tran vdout1_37ck60 FIND v(dout1_37) AT=305.025n

* CHECK dout1_38 Vdout1_38ck60 = 0 time = 305
.meas tran vdout1_38ck60 FIND v(dout1_38) AT=305.025n

* CHECK dout1_39 Vdout1_39ck60 = 0 time = 305
.meas tran vdout1_39ck60 FIND v(dout1_39) AT=305.025n

* CHECK dout1_40 Vdout1_40ck60 = 0.9 time = 305
.meas tran vdout1_40ck60 FIND v(dout1_40) AT=305.025n

* CHECK dout1_41 Vdout1_41ck60 = 0 time = 305
.meas tran vdout1_41ck60 FIND v(dout1_41) AT=305.025n

* CHECK dout1_42 Vdout1_42ck60 = 0.9 time = 305
.meas tran vdout1_42ck60 FIND v(dout1_42) AT=305.025n

* CHECK dout1_43 Vdout1_43ck60 = 0.9 time = 305
.meas tran vdout1_43ck60 FIND v(dout1_43) AT=305.025n

* CHECK dout1_44 Vdout1_44ck60 = 0 time = 305
.meas tran vdout1_44ck60 FIND v(dout1_44) AT=305.025n

* CHECK dout1_45 Vdout1_45ck60 = 0.9 time = 305
.meas tran vdout1_45ck60 FIND v(dout1_45) AT=305.025n

* CHECK dout1_46 Vdout1_46ck60 = 0.9 time = 305
.meas tran vdout1_46ck60 FIND v(dout1_46) AT=305.025n

* CHECK dout1_47 Vdout1_47ck60 = 0 time = 305
.meas tran vdout1_47ck60 FIND v(dout1_47) AT=305.025n

* CHECK dout1_48 Vdout1_48ck60 = 0.9 time = 305
.meas tran vdout1_48ck60 FIND v(dout1_48) AT=305.025n

* CHECK dout1_49 Vdout1_49ck60 = 0.9 time = 305
.meas tran vdout1_49ck60 FIND v(dout1_49) AT=305.025n

* CHECK dout1_50 Vdout1_50ck60 = 0 time = 305
.meas tran vdout1_50ck60 FIND v(dout1_50) AT=305.025n

* CHECK dout1_51 Vdout1_51ck60 = 0.9 time = 305
.meas tran vdout1_51ck60 FIND v(dout1_51) AT=305.025n

* CHECK dout1_52 Vdout1_52ck60 = 0 time = 305
.meas tran vdout1_52ck60 FIND v(dout1_52) AT=305.025n

* CHECK dout1_53 Vdout1_53ck60 = 0 time = 305
.meas tran vdout1_53ck60 FIND v(dout1_53) AT=305.025n

* CHECK dout1_54 Vdout1_54ck60 = 0.9 time = 305
.meas tran vdout1_54ck60 FIND v(dout1_54) AT=305.025n

* CHECK dout1_55 Vdout1_55ck60 = 0.9 time = 305
.meas tran vdout1_55ck60 FIND v(dout1_55) AT=305.025n

* CHECK dout1_56 Vdout1_56ck60 = 0 time = 305
.meas tran vdout1_56ck60 FIND v(dout1_56) AT=305.025n

* CHECK dout1_57 Vdout1_57ck60 = 0 time = 305
.meas tran vdout1_57ck60 FIND v(dout1_57) AT=305.025n

* CHECK dout1_58 Vdout1_58ck60 = 0 time = 305
.meas tran vdout1_58ck60 FIND v(dout1_58) AT=305.025n

* CHECK dout1_59 Vdout1_59ck60 = 0 time = 305
.meas tran vdout1_59ck60 FIND v(dout1_59) AT=305.025n

* CHECK dout1_60 Vdout1_60ck60 = 0.9 time = 305
.meas tran vdout1_60ck60 FIND v(dout1_60) AT=305.025n

* CHECK dout1_61 Vdout1_61ck60 = 0 time = 305
.meas tran vdout1_61ck60 FIND v(dout1_61) AT=305.025n

* CHECK dout1_62 Vdout1_62ck60 = 0 time = 305
.meas tran vdout1_62ck60 FIND v(dout1_62) AT=305.025n

* CHECK dout1_63 Vdout1_63ck60 = 0 time = 305
.meas tran vdout1_63ck60 FIND v(dout1_63) AT=305.025n

* CHECK dout1_64 Vdout1_64ck60 = 0.9 time = 305
.meas tran vdout1_64ck60 FIND v(dout1_64) AT=305.025n

* CHECK dout1_65 Vdout1_65ck60 = 0 time = 305
.meas tran vdout1_65ck60 FIND v(dout1_65) AT=305.025n

* CHECK dout1_66 Vdout1_66ck60 = 0 time = 305
.meas tran vdout1_66ck60 FIND v(dout1_66) AT=305.025n

* CHECK dout1_67 Vdout1_67ck60 = 0.9 time = 305
.meas tran vdout1_67ck60 FIND v(dout1_67) AT=305.025n

* CHECK dout1_68 Vdout1_68ck60 = 0 time = 305
.meas tran vdout1_68ck60 FIND v(dout1_68) AT=305.025n

* CHECK dout1_69 Vdout1_69ck60 = 0.9 time = 305
.meas tran vdout1_69ck60 FIND v(dout1_69) AT=305.025n

* CHECK dout1_70 Vdout1_70ck60 = 0.9 time = 305
.meas tran vdout1_70ck60 FIND v(dout1_70) AT=305.025n

* CHECK dout1_71 Vdout1_71ck60 = 0.9 time = 305
.meas tran vdout1_71ck60 FIND v(dout1_71) AT=305.025n

* CHECK dout1_0 Vdout1_0ck69 = 0.9 time = 350
.meas tran vdout1_0ck69 FIND v(dout1_0) AT=350.025n

* CHECK dout1_1 Vdout1_1ck69 = 0 time = 350
.meas tran vdout1_1ck69 FIND v(dout1_1) AT=350.025n

* CHECK dout1_2 Vdout1_2ck69 = 0.9 time = 350
.meas tran vdout1_2ck69 FIND v(dout1_2) AT=350.025n

* CHECK dout1_3 Vdout1_3ck69 = 0.9 time = 350
.meas tran vdout1_3ck69 FIND v(dout1_3) AT=350.025n

* CHECK dout1_4 Vdout1_4ck69 = 0 time = 350
.meas tran vdout1_4ck69 FIND v(dout1_4) AT=350.025n

* CHECK dout1_5 Vdout1_5ck69 = 0.9 time = 350
.meas tran vdout1_5ck69 FIND v(dout1_5) AT=350.025n

* CHECK dout1_6 Vdout1_6ck69 = 0.9 time = 350
.meas tran vdout1_6ck69 FIND v(dout1_6) AT=350.025n

* CHECK dout1_7 Vdout1_7ck69 = 0 time = 350
.meas tran vdout1_7ck69 FIND v(dout1_7) AT=350.025n

* CHECK dout1_8 Vdout1_8ck69 = 0 time = 350
.meas tran vdout1_8ck69 FIND v(dout1_8) AT=350.025n

* CHECK dout1_9 Vdout1_9ck69 = 0 time = 350
.meas tran vdout1_9ck69 FIND v(dout1_9) AT=350.025n

* CHECK dout1_10 Vdout1_10ck69 = 0 time = 350
.meas tran vdout1_10ck69 FIND v(dout1_10) AT=350.025n

* CHECK dout1_11 Vdout1_11ck69 = 0 time = 350
.meas tran vdout1_11ck69 FIND v(dout1_11) AT=350.025n

* CHECK dout1_12 Vdout1_12ck69 = 0 time = 350
.meas tran vdout1_12ck69 FIND v(dout1_12) AT=350.025n

* CHECK dout1_13 Vdout1_13ck69 = 0 time = 350
.meas tran vdout1_13ck69 FIND v(dout1_13) AT=350.025n

* CHECK dout1_14 Vdout1_14ck69 = 0 time = 350
.meas tran vdout1_14ck69 FIND v(dout1_14) AT=350.025n

* CHECK dout1_15 Vdout1_15ck69 = 0.9 time = 350
.meas tran vdout1_15ck69 FIND v(dout1_15) AT=350.025n

* CHECK dout1_16 Vdout1_16ck69 = 0.9 time = 350
.meas tran vdout1_16ck69 FIND v(dout1_16) AT=350.025n

* CHECK dout1_17 Vdout1_17ck69 = 0 time = 350
.meas tran vdout1_17ck69 FIND v(dout1_17) AT=350.025n

* CHECK dout1_18 Vdout1_18ck69 = 0.9 time = 350
.meas tran vdout1_18ck69 FIND v(dout1_18) AT=350.025n

* CHECK dout1_19 Vdout1_19ck69 = 0 time = 350
.meas tran vdout1_19ck69 FIND v(dout1_19) AT=350.025n

* CHECK dout1_20 Vdout1_20ck69 = 0 time = 350
.meas tran vdout1_20ck69 FIND v(dout1_20) AT=350.025n

* CHECK dout1_21 Vdout1_21ck69 = 0.9 time = 350
.meas tran vdout1_21ck69 FIND v(dout1_21) AT=350.025n

* CHECK dout1_22 Vdout1_22ck69 = 0 time = 350
.meas tran vdout1_22ck69 FIND v(dout1_22) AT=350.025n

* CHECK dout1_23 Vdout1_23ck69 = 0 time = 350
.meas tran vdout1_23ck69 FIND v(dout1_23) AT=350.025n

* CHECK dout1_24 Vdout1_24ck69 = 0.9 time = 350
.meas tran vdout1_24ck69 FIND v(dout1_24) AT=350.025n

* CHECK dout1_25 Vdout1_25ck69 = 0 time = 350
.meas tran vdout1_25ck69 FIND v(dout1_25) AT=350.025n

* CHECK dout1_26 Vdout1_26ck69 = 0 time = 350
.meas tran vdout1_26ck69 FIND v(dout1_26) AT=350.025n

* CHECK dout1_27 Vdout1_27ck69 = 0.9 time = 350
.meas tran vdout1_27ck69 FIND v(dout1_27) AT=350.025n

* CHECK dout1_28 Vdout1_28ck69 = 0.9 time = 350
.meas tran vdout1_28ck69 FIND v(dout1_28) AT=350.025n

* CHECK dout1_29 Vdout1_29ck69 = 0 time = 350
.meas tran vdout1_29ck69 FIND v(dout1_29) AT=350.025n

* CHECK dout1_30 Vdout1_30ck69 = 0 time = 350
.meas tran vdout1_30ck69 FIND v(dout1_30) AT=350.025n

* CHECK dout1_31 Vdout1_31ck69 = 0 time = 350
.meas tran vdout1_31ck69 FIND v(dout1_31) AT=350.025n

* CHECK dout1_32 Vdout1_32ck69 = 0.9 time = 350
.meas tran vdout1_32ck69 FIND v(dout1_32) AT=350.025n

* CHECK dout1_33 Vdout1_33ck69 = 0.9 time = 350
.meas tran vdout1_33ck69 FIND v(dout1_33) AT=350.025n

* CHECK dout1_34 Vdout1_34ck69 = 0.9 time = 350
.meas tran vdout1_34ck69 FIND v(dout1_34) AT=350.025n

* CHECK dout1_35 Vdout1_35ck69 = 0.9 time = 350
.meas tran vdout1_35ck69 FIND v(dout1_35) AT=350.025n

* CHECK dout1_36 Vdout1_36ck69 = 0 time = 350
.meas tran vdout1_36ck69 FIND v(dout1_36) AT=350.025n

* CHECK dout1_37 Vdout1_37ck69 = 0.9 time = 350
.meas tran vdout1_37ck69 FIND v(dout1_37) AT=350.025n

* CHECK dout1_38 Vdout1_38ck69 = 0.9 time = 350
.meas tran vdout1_38ck69 FIND v(dout1_38) AT=350.025n

* CHECK dout1_39 Vdout1_39ck69 = 0.9 time = 350
.meas tran vdout1_39ck69 FIND v(dout1_39) AT=350.025n

* CHECK dout1_40 Vdout1_40ck69 = 0 time = 350
.meas tran vdout1_40ck69 FIND v(dout1_40) AT=350.025n

* CHECK dout1_41 Vdout1_41ck69 = 0 time = 350
.meas tran vdout1_41ck69 FIND v(dout1_41) AT=350.025n

* CHECK dout1_42 Vdout1_42ck69 = 0.9 time = 350
.meas tran vdout1_42ck69 FIND v(dout1_42) AT=350.025n

* CHECK dout1_43 Vdout1_43ck69 = 0.9 time = 350
.meas tran vdout1_43ck69 FIND v(dout1_43) AT=350.025n

* CHECK dout1_44 Vdout1_44ck69 = 0 time = 350
.meas tran vdout1_44ck69 FIND v(dout1_44) AT=350.025n

* CHECK dout1_45 Vdout1_45ck69 = 0 time = 350
.meas tran vdout1_45ck69 FIND v(dout1_45) AT=350.025n

* CHECK dout1_46 Vdout1_46ck69 = 0.9 time = 350
.meas tran vdout1_46ck69 FIND v(dout1_46) AT=350.025n

* CHECK dout1_47 Vdout1_47ck69 = 0.9 time = 350
.meas tran vdout1_47ck69 FIND v(dout1_47) AT=350.025n

* CHECK dout1_48 Vdout1_48ck69 = 0 time = 350
.meas tran vdout1_48ck69 FIND v(dout1_48) AT=350.025n

* CHECK dout1_49 Vdout1_49ck69 = 0 time = 350
.meas tran vdout1_49ck69 FIND v(dout1_49) AT=350.025n

* CHECK dout1_50 Vdout1_50ck69 = 0.9 time = 350
.meas tran vdout1_50ck69 FIND v(dout1_50) AT=350.025n

* CHECK dout1_51 Vdout1_51ck69 = 0 time = 350
.meas tran vdout1_51ck69 FIND v(dout1_51) AT=350.025n

* CHECK dout1_52 Vdout1_52ck69 = 0 time = 350
.meas tran vdout1_52ck69 FIND v(dout1_52) AT=350.025n

* CHECK dout1_53 Vdout1_53ck69 = 0 time = 350
.meas tran vdout1_53ck69 FIND v(dout1_53) AT=350.025n

* CHECK dout1_54 Vdout1_54ck69 = 0.9 time = 350
.meas tran vdout1_54ck69 FIND v(dout1_54) AT=350.025n

* CHECK dout1_55 Vdout1_55ck69 = 0.9 time = 350
.meas tran vdout1_55ck69 FIND v(dout1_55) AT=350.025n

* CHECK dout1_56 Vdout1_56ck69 = 0.9 time = 350
.meas tran vdout1_56ck69 FIND v(dout1_56) AT=350.025n

* CHECK dout1_57 Vdout1_57ck69 = 0.9 time = 350
.meas tran vdout1_57ck69 FIND v(dout1_57) AT=350.025n

* CHECK dout1_58 Vdout1_58ck69 = 0.9 time = 350
.meas tran vdout1_58ck69 FIND v(dout1_58) AT=350.025n

* CHECK dout1_59 Vdout1_59ck69 = 0 time = 350
.meas tran vdout1_59ck69 FIND v(dout1_59) AT=350.025n

* CHECK dout1_60 Vdout1_60ck69 = 0 time = 350
.meas tran vdout1_60ck69 FIND v(dout1_60) AT=350.025n

* CHECK dout1_61 Vdout1_61ck69 = 0.9 time = 350
.meas tran vdout1_61ck69 FIND v(dout1_61) AT=350.025n

* CHECK dout1_62 Vdout1_62ck69 = 0.9 time = 350
.meas tran vdout1_62ck69 FIND v(dout1_62) AT=350.025n

* CHECK dout1_63 Vdout1_63ck69 = 0.9 time = 350
.meas tran vdout1_63ck69 FIND v(dout1_63) AT=350.025n

* CHECK dout1_64 Vdout1_64ck69 = 0.9 time = 350
.meas tran vdout1_64ck69 FIND v(dout1_64) AT=350.025n

* CHECK dout1_65 Vdout1_65ck69 = 0 time = 350
.meas tran vdout1_65ck69 FIND v(dout1_65) AT=350.025n

* CHECK dout1_66 Vdout1_66ck69 = 0 time = 350
.meas tran vdout1_66ck69 FIND v(dout1_66) AT=350.025n

* CHECK dout1_67 Vdout1_67ck69 = 0 time = 350
.meas tran vdout1_67ck69 FIND v(dout1_67) AT=350.025n

* CHECK dout1_68 Vdout1_68ck69 = 0.9 time = 350
.meas tran vdout1_68ck69 FIND v(dout1_68) AT=350.025n

* CHECK dout1_69 Vdout1_69ck69 = 0.9 time = 350
.meas tran vdout1_69ck69 FIND v(dout1_69) AT=350.025n

* CHECK dout1_70 Vdout1_70ck69 = 0 time = 350
.meas tran vdout1_70ck69 FIND v(dout1_70) AT=350.025n

* CHECK dout1_71 Vdout1_71ck69 = 0.9 time = 350
.meas tran vdout1_71ck69 FIND v(dout1_71) AT=350.025n

* CHECK dout1_0 Vdout1_0ck73 = 0 time = 370
.meas tran vdout1_0ck73 FIND v(dout1_0) AT=370.025n

* CHECK dout1_1 Vdout1_1ck73 = 0.9 time = 370
.meas tran vdout1_1ck73 FIND v(dout1_1) AT=370.025n

* CHECK dout1_2 Vdout1_2ck73 = 0.9 time = 370
.meas tran vdout1_2ck73 FIND v(dout1_2) AT=370.025n

* CHECK dout1_3 Vdout1_3ck73 = 0 time = 370
.meas tran vdout1_3ck73 FIND v(dout1_3) AT=370.025n

* CHECK dout1_4 Vdout1_4ck73 = 0.9 time = 370
.meas tran vdout1_4ck73 FIND v(dout1_4) AT=370.025n

* CHECK dout1_5 Vdout1_5ck73 = 0.9 time = 370
.meas tran vdout1_5ck73 FIND v(dout1_5) AT=370.025n

* CHECK dout1_6 Vdout1_6ck73 = 0.9 time = 370
.meas tran vdout1_6ck73 FIND v(dout1_6) AT=370.025n

* CHECK dout1_7 Vdout1_7ck73 = 0.9 time = 370
.meas tran vdout1_7ck73 FIND v(dout1_7) AT=370.025n

* CHECK dout1_8 Vdout1_8ck73 = 0.9 time = 370
.meas tran vdout1_8ck73 FIND v(dout1_8) AT=370.025n

* CHECK dout1_9 Vdout1_9ck73 = 0.9 time = 370
.meas tran vdout1_9ck73 FIND v(dout1_9) AT=370.025n

* CHECK dout1_10 Vdout1_10ck73 = 0 time = 370
.meas tran vdout1_10ck73 FIND v(dout1_10) AT=370.025n

* CHECK dout1_11 Vdout1_11ck73 = 0.9 time = 370
.meas tran vdout1_11ck73 FIND v(dout1_11) AT=370.025n

* CHECK dout1_12 Vdout1_12ck73 = 0 time = 370
.meas tran vdout1_12ck73 FIND v(dout1_12) AT=370.025n

* CHECK dout1_13 Vdout1_13ck73 = 0.9 time = 370
.meas tran vdout1_13ck73 FIND v(dout1_13) AT=370.025n

* CHECK dout1_14 Vdout1_14ck73 = 0 time = 370
.meas tran vdout1_14ck73 FIND v(dout1_14) AT=370.025n

* CHECK dout1_15 Vdout1_15ck73 = 0 time = 370
.meas tran vdout1_15ck73 FIND v(dout1_15) AT=370.025n

* CHECK dout1_16 Vdout1_16ck73 = 0.9 time = 370
.meas tran vdout1_16ck73 FIND v(dout1_16) AT=370.025n

* CHECK dout1_17 Vdout1_17ck73 = 0.9 time = 370
.meas tran vdout1_17ck73 FIND v(dout1_17) AT=370.025n

* CHECK dout1_18 Vdout1_18ck73 = 0 time = 370
.meas tran vdout1_18ck73 FIND v(dout1_18) AT=370.025n

* CHECK dout1_19 Vdout1_19ck73 = 0.9 time = 370
.meas tran vdout1_19ck73 FIND v(dout1_19) AT=370.025n

* CHECK dout1_20 Vdout1_20ck73 = 0.9 time = 370
.meas tran vdout1_20ck73 FIND v(dout1_20) AT=370.025n

* CHECK dout1_21 Vdout1_21ck73 = 0 time = 370
.meas tran vdout1_21ck73 FIND v(dout1_21) AT=370.025n

* CHECK dout1_22 Vdout1_22ck73 = 0.9 time = 370
.meas tran vdout1_22ck73 FIND v(dout1_22) AT=370.025n

* CHECK dout1_23 Vdout1_23ck73 = 0.9 time = 370
.meas tran vdout1_23ck73 FIND v(dout1_23) AT=370.025n

* CHECK dout1_24 Vdout1_24ck73 = 0 time = 370
.meas tran vdout1_24ck73 FIND v(dout1_24) AT=370.025n

* CHECK dout1_25 Vdout1_25ck73 = 0.9 time = 370
.meas tran vdout1_25ck73 FIND v(dout1_25) AT=370.025n

* CHECK dout1_26 Vdout1_26ck73 = 0.9 time = 370
.meas tran vdout1_26ck73 FIND v(dout1_26) AT=370.025n

* CHECK dout1_27 Vdout1_27ck73 = 0 time = 370
.meas tran vdout1_27ck73 FIND v(dout1_27) AT=370.025n

* CHECK dout1_28 Vdout1_28ck73 = 0.9 time = 370
.meas tran vdout1_28ck73 FIND v(dout1_28) AT=370.025n

* CHECK dout1_29 Vdout1_29ck73 = 0.9 time = 370
.meas tran vdout1_29ck73 FIND v(dout1_29) AT=370.025n

* CHECK dout1_30 Vdout1_30ck73 = 0.9 time = 370
.meas tran vdout1_30ck73 FIND v(dout1_30) AT=370.025n

* CHECK dout1_31 Vdout1_31ck73 = 0.9 time = 370
.meas tran vdout1_31ck73 FIND v(dout1_31) AT=370.025n

* CHECK dout1_32 Vdout1_32ck73 = 0.9 time = 370
.meas tran vdout1_32ck73 FIND v(dout1_32) AT=370.025n

* CHECK dout1_33 Vdout1_33ck73 = 0.9 time = 370
.meas tran vdout1_33ck73 FIND v(dout1_33) AT=370.025n

* CHECK dout1_34 Vdout1_34ck73 = 0.9 time = 370
.meas tran vdout1_34ck73 FIND v(dout1_34) AT=370.025n

* CHECK dout1_35 Vdout1_35ck73 = 0.9 time = 370
.meas tran vdout1_35ck73 FIND v(dout1_35) AT=370.025n

* CHECK dout1_36 Vdout1_36ck73 = 0 time = 370
.meas tran vdout1_36ck73 FIND v(dout1_36) AT=370.025n

* CHECK dout1_37 Vdout1_37ck73 = 0 time = 370
.meas tran vdout1_37ck73 FIND v(dout1_37) AT=370.025n

* CHECK dout1_38 Vdout1_38ck73 = 0 time = 370
.meas tran vdout1_38ck73 FIND v(dout1_38) AT=370.025n

* CHECK dout1_39 Vdout1_39ck73 = 0.9 time = 370
.meas tran vdout1_39ck73 FIND v(dout1_39) AT=370.025n

* CHECK dout1_40 Vdout1_40ck73 = 0 time = 370
.meas tran vdout1_40ck73 FIND v(dout1_40) AT=370.025n

* CHECK dout1_41 Vdout1_41ck73 = 0.9 time = 370
.meas tran vdout1_41ck73 FIND v(dout1_41) AT=370.025n

* CHECK dout1_42 Vdout1_42ck73 = 0.9 time = 370
.meas tran vdout1_42ck73 FIND v(dout1_42) AT=370.025n

* CHECK dout1_43 Vdout1_43ck73 = 0 time = 370
.meas tran vdout1_43ck73 FIND v(dout1_43) AT=370.025n

* CHECK dout1_44 Vdout1_44ck73 = 0 time = 370
.meas tran vdout1_44ck73 FIND v(dout1_44) AT=370.025n

* CHECK dout1_45 Vdout1_45ck73 = 0 time = 370
.meas tran vdout1_45ck73 FIND v(dout1_45) AT=370.025n

* CHECK dout1_46 Vdout1_46ck73 = 0 time = 370
.meas tran vdout1_46ck73 FIND v(dout1_46) AT=370.025n

* CHECK dout1_47 Vdout1_47ck73 = 0.9 time = 370
.meas tran vdout1_47ck73 FIND v(dout1_47) AT=370.025n

* CHECK dout1_48 Vdout1_48ck73 = 0.9 time = 370
.meas tran vdout1_48ck73 FIND v(dout1_48) AT=370.025n

* CHECK dout1_49 Vdout1_49ck73 = 0.9 time = 370
.meas tran vdout1_49ck73 FIND v(dout1_49) AT=370.025n

* CHECK dout1_50 Vdout1_50ck73 = 0.9 time = 370
.meas tran vdout1_50ck73 FIND v(dout1_50) AT=370.025n

* CHECK dout1_51 Vdout1_51ck73 = 0.9 time = 370
.meas tran vdout1_51ck73 FIND v(dout1_51) AT=370.025n

* CHECK dout1_52 Vdout1_52ck73 = 0 time = 370
.meas tran vdout1_52ck73 FIND v(dout1_52) AT=370.025n

* CHECK dout1_53 Vdout1_53ck73 = 0.9 time = 370
.meas tran vdout1_53ck73 FIND v(dout1_53) AT=370.025n

* CHECK dout1_54 Vdout1_54ck73 = 0 time = 370
.meas tran vdout1_54ck73 FIND v(dout1_54) AT=370.025n

* CHECK dout1_55 Vdout1_55ck73 = 0 time = 370
.meas tran vdout1_55ck73 FIND v(dout1_55) AT=370.025n

* CHECK dout1_56 Vdout1_56ck73 = 0 time = 370
.meas tran vdout1_56ck73 FIND v(dout1_56) AT=370.025n

* CHECK dout1_57 Vdout1_57ck73 = 0.9 time = 370
.meas tran vdout1_57ck73 FIND v(dout1_57) AT=370.025n

* CHECK dout1_58 Vdout1_58ck73 = 0 time = 370
.meas tran vdout1_58ck73 FIND v(dout1_58) AT=370.025n

* CHECK dout1_59 Vdout1_59ck73 = 0.9 time = 370
.meas tran vdout1_59ck73 FIND v(dout1_59) AT=370.025n

* CHECK dout1_60 Vdout1_60ck73 = 0.9 time = 370
.meas tran vdout1_60ck73 FIND v(dout1_60) AT=370.025n

* CHECK dout1_61 Vdout1_61ck73 = 0.9 time = 370
.meas tran vdout1_61ck73 FIND v(dout1_61) AT=370.025n

* CHECK dout1_62 Vdout1_62ck73 = 0 time = 370
.meas tran vdout1_62ck73 FIND v(dout1_62) AT=370.025n

* CHECK dout1_63 Vdout1_63ck73 = 0 time = 370
.meas tran vdout1_63ck73 FIND v(dout1_63) AT=370.025n

* CHECK dout1_64 Vdout1_64ck73 = 0 time = 370
.meas tran vdout1_64ck73 FIND v(dout1_64) AT=370.025n

* CHECK dout1_65 Vdout1_65ck73 = 0.9 time = 370
.meas tran vdout1_65ck73 FIND v(dout1_65) AT=370.025n

* CHECK dout1_66 Vdout1_66ck73 = 0.9 time = 370
.meas tran vdout1_66ck73 FIND v(dout1_66) AT=370.025n

* CHECK dout1_67 Vdout1_67ck73 = 0 time = 370
.meas tran vdout1_67ck73 FIND v(dout1_67) AT=370.025n

* CHECK dout1_68 Vdout1_68ck73 = 0 time = 370
.meas tran vdout1_68ck73 FIND v(dout1_68) AT=370.025n

* CHECK dout1_69 Vdout1_69ck73 = 0.9 time = 370
.meas tran vdout1_69ck73 FIND v(dout1_69) AT=370.025n

* CHECK dout1_70 Vdout1_70ck73 = 0 time = 370
.meas tran vdout1_70ck73 FIND v(dout1_70) AT=370.025n

* CHECK dout1_71 Vdout1_71ck73 = 0 time = 370
.meas tran vdout1_71ck73 FIND v(dout1_71) AT=370.025n

* CHECK dout1_0 Vdout1_0ck76 = 0 time = 385
.meas tran vdout1_0ck76 FIND v(dout1_0) AT=385.025n

* CHECK dout1_1 Vdout1_1ck76 = 0.9 time = 385
.meas tran vdout1_1ck76 FIND v(dout1_1) AT=385.025n

* CHECK dout1_2 Vdout1_2ck76 = 0.9 time = 385
.meas tran vdout1_2ck76 FIND v(dout1_2) AT=385.025n

* CHECK dout1_3 Vdout1_3ck76 = 0 time = 385
.meas tran vdout1_3ck76 FIND v(dout1_3) AT=385.025n

* CHECK dout1_4 Vdout1_4ck76 = 0.9 time = 385
.meas tran vdout1_4ck76 FIND v(dout1_4) AT=385.025n

* CHECK dout1_5 Vdout1_5ck76 = 0.9 time = 385
.meas tran vdout1_5ck76 FIND v(dout1_5) AT=385.025n

* CHECK dout1_6 Vdout1_6ck76 = 0.9 time = 385
.meas tran vdout1_6ck76 FIND v(dout1_6) AT=385.025n

* CHECK dout1_7 Vdout1_7ck76 = 0.9 time = 385
.meas tran vdout1_7ck76 FIND v(dout1_7) AT=385.025n

* CHECK dout1_8 Vdout1_8ck76 = 0.9 time = 385
.meas tran vdout1_8ck76 FIND v(dout1_8) AT=385.025n

* CHECK dout1_9 Vdout1_9ck76 = 0.9 time = 385
.meas tran vdout1_9ck76 FIND v(dout1_9) AT=385.025n

* CHECK dout1_10 Vdout1_10ck76 = 0 time = 385
.meas tran vdout1_10ck76 FIND v(dout1_10) AT=385.025n

* CHECK dout1_11 Vdout1_11ck76 = 0.9 time = 385
.meas tran vdout1_11ck76 FIND v(dout1_11) AT=385.025n

* CHECK dout1_12 Vdout1_12ck76 = 0 time = 385
.meas tran vdout1_12ck76 FIND v(dout1_12) AT=385.025n

* CHECK dout1_13 Vdout1_13ck76 = 0.9 time = 385
.meas tran vdout1_13ck76 FIND v(dout1_13) AT=385.025n

* CHECK dout1_14 Vdout1_14ck76 = 0 time = 385
.meas tran vdout1_14ck76 FIND v(dout1_14) AT=385.025n

* CHECK dout1_15 Vdout1_15ck76 = 0 time = 385
.meas tran vdout1_15ck76 FIND v(dout1_15) AT=385.025n

* CHECK dout1_16 Vdout1_16ck76 = 0.9 time = 385
.meas tran vdout1_16ck76 FIND v(dout1_16) AT=385.025n

* CHECK dout1_17 Vdout1_17ck76 = 0.9 time = 385
.meas tran vdout1_17ck76 FIND v(dout1_17) AT=385.025n

* CHECK dout1_18 Vdout1_18ck76 = 0 time = 385
.meas tran vdout1_18ck76 FIND v(dout1_18) AT=385.025n

* CHECK dout1_19 Vdout1_19ck76 = 0.9 time = 385
.meas tran vdout1_19ck76 FIND v(dout1_19) AT=385.025n

* CHECK dout1_20 Vdout1_20ck76 = 0.9 time = 385
.meas tran vdout1_20ck76 FIND v(dout1_20) AT=385.025n

* CHECK dout1_21 Vdout1_21ck76 = 0 time = 385
.meas tran vdout1_21ck76 FIND v(dout1_21) AT=385.025n

* CHECK dout1_22 Vdout1_22ck76 = 0.9 time = 385
.meas tran vdout1_22ck76 FIND v(dout1_22) AT=385.025n

* CHECK dout1_23 Vdout1_23ck76 = 0.9 time = 385
.meas tran vdout1_23ck76 FIND v(dout1_23) AT=385.025n

* CHECK dout1_24 Vdout1_24ck76 = 0 time = 385
.meas tran vdout1_24ck76 FIND v(dout1_24) AT=385.025n

* CHECK dout1_25 Vdout1_25ck76 = 0.9 time = 385
.meas tran vdout1_25ck76 FIND v(dout1_25) AT=385.025n

* CHECK dout1_26 Vdout1_26ck76 = 0.9 time = 385
.meas tran vdout1_26ck76 FIND v(dout1_26) AT=385.025n

* CHECK dout1_27 Vdout1_27ck76 = 0 time = 385
.meas tran vdout1_27ck76 FIND v(dout1_27) AT=385.025n

* CHECK dout1_28 Vdout1_28ck76 = 0.9 time = 385
.meas tran vdout1_28ck76 FIND v(dout1_28) AT=385.025n

* CHECK dout1_29 Vdout1_29ck76 = 0.9 time = 385
.meas tran vdout1_29ck76 FIND v(dout1_29) AT=385.025n

* CHECK dout1_30 Vdout1_30ck76 = 0.9 time = 385
.meas tran vdout1_30ck76 FIND v(dout1_30) AT=385.025n

* CHECK dout1_31 Vdout1_31ck76 = 0.9 time = 385
.meas tran vdout1_31ck76 FIND v(dout1_31) AT=385.025n

* CHECK dout1_32 Vdout1_32ck76 = 0.9 time = 385
.meas tran vdout1_32ck76 FIND v(dout1_32) AT=385.025n

* CHECK dout1_33 Vdout1_33ck76 = 0.9 time = 385
.meas tran vdout1_33ck76 FIND v(dout1_33) AT=385.025n

* CHECK dout1_34 Vdout1_34ck76 = 0.9 time = 385
.meas tran vdout1_34ck76 FIND v(dout1_34) AT=385.025n

* CHECK dout1_35 Vdout1_35ck76 = 0.9 time = 385
.meas tran vdout1_35ck76 FIND v(dout1_35) AT=385.025n

* CHECK dout1_36 Vdout1_36ck76 = 0 time = 385
.meas tran vdout1_36ck76 FIND v(dout1_36) AT=385.025n

* CHECK dout1_37 Vdout1_37ck76 = 0 time = 385
.meas tran vdout1_37ck76 FIND v(dout1_37) AT=385.025n

* CHECK dout1_38 Vdout1_38ck76 = 0 time = 385
.meas tran vdout1_38ck76 FIND v(dout1_38) AT=385.025n

* CHECK dout1_39 Vdout1_39ck76 = 0.9 time = 385
.meas tran vdout1_39ck76 FIND v(dout1_39) AT=385.025n

* CHECK dout1_40 Vdout1_40ck76 = 0 time = 385
.meas tran vdout1_40ck76 FIND v(dout1_40) AT=385.025n

* CHECK dout1_41 Vdout1_41ck76 = 0.9 time = 385
.meas tran vdout1_41ck76 FIND v(dout1_41) AT=385.025n

* CHECK dout1_42 Vdout1_42ck76 = 0.9 time = 385
.meas tran vdout1_42ck76 FIND v(dout1_42) AT=385.025n

* CHECK dout1_43 Vdout1_43ck76 = 0 time = 385
.meas tran vdout1_43ck76 FIND v(dout1_43) AT=385.025n

* CHECK dout1_44 Vdout1_44ck76 = 0 time = 385
.meas tran vdout1_44ck76 FIND v(dout1_44) AT=385.025n

* CHECK dout1_45 Vdout1_45ck76 = 0 time = 385
.meas tran vdout1_45ck76 FIND v(dout1_45) AT=385.025n

* CHECK dout1_46 Vdout1_46ck76 = 0 time = 385
.meas tran vdout1_46ck76 FIND v(dout1_46) AT=385.025n

* CHECK dout1_47 Vdout1_47ck76 = 0.9 time = 385
.meas tran vdout1_47ck76 FIND v(dout1_47) AT=385.025n

* CHECK dout1_48 Vdout1_48ck76 = 0.9 time = 385
.meas tran vdout1_48ck76 FIND v(dout1_48) AT=385.025n

* CHECK dout1_49 Vdout1_49ck76 = 0.9 time = 385
.meas tran vdout1_49ck76 FIND v(dout1_49) AT=385.025n

* CHECK dout1_50 Vdout1_50ck76 = 0.9 time = 385
.meas tran vdout1_50ck76 FIND v(dout1_50) AT=385.025n

* CHECK dout1_51 Vdout1_51ck76 = 0.9 time = 385
.meas tran vdout1_51ck76 FIND v(dout1_51) AT=385.025n

* CHECK dout1_52 Vdout1_52ck76 = 0 time = 385
.meas tran vdout1_52ck76 FIND v(dout1_52) AT=385.025n

* CHECK dout1_53 Vdout1_53ck76 = 0.9 time = 385
.meas tran vdout1_53ck76 FIND v(dout1_53) AT=385.025n

* CHECK dout1_54 Vdout1_54ck76 = 0 time = 385
.meas tran vdout1_54ck76 FIND v(dout1_54) AT=385.025n

* CHECK dout1_55 Vdout1_55ck76 = 0 time = 385
.meas tran vdout1_55ck76 FIND v(dout1_55) AT=385.025n

* CHECK dout1_56 Vdout1_56ck76 = 0 time = 385
.meas tran vdout1_56ck76 FIND v(dout1_56) AT=385.025n

* CHECK dout1_57 Vdout1_57ck76 = 0.9 time = 385
.meas tran vdout1_57ck76 FIND v(dout1_57) AT=385.025n

* CHECK dout1_58 Vdout1_58ck76 = 0 time = 385
.meas tran vdout1_58ck76 FIND v(dout1_58) AT=385.025n

* CHECK dout1_59 Vdout1_59ck76 = 0.9 time = 385
.meas tran vdout1_59ck76 FIND v(dout1_59) AT=385.025n

* CHECK dout1_60 Vdout1_60ck76 = 0.9 time = 385
.meas tran vdout1_60ck76 FIND v(dout1_60) AT=385.025n

* CHECK dout1_61 Vdout1_61ck76 = 0.9 time = 385
.meas tran vdout1_61ck76 FIND v(dout1_61) AT=385.025n

* CHECK dout1_62 Vdout1_62ck76 = 0 time = 385
.meas tran vdout1_62ck76 FIND v(dout1_62) AT=385.025n

* CHECK dout1_63 Vdout1_63ck76 = 0 time = 385
.meas tran vdout1_63ck76 FIND v(dout1_63) AT=385.025n

* CHECK dout1_64 Vdout1_64ck76 = 0 time = 385
.meas tran vdout1_64ck76 FIND v(dout1_64) AT=385.025n

* CHECK dout1_65 Vdout1_65ck76 = 0.9 time = 385
.meas tran vdout1_65ck76 FIND v(dout1_65) AT=385.025n

* CHECK dout1_66 Vdout1_66ck76 = 0.9 time = 385
.meas tran vdout1_66ck76 FIND v(dout1_66) AT=385.025n

* CHECK dout1_67 Vdout1_67ck76 = 0 time = 385
.meas tran vdout1_67ck76 FIND v(dout1_67) AT=385.025n

* CHECK dout1_68 Vdout1_68ck76 = 0 time = 385
.meas tran vdout1_68ck76 FIND v(dout1_68) AT=385.025n

* CHECK dout1_69 Vdout1_69ck76 = 0.9 time = 385
.meas tran vdout1_69ck76 FIND v(dout1_69) AT=385.025n

* CHECK dout1_70 Vdout1_70ck76 = 0 time = 385
.meas tran vdout1_70ck76 FIND v(dout1_70) AT=385.025n

* CHECK dout1_71 Vdout1_71ck76 = 0 time = 385
.meas tran vdout1_71ck76 FIND v(dout1_71) AT=385.025n

* CHECK dout1_0 Vdout1_0ck77 = 0.9 time = 390
.meas tran vdout1_0ck77 FIND v(dout1_0) AT=390.025n

* CHECK dout1_1 Vdout1_1ck77 = 0 time = 390
.meas tran vdout1_1ck77 FIND v(dout1_1) AT=390.025n

* CHECK dout1_2 Vdout1_2ck77 = 0 time = 390
.meas tran vdout1_2ck77 FIND v(dout1_2) AT=390.025n

* CHECK dout1_3 Vdout1_3ck77 = 0 time = 390
.meas tran vdout1_3ck77 FIND v(dout1_3) AT=390.025n

* CHECK dout1_4 Vdout1_4ck77 = 0.9 time = 390
.meas tran vdout1_4ck77 FIND v(dout1_4) AT=390.025n

* CHECK dout1_5 Vdout1_5ck77 = 0.9 time = 390
.meas tran vdout1_5ck77 FIND v(dout1_5) AT=390.025n

* CHECK dout1_6 Vdout1_6ck77 = 0 time = 390
.meas tran vdout1_6ck77 FIND v(dout1_6) AT=390.025n

* CHECK dout1_7 Vdout1_7ck77 = 0.9 time = 390
.meas tran vdout1_7ck77 FIND v(dout1_7) AT=390.025n

* CHECK dout1_8 Vdout1_8ck77 = 0 time = 390
.meas tran vdout1_8ck77 FIND v(dout1_8) AT=390.025n

* CHECK dout1_9 Vdout1_9ck77 = 0 time = 390
.meas tran vdout1_9ck77 FIND v(dout1_9) AT=390.025n

* CHECK dout1_10 Vdout1_10ck77 = 0.9 time = 390
.meas tran vdout1_10ck77 FIND v(dout1_10) AT=390.025n

* CHECK dout1_11 Vdout1_11ck77 = 0.9 time = 390
.meas tran vdout1_11ck77 FIND v(dout1_11) AT=390.025n

* CHECK dout1_12 Vdout1_12ck77 = 0 time = 390
.meas tran vdout1_12ck77 FIND v(dout1_12) AT=390.025n

* CHECK dout1_13 Vdout1_13ck77 = 0.9 time = 390
.meas tran vdout1_13ck77 FIND v(dout1_13) AT=390.025n

* CHECK dout1_14 Vdout1_14ck77 = 0.9 time = 390
.meas tran vdout1_14ck77 FIND v(dout1_14) AT=390.025n

* CHECK dout1_15 Vdout1_15ck77 = 0.9 time = 390
.meas tran vdout1_15ck77 FIND v(dout1_15) AT=390.025n

* CHECK dout1_16 Vdout1_16ck77 = 0.9 time = 390
.meas tran vdout1_16ck77 FIND v(dout1_16) AT=390.025n

* CHECK dout1_17 Vdout1_17ck77 = 0 time = 390
.meas tran vdout1_17ck77 FIND v(dout1_17) AT=390.025n

* CHECK dout1_18 Vdout1_18ck77 = 0 time = 390
.meas tran vdout1_18ck77 FIND v(dout1_18) AT=390.025n

* CHECK dout1_19 Vdout1_19ck77 = 0.9 time = 390
.meas tran vdout1_19ck77 FIND v(dout1_19) AT=390.025n

* CHECK dout1_20 Vdout1_20ck77 = 0.9 time = 390
.meas tran vdout1_20ck77 FIND v(dout1_20) AT=390.025n

* CHECK dout1_21 Vdout1_21ck77 = 0 time = 390
.meas tran vdout1_21ck77 FIND v(dout1_21) AT=390.025n

* CHECK dout1_22 Vdout1_22ck77 = 0 time = 390
.meas tran vdout1_22ck77 FIND v(dout1_22) AT=390.025n

* CHECK dout1_23 Vdout1_23ck77 = 0 time = 390
.meas tran vdout1_23ck77 FIND v(dout1_23) AT=390.025n

* CHECK dout1_24 Vdout1_24ck77 = 0 time = 390
.meas tran vdout1_24ck77 FIND v(dout1_24) AT=390.025n

* CHECK dout1_25 Vdout1_25ck77 = 0.9 time = 390
.meas tran vdout1_25ck77 FIND v(dout1_25) AT=390.025n

* CHECK dout1_26 Vdout1_26ck77 = 0 time = 390
.meas tran vdout1_26ck77 FIND v(dout1_26) AT=390.025n

* CHECK dout1_27 Vdout1_27ck77 = 0.9 time = 390
.meas tran vdout1_27ck77 FIND v(dout1_27) AT=390.025n

* CHECK dout1_28 Vdout1_28ck77 = 0.9 time = 390
.meas tran vdout1_28ck77 FIND v(dout1_28) AT=390.025n

* CHECK dout1_29 Vdout1_29ck77 = 0.9 time = 390
.meas tran vdout1_29ck77 FIND v(dout1_29) AT=390.025n

* CHECK dout1_30 Vdout1_30ck77 = 0 time = 390
.meas tran vdout1_30ck77 FIND v(dout1_30) AT=390.025n

* CHECK dout1_31 Vdout1_31ck77 = 0.9 time = 390
.meas tran vdout1_31ck77 FIND v(dout1_31) AT=390.025n

* CHECK dout1_32 Vdout1_32ck77 = 0.9 time = 390
.meas tran vdout1_32ck77 FIND v(dout1_32) AT=390.025n

* CHECK dout1_33 Vdout1_33ck77 = 0.9 time = 390
.meas tran vdout1_33ck77 FIND v(dout1_33) AT=390.025n

* CHECK dout1_34 Vdout1_34ck77 = 0.9 time = 390
.meas tran vdout1_34ck77 FIND v(dout1_34) AT=390.025n

* CHECK dout1_35 Vdout1_35ck77 = 0.9 time = 390
.meas tran vdout1_35ck77 FIND v(dout1_35) AT=390.025n

* CHECK dout1_36 Vdout1_36ck77 = 0 time = 390
.meas tran vdout1_36ck77 FIND v(dout1_36) AT=390.025n

* CHECK dout1_37 Vdout1_37ck77 = 0.9 time = 390
.meas tran vdout1_37ck77 FIND v(dout1_37) AT=390.025n

* CHECK dout1_38 Vdout1_38ck77 = 0.9 time = 390
.meas tran vdout1_38ck77 FIND v(dout1_38) AT=390.025n

* CHECK dout1_39 Vdout1_39ck77 = 0 time = 390
.meas tran vdout1_39ck77 FIND v(dout1_39) AT=390.025n

* CHECK dout1_40 Vdout1_40ck77 = 0 time = 390
.meas tran vdout1_40ck77 FIND v(dout1_40) AT=390.025n

* CHECK dout1_41 Vdout1_41ck77 = 0 time = 390
.meas tran vdout1_41ck77 FIND v(dout1_41) AT=390.025n

* CHECK dout1_42 Vdout1_42ck77 = 0 time = 390
.meas tran vdout1_42ck77 FIND v(dout1_42) AT=390.025n

* CHECK dout1_43 Vdout1_43ck77 = 0 time = 390
.meas tran vdout1_43ck77 FIND v(dout1_43) AT=390.025n

* CHECK dout1_44 Vdout1_44ck77 = 0 time = 390
.meas tran vdout1_44ck77 FIND v(dout1_44) AT=390.025n

* CHECK dout1_45 Vdout1_45ck77 = 0.9 time = 390
.meas tran vdout1_45ck77 FIND v(dout1_45) AT=390.025n

* CHECK dout1_46 Vdout1_46ck77 = 0 time = 390
.meas tran vdout1_46ck77 FIND v(dout1_46) AT=390.025n

* CHECK dout1_47 Vdout1_47ck77 = 0.9 time = 390
.meas tran vdout1_47ck77 FIND v(dout1_47) AT=390.025n

* CHECK dout1_48 Vdout1_48ck77 = 0 time = 390
.meas tran vdout1_48ck77 FIND v(dout1_48) AT=390.025n

* CHECK dout1_49 Vdout1_49ck77 = 0.9 time = 390
.meas tran vdout1_49ck77 FIND v(dout1_49) AT=390.025n

* CHECK dout1_50 Vdout1_50ck77 = 0.9 time = 390
.meas tran vdout1_50ck77 FIND v(dout1_50) AT=390.025n

* CHECK dout1_51 Vdout1_51ck77 = 0 time = 390
.meas tran vdout1_51ck77 FIND v(dout1_51) AT=390.025n

* CHECK dout1_52 Vdout1_52ck77 = 0 time = 390
.meas tran vdout1_52ck77 FIND v(dout1_52) AT=390.025n

* CHECK dout1_53 Vdout1_53ck77 = 0 time = 390
.meas tran vdout1_53ck77 FIND v(dout1_53) AT=390.025n

* CHECK dout1_54 Vdout1_54ck77 = 0 time = 390
.meas tran vdout1_54ck77 FIND v(dout1_54) AT=390.025n

* CHECK dout1_55 Vdout1_55ck77 = 0.9 time = 390
.meas tran vdout1_55ck77 FIND v(dout1_55) AT=390.025n

* CHECK dout1_56 Vdout1_56ck77 = 0 time = 390
.meas tran vdout1_56ck77 FIND v(dout1_56) AT=390.025n

* CHECK dout1_57 Vdout1_57ck77 = 0.9 time = 390
.meas tran vdout1_57ck77 FIND v(dout1_57) AT=390.025n

* CHECK dout1_58 Vdout1_58ck77 = 0.9 time = 390
.meas tran vdout1_58ck77 FIND v(dout1_58) AT=390.025n

* CHECK dout1_59 Vdout1_59ck77 = 0.9 time = 390
.meas tran vdout1_59ck77 FIND v(dout1_59) AT=390.025n

* CHECK dout1_60 Vdout1_60ck77 = 0 time = 390
.meas tran vdout1_60ck77 FIND v(dout1_60) AT=390.025n

* CHECK dout1_61 Vdout1_61ck77 = 0 time = 390
.meas tran vdout1_61ck77 FIND v(dout1_61) AT=390.025n

* CHECK dout1_62 Vdout1_62ck77 = 0 time = 390
.meas tran vdout1_62ck77 FIND v(dout1_62) AT=390.025n

* CHECK dout1_63 Vdout1_63ck77 = 0.9 time = 390
.meas tran vdout1_63ck77 FIND v(dout1_63) AT=390.025n

* CHECK dout1_64 Vdout1_64ck77 = 0.9 time = 390
.meas tran vdout1_64ck77 FIND v(dout1_64) AT=390.025n

* CHECK dout1_65 Vdout1_65ck77 = 0.9 time = 390
.meas tran vdout1_65ck77 FIND v(dout1_65) AT=390.025n

* CHECK dout1_66 Vdout1_66ck77 = 0 time = 390
.meas tran vdout1_66ck77 FIND v(dout1_66) AT=390.025n

* CHECK dout1_67 Vdout1_67ck77 = 0.9 time = 390
.meas tran vdout1_67ck77 FIND v(dout1_67) AT=390.025n

* CHECK dout1_68 Vdout1_68ck77 = 0 time = 390
.meas tran vdout1_68ck77 FIND v(dout1_68) AT=390.025n

* CHECK dout1_69 Vdout1_69ck77 = 0 time = 390
.meas tran vdout1_69ck77 FIND v(dout1_69) AT=390.025n

* CHECK dout1_70 Vdout1_70ck77 = 0.9 time = 390
.meas tran vdout1_70ck77 FIND v(dout1_70) AT=390.025n

* CHECK dout1_71 Vdout1_71ck77 = 0.9 time = 390
.meas tran vdout1_71ck77 FIND v(dout1_71) AT=390.025n

* CHECK dout1_0 Vdout1_0ck80 = 0 time = 405
.meas tran vdout1_0ck80 FIND v(dout1_0) AT=405.025n

* CHECK dout1_1 Vdout1_1ck80 = 0.9 time = 405
.meas tran vdout1_1ck80 FIND v(dout1_1) AT=405.025n

* CHECK dout1_2 Vdout1_2ck80 = 0.9 time = 405
.meas tran vdout1_2ck80 FIND v(dout1_2) AT=405.025n

* CHECK dout1_3 Vdout1_3ck80 = 0 time = 405
.meas tran vdout1_3ck80 FIND v(dout1_3) AT=405.025n

* CHECK dout1_4 Vdout1_4ck80 = 0.9 time = 405
.meas tran vdout1_4ck80 FIND v(dout1_4) AT=405.025n

* CHECK dout1_5 Vdout1_5ck80 = 0.9 time = 405
.meas tran vdout1_5ck80 FIND v(dout1_5) AT=405.025n

* CHECK dout1_6 Vdout1_6ck80 = 0.9 time = 405
.meas tran vdout1_6ck80 FIND v(dout1_6) AT=405.025n

* CHECK dout1_7 Vdout1_7ck80 = 0.9 time = 405
.meas tran vdout1_7ck80 FIND v(dout1_7) AT=405.025n

* CHECK dout1_8 Vdout1_8ck80 = 0.9 time = 405
.meas tran vdout1_8ck80 FIND v(dout1_8) AT=405.025n

* CHECK dout1_9 Vdout1_9ck80 = 0.9 time = 405
.meas tran vdout1_9ck80 FIND v(dout1_9) AT=405.025n

* CHECK dout1_10 Vdout1_10ck80 = 0 time = 405
.meas tran vdout1_10ck80 FIND v(dout1_10) AT=405.025n

* CHECK dout1_11 Vdout1_11ck80 = 0.9 time = 405
.meas tran vdout1_11ck80 FIND v(dout1_11) AT=405.025n

* CHECK dout1_12 Vdout1_12ck80 = 0 time = 405
.meas tran vdout1_12ck80 FIND v(dout1_12) AT=405.025n

* CHECK dout1_13 Vdout1_13ck80 = 0.9 time = 405
.meas tran vdout1_13ck80 FIND v(dout1_13) AT=405.025n

* CHECK dout1_14 Vdout1_14ck80 = 0 time = 405
.meas tran vdout1_14ck80 FIND v(dout1_14) AT=405.025n

* CHECK dout1_15 Vdout1_15ck80 = 0 time = 405
.meas tran vdout1_15ck80 FIND v(dout1_15) AT=405.025n

* CHECK dout1_16 Vdout1_16ck80 = 0.9 time = 405
.meas tran vdout1_16ck80 FIND v(dout1_16) AT=405.025n

* CHECK dout1_17 Vdout1_17ck80 = 0.9 time = 405
.meas tran vdout1_17ck80 FIND v(dout1_17) AT=405.025n

* CHECK dout1_18 Vdout1_18ck80 = 0 time = 405
.meas tran vdout1_18ck80 FIND v(dout1_18) AT=405.025n

* CHECK dout1_19 Vdout1_19ck80 = 0.9 time = 405
.meas tran vdout1_19ck80 FIND v(dout1_19) AT=405.025n

* CHECK dout1_20 Vdout1_20ck80 = 0.9 time = 405
.meas tran vdout1_20ck80 FIND v(dout1_20) AT=405.025n

* CHECK dout1_21 Vdout1_21ck80 = 0 time = 405
.meas tran vdout1_21ck80 FIND v(dout1_21) AT=405.025n

* CHECK dout1_22 Vdout1_22ck80 = 0.9 time = 405
.meas tran vdout1_22ck80 FIND v(dout1_22) AT=405.025n

* CHECK dout1_23 Vdout1_23ck80 = 0.9 time = 405
.meas tran vdout1_23ck80 FIND v(dout1_23) AT=405.025n

* CHECK dout1_24 Vdout1_24ck80 = 0 time = 405
.meas tran vdout1_24ck80 FIND v(dout1_24) AT=405.025n

* CHECK dout1_25 Vdout1_25ck80 = 0.9 time = 405
.meas tran vdout1_25ck80 FIND v(dout1_25) AT=405.025n

* CHECK dout1_26 Vdout1_26ck80 = 0.9 time = 405
.meas tran vdout1_26ck80 FIND v(dout1_26) AT=405.025n

* CHECK dout1_27 Vdout1_27ck80 = 0 time = 405
.meas tran vdout1_27ck80 FIND v(dout1_27) AT=405.025n

* CHECK dout1_28 Vdout1_28ck80 = 0.9 time = 405
.meas tran vdout1_28ck80 FIND v(dout1_28) AT=405.025n

* CHECK dout1_29 Vdout1_29ck80 = 0.9 time = 405
.meas tran vdout1_29ck80 FIND v(dout1_29) AT=405.025n

* CHECK dout1_30 Vdout1_30ck80 = 0.9 time = 405
.meas tran vdout1_30ck80 FIND v(dout1_30) AT=405.025n

* CHECK dout1_31 Vdout1_31ck80 = 0.9 time = 405
.meas tran vdout1_31ck80 FIND v(dout1_31) AT=405.025n

* CHECK dout1_32 Vdout1_32ck80 = 0.9 time = 405
.meas tran vdout1_32ck80 FIND v(dout1_32) AT=405.025n

* CHECK dout1_33 Vdout1_33ck80 = 0.9 time = 405
.meas tran vdout1_33ck80 FIND v(dout1_33) AT=405.025n

* CHECK dout1_34 Vdout1_34ck80 = 0.9 time = 405
.meas tran vdout1_34ck80 FIND v(dout1_34) AT=405.025n

* CHECK dout1_35 Vdout1_35ck80 = 0.9 time = 405
.meas tran vdout1_35ck80 FIND v(dout1_35) AT=405.025n

* CHECK dout1_36 Vdout1_36ck80 = 0 time = 405
.meas tran vdout1_36ck80 FIND v(dout1_36) AT=405.025n

* CHECK dout1_37 Vdout1_37ck80 = 0 time = 405
.meas tran vdout1_37ck80 FIND v(dout1_37) AT=405.025n

* CHECK dout1_38 Vdout1_38ck80 = 0 time = 405
.meas tran vdout1_38ck80 FIND v(dout1_38) AT=405.025n

* CHECK dout1_39 Vdout1_39ck80 = 0.9 time = 405
.meas tran vdout1_39ck80 FIND v(dout1_39) AT=405.025n

* CHECK dout1_40 Vdout1_40ck80 = 0 time = 405
.meas tran vdout1_40ck80 FIND v(dout1_40) AT=405.025n

* CHECK dout1_41 Vdout1_41ck80 = 0.9 time = 405
.meas tran vdout1_41ck80 FIND v(dout1_41) AT=405.025n

* CHECK dout1_42 Vdout1_42ck80 = 0.9 time = 405
.meas tran vdout1_42ck80 FIND v(dout1_42) AT=405.025n

* CHECK dout1_43 Vdout1_43ck80 = 0 time = 405
.meas tran vdout1_43ck80 FIND v(dout1_43) AT=405.025n

* CHECK dout1_44 Vdout1_44ck80 = 0 time = 405
.meas tran vdout1_44ck80 FIND v(dout1_44) AT=405.025n

* CHECK dout1_45 Vdout1_45ck80 = 0 time = 405
.meas tran vdout1_45ck80 FIND v(dout1_45) AT=405.025n

* CHECK dout1_46 Vdout1_46ck80 = 0 time = 405
.meas tran vdout1_46ck80 FIND v(dout1_46) AT=405.025n

* CHECK dout1_47 Vdout1_47ck80 = 0.9 time = 405
.meas tran vdout1_47ck80 FIND v(dout1_47) AT=405.025n

* CHECK dout1_48 Vdout1_48ck80 = 0.9 time = 405
.meas tran vdout1_48ck80 FIND v(dout1_48) AT=405.025n

* CHECK dout1_49 Vdout1_49ck80 = 0.9 time = 405
.meas tran vdout1_49ck80 FIND v(dout1_49) AT=405.025n

* CHECK dout1_50 Vdout1_50ck80 = 0.9 time = 405
.meas tran vdout1_50ck80 FIND v(dout1_50) AT=405.025n

* CHECK dout1_51 Vdout1_51ck80 = 0.9 time = 405
.meas tran vdout1_51ck80 FIND v(dout1_51) AT=405.025n

* CHECK dout1_52 Vdout1_52ck80 = 0 time = 405
.meas tran vdout1_52ck80 FIND v(dout1_52) AT=405.025n

* CHECK dout1_53 Vdout1_53ck80 = 0.9 time = 405
.meas tran vdout1_53ck80 FIND v(dout1_53) AT=405.025n

* CHECK dout1_54 Vdout1_54ck80 = 0 time = 405
.meas tran vdout1_54ck80 FIND v(dout1_54) AT=405.025n

* CHECK dout1_55 Vdout1_55ck80 = 0 time = 405
.meas tran vdout1_55ck80 FIND v(dout1_55) AT=405.025n

* CHECK dout1_56 Vdout1_56ck80 = 0 time = 405
.meas tran vdout1_56ck80 FIND v(dout1_56) AT=405.025n

* CHECK dout1_57 Vdout1_57ck80 = 0.9 time = 405
.meas tran vdout1_57ck80 FIND v(dout1_57) AT=405.025n

* CHECK dout1_58 Vdout1_58ck80 = 0 time = 405
.meas tran vdout1_58ck80 FIND v(dout1_58) AT=405.025n

* CHECK dout1_59 Vdout1_59ck80 = 0.9 time = 405
.meas tran vdout1_59ck80 FIND v(dout1_59) AT=405.025n

* CHECK dout1_60 Vdout1_60ck80 = 0.9 time = 405
.meas tran vdout1_60ck80 FIND v(dout1_60) AT=405.025n

* CHECK dout1_61 Vdout1_61ck80 = 0.9 time = 405
.meas tran vdout1_61ck80 FIND v(dout1_61) AT=405.025n

* CHECK dout1_62 Vdout1_62ck80 = 0 time = 405
.meas tran vdout1_62ck80 FIND v(dout1_62) AT=405.025n

* CHECK dout1_63 Vdout1_63ck80 = 0 time = 405
.meas tran vdout1_63ck80 FIND v(dout1_63) AT=405.025n

* CHECK dout1_64 Vdout1_64ck80 = 0 time = 405
.meas tran vdout1_64ck80 FIND v(dout1_64) AT=405.025n

* CHECK dout1_65 Vdout1_65ck80 = 0.9 time = 405
.meas tran vdout1_65ck80 FIND v(dout1_65) AT=405.025n

* CHECK dout1_66 Vdout1_66ck80 = 0.9 time = 405
.meas tran vdout1_66ck80 FIND v(dout1_66) AT=405.025n

* CHECK dout1_67 Vdout1_67ck80 = 0 time = 405
.meas tran vdout1_67ck80 FIND v(dout1_67) AT=405.025n

* CHECK dout1_68 Vdout1_68ck80 = 0 time = 405
.meas tran vdout1_68ck80 FIND v(dout1_68) AT=405.025n

* CHECK dout1_69 Vdout1_69ck80 = 0.9 time = 405
.meas tran vdout1_69ck80 FIND v(dout1_69) AT=405.025n

* CHECK dout1_70 Vdout1_70ck80 = 0 time = 405
.meas tran vdout1_70ck80 FIND v(dout1_70) AT=405.025n

* CHECK dout1_71 Vdout1_71ck80 = 0 time = 405
.meas tran vdout1_71ck80 FIND v(dout1_71) AT=405.025n

* CHECK dout1_0 Vdout1_0ck83 = 0 time = 420
.meas tran vdout1_0ck83 FIND v(dout1_0) AT=420.025n

* CHECK dout1_1 Vdout1_1ck83 = 0.9 time = 420
.meas tran vdout1_1ck83 FIND v(dout1_1) AT=420.025n

* CHECK dout1_2 Vdout1_2ck83 = 0.9 time = 420
.meas tran vdout1_2ck83 FIND v(dout1_2) AT=420.025n

* CHECK dout1_3 Vdout1_3ck83 = 0 time = 420
.meas tran vdout1_3ck83 FIND v(dout1_3) AT=420.025n

* CHECK dout1_4 Vdout1_4ck83 = 0.9 time = 420
.meas tran vdout1_4ck83 FIND v(dout1_4) AT=420.025n

* CHECK dout1_5 Vdout1_5ck83 = 0 time = 420
.meas tran vdout1_5ck83 FIND v(dout1_5) AT=420.025n

* CHECK dout1_6 Vdout1_6ck83 = 0.9 time = 420
.meas tran vdout1_6ck83 FIND v(dout1_6) AT=420.025n

* CHECK dout1_7 Vdout1_7ck83 = 0.9 time = 420
.meas tran vdout1_7ck83 FIND v(dout1_7) AT=420.025n

* CHECK dout1_8 Vdout1_8ck83 = 0 time = 420
.meas tran vdout1_8ck83 FIND v(dout1_8) AT=420.025n

* CHECK dout1_9 Vdout1_9ck83 = 0.9 time = 420
.meas tran vdout1_9ck83 FIND v(dout1_9) AT=420.025n

* CHECK dout1_10 Vdout1_10ck83 = 0.9 time = 420
.meas tran vdout1_10ck83 FIND v(dout1_10) AT=420.025n

* CHECK dout1_11 Vdout1_11ck83 = 0.9 time = 420
.meas tran vdout1_11ck83 FIND v(dout1_11) AT=420.025n

* CHECK dout1_12 Vdout1_12ck83 = 0 time = 420
.meas tran vdout1_12ck83 FIND v(dout1_12) AT=420.025n

* CHECK dout1_13 Vdout1_13ck83 = 0.9 time = 420
.meas tran vdout1_13ck83 FIND v(dout1_13) AT=420.025n

* CHECK dout1_14 Vdout1_14ck83 = 0.9 time = 420
.meas tran vdout1_14ck83 FIND v(dout1_14) AT=420.025n

* CHECK dout1_15 Vdout1_15ck83 = 0 time = 420
.meas tran vdout1_15ck83 FIND v(dout1_15) AT=420.025n

* CHECK dout1_16 Vdout1_16ck83 = 0.9 time = 420
.meas tran vdout1_16ck83 FIND v(dout1_16) AT=420.025n

* CHECK dout1_17 Vdout1_17ck83 = 0 time = 420
.meas tran vdout1_17ck83 FIND v(dout1_17) AT=420.025n

* CHECK dout1_18 Vdout1_18ck83 = 0 time = 420
.meas tran vdout1_18ck83 FIND v(dout1_18) AT=420.025n

* CHECK dout1_19 Vdout1_19ck83 = 0 time = 420
.meas tran vdout1_19ck83 FIND v(dout1_19) AT=420.025n

* CHECK dout1_20 Vdout1_20ck83 = 0 time = 420
.meas tran vdout1_20ck83 FIND v(dout1_20) AT=420.025n

* CHECK dout1_21 Vdout1_21ck83 = 0 time = 420
.meas tran vdout1_21ck83 FIND v(dout1_21) AT=420.025n

* CHECK dout1_22 Vdout1_22ck83 = 0 time = 420
.meas tran vdout1_22ck83 FIND v(dout1_22) AT=420.025n

* CHECK dout1_23 Vdout1_23ck83 = 0 time = 420
.meas tran vdout1_23ck83 FIND v(dout1_23) AT=420.025n

* CHECK dout1_24 Vdout1_24ck83 = 0.9 time = 420
.meas tran vdout1_24ck83 FIND v(dout1_24) AT=420.025n

* CHECK dout1_25 Vdout1_25ck83 = 0 time = 420
.meas tran vdout1_25ck83 FIND v(dout1_25) AT=420.025n

* CHECK dout1_26 Vdout1_26ck83 = 0 time = 420
.meas tran vdout1_26ck83 FIND v(dout1_26) AT=420.025n

* CHECK dout1_27 Vdout1_27ck83 = 0.9 time = 420
.meas tran vdout1_27ck83 FIND v(dout1_27) AT=420.025n

* CHECK dout1_28 Vdout1_28ck83 = 0 time = 420
.meas tran vdout1_28ck83 FIND v(dout1_28) AT=420.025n

* CHECK dout1_29 Vdout1_29ck83 = 0.9 time = 420
.meas tran vdout1_29ck83 FIND v(dout1_29) AT=420.025n

* CHECK dout1_30 Vdout1_30ck83 = 0.9 time = 420
.meas tran vdout1_30ck83 FIND v(dout1_30) AT=420.025n

* CHECK dout1_31 Vdout1_31ck83 = 0 time = 420
.meas tran vdout1_31ck83 FIND v(dout1_31) AT=420.025n

* CHECK dout1_32 Vdout1_32ck83 = 0 time = 420
.meas tran vdout1_32ck83 FIND v(dout1_32) AT=420.025n

* CHECK dout1_33 Vdout1_33ck83 = 0.9 time = 420
.meas tran vdout1_33ck83 FIND v(dout1_33) AT=420.025n

* CHECK dout1_34 Vdout1_34ck83 = 0.9 time = 420
.meas tran vdout1_34ck83 FIND v(dout1_34) AT=420.025n

* CHECK dout1_35 Vdout1_35ck83 = 0 time = 420
.meas tran vdout1_35ck83 FIND v(dout1_35) AT=420.025n

* CHECK dout1_36 Vdout1_36ck83 = 0 time = 420
.meas tran vdout1_36ck83 FIND v(dout1_36) AT=420.025n

* CHECK dout1_37 Vdout1_37ck83 = 0.9 time = 420
.meas tran vdout1_37ck83 FIND v(dout1_37) AT=420.025n

* CHECK dout1_38 Vdout1_38ck83 = 0 time = 420
.meas tran vdout1_38ck83 FIND v(dout1_38) AT=420.025n

* CHECK dout1_39 Vdout1_39ck83 = 0 time = 420
.meas tran vdout1_39ck83 FIND v(dout1_39) AT=420.025n

* CHECK dout1_40 Vdout1_40ck83 = 0 time = 420
.meas tran vdout1_40ck83 FIND v(dout1_40) AT=420.025n

* CHECK dout1_41 Vdout1_41ck83 = 0.9 time = 420
.meas tran vdout1_41ck83 FIND v(dout1_41) AT=420.025n

* CHECK dout1_42 Vdout1_42ck83 = 0.9 time = 420
.meas tran vdout1_42ck83 FIND v(dout1_42) AT=420.025n

* CHECK dout1_43 Vdout1_43ck83 = 0.9 time = 420
.meas tran vdout1_43ck83 FIND v(dout1_43) AT=420.025n

* CHECK dout1_44 Vdout1_44ck83 = 0 time = 420
.meas tran vdout1_44ck83 FIND v(dout1_44) AT=420.025n

* CHECK dout1_45 Vdout1_45ck83 = 0.9 time = 420
.meas tran vdout1_45ck83 FIND v(dout1_45) AT=420.025n

* CHECK dout1_46 Vdout1_46ck83 = 0 time = 420
.meas tran vdout1_46ck83 FIND v(dout1_46) AT=420.025n

* CHECK dout1_47 Vdout1_47ck83 = 0 time = 420
.meas tran vdout1_47ck83 FIND v(dout1_47) AT=420.025n

* CHECK dout1_48 Vdout1_48ck83 = 0 time = 420
.meas tran vdout1_48ck83 FIND v(dout1_48) AT=420.025n

* CHECK dout1_49 Vdout1_49ck83 = 0.9 time = 420
.meas tran vdout1_49ck83 FIND v(dout1_49) AT=420.025n

* CHECK dout1_50 Vdout1_50ck83 = 0 time = 420
.meas tran vdout1_50ck83 FIND v(dout1_50) AT=420.025n

* CHECK dout1_51 Vdout1_51ck83 = 0 time = 420
.meas tran vdout1_51ck83 FIND v(dout1_51) AT=420.025n

* CHECK dout1_52 Vdout1_52ck83 = 0.9 time = 420
.meas tran vdout1_52ck83 FIND v(dout1_52) AT=420.025n

* CHECK dout1_53 Vdout1_53ck83 = 0 time = 420
.meas tran vdout1_53ck83 FIND v(dout1_53) AT=420.025n

* CHECK dout1_54 Vdout1_54ck83 = 0.9 time = 420
.meas tran vdout1_54ck83 FIND v(dout1_54) AT=420.025n

* CHECK dout1_55 Vdout1_55ck83 = 0.9 time = 420
.meas tran vdout1_55ck83 FIND v(dout1_55) AT=420.025n

* CHECK dout1_56 Vdout1_56ck83 = 0.9 time = 420
.meas tran vdout1_56ck83 FIND v(dout1_56) AT=420.025n

* CHECK dout1_57 Vdout1_57ck83 = 0 time = 420
.meas tran vdout1_57ck83 FIND v(dout1_57) AT=420.025n

* CHECK dout1_58 Vdout1_58ck83 = 0.9 time = 420
.meas tran vdout1_58ck83 FIND v(dout1_58) AT=420.025n

* CHECK dout1_59 Vdout1_59ck83 = 0.9 time = 420
.meas tran vdout1_59ck83 FIND v(dout1_59) AT=420.025n

* CHECK dout1_60 Vdout1_60ck83 = 0 time = 420
.meas tran vdout1_60ck83 FIND v(dout1_60) AT=420.025n

* CHECK dout1_61 Vdout1_61ck83 = 0 time = 420
.meas tran vdout1_61ck83 FIND v(dout1_61) AT=420.025n

* CHECK dout1_62 Vdout1_62ck83 = 0.9 time = 420
.meas tran vdout1_62ck83 FIND v(dout1_62) AT=420.025n

* CHECK dout1_63 Vdout1_63ck83 = 0 time = 420
.meas tran vdout1_63ck83 FIND v(dout1_63) AT=420.025n

* CHECK dout1_64 Vdout1_64ck83 = 0 time = 420
.meas tran vdout1_64ck83 FIND v(dout1_64) AT=420.025n

* CHECK dout1_65 Vdout1_65ck83 = 0 time = 420
.meas tran vdout1_65ck83 FIND v(dout1_65) AT=420.025n

* CHECK dout1_66 Vdout1_66ck83 = 0.9 time = 420
.meas tran vdout1_66ck83 FIND v(dout1_66) AT=420.025n

* CHECK dout1_67 Vdout1_67ck83 = 0 time = 420
.meas tran vdout1_67ck83 FIND v(dout1_67) AT=420.025n

* CHECK dout1_68 Vdout1_68ck83 = 0.9 time = 420
.meas tran vdout1_68ck83 FIND v(dout1_68) AT=420.025n

* CHECK dout1_69 Vdout1_69ck83 = 0.9 time = 420
.meas tran vdout1_69ck83 FIND v(dout1_69) AT=420.025n

* CHECK dout1_70 Vdout1_70ck83 = 0 time = 420
.meas tran vdout1_70ck83 FIND v(dout1_70) AT=420.025n

* CHECK dout1_71 Vdout1_71ck83 = 0.9 time = 420
.meas tran vdout1_71ck83 FIND v(dout1_71) AT=420.025n

* CHECK dout1_0 Vdout1_0ck88 = 0.9 time = 445
.meas tran vdout1_0ck88 FIND v(dout1_0) AT=445.025n

* CHECK dout1_1 Vdout1_1ck88 = 0 time = 445
.meas tran vdout1_1ck88 FIND v(dout1_1) AT=445.025n

* CHECK dout1_2 Vdout1_2ck88 = 0 time = 445
.meas tran vdout1_2ck88 FIND v(dout1_2) AT=445.025n

* CHECK dout1_3 Vdout1_3ck88 = 0 time = 445
.meas tran vdout1_3ck88 FIND v(dout1_3) AT=445.025n

* CHECK dout1_4 Vdout1_4ck88 = 0.9 time = 445
.meas tran vdout1_4ck88 FIND v(dout1_4) AT=445.025n

* CHECK dout1_5 Vdout1_5ck88 = 0 time = 445
.meas tran vdout1_5ck88 FIND v(dout1_5) AT=445.025n

* CHECK dout1_6 Vdout1_6ck88 = 0.9 time = 445
.meas tran vdout1_6ck88 FIND v(dout1_6) AT=445.025n

* CHECK dout1_7 Vdout1_7ck88 = 0.9 time = 445
.meas tran vdout1_7ck88 FIND v(dout1_7) AT=445.025n

* CHECK dout1_8 Vdout1_8ck88 = 0.9 time = 445
.meas tran vdout1_8ck88 FIND v(dout1_8) AT=445.025n

* CHECK dout1_9 Vdout1_9ck88 = 0.9 time = 445
.meas tran vdout1_9ck88 FIND v(dout1_9) AT=445.025n

* CHECK dout1_10 Vdout1_10ck88 = 0 time = 445
.meas tran vdout1_10ck88 FIND v(dout1_10) AT=445.025n

* CHECK dout1_11 Vdout1_11ck88 = 0 time = 445
.meas tran vdout1_11ck88 FIND v(dout1_11) AT=445.025n

* CHECK dout1_12 Vdout1_12ck88 = 0 time = 445
.meas tran vdout1_12ck88 FIND v(dout1_12) AT=445.025n

* CHECK dout1_13 Vdout1_13ck88 = 0 time = 445
.meas tran vdout1_13ck88 FIND v(dout1_13) AT=445.025n

* CHECK dout1_14 Vdout1_14ck88 = 0.9 time = 445
.meas tran vdout1_14ck88 FIND v(dout1_14) AT=445.025n

* CHECK dout1_15 Vdout1_15ck88 = 0 time = 445
.meas tran vdout1_15ck88 FIND v(dout1_15) AT=445.025n

* CHECK dout1_16 Vdout1_16ck88 = 0.9 time = 445
.meas tran vdout1_16ck88 FIND v(dout1_16) AT=445.025n

* CHECK dout1_17 Vdout1_17ck88 = 0.9 time = 445
.meas tran vdout1_17ck88 FIND v(dout1_17) AT=445.025n

* CHECK dout1_18 Vdout1_18ck88 = 0 time = 445
.meas tran vdout1_18ck88 FIND v(dout1_18) AT=445.025n

* CHECK dout1_19 Vdout1_19ck88 = 0 time = 445
.meas tran vdout1_19ck88 FIND v(dout1_19) AT=445.025n

* CHECK dout1_20 Vdout1_20ck88 = 0.9 time = 445
.meas tran vdout1_20ck88 FIND v(dout1_20) AT=445.025n

* CHECK dout1_21 Vdout1_21ck88 = 0 time = 445
.meas tran vdout1_21ck88 FIND v(dout1_21) AT=445.025n

* CHECK dout1_22 Vdout1_22ck88 = 0.9 time = 445
.meas tran vdout1_22ck88 FIND v(dout1_22) AT=445.025n

* CHECK dout1_23 Vdout1_23ck88 = 0.9 time = 445
.meas tran vdout1_23ck88 FIND v(dout1_23) AT=445.025n

* CHECK dout1_24 Vdout1_24ck88 = 0.9 time = 445
.meas tran vdout1_24ck88 FIND v(dout1_24) AT=445.025n

* CHECK dout1_25 Vdout1_25ck88 = 0 time = 445
.meas tran vdout1_25ck88 FIND v(dout1_25) AT=445.025n

* CHECK dout1_26 Vdout1_26ck88 = 0.9 time = 445
.meas tran vdout1_26ck88 FIND v(dout1_26) AT=445.025n

* CHECK dout1_27 Vdout1_27ck88 = 0.9 time = 445
.meas tran vdout1_27ck88 FIND v(dout1_27) AT=445.025n

* CHECK dout1_28 Vdout1_28ck88 = 0 time = 445
.meas tran vdout1_28ck88 FIND v(dout1_28) AT=445.025n

* CHECK dout1_29 Vdout1_29ck88 = 0 time = 445
.meas tran vdout1_29ck88 FIND v(dout1_29) AT=445.025n

* CHECK dout1_30 Vdout1_30ck88 = 0 time = 445
.meas tran vdout1_30ck88 FIND v(dout1_30) AT=445.025n

* CHECK dout1_31 Vdout1_31ck88 = 0.9 time = 445
.meas tran vdout1_31ck88 FIND v(dout1_31) AT=445.025n

* CHECK dout1_32 Vdout1_32ck88 = 0.9 time = 445
.meas tran vdout1_32ck88 FIND v(dout1_32) AT=445.025n

* CHECK dout1_33 Vdout1_33ck88 = 0.9 time = 445
.meas tran vdout1_33ck88 FIND v(dout1_33) AT=445.025n

* CHECK dout1_34 Vdout1_34ck88 = 0 time = 445
.meas tran vdout1_34ck88 FIND v(dout1_34) AT=445.025n

* CHECK dout1_35 Vdout1_35ck88 = 0.9 time = 445
.meas tran vdout1_35ck88 FIND v(dout1_35) AT=445.025n

* CHECK dout1_36 Vdout1_36ck88 = 0 time = 445
.meas tran vdout1_36ck88 FIND v(dout1_36) AT=445.025n

* CHECK dout1_37 Vdout1_37ck88 = 0.9 time = 445
.meas tran vdout1_37ck88 FIND v(dout1_37) AT=445.025n

* CHECK dout1_38 Vdout1_38ck88 = 0.9 time = 445
.meas tran vdout1_38ck88 FIND v(dout1_38) AT=445.025n

* CHECK dout1_39 Vdout1_39ck88 = 0 time = 445
.meas tran vdout1_39ck88 FIND v(dout1_39) AT=445.025n

* CHECK dout1_40 Vdout1_40ck88 = 0.9 time = 445
.meas tran vdout1_40ck88 FIND v(dout1_40) AT=445.025n

* CHECK dout1_41 Vdout1_41ck88 = 0 time = 445
.meas tran vdout1_41ck88 FIND v(dout1_41) AT=445.025n

* CHECK dout1_42 Vdout1_42ck88 = 0.9 time = 445
.meas tran vdout1_42ck88 FIND v(dout1_42) AT=445.025n

* CHECK dout1_43 Vdout1_43ck88 = 0 time = 445
.meas tran vdout1_43ck88 FIND v(dout1_43) AT=445.025n

* CHECK dout1_44 Vdout1_44ck88 = 0 time = 445
.meas tran vdout1_44ck88 FIND v(dout1_44) AT=445.025n

* CHECK dout1_45 Vdout1_45ck88 = 0.9 time = 445
.meas tran vdout1_45ck88 FIND v(dout1_45) AT=445.025n

* CHECK dout1_46 Vdout1_46ck88 = 0.9 time = 445
.meas tran vdout1_46ck88 FIND v(dout1_46) AT=445.025n

* CHECK dout1_47 Vdout1_47ck88 = 0.9 time = 445
.meas tran vdout1_47ck88 FIND v(dout1_47) AT=445.025n

* CHECK dout1_48 Vdout1_48ck88 = 0.9 time = 445
.meas tran vdout1_48ck88 FIND v(dout1_48) AT=445.025n

* CHECK dout1_49 Vdout1_49ck88 = 0 time = 445
.meas tran vdout1_49ck88 FIND v(dout1_49) AT=445.025n

* CHECK dout1_50 Vdout1_50ck88 = 0 time = 445
.meas tran vdout1_50ck88 FIND v(dout1_50) AT=445.025n

* CHECK dout1_51 Vdout1_51ck88 = 0 time = 445
.meas tran vdout1_51ck88 FIND v(dout1_51) AT=445.025n

* CHECK dout1_52 Vdout1_52ck88 = 0.9 time = 445
.meas tran vdout1_52ck88 FIND v(dout1_52) AT=445.025n

* CHECK dout1_53 Vdout1_53ck88 = 0 time = 445
.meas tran vdout1_53ck88 FIND v(dout1_53) AT=445.025n

* CHECK dout1_54 Vdout1_54ck88 = 0.9 time = 445
.meas tran vdout1_54ck88 FIND v(dout1_54) AT=445.025n

* CHECK dout1_55 Vdout1_55ck88 = 0 time = 445
.meas tran vdout1_55ck88 FIND v(dout1_55) AT=445.025n

* CHECK dout1_56 Vdout1_56ck88 = 0 time = 445
.meas tran vdout1_56ck88 FIND v(dout1_56) AT=445.025n

* CHECK dout1_57 Vdout1_57ck88 = 0 time = 445
.meas tran vdout1_57ck88 FIND v(dout1_57) AT=445.025n

* CHECK dout1_58 Vdout1_58ck88 = 0.9 time = 445
.meas tran vdout1_58ck88 FIND v(dout1_58) AT=445.025n

* CHECK dout1_59 Vdout1_59ck88 = 0.9 time = 445
.meas tran vdout1_59ck88 FIND v(dout1_59) AT=445.025n

* CHECK dout1_60 Vdout1_60ck88 = 0.9 time = 445
.meas tran vdout1_60ck88 FIND v(dout1_60) AT=445.025n

* CHECK dout1_61 Vdout1_61ck88 = 0 time = 445
.meas tran vdout1_61ck88 FIND v(dout1_61) AT=445.025n

* CHECK dout1_62 Vdout1_62ck88 = 0.9 time = 445
.meas tran vdout1_62ck88 FIND v(dout1_62) AT=445.025n

* CHECK dout1_63 Vdout1_63ck88 = 0 time = 445
.meas tran vdout1_63ck88 FIND v(dout1_63) AT=445.025n

* CHECK dout1_64 Vdout1_64ck88 = 0 time = 445
.meas tran vdout1_64ck88 FIND v(dout1_64) AT=445.025n

* CHECK dout1_65 Vdout1_65ck88 = 0.9 time = 445
.meas tran vdout1_65ck88 FIND v(dout1_65) AT=445.025n

* CHECK dout1_66 Vdout1_66ck88 = 0.9 time = 445
.meas tran vdout1_66ck88 FIND v(dout1_66) AT=445.025n

* CHECK dout1_67 Vdout1_67ck88 = 0 time = 445
.meas tran vdout1_67ck88 FIND v(dout1_67) AT=445.025n

* CHECK dout1_68 Vdout1_68ck88 = 0.9 time = 445
.meas tran vdout1_68ck88 FIND v(dout1_68) AT=445.025n

* CHECK dout1_69 Vdout1_69ck88 = 0 time = 445
.meas tran vdout1_69ck88 FIND v(dout1_69) AT=445.025n

* CHECK dout1_70 Vdout1_70ck88 = 0.9 time = 445
.meas tran vdout1_70ck88 FIND v(dout1_70) AT=445.025n

* CHECK dout1_71 Vdout1_71ck88 = 0.9 time = 445
.meas tran vdout1_71ck88 FIND v(dout1_71) AT=445.025n

* CHECK dout1_0 Vdout1_0ck92 = 0 time = 465
.meas tran vdout1_0ck92 FIND v(dout1_0) AT=465.025n

* CHECK dout1_1 Vdout1_1ck92 = 0.9 time = 465
.meas tran vdout1_1ck92 FIND v(dout1_1) AT=465.025n

* CHECK dout1_2 Vdout1_2ck92 = 0.9 time = 465
.meas tran vdout1_2ck92 FIND v(dout1_2) AT=465.025n

* CHECK dout1_3 Vdout1_3ck92 = 0 time = 465
.meas tran vdout1_3ck92 FIND v(dout1_3) AT=465.025n

* CHECK dout1_4 Vdout1_4ck92 = 0.9 time = 465
.meas tran vdout1_4ck92 FIND v(dout1_4) AT=465.025n

* CHECK dout1_5 Vdout1_5ck92 = 0.9 time = 465
.meas tran vdout1_5ck92 FIND v(dout1_5) AT=465.025n

* CHECK dout1_6 Vdout1_6ck92 = 0 time = 465
.meas tran vdout1_6ck92 FIND v(dout1_6) AT=465.025n

* CHECK dout1_7 Vdout1_7ck92 = 0.9 time = 465
.meas tran vdout1_7ck92 FIND v(dout1_7) AT=465.025n

* CHECK dout1_8 Vdout1_8ck92 = 0 time = 465
.meas tran vdout1_8ck92 FIND v(dout1_8) AT=465.025n

* CHECK dout1_9 Vdout1_9ck92 = 0 time = 465
.meas tran vdout1_9ck92 FIND v(dout1_9) AT=465.025n

* CHECK dout1_10 Vdout1_10ck92 = 0.9 time = 465
.meas tran vdout1_10ck92 FIND v(dout1_10) AT=465.025n

* CHECK dout1_11 Vdout1_11ck92 = 0 time = 465
.meas tran vdout1_11ck92 FIND v(dout1_11) AT=465.025n

* CHECK dout1_12 Vdout1_12ck92 = 0.9 time = 465
.meas tran vdout1_12ck92 FIND v(dout1_12) AT=465.025n

* CHECK dout1_13 Vdout1_13ck92 = 0 time = 465
.meas tran vdout1_13ck92 FIND v(dout1_13) AT=465.025n

* CHECK dout1_14 Vdout1_14ck92 = 0.9 time = 465
.meas tran vdout1_14ck92 FIND v(dout1_14) AT=465.025n

* CHECK dout1_15 Vdout1_15ck92 = 0.9 time = 465
.meas tran vdout1_15ck92 FIND v(dout1_15) AT=465.025n

* CHECK dout1_16 Vdout1_16ck92 = 0 time = 465
.meas tran vdout1_16ck92 FIND v(dout1_16) AT=465.025n

* CHECK dout1_17 Vdout1_17ck92 = 0.9 time = 465
.meas tran vdout1_17ck92 FIND v(dout1_17) AT=465.025n

* CHECK dout1_18 Vdout1_18ck92 = 0.9 time = 465
.meas tran vdout1_18ck92 FIND v(dout1_18) AT=465.025n

* CHECK dout1_19 Vdout1_19ck92 = 0.9 time = 465
.meas tran vdout1_19ck92 FIND v(dout1_19) AT=465.025n

* CHECK dout1_20 Vdout1_20ck92 = 0 time = 465
.meas tran vdout1_20ck92 FIND v(dout1_20) AT=465.025n

* CHECK dout1_21 Vdout1_21ck92 = 0.9 time = 465
.meas tran vdout1_21ck92 FIND v(dout1_21) AT=465.025n

* CHECK dout1_22 Vdout1_22ck92 = 0 time = 465
.meas tran vdout1_22ck92 FIND v(dout1_22) AT=465.025n

* CHECK dout1_23 Vdout1_23ck92 = 0.9 time = 465
.meas tran vdout1_23ck92 FIND v(dout1_23) AT=465.025n

* CHECK dout1_24 Vdout1_24ck92 = 0 time = 465
.meas tran vdout1_24ck92 FIND v(dout1_24) AT=465.025n

* CHECK dout1_25 Vdout1_25ck92 = 0 time = 465
.meas tran vdout1_25ck92 FIND v(dout1_25) AT=465.025n

* CHECK dout1_26 Vdout1_26ck92 = 0.9 time = 465
.meas tran vdout1_26ck92 FIND v(dout1_26) AT=465.025n

* CHECK dout1_27 Vdout1_27ck92 = 0.9 time = 465
.meas tran vdout1_27ck92 FIND v(dout1_27) AT=465.025n

* CHECK dout1_28 Vdout1_28ck92 = 0 time = 465
.meas tran vdout1_28ck92 FIND v(dout1_28) AT=465.025n

* CHECK dout1_29 Vdout1_29ck92 = 0 time = 465
.meas tran vdout1_29ck92 FIND v(dout1_29) AT=465.025n

* CHECK dout1_30 Vdout1_30ck92 = 0.9 time = 465
.meas tran vdout1_30ck92 FIND v(dout1_30) AT=465.025n

* CHECK dout1_31 Vdout1_31ck92 = 0 time = 465
.meas tran vdout1_31ck92 FIND v(dout1_31) AT=465.025n

* CHECK dout1_32 Vdout1_32ck92 = 0.9 time = 465
.meas tran vdout1_32ck92 FIND v(dout1_32) AT=465.025n

* CHECK dout1_33 Vdout1_33ck92 = 0 time = 465
.meas tran vdout1_33ck92 FIND v(dout1_33) AT=465.025n

* CHECK dout1_34 Vdout1_34ck92 = 0 time = 465
.meas tran vdout1_34ck92 FIND v(dout1_34) AT=465.025n

* CHECK dout1_35 Vdout1_35ck92 = 0 time = 465
.meas tran vdout1_35ck92 FIND v(dout1_35) AT=465.025n

* CHECK dout1_36 Vdout1_36ck92 = 0.9 time = 465
.meas tran vdout1_36ck92 FIND v(dout1_36) AT=465.025n

* CHECK dout1_37 Vdout1_37ck92 = 0 time = 465
.meas tran vdout1_37ck92 FIND v(dout1_37) AT=465.025n

* CHECK dout1_38 Vdout1_38ck92 = 0.9 time = 465
.meas tran vdout1_38ck92 FIND v(dout1_38) AT=465.025n

* CHECK dout1_39 Vdout1_39ck92 = 0.9 time = 465
.meas tran vdout1_39ck92 FIND v(dout1_39) AT=465.025n

* CHECK dout1_40 Vdout1_40ck92 = 0 time = 465
.meas tran vdout1_40ck92 FIND v(dout1_40) AT=465.025n

* CHECK dout1_41 Vdout1_41ck92 = 0 time = 465
.meas tran vdout1_41ck92 FIND v(dout1_41) AT=465.025n

* CHECK dout1_42 Vdout1_42ck92 = 0.9 time = 465
.meas tran vdout1_42ck92 FIND v(dout1_42) AT=465.025n

* CHECK dout1_43 Vdout1_43ck92 = 0 time = 465
.meas tran vdout1_43ck92 FIND v(dout1_43) AT=465.025n

* CHECK dout1_44 Vdout1_44ck92 = 0 time = 465
.meas tran vdout1_44ck92 FIND v(dout1_44) AT=465.025n

* CHECK dout1_45 Vdout1_45ck92 = 0 time = 465
.meas tran vdout1_45ck92 FIND v(dout1_45) AT=465.025n

* CHECK dout1_46 Vdout1_46ck92 = 0 time = 465
.meas tran vdout1_46ck92 FIND v(dout1_46) AT=465.025n

* CHECK dout1_47 Vdout1_47ck92 = 0.9 time = 465
.meas tran vdout1_47ck92 FIND v(dout1_47) AT=465.025n

* CHECK dout1_48 Vdout1_48ck92 = 0.9 time = 465
.meas tran vdout1_48ck92 FIND v(dout1_48) AT=465.025n

* CHECK dout1_49 Vdout1_49ck92 = 0.9 time = 465
.meas tran vdout1_49ck92 FIND v(dout1_49) AT=465.025n

* CHECK dout1_50 Vdout1_50ck92 = 0.9 time = 465
.meas tran vdout1_50ck92 FIND v(dout1_50) AT=465.025n

* CHECK dout1_51 Vdout1_51ck92 = 0 time = 465
.meas tran vdout1_51ck92 FIND v(dout1_51) AT=465.025n

* CHECK dout1_52 Vdout1_52ck92 = 0.9 time = 465
.meas tran vdout1_52ck92 FIND v(dout1_52) AT=465.025n

* CHECK dout1_53 Vdout1_53ck92 = 0.9 time = 465
.meas tran vdout1_53ck92 FIND v(dout1_53) AT=465.025n

* CHECK dout1_54 Vdout1_54ck92 = 0.9 time = 465
.meas tran vdout1_54ck92 FIND v(dout1_54) AT=465.025n

* CHECK dout1_55 Vdout1_55ck92 = 0 time = 465
.meas tran vdout1_55ck92 FIND v(dout1_55) AT=465.025n

* CHECK dout1_56 Vdout1_56ck92 = 0.9 time = 465
.meas tran vdout1_56ck92 FIND v(dout1_56) AT=465.025n

* CHECK dout1_57 Vdout1_57ck92 = 0 time = 465
.meas tran vdout1_57ck92 FIND v(dout1_57) AT=465.025n

* CHECK dout1_58 Vdout1_58ck92 = 0 time = 465
.meas tran vdout1_58ck92 FIND v(dout1_58) AT=465.025n

* CHECK dout1_59 Vdout1_59ck92 = 0.9 time = 465
.meas tran vdout1_59ck92 FIND v(dout1_59) AT=465.025n

* CHECK dout1_60 Vdout1_60ck92 = 0 time = 465
.meas tran vdout1_60ck92 FIND v(dout1_60) AT=465.025n

* CHECK dout1_61 Vdout1_61ck92 = 0.9 time = 465
.meas tran vdout1_61ck92 FIND v(dout1_61) AT=465.025n

* CHECK dout1_62 Vdout1_62ck92 = 0.9 time = 465
.meas tran vdout1_62ck92 FIND v(dout1_62) AT=465.025n

* CHECK dout1_63 Vdout1_63ck92 = 0 time = 465
.meas tran vdout1_63ck92 FIND v(dout1_63) AT=465.025n

* CHECK dout1_64 Vdout1_64ck92 = 0.9 time = 465
.meas tran vdout1_64ck92 FIND v(dout1_64) AT=465.025n

* CHECK dout1_65 Vdout1_65ck92 = 0 time = 465
.meas tran vdout1_65ck92 FIND v(dout1_65) AT=465.025n

* CHECK dout1_66 Vdout1_66ck92 = 0.9 time = 465
.meas tran vdout1_66ck92 FIND v(dout1_66) AT=465.025n

* CHECK dout1_67 Vdout1_67ck92 = 0.9 time = 465
.meas tran vdout1_67ck92 FIND v(dout1_67) AT=465.025n

* CHECK dout1_68 Vdout1_68ck92 = 0.9 time = 465
.meas tran vdout1_68ck92 FIND v(dout1_68) AT=465.025n

* CHECK dout1_69 Vdout1_69ck92 = 0.9 time = 465
.meas tran vdout1_69ck92 FIND v(dout1_69) AT=465.025n

* CHECK dout1_70 Vdout1_70ck92 = 0 time = 465
.meas tran vdout1_70ck92 FIND v(dout1_70) AT=465.025n

* CHECK dout1_71 Vdout1_71ck92 = 0.9 time = 465
.meas tran vdout1_71ck92 FIND v(dout1_71) AT=465.025n

* CHECK dout1_0 Vdout1_0ck93 = 0 time = 470
.meas tran vdout1_0ck93 FIND v(dout1_0) AT=470.025n

* CHECK dout1_1 Vdout1_1ck93 = 0 time = 470
.meas tran vdout1_1ck93 FIND v(dout1_1) AT=470.025n

* CHECK dout1_2 Vdout1_2ck93 = 0 time = 470
.meas tran vdout1_2ck93 FIND v(dout1_2) AT=470.025n

* CHECK dout1_3 Vdout1_3ck93 = 0 time = 470
.meas tran vdout1_3ck93 FIND v(dout1_3) AT=470.025n

* CHECK dout1_4 Vdout1_4ck93 = 0 time = 470
.meas tran vdout1_4ck93 FIND v(dout1_4) AT=470.025n

* CHECK dout1_5 Vdout1_5ck93 = 0 time = 470
.meas tran vdout1_5ck93 FIND v(dout1_5) AT=470.025n

* CHECK dout1_6 Vdout1_6ck93 = 0.9 time = 470
.meas tran vdout1_6ck93 FIND v(dout1_6) AT=470.025n

* CHECK dout1_7 Vdout1_7ck93 = 0.9 time = 470
.meas tran vdout1_7ck93 FIND v(dout1_7) AT=470.025n

* CHECK dout1_8 Vdout1_8ck93 = 0 time = 470
.meas tran vdout1_8ck93 FIND v(dout1_8) AT=470.025n

* CHECK dout1_9 Vdout1_9ck93 = 0.9 time = 470
.meas tran vdout1_9ck93 FIND v(dout1_9) AT=470.025n

* CHECK dout1_10 Vdout1_10ck93 = 0 time = 470
.meas tran vdout1_10ck93 FIND v(dout1_10) AT=470.025n

* CHECK dout1_11 Vdout1_11ck93 = 0 time = 470
.meas tran vdout1_11ck93 FIND v(dout1_11) AT=470.025n

* CHECK dout1_12 Vdout1_12ck93 = 0.9 time = 470
.meas tran vdout1_12ck93 FIND v(dout1_12) AT=470.025n

* CHECK dout1_13 Vdout1_13ck93 = 0 time = 470
.meas tran vdout1_13ck93 FIND v(dout1_13) AT=470.025n

* CHECK dout1_14 Vdout1_14ck93 = 0.9 time = 470
.meas tran vdout1_14ck93 FIND v(dout1_14) AT=470.025n

* CHECK dout1_15 Vdout1_15ck93 = 0 time = 470
.meas tran vdout1_15ck93 FIND v(dout1_15) AT=470.025n

* CHECK dout1_16 Vdout1_16ck93 = 0.9 time = 470
.meas tran vdout1_16ck93 FIND v(dout1_16) AT=470.025n

* CHECK dout1_17 Vdout1_17ck93 = 0 time = 470
.meas tran vdout1_17ck93 FIND v(dout1_17) AT=470.025n

* CHECK dout1_18 Vdout1_18ck93 = 0.9 time = 470
.meas tran vdout1_18ck93 FIND v(dout1_18) AT=470.025n

* CHECK dout1_19 Vdout1_19ck93 = 0.9 time = 470
.meas tran vdout1_19ck93 FIND v(dout1_19) AT=470.025n

* CHECK dout1_20 Vdout1_20ck93 = 0 time = 470
.meas tran vdout1_20ck93 FIND v(dout1_20) AT=470.025n

* CHECK dout1_21 Vdout1_21ck93 = 0.9 time = 470
.meas tran vdout1_21ck93 FIND v(dout1_21) AT=470.025n

* CHECK dout1_22 Vdout1_22ck93 = 0 time = 470
.meas tran vdout1_22ck93 FIND v(dout1_22) AT=470.025n

* CHECK dout1_23 Vdout1_23ck93 = 0 time = 470
.meas tran vdout1_23ck93 FIND v(dout1_23) AT=470.025n

* CHECK dout1_24 Vdout1_24ck93 = 0 time = 470
.meas tran vdout1_24ck93 FIND v(dout1_24) AT=470.025n

* CHECK dout1_25 Vdout1_25ck93 = 0.9 time = 470
.meas tran vdout1_25ck93 FIND v(dout1_25) AT=470.025n

* CHECK dout1_26 Vdout1_26ck93 = 0 time = 470
.meas tran vdout1_26ck93 FIND v(dout1_26) AT=470.025n

* CHECK dout1_27 Vdout1_27ck93 = 0.9 time = 470
.meas tran vdout1_27ck93 FIND v(dout1_27) AT=470.025n

* CHECK dout1_28 Vdout1_28ck93 = 0 time = 470
.meas tran vdout1_28ck93 FIND v(dout1_28) AT=470.025n

* CHECK dout1_29 Vdout1_29ck93 = 0 time = 470
.meas tran vdout1_29ck93 FIND v(dout1_29) AT=470.025n

* CHECK dout1_30 Vdout1_30ck93 = 0 time = 470
.meas tran vdout1_30ck93 FIND v(dout1_30) AT=470.025n

* CHECK dout1_31 Vdout1_31ck93 = 0 time = 470
.meas tran vdout1_31ck93 FIND v(dout1_31) AT=470.025n

* CHECK dout1_32 Vdout1_32ck93 = 0 time = 470
.meas tran vdout1_32ck93 FIND v(dout1_32) AT=470.025n

* CHECK dout1_33 Vdout1_33ck93 = 0 time = 470
.meas tran vdout1_33ck93 FIND v(dout1_33) AT=470.025n

* CHECK dout1_34 Vdout1_34ck93 = 0 time = 470
.meas tran vdout1_34ck93 FIND v(dout1_34) AT=470.025n

* CHECK dout1_35 Vdout1_35ck93 = 0.9 time = 470
.meas tran vdout1_35ck93 FIND v(dout1_35) AT=470.025n

* CHECK dout1_36 Vdout1_36ck93 = 0 time = 470
.meas tran vdout1_36ck93 FIND v(dout1_36) AT=470.025n

* CHECK dout1_37 Vdout1_37ck93 = 0.9 time = 470
.meas tran vdout1_37ck93 FIND v(dout1_37) AT=470.025n

* CHECK dout1_38 Vdout1_38ck93 = 0 time = 470
.meas tran vdout1_38ck93 FIND v(dout1_38) AT=470.025n

* CHECK dout1_39 Vdout1_39ck93 = 0 time = 470
.meas tran vdout1_39ck93 FIND v(dout1_39) AT=470.025n

* CHECK dout1_40 Vdout1_40ck93 = 0 time = 470
.meas tran vdout1_40ck93 FIND v(dout1_40) AT=470.025n

* CHECK dout1_41 Vdout1_41ck93 = 0.9 time = 470
.meas tran vdout1_41ck93 FIND v(dout1_41) AT=470.025n

* CHECK dout1_42 Vdout1_42ck93 = 0.9 time = 470
.meas tran vdout1_42ck93 FIND v(dout1_42) AT=470.025n

* CHECK dout1_43 Vdout1_43ck93 = 0 time = 470
.meas tran vdout1_43ck93 FIND v(dout1_43) AT=470.025n

* CHECK dout1_44 Vdout1_44ck93 = 0 time = 470
.meas tran vdout1_44ck93 FIND v(dout1_44) AT=470.025n

* CHECK dout1_45 Vdout1_45ck93 = 0 time = 470
.meas tran vdout1_45ck93 FIND v(dout1_45) AT=470.025n

* CHECK dout1_46 Vdout1_46ck93 = 0 time = 470
.meas tran vdout1_46ck93 FIND v(dout1_46) AT=470.025n

* CHECK dout1_47 Vdout1_47ck93 = 0 time = 470
.meas tran vdout1_47ck93 FIND v(dout1_47) AT=470.025n

* CHECK dout1_48 Vdout1_48ck93 = 0 time = 470
.meas tran vdout1_48ck93 FIND v(dout1_48) AT=470.025n

* CHECK dout1_49 Vdout1_49ck93 = 0 time = 470
.meas tran vdout1_49ck93 FIND v(dout1_49) AT=470.025n

* CHECK dout1_50 Vdout1_50ck93 = 0.9 time = 470
.meas tran vdout1_50ck93 FIND v(dout1_50) AT=470.025n

* CHECK dout1_51 Vdout1_51ck93 = 0 time = 470
.meas tran vdout1_51ck93 FIND v(dout1_51) AT=470.025n

* CHECK dout1_52 Vdout1_52ck93 = 0 time = 470
.meas tran vdout1_52ck93 FIND v(dout1_52) AT=470.025n

* CHECK dout1_53 Vdout1_53ck93 = 0.9 time = 470
.meas tran vdout1_53ck93 FIND v(dout1_53) AT=470.025n

* CHECK dout1_54 Vdout1_54ck93 = 0.9 time = 470
.meas tran vdout1_54ck93 FIND v(dout1_54) AT=470.025n

* CHECK dout1_55 Vdout1_55ck93 = 0.9 time = 470
.meas tran vdout1_55ck93 FIND v(dout1_55) AT=470.025n

* CHECK dout1_56 Vdout1_56ck93 = 0 time = 470
.meas tran vdout1_56ck93 FIND v(dout1_56) AT=470.025n

* CHECK dout1_57 Vdout1_57ck93 = 0.9 time = 470
.meas tran vdout1_57ck93 FIND v(dout1_57) AT=470.025n

* CHECK dout1_58 Vdout1_58ck93 = 0.9 time = 470
.meas tran vdout1_58ck93 FIND v(dout1_58) AT=470.025n

* CHECK dout1_59 Vdout1_59ck93 = 0 time = 470
.meas tran vdout1_59ck93 FIND v(dout1_59) AT=470.025n

* CHECK dout1_60 Vdout1_60ck93 = 0.9 time = 470
.meas tran vdout1_60ck93 FIND v(dout1_60) AT=470.025n

* CHECK dout1_61 Vdout1_61ck93 = 0.9 time = 470
.meas tran vdout1_61ck93 FIND v(dout1_61) AT=470.025n

* CHECK dout1_62 Vdout1_62ck93 = 0.9 time = 470
.meas tran vdout1_62ck93 FIND v(dout1_62) AT=470.025n

* CHECK dout1_63 Vdout1_63ck93 = 0 time = 470
.meas tran vdout1_63ck93 FIND v(dout1_63) AT=470.025n

* CHECK dout1_64 Vdout1_64ck93 = 0 time = 470
.meas tran vdout1_64ck93 FIND v(dout1_64) AT=470.025n

* CHECK dout1_65 Vdout1_65ck93 = 0.9 time = 470
.meas tran vdout1_65ck93 FIND v(dout1_65) AT=470.025n

* CHECK dout1_66 Vdout1_66ck93 = 0.9 time = 470
.meas tran vdout1_66ck93 FIND v(dout1_66) AT=470.025n

* CHECK dout1_67 Vdout1_67ck93 = 0 time = 470
.meas tran vdout1_67ck93 FIND v(dout1_67) AT=470.025n

* CHECK dout1_68 Vdout1_68ck93 = 0.9 time = 470
.meas tran vdout1_68ck93 FIND v(dout1_68) AT=470.025n

* CHECK dout1_69 Vdout1_69ck93 = 0.9 time = 470
.meas tran vdout1_69ck93 FIND v(dout1_69) AT=470.025n

* CHECK dout1_70 Vdout1_70ck93 = 0 time = 470
.meas tran vdout1_70ck93 FIND v(dout1_70) AT=470.025n

* CHECK dout1_71 Vdout1_71ck93 = 0 time = 470
.meas tran vdout1_71ck93 FIND v(dout1_71) AT=470.025n

* CHECK dout1_0 Vdout1_0ck97 = 0 time = 490
.meas tran vdout1_0ck97 FIND v(dout1_0) AT=490.025n

* CHECK dout1_1 Vdout1_1ck97 = 0 time = 490
.meas tran vdout1_1ck97 FIND v(dout1_1) AT=490.025n

* CHECK dout1_2 Vdout1_2ck97 = 0 time = 490
.meas tran vdout1_2ck97 FIND v(dout1_2) AT=490.025n

* CHECK dout1_3 Vdout1_3ck97 = 0 time = 490
.meas tran vdout1_3ck97 FIND v(dout1_3) AT=490.025n

* CHECK dout1_4 Vdout1_4ck97 = 0 time = 490
.meas tran vdout1_4ck97 FIND v(dout1_4) AT=490.025n

* CHECK dout1_5 Vdout1_5ck97 = 0 time = 490
.meas tran vdout1_5ck97 FIND v(dout1_5) AT=490.025n

* CHECK dout1_6 Vdout1_6ck97 = 0.9 time = 490
.meas tran vdout1_6ck97 FIND v(dout1_6) AT=490.025n

* CHECK dout1_7 Vdout1_7ck97 = 0.9 time = 490
.meas tran vdout1_7ck97 FIND v(dout1_7) AT=490.025n

* CHECK dout1_8 Vdout1_8ck97 = 0 time = 490
.meas tran vdout1_8ck97 FIND v(dout1_8) AT=490.025n

* CHECK dout1_9 Vdout1_9ck97 = 0.9 time = 490
.meas tran vdout1_9ck97 FIND v(dout1_9) AT=490.025n

* CHECK dout1_10 Vdout1_10ck97 = 0 time = 490
.meas tran vdout1_10ck97 FIND v(dout1_10) AT=490.025n

* CHECK dout1_11 Vdout1_11ck97 = 0 time = 490
.meas tran vdout1_11ck97 FIND v(dout1_11) AT=490.025n

* CHECK dout1_12 Vdout1_12ck97 = 0.9 time = 490
.meas tran vdout1_12ck97 FIND v(dout1_12) AT=490.025n

* CHECK dout1_13 Vdout1_13ck97 = 0 time = 490
.meas tran vdout1_13ck97 FIND v(dout1_13) AT=490.025n

* CHECK dout1_14 Vdout1_14ck97 = 0.9 time = 490
.meas tran vdout1_14ck97 FIND v(dout1_14) AT=490.025n

* CHECK dout1_15 Vdout1_15ck97 = 0 time = 490
.meas tran vdout1_15ck97 FIND v(dout1_15) AT=490.025n

* CHECK dout1_16 Vdout1_16ck97 = 0.9 time = 490
.meas tran vdout1_16ck97 FIND v(dout1_16) AT=490.025n

* CHECK dout1_17 Vdout1_17ck97 = 0 time = 490
.meas tran vdout1_17ck97 FIND v(dout1_17) AT=490.025n

* CHECK dout1_18 Vdout1_18ck97 = 0.9 time = 490
.meas tran vdout1_18ck97 FIND v(dout1_18) AT=490.025n

* CHECK dout1_19 Vdout1_19ck97 = 0.9 time = 490
.meas tran vdout1_19ck97 FIND v(dout1_19) AT=490.025n

* CHECK dout1_20 Vdout1_20ck97 = 0 time = 490
.meas tran vdout1_20ck97 FIND v(dout1_20) AT=490.025n

* CHECK dout1_21 Vdout1_21ck97 = 0.9 time = 490
.meas tran vdout1_21ck97 FIND v(dout1_21) AT=490.025n

* CHECK dout1_22 Vdout1_22ck97 = 0 time = 490
.meas tran vdout1_22ck97 FIND v(dout1_22) AT=490.025n

* CHECK dout1_23 Vdout1_23ck97 = 0 time = 490
.meas tran vdout1_23ck97 FIND v(dout1_23) AT=490.025n

* CHECK dout1_24 Vdout1_24ck97 = 0 time = 490
.meas tran vdout1_24ck97 FIND v(dout1_24) AT=490.025n

* CHECK dout1_25 Vdout1_25ck97 = 0.9 time = 490
.meas tran vdout1_25ck97 FIND v(dout1_25) AT=490.025n

* CHECK dout1_26 Vdout1_26ck97 = 0 time = 490
.meas tran vdout1_26ck97 FIND v(dout1_26) AT=490.025n

* CHECK dout1_27 Vdout1_27ck97 = 0.9 time = 490
.meas tran vdout1_27ck97 FIND v(dout1_27) AT=490.025n

* CHECK dout1_28 Vdout1_28ck97 = 0 time = 490
.meas tran vdout1_28ck97 FIND v(dout1_28) AT=490.025n

* CHECK dout1_29 Vdout1_29ck97 = 0 time = 490
.meas tran vdout1_29ck97 FIND v(dout1_29) AT=490.025n

* CHECK dout1_30 Vdout1_30ck97 = 0 time = 490
.meas tran vdout1_30ck97 FIND v(dout1_30) AT=490.025n

* CHECK dout1_31 Vdout1_31ck97 = 0 time = 490
.meas tran vdout1_31ck97 FIND v(dout1_31) AT=490.025n

* CHECK dout1_32 Vdout1_32ck97 = 0 time = 490
.meas tran vdout1_32ck97 FIND v(dout1_32) AT=490.025n

* CHECK dout1_33 Vdout1_33ck97 = 0 time = 490
.meas tran vdout1_33ck97 FIND v(dout1_33) AT=490.025n

* CHECK dout1_34 Vdout1_34ck97 = 0 time = 490
.meas tran vdout1_34ck97 FIND v(dout1_34) AT=490.025n

* CHECK dout1_35 Vdout1_35ck97 = 0.9 time = 490
.meas tran vdout1_35ck97 FIND v(dout1_35) AT=490.025n

* CHECK dout1_36 Vdout1_36ck97 = 0 time = 490
.meas tran vdout1_36ck97 FIND v(dout1_36) AT=490.025n

* CHECK dout1_37 Vdout1_37ck97 = 0.9 time = 490
.meas tran vdout1_37ck97 FIND v(dout1_37) AT=490.025n

* CHECK dout1_38 Vdout1_38ck97 = 0 time = 490
.meas tran vdout1_38ck97 FIND v(dout1_38) AT=490.025n

* CHECK dout1_39 Vdout1_39ck97 = 0 time = 490
.meas tran vdout1_39ck97 FIND v(dout1_39) AT=490.025n

* CHECK dout1_40 Vdout1_40ck97 = 0 time = 490
.meas tran vdout1_40ck97 FIND v(dout1_40) AT=490.025n

* CHECK dout1_41 Vdout1_41ck97 = 0.9 time = 490
.meas tran vdout1_41ck97 FIND v(dout1_41) AT=490.025n

* CHECK dout1_42 Vdout1_42ck97 = 0.9 time = 490
.meas tran vdout1_42ck97 FIND v(dout1_42) AT=490.025n

* CHECK dout1_43 Vdout1_43ck97 = 0 time = 490
.meas tran vdout1_43ck97 FIND v(dout1_43) AT=490.025n

* CHECK dout1_44 Vdout1_44ck97 = 0 time = 490
.meas tran vdout1_44ck97 FIND v(dout1_44) AT=490.025n

* CHECK dout1_45 Vdout1_45ck97 = 0 time = 490
.meas tran vdout1_45ck97 FIND v(dout1_45) AT=490.025n

* CHECK dout1_46 Vdout1_46ck97 = 0 time = 490
.meas tran vdout1_46ck97 FIND v(dout1_46) AT=490.025n

* CHECK dout1_47 Vdout1_47ck97 = 0 time = 490
.meas tran vdout1_47ck97 FIND v(dout1_47) AT=490.025n

* CHECK dout1_48 Vdout1_48ck97 = 0 time = 490
.meas tran vdout1_48ck97 FIND v(dout1_48) AT=490.025n

* CHECK dout1_49 Vdout1_49ck97 = 0 time = 490
.meas tran vdout1_49ck97 FIND v(dout1_49) AT=490.025n

* CHECK dout1_50 Vdout1_50ck97 = 0.9 time = 490
.meas tran vdout1_50ck97 FIND v(dout1_50) AT=490.025n

* CHECK dout1_51 Vdout1_51ck97 = 0 time = 490
.meas tran vdout1_51ck97 FIND v(dout1_51) AT=490.025n

* CHECK dout1_52 Vdout1_52ck97 = 0 time = 490
.meas tran vdout1_52ck97 FIND v(dout1_52) AT=490.025n

* CHECK dout1_53 Vdout1_53ck97 = 0.9 time = 490
.meas tran vdout1_53ck97 FIND v(dout1_53) AT=490.025n

* CHECK dout1_54 Vdout1_54ck97 = 0.9 time = 490
.meas tran vdout1_54ck97 FIND v(dout1_54) AT=490.025n

* CHECK dout1_55 Vdout1_55ck97 = 0.9 time = 490
.meas tran vdout1_55ck97 FIND v(dout1_55) AT=490.025n

* CHECK dout1_56 Vdout1_56ck97 = 0 time = 490
.meas tran vdout1_56ck97 FIND v(dout1_56) AT=490.025n

* CHECK dout1_57 Vdout1_57ck97 = 0.9 time = 490
.meas tran vdout1_57ck97 FIND v(dout1_57) AT=490.025n

* CHECK dout1_58 Vdout1_58ck97 = 0.9 time = 490
.meas tran vdout1_58ck97 FIND v(dout1_58) AT=490.025n

* CHECK dout1_59 Vdout1_59ck97 = 0 time = 490
.meas tran vdout1_59ck97 FIND v(dout1_59) AT=490.025n

* CHECK dout1_60 Vdout1_60ck97 = 0.9 time = 490
.meas tran vdout1_60ck97 FIND v(dout1_60) AT=490.025n

* CHECK dout1_61 Vdout1_61ck97 = 0.9 time = 490
.meas tran vdout1_61ck97 FIND v(dout1_61) AT=490.025n

* CHECK dout1_62 Vdout1_62ck97 = 0.9 time = 490
.meas tran vdout1_62ck97 FIND v(dout1_62) AT=490.025n

* CHECK dout1_63 Vdout1_63ck97 = 0 time = 490
.meas tran vdout1_63ck97 FIND v(dout1_63) AT=490.025n

* CHECK dout1_64 Vdout1_64ck97 = 0 time = 490
.meas tran vdout1_64ck97 FIND v(dout1_64) AT=490.025n

* CHECK dout1_65 Vdout1_65ck97 = 0.9 time = 490
.meas tran vdout1_65ck97 FIND v(dout1_65) AT=490.025n

* CHECK dout1_66 Vdout1_66ck97 = 0.9 time = 490
.meas tran vdout1_66ck97 FIND v(dout1_66) AT=490.025n

* CHECK dout1_67 Vdout1_67ck97 = 0 time = 490
.meas tran vdout1_67ck97 FIND v(dout1_67) AT=490.025n

* CHECK dout1_68 Vdout1_68ck97 = 0.9 time = 490
.meas tran vdout1_68ck97 FIND v(dout1_68) AT=490.025n

* CHECK dout1_69 Vdout1_69ck97 = 0.9 time = 490
.meas tran vdout1_69ck97 FIND v(dout1_69) AT=490.025n

* CHECK dout1_70 Vdout1_70ck97 = 0 time = 490
.meas tran vdout1_70ck97 FIND v(dout1_70) AT=490.025n

* CHECK dout1_71 Vdout1_71ck97 = 0 time = 490
.meas tran vdout1_71ck97 FIND v(dout1_71) AT=490.025n

* CHECK dout1_0 Vdout1_0ck98 = 0 time = 495
.meas tran vdout1_0ck98 FIND v(dout1_0) AT=495.025n

* CHECK dout1_1 Vdout1_1ck98 = 0 time = 495
.meas tran vdout1_1ck98 FIND v(dout1_1) AT=495.025n

* CHECK dout1_2 Vdout1_2ck98 = 0 time = 495
.meas tran vdout1_2ck98 FIND v(dout1_2) AT=495.025n

* CHECK dout1_3 Vdout1_3ck98 = 0 time = 495
.meas tran vdout1_3ck98 FIND v(dout1_3) AT=495.025n

* CHECK dout1_4 Vdout1_4ck98 = 0 time = 495
.meas tran vdout1_4ck98 FIND v(dout1_4) AT=495.025n

* CHECK dout1_5 Vdout1_5ck98 = 0 time = 495
.meas tran vdout1_5ck98 FIND v(dout1_5) AT=495.025n

* CHECK dout1_6 Vdout1_6ck98 = 0.9 time = 495
.meas tran vdout1_6ck98 FIND v(dout1_6) AT=495.025n

* CHECK dout1_7 Vdout1_7ck98 = 0.9 time = 495
.meas tran vdout1_7ck98 FIND v(dout1_7) AT=495.025n

* CHECK dout1_8 Vdout1_8ck98 = 0 time = 495
.meas tran vdout1_8ck98 FIND v(dout1_8) AT=495.025n

* CHECK dout1_9 Vdout1_9ck98 = 0.9 time = 495
.meas tran vdout1_9ck98 FIND v(dout1_9) AT=495.025n

* CHECK dout1_10 Vdout1_10ck98 = 0 time = 495
.meas tran vdout1_10ck98 FIND v(dout1_10) AT=495.025n

* CHECK dout1_11 Vdout1_11ck98 = 0 time = 495
.meas tran vdout1_11ck98 FIND v(dout1_11) AT=495.025n

* CHECK dout1_12 Vdout1_12ck98 = 0.9 time = 495
.meas tran vdout1_12ck98 FIND v(dout1_12) AT=495.025n

* CHECK dout1_13 Vdout1_13ck98 = 0 time = 495
.meas tran vdout1_13ck98 FIND v(dout1_13) AT=495.025n

* CHECK dout1_14 Vdout1_14ck98 = 0.9 time = 495
.meas tran vdout1_14ck98 FIND v(dout1_14) AT=495.025n

* CHECK dout1_15 Vdout1_15ck98 = 0 time = 495
.meas tran vdout1_15ck98 FIND v(dout1_15) AT=495.025n

* CHECK dout1_16 Vdout1_16ck98 = 0.9 time = 495
.meas tran vdout1_16ck98 FIND v(dout1_16) AT=495.025n

* CHECK dout1_17 Vdout1_17ck98 = 0 time = 495
.meas tran vdout1_17ck98 FIND v(dout1_17) AT=495.025n

* CHECK dout1_18 Vdout1_18ck98 = 0.9 time = 495
.meas tran vdout1_18ck98 FIND v(dout1_18) AT=495.025n

* CHECK dout1_19 Vdout1_19ck98 = 0.9 time = 495
.meas tran vdout1_19ck98 FIND v(dout1_19) AT=495.025n

* CHECK dout1_20 Vdout1_20ck98 = 0 time = 495
.meas tran vdout1_20ck98 FIND v(dout1_20) AT=495.025n

* CHECK dout1_21 Vdout1_21ck98 = 0.9 time = 495
.meas tran vdout1_21ck98 FIND v(dout1_21) AT=495.025n

* CHECK dout1_22 Vdout1_22ck98 = 0 time = 495
.meas tran vdout1_22ck98 FIND v(dout1_22) AT=495.025n

* CHECK dout1_23 Vdout1_23ck98 = 0 time = 495
.meas tran vdout1_23ck98 FIND v(dout1_23) AT=495.025n

* CHECK dout1_24 Vdout1_24ck98 = 0 time = 495
.meas tran vdout1_24ck98 FIND v(dout1_24) AT=495.025n

* CHECK dout1_25 Vdout1_25ck98 = 0.9 time = 495
.meas tran vdout1_25ck98 FIND v(dout1_25) AT=495.025n

* CHECK dout1_26 Vdout1_26ck98 = 0 time = 495
.meas tran vdout1_26ck98 FIND v(dout1_26) AT=495.025n

* CHECK dout1_27 Vdout1_27ck98 = 0.9 time = 495
.meas tran vdout1_27ck98 FIND v(dout1_27) AT=495.025n

* CHECK dout1_28 Vdout1_28ck98 = 0 time = 495
.meas tran vdout1_28ck98 FIND v(dout1_28) AT=495.025n

* CHECK dout1_29 Vdout1_29ck98 = 0 time = 495
.meas tran vdout1_29ck98 FIND v(dout1_29) AT=495.025n

* CHECK dout1_30 Vdout1_30ck98 = 0 time = 495
.meas tran vdout1_30ck98 FIND v(dout1_30) AT=495.025n

* CHECK dout1_31 Vdout1_31ck98 = 0 time = 495
.meas tran vdout1_31ck98 FIND v(dout1_31) AT=495.025n

* CHECK dout1_32 Vdout1_32ck98 = 0 time = 495
.meas tran vdout1_32ck98 FIND v(dout1_32) AT=495.025n

* CHECK dout1_33 Vdout1_33ck98 = 0 time = 495
.meas tran vdout1_33ck98 FIND v(dout1_33) AT=495.025n

* CHECK dout1_34 Vdout1_34ck98 = 0 time = 495
.meas tran vdout1_34ck98 FIND v(dout1_34) AT=495.025n

* CHECK dout1_35 Vdout1_35ck98 = 0.9 time = 495
.meas tran vdout1_35ck98 FIND v(dout1_35) AT=495.025n

* CHECK dout1_36 Vdout1_36ck98 = 0 time = 495
.meas tran vdout1_36ck98 FIND v(dout1_36) AT=495.025n

* CHECK dout1_37 Vdout1_37ck98 = 0.9 time = 495
.meas tran vdout1_37ck98 FIND v(dout1_37) AT=495.025n

* CHECK dout1_38 Vdout1_38ck98 = 0 time = 495
.meas tran vdout1_38ck98 FIND v(dout1_38) AT=495.025n

* CHECK dout1_39 Vdout1_39ck98 = 0 time = 495
.meas tran vdout1_39ck98 FIND v(dout1_39) AT=495.025n

* CHECK dout1_40 Vdout1_40ck98 = 0 time = 495
.meas tran vdout1_40ck98 FIND v(dout1_40) AT=495.025n

* CHECK dout1_41 Vdout1_41ck98 = 0.9 time = 495
.meas tran vdout1_41ck98 FIND v(dout1_41) AT=495.025n

* CHECK dout1_42 Vdout1_42ck98 = 0.9 time = 495
.meas tran vdout1_42ck98 FIND v(dout1_42) AT=495.025n

* CHECK dout1_43 Vdout1_43ck98 = 0 time = 495
.meas tran vdout1_43ck98 FIND v(dout1_43) AT=495.025n

* CHECK dout1_44 Vdout1_44ck98 = 0 time = 495
.meas tran vdout1_44ck98 FIND v(dout1_44) AT=495.025n

* CHECK dout1_45 Vdout1_45ck98 = 0 time = 495
.meas tran vdout1_45ck98 FIND v(dout1_45) AT=495.025n

* CHECK dout1_46 Vdout1_46ck98 = 0 time = 495
.meas tran vdout1_46ck98 FIND v(dout1_46) AT=495.025n

* CHECK dout1_47 Vdout1_47ck98 = 0 time = 495
.meas tran vdout1_47ck98 FIND v(dout1_47) AT=495.025n

* CHECK dout1_48 Vdout1_48ck98 = 0 time = 495
.meas tran vdout1_48ck98 FIND v(dout1_48) AT=495.025n

* CHECK dout1_49 Vdout1_49ck98 = 0 time = 495
.meas tran vdout1_49ck98 FIND v(dout1_49) AT=495.025n

* CHECK dout1_50 Vdout1_50ck98 = 0.9 time = 495
.meas tran vdout1_50ck98 FIND v(dout1_50) AT=495.025n

* CHECK dout1_51 Vdout1_51ck98 = 0 time = 495
.meas tran vdout1_51ck98 FIND v(dout1_51) AT=495.025n

* CHECK dout1_52 Vdout1_52ck98 = 0 time = 495
.meas tran vdout1_52ck98 FIND v(dout1_52) AT=495.025n

* CHECK dout1_53 Vdout1_53ck98 = 0.9 time = 495
.meas tran vdout1_53ck98 FIND v(dout1_53) AT=495.025n

* CHECK dout1_54 Vdout1_54ck98 = 0.9 time = 495
.meas tran vdout1_54ck98 FIND v(dout1_54) AT=495.025n

* CHECK dout1_55 Vdout1_55ck98 = 0.9 time = 495
.meas tran vdout1_55ck98 FIND v(dout1_55) AT=495.025n

* CHECK dout1_56 Vdout1_56ck98 = 0 time = 495
.meas tran vdout1_56ck98 FIND v(dout1_56) AT=495.025n

* CHECK dout1_57 Vdout1_57ck98 = 0.9 time = 495
.meas tran vdout1_57ck98 FIND v(dout1_57) AT=495.025n

* CHECK dout1_58 Vdout1_58ck98 = 0.9 time = 495
.meas tran vdout1_58ck98 FIND v(dout1_58) AT=495.025n

* CHECK dout1_59 Vdout1_59ck98 = 0 time = 495
.meas tran vdout1_59ck98 FIND v(dout1_59) AT=495.025n

* CHECK dout1_60 Vdout1_60ck98 = 0.9 time = 495
.meas tran vdout1_60ck98 FIND v(dout1_60) AT=495.025n

* CHECK dout1_61 Vdout1_61ck98 = 0.9 time = 495
.meas tran vdout1_61ck98 FIND v(dout1_61) AT=495.025n

* CHECK dout1_62 Vdout1_62ck98 = 0.9 time = 495
.meas tran vdout1_62ck98 FIND v(dout1_62) AT=495.025n

* CHECK dout1_63 Vdout1_63ck98 = 0 time = 495
.meas tran vdout1_63ck98 FIND v(dout1_63) AT=495.025n

* CHECK dout1_64 Vdout1_64ck98 = 0 time = 495
.meas tran vdout1_64ck98 FIND v(dout1_64) AT=495.025n

* CHECK dout1_65 Vdout1_65ck98 = 0.9 time = 495
.meas tran vdout1_65ck98 FIND v(dout1_65) AT=495.025n

* CHECK dout1_66 Vdout1_66ck98 = 0.9 time = 495
.meas tran vdout1_66ck98 FIND v(dout1_66) AT=495.025n

* CHECK dout1_67 Vdout1_67ck98 = 0 time = 495
.meas tran vdout1_67ck98 FIND v(dout1_67) AT=495.025n

* CHECK dout1_68 Vdout1_68ck98 = 0.9 time = 495
.meas tran vdout1_68ck98 FIND v(dout1_68) AT=495.025n

* CHECK dout1_69 Vdout1_69ck98 = 0.9 time = 495
.meas tran vdout1_69ck98 FIND v(dout1_69) AT=495.025n

* CHECK dout1_70 Vdout1_70ck98 = 0 time = 495
.meas tran vdout1_70ck98 FIND v(dout1_70) AT=495.025n

* CHECK dout1_71 Vdout1_71ck98 = 0 time = 495
.meas tran vdout1_71ck98 FIND v(dout1_71) AT=495.025n

* CHECK dout1_0 Vdout1_0ck100 = 0.9 time = 505
.meas tran vdout1_0ck100 FIND v(dout1_0) AT=505.025n

* CHECK dout1_1 Vdout1_1ck100 = 0 time = 505
.meas tran vdout1_1ck100 FIND v(dout1_1) AT=505.025n

* CHECK dout1_2 Vdout1_2ck100 = 0.9 time = 505
.meas tran vdout1_2ck100 FIND v(dout1_2) AT=505.025n

* CHECK dout1_3 Vdout1_3ck100 = 0.9 time = 505
.meas tran vdout1_3ck100 FIND v(dout1_3) AT=505.025n

* CHECK dout1_4 Vdout1_4ck100 = 0.9 time = 505
.meas tran vdout1_4ck100 FIND v(dout1_4) AT=505.025n

* CHECK dout1_5 Vdout1_5ck100 = 0.9 time = 505
.meas tran vdout1_5ck100 FIND v(dout1_5) AT=505.025n

* CHECK dout1_6 Vdout1_6ck100 = 0.9 time = 505
.meas tran vdout1_6ck100 FIND v(dout1_6) AT=505.025n

* CHECK dout1_7 Vdout1_7ck100 = 0 time = 505
.meas tran vdout1_7ck100 FIND v(dout1_7) AT=505.025n

* CHECK dout1_8 Vdout1_8ck100 = 0.9 time = 505
.meas tran vdout1_8ck100 FIND v(dout1_8) AT=505.025n

* CHECK dout1_9 Vdout1_9ck100 = 0.9 time = 505
.meas tran vdout1_9ck100 FIND v(dout1_9) AT=505.025n

* CHECK dout1_10 Vdout1_10ck100 = 0.9 time = 505
.meas tran vdout1_10ck100 FIND v(dout1_10) AT=505.025n

* CHECK dout1_11 Vdout1_11ck100 = 0 time = 505
.meas tran vdout1_11ck100 FIND v(dout1_11) AT=505.025n

* CHECK dout1_12 Vdout1_12ck100 = 0 time = 505
.meas tran vdout1_12ck100 FIND v(dout1_12) AT=505.025n

* CHECK dout1_13 Vdout1_13ck100 = 0.9 time = 505
.meas tran vdout1_13ck100 FIND v(dout1_13) AT=505.025n

* CHECK dout1_14 Vdout1_14ck100 = 0.9 time = 505
.meas tran vdout1_14ck100 FIND v(dout1_14) AT=505.025n

* CHECK dout1_15 Vdout1_15ck100 = 0 time = 505
.meas tran vdout1_15ck100 FIND v(dout1_15) AT=505.025n

* CHECK dout1_16 Vdout1_16ck100 = 0 time = 505
.meas tran vdout1_16ck100 FIND v(dout1_16) AT=505.025n

* CHECK dout1_17 Vdout1_17ck100 = 0 time = 505
.meas tran vdout1_17ck100 FIND v(dout1_17) AT=505.025n

* CHECK dout1_18 Vdout1_18ck100 = 0.9 time = 505
.meas tran vdout1_18ck100 FIND v(dout1_18) AT=505.025n

* CHECK dout1_19 Vdout1_19ck100 = 0.9 time = 505
.meas tran vdout1_19ck100 FIND v(dout1_19) AT=505.025n

* CHECK dout1_20 Vdout1_20ck100 = 0 time = 505
.meas tran vdout1_20ck100 FIND v(dout1_20) AT=505.025n

* CHECK dout1_21 Vdout1_21ck100 = 0 time = 505
.meas tran vdout1_21ck100 FIND v(dout1_21) AT=505.025n

* CHECK dout1_22 Vdout1_22ck100 = 0 time = 505
.meas tran vdout1_22ck100 FIND v(dout1_22) AT=505.025n

* CHECK dout1_23 Vdout1_23ck100 = 0.9 time = 505
.meas tran vdout1_23ck100 FIND v(dout1_23) AT=505.025n

* CHECK dout1_24 Vdout1_24ck100 = 0 time = 505
.meas tran vdout1_24ck100 FIND v(dout1_24) AT=505.025n

* CHECK dout1_25 Vdout1_25ck100 = 0 time = 505
.meas tran vdout1_25ck100 FIND v(dout1_25) AT=505.025n

* CHECK dout1_26 Vdout1_26ck100 = 0 time = 505
.meas tran vdout1_26ck100 FIND v(dout1_26) AT=505.025n

* CHECK dout1_27 Vdout1_27ck100 = 0 time = 505
.meas tran vdout1_27ck100 FIND v(dout1_27) AT=505.025n

* CHECK dout1_28 Vdout1_28ck100 = 0 time = 505
.meas tran vdout1_28ck100 FIND v(dout1_28) AT=505.025n

* CHECK dout1_29 Vdout1_29ck100 = 0.9 time = 505
.meas tran vdout1_29ck100 FIND v(dout1_29) AT=505.025n

* CHECK dout1_30 Vdout1_30ck100 = 0.9 time = 505
.meas tran vdout1_30ck100 FIND v(dout1_30) AT=505.025n

* CHECK dout1_31 Vdout1_31ck100 = 0 time = 505
.meas tran vdout1_31ck100 FIND v(dout1_31) AT=505.025n

* CHECK dout1_32 Vdout1_32ck100 = 0 time = 505
.meas tran vdout1_32ck100 FIND v(dout1_32) AT=505.025n

* CHECK dout1_33 Vdout1_33ck100 = 0.9 time = 505
.meas tran vdout1_33ck100 FIND v(dout1_33) AT=505.025n

* CHECK dout1_34 Vdout1_34ck100 = 0.9 time = 505
.meas tran vdout1_34ck100 FIND v(dout1_34) AT=505.025n

* CHECK dout1_35 Vdout1_35ck100 = 0.9 time = 505
.meas tran vdout1_35ck100 FIND v(dout1_35) AT=505.025n

* CHECK dout1_36 Vdout1_36ck100 = 0.9 time = 505
.meas tran vdout1_36ck100 FIND v(dout1_36) AT=505.025n

* CHECK dout1_37 Vdout1_37ck100 = 0 time = 505
.meas tran vdout1_37ck100 FIND v(dout1_37) AT=505.025n

* CHECK dout1_38 Vdout1_38ck100 = 0 time = 505
.meas tran vdout1_38ck100 FIND v(dout1_38) AT=505.025n

* CHECK dout1_39 Vdout1_39ck100 = 0 time = 505
.meas tran vdout1_39ck100 FIND v(dout1_39) AT=505.025n

* CHECK dout1_40 Vdout1_40ck100 = 0 time = 505
.meas tran vdout1_40ck100 FIND v(dout1_40) AT=505.025n

* CHECK dout1_41 Vdout1_41ck100 = 0 time = 505
.meas tran vdout1_41ck100 FIND v(dout1_41) AT=505.025n

* CHECK dout1_42 Vdout1_42ck100 = 0 time = 505
.meas tran vdout1_42ck100 FIND v(dout1_42) AT=505.025n

* CHECK dout1_43 Vdout1_43ck100 = 0 time = 505
.meas tran vdout1_43ck100 FIND v(dout1_43) AT=505.025n

* CHECK dout1_44 Vdout1_44ck100 = 0.9 time = 505
.meas tran vdout1_44ck100 FIND v(dout1_44) AT=505.025n

* CHECK dout1_45 Vdout1_45ck100 = 0.9 time = 505
.meas tran vdout1_45ck100 FIND v(dout1_45) AT=505.025n

* CHECK dout1_46 Vdout1_46ck100 = 0 time = 505
.meas tran vdout1_46ck100 FIND v(dout1_46) AT=505.025n

* CHECK dout1_47 Vdout1_47ck100 = 0 time = 505
.meas tran vdout1_47ck100 FIND v(dout1_47) AT=505.025n

* CHECK dout1_48 Vdout1_48ck100 = 0 time = 505
.meas tran vdout1_48ck100 FIND v(dout1_48) AT=505.025n

* CHECK dout1_49 Vdout1_49ck100 = 0 time = 505
.meas tran vdout1_49ck100 FIND v(dout1_49) AT=505.025n

* CHECK dout1_50 Vdout1_50ck100 = 0.9 time = 505
.meas tran vdout1_50ck100 FIND v(dout1_50) AT=505.025n

* CHECK dout1_51 Vdout1_51ck100 = 0 time = 505
.meas tran vdout1_51ck100 FIND v(dout1_51) AT=505.025n

* CHECK dout1_52 Vdout1_52ck100 = 0 time = 505
.meas tran vdout1_52ck100 FIND v(dout1_52) AT=505.025n

* CHECK dout1_53 Vdout1_53ck100 = 0 time = 505
.meas tran vdout1_53ck100 FIND v(dout1_53) AT=505.025n

* CHECK dout1_54 Vdout1_54ck100 = 0 time = 505
.meas tran vdout1_54ck100 FIND v(dout1_54) AT=505.025n

* CHECK dout1_55 Vdout1_55ck100 = 0 time = 505
.meas tran vdout1_55ck100 FIND v(dout1_55) AT=505.025n

* CHECK dout1_56 Vdout1_56ck100 = 0 time = 505
.meas tran vdout1_56ck100 FIND v(dout1_56) AT=505.025n

* CHECK dout1_57 Vdout1_57ck100 = 0.9 time = 505
.meas tran vdout1_57ck100 FIND v(dout1_57) AT=505.025n

* CHECK dout1_58 Vdout1_58ck100 = 0.9 time = 505
.meas tran vdout1_58ck100 FIND v(dout1_58) AT=505.025n

* CHECK dout1_59 Vdout1_59ck100 = 0.9 time = 505
.meas tran vdout1_59ck100 FIND v(dout1_59) AT=505.025n

* CHECK dout1_60 Vdout1_60ck100 = 0.9 time = 505
.meas tran vdout1_60ck100 FIND v(dout1_60) AT=505.025n

* CHECK dout1_61 Vdout1_61ck100 = 0.9 time = 505
.meas tran vdout1_61ck100 FIND v(dout1_61) AT=505.025n

* CHECK dout1_62 Vdout1_62ck100 = 0 time = 505
.meas tran vdout1_62ck100 FIND v(dout1_62) AT=505.025n

* CHECK dout1_63 Vdout1_63ck100 = 0 time = 505
.meas tran vdout1_63ck100 FIND v(dout1_63) AT=505.025n

* CHECK dout1_64 Vdout1_64ck100 = 0.9 time = 505
.meas tran vdout1_64ck100 FIND v(dout1_64) AT=505.025n

* CHECK dout1_65 Vdout1_65ck100 = 0 time = 505
.meas tran vdout1_65ck100 FIND v(dout1_65) AT=505.025n

* CHECK dout1_66 Vdout1_66ck100 = 0.9 time = 505
.meas tran vdout1_66ck100 FIND v(dout1_66) AT=505.025n

* CHECK dout1_67 Vdout1_67ck100 = 0 time = 505
.meas tran vdout1_67ck100 FIND v(dout1_67) AT=505.025n

* CHECK dout1_68 Vdout1_68ck100 = 0 time = 505
.meas tran vdout1_68ck100 FIND v(dout1_68) AT=505.025n

* CHECK dout1_69 Vdout1_69ck100 = 0.9 time = 505
.meas tran vdout1_69ck100 FIND v(dout1_69) AT=505.025n

* CHECK dout1_70 Vdout1_70ck100 = 0 time = 505
.meas tran vdout1_70ck100 FIND v(dout1_70) AT=505.025n

* CHECK dout1_71 Vdout1_71ck100 = 0.9 time = 505
.meas tran vdout1_71ck100 FIND v(dout1_71) AT=505.025n

* CHECK dout1_0 Vdout1_0ck102 = 0.9 time = 515
.meas tran vdout1_0ck102 FIND v(dout1_0) AT=515.025n

* CHECK dout1_1 Vdout1_1ck102 = 0.9 time = 515
.meas tran vdout1_1ck102 FIND v(dout1_1) AT=515.025n

* CHECK dout1_2 Vdout1_2ck102 = 0.9 time = 515
.meas tran vdout1_2ck102 FIND v(dout1_2) AT=515.025n

* CHECK dout1_3 Vdout1_3ck102 = 0 time = 515
.meas tran vdout1_3ck102 FIND v(dout1_3) AT=515.025n

* CHECK dout1_4 Vdout1_4ck102 = 0 time = 515
.meas tran vdout1_4ck102 FIND v(dout1_4) AT=515.025n

* CHECK dout1_5 Vdout1_5ck102 = 0 time = 515
.meas tran vdout1_5ck102 FIND v(dout1_5) AT=515.025n

* CHECK dout1_6 Vdout1_6ck102 = 0.9 time = 515
.meas tran vdout1_6ck102 FIND v(dout1_6) AT=515.025n

* CHECK dout1_7 Vdout1_7ck102 = 0.9 time = 515
.meas tran vdout1_7ck102 FIND v(dout1_7) AT=515.025n

* CHECK dout1_8 Vdout1_8ck102 = 0 time = 515
.meas tran vdout1_8ck102 FIND v(dout1_8) AT=515.025n

* CHECK dout1_9 Vdout1_9ck102 = 0.9 time = 515
.meas tran vdout1_9ck102 FIND v(dout1_9) AT=515.025n

* CHECK dout1_10 Vdout1_10ck102 = 0 time = 515
.meas tran vdout1_10ck102 FIND v(dout1_10) AT=515.025n

* CHECK dout1_11 Vdout1_11ck102 = 0.9 time = 515
.meas tran vdout1_11ck102 FIND v(dout1_11) AT=515.025n

* CHECK dout1_12 Vdout1_12ck102 = 0.9 time = 515
.meas tran vdout1_12ck102 FIND v(dout1_12) AT=515.025n

* CHECK dout1_13 Vdout1_13ck102 = 0 time = 515
.meas tran vdout1_13ck102 FIND v(dout1_13) AT=515.025n

* CHECK dout1_14 Vdout1_14ck102 = 0 time = 515
.meas tran vdout1_14ck102 FIND v(dout1_14) AT=515.025n

* CHECK dout1_15 Vdout1_15ck102 = 0 time = 515
.meas tran vdout1_15ck102 FIND v(dout1_15) AT=515.025n

* CHECK dout1_16 Vdout1_16ck102 = 0.9 time = 515
.meas tran vdout1_16ck102 FIND v(dout1_16) AT=515.025n

* CHECK dout1_17 Vdout1_17ck102 = 0 time = 515
.meas tran vdout1_17ck102 FIND v(dout1_17) AT=515.025n

* CHECK dout1_18 Vdout1_18ck102 = 0 time = 515
.meas tran vdout1_18ck102 FIND v(dout1_18) AT=515.025n

* CHECK dout1_19 Vdout1_19ck102 = 0 time = 515
.meas tran vdout1_19ck102 FIND v(dout1_19) AT=515.025n

* CHECK dout1_20 Vdout1_20ck102 = 0.9 time = 515
.meas tran vdout1_20ck102 FIND v(dout1_20) AT=515.025n

* CHECK dout1_21 Vdout1_21ck102 = 0.9 time = 515
.meas tran vdout1_21ck102 FIND v(dout1_21) AT=515.025n

* CHECK dout1_22 Vdout1_22ck102 = 0 time = 515
.meas tran vdout1_22ck102 FIND v(dout1_22) AT=515.025n

* CHECK dout1_23 Vdout1_23ck102 = 0.9 time = 515
.meas tran vdout1_23ck102 FIND v(dout1_23) AT=515.025n

* CHECK dout1_24 Vdout1_24ck102 = 0 time = 515
.meas tran vdout1_24ck102 FIND v(dout1_24) AT=515.025n

* CHECK dout1_25 Vdout1_25ck102 = 0.9 time = 515
.meas tran vdout1_25ck102 FIND v(dout1_25) AT=515.025n

* CHECK dout1_26 Vdout1_26ck102 = 0.9 time = 515
.meas tran vdout1_26ck102 FIND v(dout1_26) AT=515.025n

* CHECK dout1_27 Vdout1_27ck102 = 0 time = 515
.meas tran vdout1_27ck102 FIND v(dout1_27) AT=515.025n

* CHECK dout1_28 Vdout1_28ck102 = 0 time = 515
.meas tran vdout1_28ck102 FIND v(dout1_28) AT=515.025n

* CHECK dout1_29 Vdout1_29ck102 = 0 time = 515
.meas tran vdout1_29ck102 FIND v(dout1_29) AT=515.025n

* CHECK dout1_30 Vdout1_30ck102 = 0 time = 515
.meas tran vdout1_30ck102 FIND v(dout1_30) AT=515.025n

* CHECK dout1_31 Vdout1_31ck102 = 0 time = 515
.meas tran vdout1_31ck102 FIND v(dout1_31) AT=515.025n

* CHECK dout1_32 Vdout1_32ck102 = 0.9 time = 515
.meas tran vdout1_32ck102 FIND v(dout1_32) AT=515.025n

* CHECK dout1_33 Vdout1_33ck102 = 0 time = 515
.meas tran vdout1_33ck102 FIND v(dout1_33) AT=515.025n

* CHECK dout1_34 Vdout1_34ck102 = 0 time = 515
.meas tran vdout1_34ck102 FIND v(dout1_34) AT=515.025n

* CHECK dout1_35 Vdout1_35ck102 = 0 time = 515
.meas tran vdout1_35ck102 FIND v(dout1_35) AT=515.025n

* CHECK dout1_36 Vdout1_36ck102 = 0.9 time = 515
.meas tran vdout1_36ck102 FIND v(dout1_36) AT=515.025n

* CHECK dout1_37 Vdout1_37ck102 = 0 time = 515
.meas tran vdout1_37ck102 FIND v(dout1_37) AT=515.025n

* CHECK dout1_38 Vdout1_38ck102 = 0 time = 515
.meas tran vdout1_38ck102 FIND v(dout1_38) AT=515.025n

* CHECK dout1_39 Vdout1_39ck102 = 0 time = 515
.meas tran vdout1_39ck102 FIND v(dout1_39) AT=515.025n

* CHECK dout1_40 Vdout1_40ck102 = 0 time = 515
.meas tran vdout1_40ck102 FIND v(dout1_40) AT=515.025n

* CHECK dout1_41 Vdout1_41ck102 = 0 time = 515
.meas tran vdout1_41ck102 FIND v(dout1_41) AT=515.025n

* CHECK dout1_42 Vdout1_42ck102 = 0.9 time = 515
.meas tran vdout1_42ck102 FIND v(dout1_42) AT=515.025n

* CHECK dout1_43 Vdout1_43ck102 = 0.9 time = 515
.meas tran vdout1_43ck102 FIND v(dout1_43) AT=515.025n

* CHECK dout1_44 Vdout1_44ck102 = 0.9 time = 515
.meas tran vdout1_44ck102 FIND v(dout1_44) AT=515.025n

* CHECK dout1_45 Vdout1_45ck102 = 0.9 time = 515
.meas tran vdout1_45ck102 FIND v(dout1_45) AT=515.025n

* CHECK dout1_46 Vdout1_46ck102 = 0 time = 515
.meas tran vdout1_46ck102 FIND v(dout1_46) AT=515.025n

* CHECK dout1_47 Vdout1_47ck102 = 0 time = 515
.meas tran vdout1_47ck102 FIND v(dout1_47) AT=515.025n

* CHECK dout1_48 Vdout1_48ck102 = 0 time = 515
.meas tran vdout1_48ck102 FIND v(dout1_48) AT=515.025n

* CHECK dout1_49 Vdout1_49ck102 = 0 time = 515
.meas tran vdout1_49ck102 FIND v(dout1_49) AT=515.025n

* CHECK dout1_50 Vdout1_50ck102 = 0.9 time = 515
.meas tran vdout1_50ck102 FIND v(dout1_50) AT=515.025n

* CHECK dout1_51 Vdout1_51ck102 = 0.9 time = 515
.meas tran vdout1_51ck102 FIND v(dout1_51) AT=515.025n

* CHECK dout1_52 Vdout1_52ck102 = 0 time = 515
.meas tran vdout1_52ck102 FIND v(dout1_52) AT=515.025n

* CHECK dout1_53 Vdout1_53ck102 = 0.9 time = 515
.meas tran vdout1_53ck102 FIND v(dout1_53) AT=515.025n

* CHECK dout1_54 Vdout1_54ck102 = 0 time = 515
.meas tran vdout1_54ck102 FIND v(dout1_54) AT=515.025n

* CHECK dout1_55 Vdout1_55ck102 = 0.9 time = 515
.meas tran vdout1_55ck102 FIND v(dout1_55) AT=515.025n

* CHECK dout1_56 Vdout1_56ck102 = 0.9 time = 515
.meas tran vdout1_56ck102 FIND v(dout1_56) AT=515.025n

* CHECK dout1_57 Vdout1_57ck102 = 0.9 time = 515
.meas tran vdout1_57ck102 FIND v(dout1_57) AT=515.025n

* CHECK dout1_58 Vdout1_58ck102 = 0.9 time = 515
.meas tran vdout1_58ck102 FIND v(dout1_58) AT=515.025n

* CHECK dout1_59 Vdout1_59ck102 = 0 time = 515
.meas tran vdout1_59ck102 FIND v(dout1_59) AT=515.025n

* CHECK dout1_60 Vdout1_60ck102 = 0 time = 515
.meas tran vdout1_60ck102 FIND v(dout1_60) AT=515.025n

* CHECK dout1_61 Vdout1_61ck102 = 0 time = 515
.meas tran vdout1_61ck102 FIND v(dout1_61) AT=515.025n

* CHECK dout1_62 Vdout1_62ck102 = 0 time = 515
.meas tran vdout1_62ck102 FIND v(dout1_62) AT=515.025n

* CHECK dout1_63 Vdout1_63ck102 = 0 time = 515
.meas tran vdout1_63ck102 FIND v(dout1_63) AT=515.025n

* CHECK dout1_64 Vdout1_64ck102 = 0.9 time = 515
.meas tran vdout1_64ck102 FIND v(dout1_64) AT=515.025n

* CHECK dout1_65 Vdout1_65ck102 = 0.9 time = 515
.meas tran vdout1_65ck102 FIND v(dout1_65) AT=515.025n

* CHECK dout1_66 Vdout1_66ck102 = 0.9 time = 515
.meas tran vdout1_66ck102 FIND v(dout1_66) AT=515.025n

* CHECK dout1_67 Vdout1_67ck102 = 0.9 time = 515
.meas tran vdout1_67ck102 FIND v(dout1_67) AT=515.025n

* CHECK dout1_68 Vdout1_68ck102 = 0 time = 515
.meas tran vdout1_68ck102 FIND v(dout1_68) AT=515.025n

* CHECK dout1_69 Vdout1_69ck102 = 0 time = 515
.meas tran vdout1_69ck102 FIND v(dout1_69) AT=515.025n

* CHECK dout1_70 Vdout1_70ck102 = 0.9 time = 515
.meas tran vdout1_70ck102 FIND v(dout1_70) AT=515.025n

* CHECK dout1_71 Vdout1_71ck102 = 0.9 time = 515
.meas tran vdout1_71ck102 FIND v(dout1_71) AT=515.025n

* CHECK dout1_0 Vdout1_0ck103 = 0.9 time = 520
.meas tran vdout1_0ck103 FIND v(dout1_0) AT=520.025n

* CHECK dout1_1 Vdout1_1ck103 = 0.9 time = 520
.meas tran vdout1_1ck103 FIND v(dout1_1) AT=520.025n

* CHECK dout1_2 Vdout1_2ck103 = 0.9 time = 520
.meas tran vdout1_2ck103 FIND v(dout1_2) AT=520.025n

* CHECK dout1_3 Vdout1_3ck103 = 0 time = 520
.meas tran vdout1_3ck103 FIND v(dout1_3) AT=520.025n

* CHECK dout1_4 Vdout1_4ck103 = 0 time = 520
.meas tran vdout1_4ck103 FIND v(dout1_4) AT=520.025n

* CHECK dout1_5 Vdout1_5ck103 = 0 time = 520
.meas tran vdout1_5ck103 FIND v(dout1_5) AT=520.025n

* CHECK dout1_6 Vdout1_6ck103 = 0.9 time = 520
.meas tran vdout1_6ck103 FIND v(dout1_6) AT=520.025n

* CHECK dout1_7 Vdout1_7ck103 = 0.9 time = 520
.meas tran vdout1_7ck103 FIND v(dout1_7) AT=520.025n

* CHECK dout1_8 Vdout1_8ck103 = 0 time = 520
.meas tran vdout1_8ck103 FIND v(dout1_8) AT=520.025n

* CHECK dout1_9 Vdout1_9ck103 = 0.9 time = 520
.meas tran vdout1_9ck103 FIND v(dout1_9) AT=520.025n

* CHECK dout1_10 Vdout1_10ck103 = 0 time = 520
.meas tran vdout1_10ck103 FIND v(dout1_10) AT=520.025n

* CHECK dout1_11 Vdout1_11ck103 = 0.9 time = 520
.meas tran vdout1_11ck103 FIND v(dout1_11) AT=520.025n

* CHECK dout1_12 Vdout1_12ck103 = 0.9 time = 520
.meas tran vdout1_12ck103 FIND v(dout1_12) AT=520.025n

* CHECK dout1_13 Vdout1_13ck103 = 0 time = 520
.meas tran vdout1_13ck103 FIND v(dout1_13) AT=520.025n

* CHECK dout1_14 Vdout1_14ck103 = 0 time = 520
.meas tran vdout1_14ck103 FIND v(dout1_14) AT=520.025n

* CHECK dout1_15 Vdout1_15ck103 = 0 time = 520
.meas tran vdout1_15ck103 FIND v(dout1_15) AT=520.025n

* CHECK dout1_16 Vdout1_16ck103 = 0.9 time = 520
.meas tran vdout1_16ck103 FIND v(dout1_16) AT=520.025n

* CHECK dout1_17 Vdout1_17ck103 = 0 time = 520
.meas tran vdout1_17ck103 FIND v(dout1_17) AT=520.025n

* CHECK dout1_18 Vdout1_18ck103 = 0 time = 520
.meas tran vdout1_18ck103 FIND v(dout1_18) AT=520.025n

* CHECK dout1_19 Vdout1_19ck103 = 0 time = 520
.meas tran vdout1_19ck103 FIND v(dout1_19) AT=520.025n

* CHECK dout1_20 Vdout1_20ck103 = 0.9 time = 520
.meas tran vdout1_20ck103 FIND v(dout1_20) AT=520.025n

* CHECK dout1_21 Vdout1_21ck103 = 0.9 time = 520
.meas tran vdout1_21ck103 FIND v(dout1_21) AT=520.025n

* CHECK dout1_22 Vdout1_22ck103 = 0 time = 520
.meas tran vdout1_22ck103 FIND v(dout1_22) AT=520.025n

* CHECK dout1_23 Vdout1_23ck103 = 0.9 time = 520
.meas tran vdout1_23ck103 FIND v(dout1_23) AT=520.025n

* CHECK dout1_24 Vdout1_24ck103 = 0 time = 520
.meas tran vdout1_24ck103 FIND v(dout1_24) AT=520.025n

* CHECK dout1_25 Vdout1_25ck103 = 0.9 time = 520
.meas tran vdout1_25ck103 FIND v(dout1_25) AT=520.025n

* CHECK dout1_26 Vdout1_26ck103 = 0.9 time = 520
.meas tran vdout1_26ck103 FIND v(dout1_26) AT=520.025n

* CHECK dout1_27 Vdout1_27ck103 = 0 time = 520
.meas tran vdout1_27ck103 FIND v(dout1_27) AT=520.025n

* CHECK dout1_28 Vdout1_28ck103 = 0 time = 520
.meas tran vdout1_28ck103 FIND v(dout1_28) AT=520.025n

* CHECK dout1_29 Vdout1_29ck103 = 0 time = 520
.meas tran vdout1_29ck103 FIND v(dout1_29) AT=520.025n

* CHECK dout1_30 Vdout1_30ck103 = 0 time = 520
.meas tran vdout1_30ck103 FIND v(dout1_30) AT=520.025n

* CHECK dout1_31 Vdout1_31ck103 = 0 time = 520
.meas tran vdout1_31ck103 FIND v(dout1_31) AT=520.025n

* CHECK dout1_32 Vdout1_32ck103 = 0.9 time = 520
.meas tran vdout1_32ck103 FIND v(dout1_32) AT=520.025n

* CHECK dout1_33 Vdout1_33ck103 = 0 time = 520
.meas tran vdout1_33ck103 FIND v(dout1_33) AT=520.025n

* CHECK dout1_34 Vdout1_34ck103 = 0 time = 520
.meas tran vdout1_34ck103 FIND v(dout1_34) AT=520.025n

* CHECK dout1_35 Vdout1_35ck103 = 0 time = 520
.meas tran vdout1_35ck103 FIND v(dout1_35) AT=520.025n

* CHECK dout1_36 Vdout1_36ck103 = 0.9 time = 520
.meas tran vdout1_36ck103 FIND v(dout1_36) AT=520.025n

* CHECK dout1_37 Vdout1_37ck103 = 0 time = 520
.meas tran vdout1_37ck103 FIND v(dout1_37) AT=520.025n

* CHECK dout1_38 Vdout1_38ck103 = 0 time = 520
.meas tran vdout1_38ck103 FIND v(dout1_38) AT=520.025n

* CHECK dout1_39 Vdout1_39ck103 = 0 time = 520
.meas tran vdout1_39ck103 FIND v(dout1_39) AT=520.025n

* CHECK dout1_40 Vdout1_40ck103 = 0 time = 520
.meas tran vdout1_40ck103 FIND v(dout1_40) AT=520.025n

* CHECK dout1_41 Vdout1_41ck103 = 0 time = 520
.meas tran vdout1_41ck103 FIND v(dout1_41) AT=520.025n

* CHECK dout1_42 Vdout1_42ck103 = 0.9 time = 520
.meas tran vdout1_42ck103 FIND v(dout1_42) AT=520.025n

* CHECK dout1_43 Vdout1_43ck103 = 0.9 time = 520
.meas tran vdout1_43ck103 FIND v(dout1_43) AT=520.025n

* CHECK dout1_44 Vdout1_44ck103 = 0.9 time = 520
.meas tran vdout1_44ck103 FIND v(dout1_44) AT=520.025n

* CHECK dout1_45 Vdout1_45ck103 = 0.9 time = 520
.meas tran vdout1_45ck103 FIND v(dout1_45) AT=520.025n

* CHECK dout1_46 Vdout1_46ck103 = 0 time = 520
.meas tran vdout1_46ck103 FIND v(dout1_46) AT=520.025n

* CHECK dout1_47 Vdout1_47ck103 = 0 time = 520
.meas tran vdout1_47ck103 FIND v(dout1_47) AT=520.025n

* CHECK dout1_48 Vdout1_48ck103 = 0 time = 520
.meas tran vdout1_48ck103 FIND v(dout1_48) AT=520.025n

* CHECK dout1_49 Vdout1_49ck103 = 0 time = 520
.meas tran vdout1_49ck103 FIND v(dout1_49) AT=520.025n

* CHECK dout1_50 Vdout1_50ck103 = 0.9 time = 520
.meas tran vdout1_50ck103 FIND v(dout1_50) AT=520.025n

* CHECK dout1_51 Vdout1_51ck103 = 0.9 time = 520
.meas tran vdout1_51ck103 FIND v(dout1_51) AT=520.025n

* CHECK dout1_52 Vdout1_52ck103 = 0 time = 520
.meas tran vdout1_52ck103 FIND v(dout1_52) AT=520.025n

* CHECK dout1_53 Vdout1_53ck103 = 0.9 time = 520
.meas tran vdout1_53ck103 FIND v(dout1_53) AT=520.025n

* CHECK dout1_54 Vdout1_54ck103 = 0 time = 520
.meas tran vdout1_54ck103 FIND v(dout1_54) AT=520.025n

* CHECK dout1_55 Vdout1_55ck103 = 0.9 time = 520
.meas tran vdout1_55ck103 FIND v(dout1_55) AT=520.025n

* CHECK dout1_56 Vdout1_56ck103 = 0.9 time = 520
.meas tran vdout1_56ck103 FIND v(dout1_56) AT=520.025n

* CHECK dout1_57 Vdout1_57ck103 = 0.9 time = 520
.meas tran vdout1_57ck103 FIND v(dout1_57) AT=520.025n

* CHECK dout1_58 Vdout1_58ck103 = 0.9 time = 520
.meas tran vdout1_58ck103 FIND v(dout1_58) AT=520.025n

* CHECK dout1_59 Vdout1_59ck103 = 0 time = 520
.meas tran vdout1_59ck103 FIND v(dout1_59) AT=520.025n

* CHECK dout1_60 Vdout1_60ck103 = 0 time = 520
.meas tran vdout1_60ck103 FIND v(dout1_60) AT=520.025n

* CHECK dout1_61 Vdout1_61ck103 = 0 time = 520
.meas tran vdout1_61ck103 FIND v(dout1_61) AT=520.025n

* CHECK dout1_62 Vdout1_62ck103 = 0 time = 520
.meas tran vdout1_62ck103 FIND v(dout1_62) AT=520.025n

* CHECK dout1_63 Vdout1_63ck103 = 0 time = 520
.meas tran vdout1_63ck103 FIND v(dout1_63) AT=520.025n

* CHECK dout1_64 Vdout1_64ck103 = 0.9 time = 520
.meas tran vdout1_64ck103 FIND v(dout1_64) AT=520.025n

* CHECK dout1_65 Vdout1_65ck103 = 0.9 time = 520
.meas tran vdout1_65ck103 FIND v(dout1_65) AT=520.025n

* CHECK dout1_66 Vdout1_66ck103 = 0.9 time = 520
.meas tran vdout1_66ck103 FIND v(dout1_66) AT=520.025n

* CHECK dout1_67 Vdout1_67ck103 = 0.9 time = 520
.meas tran vdout1_67ck103 FIND v(dout1_67) AT=520.025n

* CHECK dout1_68 Vdout1_68ck103 = 0 time = 520
.meas tran vdout1_68ck103 FIND v(dout1_68) AT=520.025n

* CHECK dout1_69 Vdout1_69ck103 = 0 time = 520
.meas tran vdout1_69ck103 FIND v(dout1_69) AT=520.025n

* CHECK dout1_70 Vdout1_70ck103 = 0.9 time = 520
.meas tran vdout1_70ck103 FIND v(dout1_70) AT=520.025n

* CHECK dout1_71 Vdout1_71ck103 = 0.9 time = 520
.meas tran vdout1_71ck103 FIND v(dout1_71) AT=520.025n

* CHECK dout1_0 Vdout1_0ck104 = 0.9 time = 525
.meas tran vdout1_0ck104 FIND v(dout1_0) AT=525.025n

* CHECK dout1_1 Vdout1_1ck104 = 0.9 time = 525
.meas tran vdout1_1ck104 FIND v(dout1_1) AT=525.025n

* CHECK dout1_2 Vdout1_2ck104 = 0.9 time = 525
.meas tran vdout1_2ck104 FIND v(dout1_2) AT=525.025n

* CHECK dout1_3 Vdout1_3ck104 = 0 time = 525
.meas tran vdout1_3ck104 FIND v(dout1_3) AT=525.025n

* CHECK dout1_4 Vdout1_4ck104 = 0 time = 525
.meas tran vdout1_4ck104 FIND v(dout1_4) AT=525.025n

* CHECK dout1_5 Vdout1_5ck104 = 0 time = 525
.meas tran vdout1_5ck104 FIND v(dout1_5) AT=525.025n

* CHECK dout1_6 Vdout1_6ck104 = 0.9 time = 525
.meas tran vdout1_6ck104 FIND v(dout1_6) AT=525.025n

* CHECK dout1_7 Vdout1_7ck104 = 0.9 time = 525
.meas tran vdout1_7ck104 FIND v(dout1_7) AT=525.025n

* CHECK dout1_8 Vdout1_8ck104 = 0 time = 525
.meas tran vdout1_8ck104 FIND v(dout1_8) AT=525.025n

* CHECK dout1_9 Vdout1_9ck104 = 0.9 time = 525
.meas tran vdout1_9ck104 FIND v(dout1_9) AT=525.025n

* CHECK dout1_10 Vdout1_10ck104 = 0 time = 525
.meas tran vdout1_10ck104 FIND v(dout1_10) AT=525.025n

* CHECK dout1_11 Vdout1_11ck104 = 0.9 time = 525
.meas tran vdout1_11ck104 FIND v(dout1_11) AT=525.025n

* CHECK dout1_12 Vdout1_12ck104 = 0.9 time = 525
.meas tran vdout1_12ck104 FIND v(dout1_12) AT=525.025n

* CHECK dout1_13 Vdout1_13ck104 = 0 time = 525
.meas tran vdout1_13ck104 FIND v(dout1_13) AT=525.025n

* CHECK dout1_14 Vdout1_14ck104 = 0 time = 525
.meas tran vdout1_14ck104 FIND v(dout1_14) AT=525.025n

* CHECK dout1_15 Vdout1_15ck104 = 0 time = 525
.meas tran vdout1_15ck104 FIND v(dout1_15) AT=525.025n

* CHECK dout1_16 Vdout1_16ck104 = 0.9 time = 525
.meas tran vdout1_16ck104 FIND v(dout1_16) AT=525.025n

* CHECK dout1_17 Vdout1_17ck104 = 0 time = 525
.meas tran vdout1_17ck104 FIND v(dout1_17) AT=525.025n

* CHECK dout1_18 Vdout1_18ck104 = 0 time = 525
.meas tran vdout1_18ck104 FIND v(dout1_18) AT=525.025n

* CHECK dout1_19 Vdout1_19ck104 = 0 time = 525
.meas tran vdout1_19ck104 FIND v(dout1_19) AT=525.025n

* CHECK dout1_20 Vdout1_20ck104 = 0.9 time = 525
.meas tran vdout1_20ck104 FIND v(dout1_20) AT=525.025n

* CHECK dout1_21 Vdout1_21ck104 = 0.9 time = 525
.meas tran vdout1_21ck104 FIND v(dout1_21) AT=525.025n

* CHECK dout1_22 Vdout1_22ck104 = 0 time = 525
.meas tran vdout1_22ck104 FIND v(dout1_22) AT=525.025n

* CHECK dout1_23 Vdout1_23ck104 = 0.9 time = 525
.meas tran vdout1_23ck104 FIND v(dout1_23) AT=525.025n

* CHECK dout1_24 Vdout1_24ck104 = 0 time = 525
.meas tran vdout1_24ck104 FIND v(dout1_24) AT=525.025n

* CHECK dout1_25 Vdout1_25ck104 = 0.9 time = 525
.meas tran vdout1_25ck104 FIND v(dout1_25) AT=525.025n

* CHECK dout1_26 Vdout1_26ck104 = 0.9 time = 525
.meas tran vdout1_26ck104 FIND v(dout1_26) AT=525.025n

* CHECK dout1_27 Vdout1_27ck104 = 0 time = 525
.meas tran vdout1_27ck104 FIND v(dout1_27) AT=525.025n

* CHECK dout1_28 Vdout1_28ck104 = 0 time = 525
.meas tran vdout1_28ck104 FIND v(dout1_28) AT=525.025n

* CHECK dout1_29 Vdout1_29ck104 = 0 time = 525
.meas tran vdout1_29ck104 FIND v(dout1_29) AT=525.025n

* CHECK dout1_30 Vdout1_30ck104 = 0 time = 525
.meas tran vdout1_30ck104 FIND v(dout1_30) AT=525.025n

* CHECK dout1_31 Vdout1_31ck104 = 0 time = 525
.meas tran vdout1_31ck104 FIND v(dout1_31) AT=525.025n

* CHECK dout1_32 Vdout1_32ck104 = 0.9 time = 525
.meas tran vdout1_32ck104 FIND v(dout1_32) AT=525.025n

* CHECK dout1_33 Vdout1_33ck104 = 0 time = 525
.meas tran vdout1_33ck104 FIND v(dout1_33) AT=525.025n

* CHECK dout1_34 Vdout1_34ck104 = 0 time = 525
.meas tran vdout1_34ck104 FIND v(dout1_34) AT=525.025n

* CHECK dout1_35 Vdout1_35ck104 = 0 time = 525
.meas tran vdout1_35ck104 FIND v(dout1_35) AT=525.025n

* CHECK dout1_36 Vdout1_36ck104 = 0.9 time = 525
.meas tran vdout1_36ck104 FIND v(dout1_36) AT=525.025n

* CHECK dout1_37 Vdout1_37ck104 = 0 time = 525
.meas tran vdout1_37ck104 FIND v(dout1_37) AT=525.025n

* CHECK dout1_38 Vdout1_38ck104 = 0 time = 525
.meas tran vdout1_38ck104 FIND v(dout1_38) AT=525.025n

* CHECK dout1_39 Vdout1_39ck104 = 0 time = 525
.meas tran vdout1_39ck104 FIND v(dout1_39) AT=525.025n

* CHECK dout1_40 Vdout1_40ck104 = 0 time = 525
.meas tran vdout1_40ck104 FIND v(dout1_40) AT=525.025n

* CHECK dout1_41 Vdout1_41ck104 = 0 time = 525
.meas tran vdout1_41ck104 FIND v(dout1_41) AT=525.025n

* CHECK dout1_42 Vdout1_42ck104 = 0.9 time = 525
.meas tran vdout1_42ck104 FIND v(dout1_42) AT=525.025n

* CHECK dout1_43 Vdout1_43ck104 = 0.9 time = 525
.meas tran vdout1_43ck104 FIND v(dout1_43) AT=525.025n

* CHECK dout1_44 Vdout1_44ck104 = 0.9 time = 525
.meas tran vdout1_44ck104 FIND v(dout1_44) AT=525.025n

* CHECK dout1_45 Vdout1_45ck104 = 0.9 time = 525
.meas tran vdout1_45ck104 FIND v(dout1_45) AT=525.025n

* CHECK dout1_46 Vdout1_46ck104 = 0 time = 525
.meas tran vdout1_46ck104 FIND v(dout1_46) AT=525.025n

* CHECK dout1_47 Vdout1_47ck104 = 0 time = 525
.meas tran vdout1_47ck104 FIND v(dout1_47) AT=525.025n

* CHECK dout1_48 Vdout1_48ck104 = 0 time = 525
.meas tran vdout1_48ck104 FIND v(dout1_48) AT=525.025n

* CHECK dout1_49 Vdout1_49ck104 = 0 time = 525
.meas tran vdout1_49ck104 FIND v(dout1_49) AT=525.025n

* CHECK dout1_50 Vdout1_50ck104 = 0.9 time = 525
.meas tran vdout1_50ck104 FIND v(dout1_50) AT=525.025n

* CHECK dout1_51 Vdout1_51ck104 = 0.9 time = 525
.meas tran vdout1_51ck104 FIND v(dout1_51) AT=525.025n

* CHECK dout1_52 Vdout1_52ck104 = 0 time = 525
.meas tran vdout1_52ck104 FIND v(dout1_52) AT=525.025n

* CHECK dout1_53 Vdout1_53ck104 = 0.9 time = 525
.meas tran vdout1_53ck104 FIND v(dout1_53) AT=525.025n

* CHECK dout1_54 Vdout1_54ck104 = 0 time = 525
.meas tran vdout1_54ck104 FIND v(dout1_54) AT=525.025n

* CHECK dout1_55 Vdout1_55ck104 = 0.9 time = 525
.meas tran vdout1_55ck104 FIND v(dout1_55) AT=525.025n

* CHECK dout1_56 Vdout1_56ck104 = 0.9 time = 525
.meas tran vdout1_56ck104 FIND v(dout1_56) AT=525.025n

* CHECK dout1_57 Vdout1_57ck104 = 0.9 time = 525
.meas tran vdout1_57ck104 FIND v(dout1_57) AT=525.025n

* CHECK dout1_58 Vdout1_58ck104 = 0.9 time = 525
.meas tran vdout1_58ck104 FIND v(dout1_58) AT=525.025n

* CHECK dout1_59 Vdout1_59ck104 = 0 time = 525
.meas tran vdout1_59ck104 FIND v(dout1_59) AT=525.025n

* CHECK dout1_60 Vdout1_60ck104 = 0 time = 525
.meas tran vdout1_60ck104 FIND v(dout1_60) AT=525.025n

* CHECK dout1_61 Vdout1_61ck104 = 0 time = 525
.meas tran vdout1_61ck104 FIND v(dout1_61) AT=525.025n

* CHECK dout1_62 Vdout1_62ck104 = 0 time = 525
.meas tran vdout1_62ck104 FIND v(dout1_62) AT=525.025n

* CHECK dout1_63 Vdout1_63ck104 = 0 time = 525
.meas tran vdout1_63ck104 FIND v(dout1_63) AT=525.025n

* CHECK dout1_64 Vdout1_64ck104 = 0.9 time = 525
.meas tran vdout1_64ck104 FIND v(dout1_64) AT=525.025n

* CHECK dout1_65 Vdout1_65ck104 = 0.9 time = 525
.meas tran vdout1_65ck104 FIND v(dout1_65) AT=525.025n

* CHECK dout1_66 Vdout1_66ck104 = 0.9 time = 525
.meas tran vdout1_66ck104 FIND v(dout1_66) AT=525.025n

* CHECK dout1_67 Vdout1_67ck104 = 0.9 time = 525
.meas tran vdout1_67ck104 FIND v(dout1_67) AT=525.025n

* CHECK dout1_68 Vdout1_68ck104 = 0 time = 525
.meas tran vdout1_68ck104 FIND v(dout1_68) AT=525.025n

* CHECK dout1_69 Vdout1_69ck104 = 0 time = 525
.meas tran vdout1_69ck104 FIND v(dout1_69) AT=525.025n

* CHECK dout1_70 Vdout1_70ck104 = 0.9 time = 525
.meas tran vdout1_70ck104 FIND v(dout1_70) AT=525.025n

* CHECK dout1_71 Vdout1_71ck104 = 0.9 time = 525
.meas tran vdout1_71ck104 FIND v(dout1_71) AT=525.025n

* CHECK dout1_0 Vdout1_0ck106 = 0.9 time = 535
.meas tran vdout1_0ck106 FIND v(dout1_0) AT=535.025n

* CHECK dout1_1 Vdout1_1ck106 = 0 time = 535
.meas tran vdout1_1ck106 FIND v(dout1_1) AT=535.025n

* CHECK dout1_2 Vdout1_2ck106 = 0 time = 535
.meas tran vdout1_2ck106 FIND v(dout1_2) AT=535.025n

* CHECK dout1_3 Vdout1_3ck106 = 0 time = 535
.meas tran vdout1_3ck106 FIND v(dout1_3) AT=535.025n

* CHECK dout1_4 Vdout1_4ck106 = 0.9 time = 535
.meas tran vdout1_4ck106 FIND v(dout1_4) AT=535.025n

* CHECK dout1_5 Vdout1_5ck106 = 0.9 time = 535
.meas tran vdout1_5ck106 FIND v(dout1_5) AT=535.025n

* CHECK dout1_6 Vdout1_6ck106 = 0.9 time = 535
.meas tran vdout1_6ck106 FIND v(dout1_6) AT=535.025n

* CHECK dout1_7 Vdout1_7ck106 = 0.9 time = 535
.meas tran vdout1_7ck106 FIND v(dout1_7) AT=535.025n

* CHECK dout1_8 Vdout1_8ck106 = 0 time = 535
.meas tran vdout1_8ck106 FIND v(dout1_8) AT=535.025n

* CHECK dout1_9 Vdout1_9ck106 = 0.9 time = 535
.meas tran vdout1_9ck106 FIND v(dout1_9) AT=535.025n

* CHECK dout1_10 Vdout1_10ck106 = 0 time = 535
.meas tran vdout1_10ck106 FIND v(dout1_10) AT=535.025n

* CHECK dout1_11 Vdout1_11ck106 = 0 time = 535
.meas tran vdout1_11ck106 FIND v(dout1_11) AT=535.025n

* CHECK dout1_12 Vdout1_12ck106 = 0.9 time = 535
.meas tran vdout1_12ck106 FIND v(dout1_12) AT=535.025n

* CHECK dout1_13 Vdout1_13ck106 = 0 time = 535
.meas tran vdout1_13ck106 FIND v(dout1_13) AT=535.025n

* CHECK dout1_14 Vdout1_14ck106 = 0.9 time = 535
.meas tran vdout1_14ck106 FIND v(dout1_14) AT=535.025n

* CHECK dout1_15 Vdout1_15ck106 = 0.9 time = 535
.meas tran vdout1_15ck106 FIND v(dout1_15) AT=535.025n

* CHECK dout1_16 Vdout1_16ck106 = 0 time = 535
.meas tran vdout1_16ck106 FIND v(dout1_16) AT=535.025n

* CHECK dout1_17 Vdout1_17ck106 = 0.9 time = 535
.meas tran vdout1_17ck106 FIND v(dout1_17) AT=535.025n

* CHECK dout1_18 Vdout1_18ck106 = 0 time = 535
.meas tran vdout1_18ck106 FIND v(dout1_18) AT=535.025n

* CHECK dout1_19 Vdout1_19ck106 = 0.9 time = 535
.meas tran vdout1_19ck106 FIND v(dout1_19) AT=535.025n

* CHECK dout1_20 Vdout1_20ck106 = 0 time = 535
.meas tran vdout1_20ck106 FIND v(dout1_20) AT=535.025n

* CHECK dout1_21 Vdout1_21ck106 = 0 time = 535
.meas tran vdout1_21ck106 FIND v(dout1_21) AT=535.025n

* CHECK dout1_22 Vdout1_22ck106 = 0 time = 535
.meas tran vdout1_22ck106 FIND v(dout1_22) AT=535.025n

* CHECK dout1_23 Vdout1_23ck106 = 0 time = 535
.meas tran vdout1_23ck106 FIND v(dout1_23) AT=535.025n

* CHECK dout1_24 Vdout1_24ck106 = 0.9 time = 535
.meas tran vdout1_24ck106 FIND v(dout1_24) AT=535.025n

* CHECK dout1_25 Vdout1_25ck106 = 0 time = 535
.meas tran vdout1_25ck106 FIND v(dout1_25) AT=535.025n

* CHECK dout1_26 Vdout1_26ck106 = 0.9 time = 535
.meas tran vdout1_26ck106 FIND v(dout1_26) AT=535.025n

* CHECK dout1_27 Vdout1_27ck106 = 0.9 time = 535
.meas tran vdout1_27ck106 FIND v(dout1_27) AT=535.025n

* CHECK dout1_28 Vdout1_28ck106 = 0 time = 535
.meas tran vdout1_28ck106 FIND v(dout1_28) AT=535.025n

* CHECK dout1_29 Vdout1_29ck106 = 0 time = 535
.meas tran vdout1_29ck106 FIND v(dout1_29) AT=535.025n

* CHECK dout1_30 Vdout1_30ck106 = 0 time = 535
.meas tran vdout1_30ck106 FIND v(dout1_30) AT=535.025n

* CHECK dout1_31 Vdout1_31ck106 = 0 time = 535
.meas tran vdout1_31ck106 FIND v(dout1_31) AT=535.025n

* CHECK dout1_32 Vdout1_32ck106 = 0 time = 535
.meas tran vdout1_32ck106 FIND v(dout1_32) AT=535.025n

* CHECK dout1_33 Vdout1_33ck106 = 0 time = 535
.meas tran vdout1_33ck106 FIND v(dout1_33) AT=535.025n

* CHECK dout1_34 Vdout1_34ck106 = 0.9 time = 535
.meas tran vdout1_34ck106 FIND v(dout1_34) AT=535.025n

* CHECK dout1_35 Vdout1_35ck106 = 0.9 time = 535
.meas tran vdout1_35ck106 FIND v(dout1_35) AT=535.025n

* CHECK dout1_36 Vdout1_36ck106 = 0.9 time = 535
.meas tran vdout1_36ck106 FIND v(dout1_36) AT=535.025n

* CHECK dout1_37 Vdout1_37ck106 = 0 time = 535
.meas tran vdout1_37ck106 FIND v(dout1_37) AT=535.025n

* CHECK dout1_38 Vdout1_38ck106 = 0 time = 535
.meas tran vdout1_38ck106 FIND v(dout1_38) AT=535.025n

* CHECK dout1_39 Vdout1_39ck106 = 0.9 time = 535
.meas tran vdout1_39ck106 FIND v(dout1_39) AT=535.025n

* CHECK dout1_40 Vdout1_40ck106 = 0 time = 535
.meas tran vdout1_40ck106 FIND v(dout1_40) AT=535.025n

* CHECK dout1_41 Vdout1_41ck106 = 0.9 time = 535
.meas tran vdout1_41ck106 FIND v(dout1_41) AT=535.025n

* CHECK dout1_42 Vdout1_42ck106 = 0 time = 535
.meas tran vdout1_42ck106 FIND v(dout1_42) AT=535.025n

* CHECK dout1_43 Vdout1_43ck106 = 0.9 time = 535
.meas tran vdout1_43ck106 FIND v(dout1_43) AT=535.025n

* CHECK dout1_44 Vdout1_44ck106 = 0 time = 535
.meas tran vdout1_44ck106 FIND v(dout1_44) AT=535.025n

* CHECK dout1_45 Vdout1_45ck106 = 0.9 time = 535
.meas tran vdout1_45ck106 FIND v(dout1_45) AT=535.025n

* CHECK dout1_46 Vdout1_46ck106 = 0 time = 535
.meas tran vdout1_46ck106 FIND v(dout1_46) AT=535.025n

* CHECK dout1_47 Vdout1_47ck106 = 0.9 time = 535
.meas tran vdout1_47ck106 FIND v(dout1_47) AT=535.025n

* CHECK dout1_48 Vdout1_48ck106 = 0.9 time = 535
.meas tran vdout1_48ck106 FIND v(dout1_48) AT=535.025n

* CHECK dout1_49 Vdout1_49ck106 = 0 time = 535
.meas tran vdout1_49ck106 FIND v(dout1_49) AT=535.025n

* CHECK dout1_50 Vdout1_50ck106 = 0 time = 535
.meas tran vdout1_50ck106 FIND v(dout1_50) AT=535.025n

* CHECK dout1_51 Vdout1_51ck106 = 0 time = 535
.meas tran vdout1_51ck106 FIND v(dout1_51) AT=535.025n

* CHECK dout1_52 Vdout1_52ck106 = 0.9 time = 535
.meas tran vdout1_52ck106 FIND v(dout1_52) AT=535.025n

* CHECK dout1_53 Vdout1_53ck106 = 0.9 time = 535
.meas tran vdout1_53ck106 FIND v(dout1_53) AT=535.025n

* CHECK dout1_54 Vdout1_54ck106 = 0 time = 535
.meas tran vdout1_54ck106 FIND v(dout1_54) AT=535.025n

* CHECK dout1_55 Vdout1_55ck106 = 0.9 time = 535
.meas tran vdout1_55ck106 FIND v(dout1_55) AT=535.025n

* CHECK dout1_56 Vdout1_56ck106 = 0 time = 535
.meas tran vdout1_56ck106 FIND v(dout1_56) AT=535.025n

* CHECK dout1_57 Vdout1_57ck106 = 0 time = 535
.meas tran vdout1_57ck106 FIND v(dout1_57) AT=535.025n

* CHECK dout1_58 Vdout1_58ck106 = 0.9 time = 535
.meas tran vdout1_58ck106 FIND v(dout1_58) AT=535.025n

* CHECK dout1_59 Vdout1_59ck106 = 0.9 time = 535
.meas tran vdout1_59ck106 FIND v(dout1_59) AT=535.025n

* CHECK dout1_60 Vdout1_60ck106 = 0.9 time = 535
.meas tran vdout1_60ck106 FIND v(dout1_60) AT=535.025n

* CHECK dout1_61 Vdout1_61ck106 = 0 time = 535
.meas tran vdout1_61ck106 FIND v(dout1_61) AT=535.025n

* CHECK dout1_62 Vdout1_62ck106 = 0 time = 535
.meas tran vdout1_62ck106 FIND v(dout1_62) AT=535.025n

* CHECK dout1_63 Vdout1_63ck106 = 0 time = 535
.meas tran vdout1_63ck106 FIND v(dout1_63) AT=535.025n

* CHECK dout1_64 Vdout1_64ck106 = 0 time = 535
.meas tran vdout1_64ck106 FIND v(dout1_64) AT=535.025n

* CHECK dout1_65 Vdout1_65ck106 = 0.9 time = 535
.meas tran vdout1_65ck106 FIND v(dout1_65) AT=535.025n

* CHECK dout1_66 Vdout1_66ck106 = 0 time = 535
.meas tran vdout1_66ck106 FIND v(dout1_66) AT=535.025n

* CHECK dout1_67 Vdout1_67ck106 = 0.9 time = 535
.meas tran vdout1_67ck106 FIND v(dout1_67) AT=535.025n

* CHECK dout1_68 Vdout1_68ck106 = 0 time = 535
.meas tran vdout1_68ck106 FIND v(dout1_68) AT=535.025n

* CHECK dout1_69 Vdout1_69ck106 = 0.9 time = 535
.meas tran vdout1_69ck106 FIND v(dout1_69) AT=535.025n

* CHECK dout1_70 Vdout1_70ck106 = 0.9 time = 535
.meas tran vdout1_70ck106 FIND v(dout1_70) AT=535.025n

* CHECK dout1_71 Vdout1_71ck106 = 0 time = 535
.meas tran vdout1_71ck106 FIND v(dout1_71) AT=535.025n

* CHECK dout1_0 Vdout1_0ck107 = 0.9 time = 540
.meas tran vdout1_0ck107 FIND v(dout1_0) AT=540.025n

* CHECK dout1_1 Vdout1_1ck107 = 0 time = 540
.meas tran vdout1_1ck107 FIND v(dout1_1) AT=540.025n

* CHECK dout1_2 Vdout1_2ck107 = 0 time = 540
.meas tran vdout1_2ck107 FIND v(dout1_2) AT=540.025n

* CHECK dout1_3 Vdout1_3ck107 = 0 time = 540
.meas tran vdout1_3ck107 FIND v(dout1_3) AT=540.025n

* CHECK dout1_4 Vdout1_4ck107 = 0.9 time = 540
.meas tran vdout1_4ck107 FIND v(dout1_4) AT=540.025n

* CHECK dout1_5 Vdout1_5ck107 = 0.9 time = 540
.meas tran vdout1_5ck107 FIND v(dout1_5) AT=540.025n

* CHECK dout1_6 Vdout1_6ck107 = 0.9 time = 540
.meas tran vdout1_6ck107 FIND v(dout1_6) AT=540.025n

* CHECK dout1_7 Vdout1_7ck107 = 0.9 time = 540
.meas tran vdout1_7ck107 FIND v(dout1_7) AT=540.025n

* CHECK dout1_8 Vdout1_8ck107 = 0 time = 540
.meas tran vdout1_8ck107 FIND v(dout1_8) AT=540.025n

* CHECK dout1_9 Vdout1_9ck107 = 0.9 time = 540
.meas tran vdout1_9ck107 FIND v(dout1_9) AT=540.025n

* CHECK dout1_10 Vdout1_10ck107 = 0 time = 540
.meas tran vdout1_10ck107 FIND v(dout1_10) AT=540.025n

* CHECK dout1_11 Vdout1_11ck107 = 0 time = 540
.meas tran vdout1_11ck107 FIND v(dout1_11) AT=540.025n

* CHECK dout1_12 Vdout1_12ck107 = 0.9 time = 540
.meas tran vdout1_12ck107 FIND v(dout1_12) AT=540.025n

* CHECK dout1_13 Vdout1_13ck107 = 0 time = 540
.meas tran vdout1_13ck107 FIND v(dout1_13) AT=540.025n

* CHECK dout1_14 Vdout1_14ck107 = 0.9 time = 540
.meas tran vdout1_14ck107 FIND v(dout1_14) AT=540.025n

* CHECK dout1_15 Vdout1_15ck107 = 0.9 time = 540
.meas tran vdout1_15ck107 FIND v(dout1_15) AT=540.025n

* CHECK dout1_16 Vdout1_16ck107 = 0 time = 540
.meas tran vdout1_16ck107 FIND v(dout1_16) AT=540.025n

* CHECK dout1_17 Vdout1_17ck107 = 0.9 time = 540
.meas tran vdout1_17ck107 FIND v(dout1_17) AT=540.025n

* CHECK dout1_18 Vdout1_18ck107 = 0 time = 540
.meas tran vdout1_18ck107 FIND v(dout1_18) AT=540.025n

* CHECK dout1_19 Vdout1_19ck107 = 0.9 time = 540
.meas tran vdout1_19ck107 FIND v(dout1_19) AT=540.025n

* CHECK dout1_20 Vdout1_20ck107 = 0 time = 540
.meas tran vdout1_20ck107 FIND v(dout1_20) AT=540.025n

* CHECK dout1_21 Vdout1_21ck107 = 0 time = 540
.meas tran vdout1_21ck107 FIND v(dout1_21) AT=540.025n

* CHECK dout1_22 Vdout1_22ck107 = 0 time = 540
.meas tran vdout1_22ck107 FIND v(dout1_22) AT=540.025n

* CHECK dout1_23 Vdout1_23ck107 = 0 time = 540
.meas tran vdout1_23ck107 FIND v(dout1_23) AT=540.025n

* CHECK dout1_24 Vdout1_24ck107 = 0.9 time = 540
.meas tran vdout1_24ck107 FIND v(dout1_24) AT=540.025n

* CHECK dout1_25 Vdout1_25ck107 = 0 time = 540
.meas tran vdout1_25ck107 FIND v(dout1_25) AT=540.025n

* CHECK dout1_26 Vdout1_26ck107 = 0.9 time = 540
.meas tran vdout1_26ck107 FIND v(dout1_26) AT=540.025n

* CHECK dout1_27 Vdout1_27ck107 = 0.9 time = 540
.meas tran vdout1_27ck107 FIND v(dout1_27) AT=540.025n

* CHECK dout1_28 Vdout1_28ck107 = 0 time = 540
.meas tran vdout1_28ck107 FIND v(dout1_28) AT=540.025n

* CHECK dout1_29 Vdout1_29ck107 = 0 time = 540
.meas tran vdout1_29ck107 FIND v(dout1_29) AT=540.025n

* CHECK dout1_30 Vdout1_30ck107 = 0 time = 540
.meas tran vdout1_30ck107 FIND v(dout1_30) AT=540.025n

* CHECK dout1_31 Vdout1_31ck107 = 0 time = 540
.meas tran vdout1_31ck107 FIND v(dout1_31) AT=540.025n

* CHECK dout1_32 Vdout1_32ck107 = 0 time = 540
.meas tran vdout1_32ck107 FIND v(dout1_32) AT=540.025n

* CHECK dout1_33 Vdout1_33ck107 = 0 time = 540
.meas tran vdout1_33ck107 FIND v(dout1_33) AT=540.025n

* CHECK dout1_34 Vdout1_34ck107 = 0.9 time = 540
.meas tran vdout1_34ck107 FIND v(dout1_34) AT=540.025n

* CHECK dout1_35 Vdout1_35ck107 = 0.9 time = 540
.meas tran vdout1_35ck107 FIND v(dout1_35) AT=540.025n

* CHECK dout1_36 Vdout1_36ck107 = 0.9 time = 540
.meas tran vdout1_36ck107 FIND v(dout1_36) AT=540.025n

* CHECK dout1_37 Vdout1_37ck107 = 0 time = 540
.meas tran vdout1_37ck107 FIND v(dout1_37) AT=540.025n

* CHECK dout1_38 Vdout1_38ck107 = 0 time = 540
.meas tran vdout1_38ck107 FIND v(dout1_38) AT=540.025n

* CHECK dout1_39 Vdout1_39ck107 = 0.9 time = 540
.meas tran vdout1_39ck107 FIND v(dout1_39) AT=540.025n

* CHECK dout1_40 Vdout1_40ck107 = 0 time = 540
.meas tran vdout1_40ck107 FIND v(dout1_40) AT=540.025n

* CHECK dout1_41 Vdout1_41ck107 = 0.9 time = 540
.meas tran vdout1_41ck107 FIND v(dout1_41) AT=540.025n

* CHECK dout1_42 Vdout1_42ck107 = 0 time = 540
.meas tran vdout1_42ck107 FIND v(dout1_42) AT=540.025n

* CHECK dout1_43 Vdout1_43ck107 = 0.9 time = 540
.meas tran vdout1_43ck107 FIND v(dout1_43) AT=540.025n

* CHECK dout1_44 Vdout1_44ck107 = 0 time = 540
.meas tran vdout1_44ck107 FIND v(dout1_44) AT=540.025n

* CHECK dout1_45 Vdout1_45ck107 = 0.9 time = 540
.meas tran vdout1_45ck107 FIND v(dout1_45) AT=540.025n

* CHECK dout1_46 Vdout1_46ck107 = 0 time = 540
.meas tran vdout1_46ck107 FIND v(dout1_46) AT=540.025n

* CHECK dout1_47 Vdout1_47ck107 = 0.9 time = 540
.meas tran vdout1_47ck107 FIND v(dout1_47) AT=540.025n

* CHECK dout1_48 Vdout1_48ck107 = 0.9 time = 540
.meas tran vdout1_48ck107 FIND v(dout1_48) AT=540.025n

* CHECK dout1_49 Vdout1_49ck107 = 0 time = 540
.meas tran vdout1_49ck107 FIND v(dout1_49) AT=540.025n

* CHECK dout1_50 Vdout1_50ck107 = 0 time = 540
.meas tran vdout1_50ck107 FIND v(dout1_50) AT=540.025n

* CHECK dout1_51 Vdout1_51ck107 = 0 time = 540
.meas tran vdout1_51ck107 FIND v(dout1_51) AT=540.025n

* CHECK dout1_52 Vdout1_52ck107 = 0.9 time = 540
.meas tran vdout1_52ck107 FIND v(dout1_52) AT=540.025n

* CHECK dout1_53 Vdout1_53ck107 = 0.9 time = 540
.meas tran vdout1_53ck107 FIND v(dout1_53) AT=540.025n

* CHECK dout1_54 Vdout1_54ck107 = 0 time = 540
.meas tran vdout1_54ck107 FIND v(dout1_54) AT=540.025n

* CHECK dout1_55 Vdout1_55ck107 = 0.9 time = 540
.meas tran vdout1_55ck107 FIND v(dout1_55) AT=540.025n

* CHECK dout1_56 Vdout1_56ck107 = 0 time = 540
.meas tran vdout1_56ck107 FIND v(dout1_56) AT=540.025n

* CHECK dout1_57 Vdout1_57ck107 = 0 time = 540
.meas tran vdout1_57ck107 FIND v(dout1_57) AT=540.025n

* CHECK dout1_58 Vdout1_58ck107 = 0.9 time = 540
.meas tran vdout1_58ck107 FIND v(dout1_58) AT=540.025n

* CHECK dout1_59 Vdout1_59ck107 = 0.9 time = 540
.meas tran vdout1_59ck107 FIND v(dout1_59) AT=540.025n

* CHECK dout1_60 Vdout1_60ck107 = 0.9 time = 540
.meas tran vdout1_60ck107 FIND v(dout1_60) AT=540.025n

* CHECK dout1_61 Vdout1_61ck107 = 0 time = 540
.meas tran vdout1_61ck107 FIND v(dout1_61) AT=540.025n

* CHECK dout1_62 Vdout1_62ck107 = 0 time = 540
.meas tran vdout1_62ck107 FIND v(dout1_62) AT=540.025n

* CHECK dout1_63 Vdout1_63ck107 = 0 time = 540
.meas tran vdout1_63ck107 FIND v(dout1_63) AT=540.025n

* CHECK dout1_64 Vdout1_64ck107 = 0 time = 540
.meas tran vdout1_64ck107 FIND v(dout1_64) AT=540.025n

* CHECK dout1_65 Vdout1_65ck107 = 0.9 time = 540
.meas tran vdout1_65ck107 FIND v(dout1_65) AT=540.025n

* CHECK dout1_66 Vdout1_66ck107 = 0 time = 540
.meas tran vdout1_66ck107 FIND v(dout1_66) AT=540.025n

* CHECK dout1_67 Vdout1_67ck107 = 0.9 time = 540
.meas tran vdout1_67ck107 FIND v(dout1_67) AT=540.025n

* CHECK dout1_68 Vdout1_68ck107 = 0 time = 540
.meas tran vdout1_68ck107 FIND v(dout1_68) AT=540.025n

* CHECK dout1_69 Vdout1_69ck107 = 0.9 time = 540
.meas tran vdout1_69ck107 FIND v(dout1_69) AT=540.025n

* CHECK dout1_70 Vdout1_70ck107 = 0.9 time = 540
.meas tran vdout1_70ck107 FIND v(dout1_70) AT=540.025n

* CHECK dout1_71 Vdout1_71ck107 = 0 time = 540
.meas tran vdout1_71ck107 FIND v(dout1_71) AT=540.025n

* CHECK dout1_0 Vdout1_0ck108 = 0.9 time = 545
.meas tran vdout1_0ck108 FIND v(dout1_0) AT=545.025n

* CHECK dout1_1 Vdout1_1ck108 = 0 time = 545
.meas tran vdout1_1ck108 FIND v(dout1_1) AT=545.025n

* CHECK dout1_2 Vdout1_2ck108 = 0.9 time = 545
.meas tran vdout1_2ck108 FIND v(dout1_2) AT=545.025n

* CHECK dout1_3 Vdout1_3ck108 = 0.9 time = 545
.meas tran vdout1_3ck108 FIND v(dout1_3) AT=545.025n

* CHECK dout1_4 Vdout1_4ck108 = 0 time = 545
.meas tran vdout1_4ck108 FIND v(dout1_4) AT=545.025n

* CHECK dout1_5 Vdout1_5ck108 = 0 time = 545
.meas tran vdout1_5ck108 FIND v(dout1_5) AT=545.025n

* CHECK dout1_6 Vdout1_6ck108 = 0 time = 545
.meas tran vdout1_6ck108 FIND v(dout1_6) AT=545.025n

* CHECK dout1_7 Vdout1_7ck108 = 0.9 time = 545
.meas tran vdout1_7ck108 FIND v(dout1_7) AT=545.025n

* CHECK dout1_8 Vdout1_8ck108 = 0 time = 545
.meas tran vdout1_8ck108 FIND v(dout1_8) AT=545.025n

* CHECK dout1_9 Vdout1_9ck108 = 0 time = 545
.meas tran vdout1_9ck108 FIND v(dout1_9) AT=545.025n

* CHECK dout1_10 Vdout1_10ck108 = 0 time = 545
.meas tran vdout1_10ck108 FIND v(dout1_10) AT=545.025n

* CHECK dout1_11 Vdout1_11ck108 = 0.9 time = 545
.meas tran vdout1_11ck108 FIND v(dout1_11) AT=545.025n

* CHECK dout1_12 Vdout1_12ck108 = 0.9 time = 545
.meas tran vdout1_12ck108 FIND v(dout1_12) AT=545.025n

* CHECK dout1_13 Vdout1_13ck108 = 0.9 time = 545
.meas tran vdout1_13ck108 FIND v(dout1_13) AT=545.025n

* CHECK dout1_14 Vdout1_14ck108 = 0.9 time = 545
.meas tran vdout1_14ck108 FIND v(dout1_14) AT=545.025n

* CHECK dout1_15 Vdout1_15ck108 = 0.9 time = 545
.meas tran vdout1_15ck108 FIND v(dout1_15) AT=545.025n

* CHECK dout1_16 Vdout1_16ck108 = 0.9 time = 545
.meas tran vdout1_16ck108 FIND v(dout1_16) AT=545.025n

* CHECK dout1_17 Vdout1_17ck108 = 0.9 time = 545
.meas tran vdout1_17ck108 FIND v(dout1_17) AT=545.025n

* CHECK dout1_18 Vdout1_18ck108 = 0.9 time = 545
.meas tran vdout1_18ck108 FIND v(dout1_18) AT=545.025n

* CHECK dout1_19 Vdout1_19ck108 = 0 time = 545
.meas tran vdout1_19ck108 FIND v(dout1_19) AT=545.025n

* CHECK dout1_20 Vdout1_20ck108 = 0 time = 545
.meas tran vdout1_20ck108 FIND v(dout1_20) AT=545.025n

* CHECK dout1_21 Vdout1_21ck108 = 0 time = 545
.meas tran vdout1_21ck108 FIND v(dout1_21) AT=545.025n

* CHECK dout1_22 Vdout1_22ck108 = 0 time = 545
.meas tran vdout1_22ck108 FIND v(dout1_22) AT=545.025n

* CHECK dout1_23 Vdout1_23ck108 = 0 time = 545
.meas tran vdout1_23ck108 FIND v(dout1_23) AT=545.025n

* CHECK dout1_24 Vdout1_24ck108 = 0 time = 545
.meas tran vdout1_24ck108 FIND v(dout1_24) AT=545.025n

* CHECK dout1_25 Vdout1_25ck108 = 0.9 time = 545
.meas tran vdout1_25ck108 FIND v(dout1_25) AT=545.025n

* CHECK dout1_26 Vdout1_26ck108 = 0.9 time = 545
.meas tran vdout1_26ck108 FIND v(dout1_26) AT=545.025n

* CHECK dout1_27 Vdout1_27ck108 = 0.9 time = 545
.meas tran vdout1_27ck108 FIND v(dout1_27) AT=545.025n

* CHECK dout1_28 Vdout1_28ck108 = 0.9 time = 545
.meas tran vdout1_28ck108 FIND v(dout1_28) AT=545.025n

* CHECK dout1_29 Vdout1_29ck108 = 0 time = 545
.meas tran vdout1_29ck108 FIND v(dout1_29) AT=545.025n

* CHECK dout1_30 Vdout1_30ck108 = 0.9 time = 545
.meas tran vdout1_30ck108 FIND v(dout1_30) AT=545.025n

* CHECK dout1_31 Vdout1_31ck108 = 0.9 time = 545
.meas tran vdout1_31ck108 FIND v(dout1_31) AT=545.025n

* CHECK dout1_32 Vdout1_32ck108 = 0.9 time = 545
.meas tran vdout1_32ck108 FIND v(dout1_32) AT=545.025n

* CHECK dout1_33 Vdout1_33ck108 = 0 time = 545
.meas tran vdout1_33ck108 FIND v(dout1_33) AT=545.025n

* CHECK dout1_34 Vdout1_34ck108 = 0 time = 545
.meas tran vdout1_34ck108 FIND v(dout1_34) AT=545.025n

* CHECK dout1_35 Vdout1_35ck108 = 0 time = 545
.meas tran vdout1_35ck108 FIND v(dout1_35) AT=545.025n

* CHECK dout1_36 Vdout1_36ck108 = 0 time = 545
.meas tran vdout1_36ck108 FIND v(dout1_36) AT=545.025n

* CHECK dout1_37 Vdout1_37ck108 = 0.9 time = 545
.meas tran vdout1_37ck108 FIND v(dout1_37) AT=545.025n

* CHECK dout1_38 Vdout1_38ck108 = 0 time = 545
.meas tran vdout1_38ck108 FIND v(dout1_38) AT=545.025n

* CHECK dout1_39 Vdout1_39ck108 = 0 time = 545
.meas tran vdout1_39ck108 FIND v(dout1_39) AT=545.025n

* CHECK dout1_40 Vdout1_40ck108 = 0 time = 545
.meas tran vdout1_40ck108 FIND v(dout1_40) AT=545.025n

* CHECK dout1_41 Vdout1_41ck108 = 0 time = 545
.meas tran vdout1_41ck108 FIND v(dout1_41) AT=545.025n

* CHECK dout1_42 Vdout1_42ck108 = 0 time = 545
.meas tran vdout1_42ck108 FIND v(dout1_42) AT=545.025n

* CHECK dout1_43 Vdout1_43ck108 = 0 time = 545
.meas tran vdout1_43ck108 FIND v(dout1_43) AT=545.025n

* CHECK dout1_44 Vdout1_44ck108 = 0 time = 545
.meas tran vdout1_44ck108 FIND v(dout1_44) AT=545.025n

* CHECK dout1_45 Vdout1_45ck108 = 0.9 time = 545
.meas tran vdout1_45ck108 FIND v(dout1_45) AT=545.025n

* CHECK dout1_46 Vdout1_46ck108 = 0 time = 545
.meas tran vdout1_46ck108 FIND v(dout1_46) AT=545.025n

* CHECK dout1_47 Vdout1_47ck108 = 0.9 time = 545
.meas tran vdout1_47ck108 FIND v(dout1_47) AT=545.025n

* CHECK dout1_48 Vdout1_48ck108 = 0.9 time = 545
.meas tran vdout1_48ck108 FIND v(dout1_48) AT=545.025n

* CHECK dout1_49 Vdout1_49ck108 = 0.9 time = 545
.meas tran vdout1_49ck108 FIND v(dout1_49) AT=545.025n

* CHECK dout1_50 Vdout1_50ck108 = 0.9 time = 545
.meas tran vdout1_50ck108 FIND v(dout1_50) AT=545.025n

* CHECK dout1_51 Vdout1_51ck108 = 0 time = 545
.meas tran vdout1_51ck108 FIND v(dout1_51) AT=545.025n

* CHECK dout1_52 Vdout1_52ck108 = 0 time = 545
.meas tran vdout1_52ck108 FIND v(dout1_52) AT=545.025n

* CHECK dout1_53 Vdout1_53ck108 = 0.9 time = 545
.meas tran vdout1_53ck108 FIND v(dout1_53) AT=545.025n

* CHECK dout1_54 Vdout1_54ck108 = 0 time = 545
.meas tran vdout1_54ck108 FIND v(dout1_54) AT=545.025n

* CHECK dout1_55 Vdout1_55ck108 = 0 time = 545
.meas tran vdout1_55ck108 FIND v(dout1_55) AT=545.025n

* CHECK dout1_56 Vdout1_56ck108 = 0 time = 545
.meas tran vdout1_56ck108 FIND v(dout1_56) AT=545.025n

* CHECK dout1_57 Vdout1_57ck108 = 0.9 time = 545
.meas tran vdout1_57ck108 FIND v(dout1_57) AT=545.025n

* CHECK dout1_58 Vdout1_58ck108 = 0 time = 545
.meas tran vdout1_58ck108 FIND v(dout1_58) AT=545.025n

* CHECK dout1_59 Vdout1_59ck108 = 0 time = 545
.meas tran vdout1_59ck108 FIND v(dout1_59) AT=545.025n

* CHECK dout1_60 Vdout1_60ck108 = 0.9 time = 545
.meas tran vdout1_60ck108 FIND v(dout1_60) AT=545.025n

* CHECK dout1_61 Vdout1_61ck108 = 0.9 time = 545
.meas tran vdout1_61ck108 FIND v(dout1_61) AT=545.025n

* CHECK dout1_62 Vdout1_62ck108 = 0.9 time = 545
.meas tran vdout1_62ck108 FIND v(dout1_62) AT=545.025n

* CHECK dout1_63 Vdout1_63ck108 = 0.9 time = 545
.meas tran vdout1_63ck108 FIND v(dout1_63) AT=545.025n

* CHECK dout1_64 Vdout1_64ck108 = 0.9 time = 545
.meas tran vdout1_64ck108 FIND v(dout1_64) AT=545.025n

* CHECK dout1_65 Vdout1_65ck108 = 0.9 time = 545
.meas tran vdout1_65ck108 FIND v(dout1_65) AT=545.025n

* CHECK dout1_66 Vdout1_66ck108 = 0.9 time = 545
.meas tran vdout1_66ck108 FIND v(dout1_66) AT=545.025n

* CHECK dout1_67 Vdout1_67ck108 = 0 time = 545
.meas tran vdout1_67ck108 FIND v(dout1_67) AT=545.025n

* CHECK dout1_68 Vdout1_68ck108 = 0 time = 545
.meas tran vdout1_68ck108 FIND v(dout1_68) AT=545.025n

* CHECK dout1_69 Vdout1_69ck108 = 0.9 time = 545
.meas tran vdout1_69ck108 FIND v(dout1_69) AT=545.025n

* CHECK dout1_70 Vdout1_70ck108 = 0.9 time = 545
.meas tran vdout1_70ck108 FIND v(dout1_70) AT=545.025n

* CHECK dout1_71 Vdout1_71ck108 = 0.9 time = 545
.meas tran vdout1_71ck108 FIND v(dout1_71) AT=545.025n

* CHECK dout1_0 Vdout1_0ck110 = 0.9 time = 555
.meas tran vdout1_0ck110 FIND v(dout1_0) AT=555.025n

* CHECK dout1_1 Vdout1_1ck110 = 0 time = 555
.meas tran vdout1_1ck110 FIND v(dout1_1) AT=555.025n

* CHECK dout1_2 Vdout1_2ck110 = 0.9 time = 555
.meas tran vdout1_2ck110 FIND v(dout1_2) AT=555.025n

* CHECK dout1_3 Vdout1_3ck110 = 0.9 time = 555
.meas tran vdout1_3ck110 FIND v(dout1_3) AT=555.025n

* CHECK dout1_4 Vdout1_4ck110 = 0 time = 555
.meas tran vdout1_4ck110 FIND v(dout1_4) AT=555.025n

* CHECK dout1_5 Vdout1_5ck110 = 0 time = 555
.meas tran vdout1_5ck110 FIND v(dout1_5) AT=555.025n

* CHECK dout1_6 Vdout1_6ck110 = 0 time = 555
.meas tran vdout1_6ck110 FIND v(dout1_6) AT=555.025n

* CHECK dout1_7 Vdout1_7ck110 = 0.9 time = 555
.meas tran vdout1_7ck110 FIND v(dout1_7) AT=555.025n

* CHECK dout1_8 Vdout1_8ck110 = 0 time = 555
.meas tran vdout1_8ck110 FIND v(dout1_8) AT=555.025n

* CHECK dout1_9 Vdout1_9ck110 = 0 time = 555
.meas tran vdout1_9ck110 FIND v(dout1_9) AT=555.025n

* CHECK dout1_10 Vdout1_10ck110 = 0 time = 555
.meas tran vdout1_10ck110 FIND v(dout1_10) AT=555.025n

* CHECK dout1_11 Vdout1_11ck110 = 0.9 time = 555
.meas tran vdout1_11ck110 FIND v(dout1_11) AT=555.025n

* CHECK dout1_12 Vdout1_12ck110 = 0.9 time = 555
.meas tran vdout1_12ck110 FIND v(dout1_12) AT=555.025n

* CHECK dout1_13 Vdout1_13ck110 = 0.9 time = 555
.meas tran vdout1_13ck110 FIND v(dout1_13) AT=555.025n

* CHECK dout1_14 Vdout1_14ck110 = 0.9 time = 555
.meas tran vdout1_14ck110 FIND v(dout1_14) AT=555.025n

* CHECK dout1_15 Vdout1_15ck110 = 0.9 time = 555
.meas tran vdout1_15ck110 FIND v(dout1_15) AT=555.025n

* CHECK dout1_16 Vdout1_16ck110 = 0.9 time = 555
.meas tran vdout1_16ck110 FIND v(dout1_16) AT=555.025n

* CHECK dout1_17 Vdout1_17ck110 = 0.9 time = 555
.meas tran vdout1_17ck110 FIND v(dout1_17) AT=555.025n

* CHECK dout1_18 Vdout1_18ck110 = 0.9 time = 555
.meas tran vdout1_18ck110 FIND v(dout1_18) AT=555.025n

* CHECK dout1_19 Vdout1_19ck110 = 0 time = 555
.meas tran vdout1_19ck110 FIND v(dout1_19) AT=555.025n

* CHECK dout1_20 Vdout1_20ck110 = 0 time = 555
.meas tran vdout1_20ck110 FIND v(dout1_20) AT=555.025n

* CHECK dout1_21 Vdout1_21ck110 = 0 time = 555
.meas tran vdout1_21ck110 FIND v(dout1_21) AT=555.025n

* CHECK dout1_22 Vdout1_22ck110 = 0 time = 555
.meas tran vdout1_22ck110 FIND v(dout1_22) AT=555.025n

* CHECK dout1_23 Vdout1_23ck110 = 0 time = 555
.meas tran vdout1_23ck110 FIND v(dout1_23) AT=555.025n

* CHECK dout1_24 Vdout1_24ck110 = 0 time = 555
.meas tran vdout1_24ck110 FIND v(dout1_24) AT=555.025n

* CHECK dout1_25 Vdout1_25ck110 = 0.9 time = 555
.meas tran vdout1_25ck110 FIND v(dout1_25) AT=555.025n

* CHECK dout1_26 Vdout1_26ck110 = 0.9 time = 555
.meas tran vdout1_26ck110 FIND v(dout1_26) AT=555.025n

* CHECK dout1_27 Vdout1_27ck110 = 0.9 time = 555
.meas tran vdout1_27ck110 FIND v(dout1_27) AT=555.025n

* CHECK dout1_28 Vdout1_28ck110 = 0.9 time = 555
.meas tran vdout1_28ck110 FIND v(dout1_28) AT=555.025n

* CHECK dout1_29 Vdout1_29ck110 = 0 time = 555
.meas tran vdout1_29ck110 FIND v(dout1_29) AT=555.025n

* CHECK dout1_30 Vdout1_30ck110 = 0.9 time = 555
.meas tran vdout1_30ck110 FIND v(dout1_30) AT=555.025n

* CHECK dout1_31 Vdout1_31ck110 = 0.9 time = 555
.meas tran vdout1_31ck110 FIND v(dout1_31) AT=555.025n

* CHECK dout1_32 Vdout1_32ck110 = 0.9 time = 555
.meas tran vdout1_32ck110 FIND v(dout1_32) AT=555.025n

* CHECK dout1_33 Vdout1_33ck110 = 0 time = 555
.meas tran vdout1_33ck110 FIND v(dout1_33) AT=555.025n

* CHECK dout1_34 Vdout1_34ck110 = 0 time = 555
.meas tran vdout1_34ck110 FIND v(dout1_34) AT=555.025n

* CHECK dout1_35 Vdout1_35ck110 = 0 time = 555
.meas tran vdout1_35ck110 FIND v(dout1_35) AT=555.025n

* CHECK dout1_36 Vdout1_36ck110 = 0 time = 555
.meas tran vdout1_36ck110 FIND v(dout1_36) AT=555.025n

* CHECK dout1_37 Vdout1_37ck110 = 0.9 time = 555
.meas tran vdout1_37ck110 FIND v(dout1_37) AT=555.025n

* CHECK dout1_38 Vdout1_38ck110 = 0 time = 555
.meas tran vdout1_38ck110 FIND v(dout1_38) AT=555.025n

* CHECK dout1_39 Vdout1_39ck110 = 0 time = 555
.meas tran vdout1_39ck110 FIND v(dout1_39) AT=555.025n

* CHECK dout1_40 Vdout1_40ck110 = 0 time = 555
.meas tran vdout1_40ck110 FIND v(dout1_40) AT=555.025n

* CHECK dout1_41 Vdout1_41ck110 = 0 time = 555
.meas tran vdout1_41ck110 FIND v(dout1_41) AT=555.025n

* CHECK dout1_42 Vdout1_42ck110 = 0 time = 555
.meas tran vdout1_42ck110 FIND v(dout1_42) AT=555.025n

* CHECK dout1_43 Vdout1_43ck110 = 0 time = 555
.meas tran vdout1_43ck110 FIND v(dout1_43) AT=555.025n

* CHECK dout1_44 Vdout1_44ck110 = 0 time = 555
.meas tran vdout1_44ck110 FIND v(dout1_44) AT=555.025n

* CHECK dout1_45 Vdout1_45ck110 = 0.9 time = 555
.meas tran vdout1_45ck110 FIND v(dout1_45) AT=555.025n

* CHECK dout1_46 Vdout1_46ck110 = 0 time = 555
.meas tran vdout1_46ck110 FIND v(dout1_46) AT=555.025n

* CHECK dout1_47 Vdout1_47ck110 = 0.9 time = 555
.meas tran vdout1_47ck110 FIND v(dout1_47) AT=555.025n

* CHECK dout1_48 Vdout1_48ck110 = 0.9 time = 555
.meas tran vdout1_48ck110 FIND v(dout1_48) AT=555.025n

* CHECK dout1_49 Vdout1_49ck110 = 0.9 time = 555
.meas tran vdout1_49ck110 FIND v(dout1_49) AT=555.025n

* CHECK dout1_50 Vdout1_50ck110 = 0.9 time = 555
.meas tran vdout1_50ck110 FIND v(dout1_50) AT=555.025n

* CHECK dout1_51 Vdout1_51ck110 = 0 time = 555
.meas tran vdout1_51ck110 FIND v(dout1_51) AT=555.025n

* CHECK dout1_52 Vdout1_52ck110 = 0 time = 555
.meas tran vdout1_52ck110 FIND v(dout1_52) AT=555.025n

* CHECK dout1_53 Vdout1_53ck110 = 0.9 time = 555
.meas tran vdout1_53ck110 FIND v(dout1_53) AT=555.025n

* CHECK dout1_54 Vdout1_54ck110 = 0 time = 555
.meas tran vdout1_54ck110 FIND v(dout1_54) AT=555.025n

* CHECK dout1_55 Vdout1_55ck110 = 0 time = 555
.meas tran vdout1_55ck110 FIND v(dout1_55) AT=555.025n

* CHECK dout1_56 Vdout1_56ck110 = 0 time = 555
.meas tran vdout1_56ck110 FIND v(dout1_56) AT=555.025n

* CHECK dout1_57 Vdout1_57ck110 = 0.9 time = 555
.meas tran vdout1_57ck110 FIND v(dout1_57) AT=555.025n

* CHECK dout1_58 Vdout1_58ck110 = 0 time = 555
.meas tran vdout1_58ck110 FIND v(dout1_58) AT=555.025n

* CHECK dout1_59 Vdout1_59ck110 = 0 time = 555
.meas tran vdout1_59ck110 FIND v(dout1_59) AT=555.025n

* CHECK dout1_60 Vdout1_60ck110 = 0.9 time = 555
.meas tran vdout1_60ck110 FIND v(dout1_60) AT=555.025n

* CHECK dout1_61 Vdout1_61ck110 = 0.9 time = 555
.meas tran vdout1_61ck110 FIND v(dout1_61) AT=555.025n

* CHECK dout1_62 Vdout1_62ck110 = 0.9 time = 555
.meas tran vdout1_62ck110 FIND v(dout1_62) AT=555.025n

* CHECK dout1_63 Vdout1_63ck110 = 0.9 time = 555
.meas tran vdout1_63ck110 FIND v(dout1_63) AT=555.025n

* CHECK dout1_64 Vdout1_64ck110 = 0.9 time = 555
.meas tran vdout1_64ck110 FIND v(dout1_64) AT=555.025n

* CHECK dout1_65 Vdout1_65ck110 = 0.9 time = 555
.meas tran vdout1_65ck110 FIND v(dout1_65) AT=555.025n

* CHECK dout1_66 Vdout1_66ck110 = 0.9 time = 555
.meas tran vdout1_66ck110 FIND v(dout1_66) AT=555.025n

* CHECK dout1_67 Vdout1_67ck110 = 0 time = 555
.meas tran vdout1_67ck110 FIND v(dout1_67) AT=555.025n

* CHECK dout1_68 Vdout1_68ck110 = 0 time = 555
.meas tran vdout1_68ck110 FIND v(dout1_68) AT=555.025n

* CHECK dout1_69 Vdout1_69ck110 = 0.9 time = 555
.meas tran vdout1_69ck110 FIND v(dout1_69) AT=555.025n

* CHECK dout1_70 Vdout1_70ck110 = 0.9 time = 555
.meas tran vdout1_70ck110 FIND v(dout1_70) AT=555.025n

* CHECK dout1_71 Vdout1_71ck110 = 0.9 time = 555
.meas tran vdout1_71ck110 FIND v(dout1_71) AT=555.025n

* CHECK dout1_0 Vdout1_0ck111 = 0 time = 560
.meas tran vdout1_0ck111 FIND v(dout1_0) AT=560.025n

* CHECK dout1_1 Vdout1_1ck111 = 0.9 time = 560
.meas tran vdout1_1ck111 FIND v(dout1_1) AT=560.025n

* CHECK dout1_2 Vdout1_2ck111 = 0 time = 560
.meas tran vdout1_2ck111 FIND v(dout1_2) AT=560.025n

* CHECK dout1_3 Vdout1_3ck111 = 0 time = 560
.meas tran vdout1_3ck111 FIND v(dout1_3) AT=560.025n

* CHECK dout1_4 Vdout1_4ck111 = 0.9 time = 560
.meas tran vdout1_4ck111 FIND v(dout1_4) AT=560.025n

* CHECK dout1_5 Vdout1_5ck111 = 0.9 time = 560
.meas tran vdout1_5ck111 FIND v(dout1_5) AT=560.025n

* CHECK dout1_6 Vdout1_6ck111 = 0.9 time = 560
.meas tran vdout1_6ck111 FIND v(dout1_6) AT=560.025n

* CHECK dout1_7 Vdout1_7ck111 = 0.9 time = 560
.meas tran vdout1_7ck111 FIND v(dout1_7) AT=560.025n

* CHECK dout1_8 Vdout1_8ck111 = 0 time = 560
.meas tran vdout1_8ck111 FIND v(dout1_8) AT=560.025n

* CHECK dout1_9 Vdout1_9ck111 = 0.9 time = 560
.meas tran vdout1_9ck111 FIND v(dout1_9) AT=560.025n

* CHECK dout1_10 Vdout1_10ck111 = 0 time = 560
.meas tran vdout1_10ck111 FIND v(dout1_10) AT=560.025n

* CHECK dout1_11 Vdout1_11ck111 = 0.9 time = 560
.meas tran vdout1_11ck111 FIND v(dout1_11) AT=560.025n

* CHECK dout1_12 Vdout1_12ck111 = 0.9 time = 560
.meas tran vdout1_12ck111 FIND v(dout1_12) AT=560.025n

* CHECK dout1_13 Vdout1_13ck111 = 0.9 time = 560
.meas tran vdout1_13ck111 FIND v(dout1_13) AT=560.025n

* CHECK dout1_14 Vdout1_14ck111 = 0 time = 560
.meas tran vdout1_14ck111 FIND v(dout1_14) AT=560.025n

* CHECK dout1_15 Vdout1_15ck111 = 0.9 time = 560
.meas tran vdout1_15ck111 FIND v(dout1_15) AT=560.025n

* CHECK dout1_16 Vdout1_16ck111 = 0.9 time = 560
.meas tran vdout1_16ck111 FIND v(dout1_16) AT=560.025n

* CHECK dout1_17 Vdout1_17ck111 = 0 time = 560
.meas tran vdout1_17ck111 FIND v(dout1_17) AT=560.025n

* CHECK dout1_18 Vdout1_18ck111 = 0.9 time = 560
.meas tran vdout1_18ck111 FIND v(dout1_18) AT=560.025n

* CHECK dout1_19 Vdout1_19ck111 = 0 time = 560
.meas tran vdout1_19ck111 FIND v(dout1_19) AT=560.025n

* CHECK dout1_20 Vdout1_20ck111 = 0 time = 560
.meas tran vdout1_20ck111 FIND v(dout1_20) AT=560.025n

* CHECK dout1_21 Vdout1_21ck111 = 0 time = 560
.meas tran vdout1_21ck111 FIND v(dout1_21) AT=560.025n

* CHECK dout1_22 Vdout1_22ck111 = 0.9 time = 560
.meas tran vdout1_22ck111 FIND v(dout1_22) AT=560.025n

* CHECK dout1_23 Vdout1_23ck111 = 0 time = 560
.meas tran vdout1_23ck111 FIND v(dout1_23) AT=560.025n

* CHECK dout1_24 Vdout1_24ck111 = 0.9 time = 560
.meas tran vdout1_24ck111 FIND v(dout1_24) AT=560.025n

* CHECK dout1_25 Vdout1_25ck111 = 0.9 time = 560
.meas tran vdout1_25ck111 FIND v(dout1_25) AT=560.025n

* CHECK dout1_26 Vdout1_26ck111 = 0 time = 560
.meas tran vdout1_26ck111 FIND v(dout1_26) AT=560.025n

* CHECK dout1_27 Vdout1_27ck111 = 0.9 time = 560
.meas tran vdout1_27ck111 FIND v(dout1_27) AT=560.025n

* CHECK dout1_28 Vdout1_28ck111 = 0.9 time = 560
.meas tran vdout1_28ck111 FIND v(dout1_28) AT=560.025n

* CHECK dout1_29 Vdout1_29ck111 = 0 time = 560
.meas tran vdout1_29ck111 FIND v(dout1_29) AT=560.025n

* CHECK dout1_30 Vdout1_30ck111 = 0 time = 560
.meas tran vdout1_30ck111 FIND v(dout1_30) AT=560.025n

* CHECK dout1_31 Vdout1_31ck111 = 0 time = 560
.meas tran vdout1_31ck111 FIND v(dout1_31) AT=560.025n

* CHECK dout1_32 Vdout1_32ck111 = 0 time = 560
.meas tran vdout1_32ck111 FIND v(dout1_32) AT=560.025n

* CHECK dout1_33 Vdout1_33ck111 = 0.9 time = 560
.meas tran vdout1_33ck111 FIND v(dout1_33) AT=560.025n

* CHECK dout1_34 Vdout1_34ck111 = 0.9 time = 560
.meas tran vdout1_34ck111 FIND v(dout1_34) AT=560.025n

* CHECK dout1_35 Vdout1_35ck111 = 0 time = 560
.meas tran vdout1_35ck111 FIND v(dout1_35) AT=560.025n

* CHECK dout1_36 Vdout1_36ck111 = 0 time = 560
.meas tran vdout1_36ck111 FIND v(dout1_36) AT=560.025n

* CHECK dout1_37 Vdout1_37ck111 = 0 time = 560
.meas tran vdout1_37ck111 FIND v(dout1_37) AT=560.025n

* CHECK dout1_38 Vdout1_38ck111 = 0.9 time = 560
.meas tran vdout1_38ck111 FIND v(dout1_38) AT=560.025n

* CHECK dout1_39 Vdout1_39ck111 = 0 time = 560
.meas tran vdout1_39ck111 FIND v(dout1_39) AT=560.025n

* CHECK dout1_40 Vdout1_40ck111 = 0 time = 560
.meas tran vdout1_40ck111 FIND v(dout1_40) AT=560.025n

* CHECK dout1_41 Vdout1_41ck111 = 0 time = 560
.meas tran vdout1_41ck111 FIND v(dout1_41) AT=560.025n

* CHECK dout1_42 Vdout1_42ck111 = 0.9 time = 560
.meas tran vdout1_42ck111 FIND v(dout1_42) AT=560.025n

* CHECK dout1_43 Vdout1_43ck111 = 0.9 time = 560
.meas tran vdout1_43ck111 FIND v(dout1_43) AT=560.025n

* CHECK dout1_44 Vdout1_44ck111 = 0.9 time = 560
.meas tran vdout1_44ck111 FIND v(dout1_44) AT=560.025n

* CHECK dout1_45 Vdout1_45ck111 = 0 time = 560
.meas tran vdout1_45ck111 FIND v(dout1_45) AT=560.025n

* CHECK dout1_46 Vdout1_46ck111 = 0.9 time = 560
.meas tran vdout1_46ck111 FIND v(dout1_46) AT=560.025n

* CHECK dout1_47 Vdout1_47ck111 = 0 time = 560
.meas tran vdout1_47ck111 FIND v(dout1_47) AT=560.025n

* CHECK dout1_48 Vdout1_48ck111 = 0.9 time = 560
.meas tran vdout1_48ck111 FIND v(dout1_48) AT=560.025n

* CHECK dout1_49 Vdout1_49ck111 = 0 time = 560
.meas tran vdout1_49ck111 FIND v(dout1_49) AT=560.025n

* CHECK dout1_50 Vdout1_50ck111 = 0 time = 560
.meas tran vdout1_50ck111 FIND v(dout1_50) AT=560.025n

* CHECK dout1_51 Vdout1_51ck111 = 0 time = 560
.meas tran vdout1_51ck111 FIND v(dout1_51) AT=560.025n

* CHECK dout1_52 Vdout1_52ck111 = 0 time = 560
.meas tran vdout1_52ck111 FIND v(dout1_52) AT=560.025n

* CHECK dout1_53 Vdout1_53ck111 = 0 time = 560
.meas tran vdout1_53ck111 FIND v(dout1_53) AT=560.025n

* CHECK dout1_54 Vdout1_54ck111 = 0.9 time = 560
.meas tran vdout1_54ck111 FIND v(dout1_54) AT=560.025n

* CHECK dout1_55 Vdout1_55ck111 = 0 time = 560
.meas tran vdout1_55ck111 FIND v(dout1_55) AT=560.025n

* CHECK dout1_56 Vdout1_56ck111 = 0 time = 560
.meas tran vdout1_56ck111 FIND v(dout1_56) AT=560.025n

* CHECK dout1_57 Vdout1_57ck111 = 0 time = 560
.meas tran vdout1_57ck111 FIND v(dout1_57) AT=560.025n

* CHECK dout1_58 Vdout1_58ck111 = 0.9 time = 560
.meas tran vdout1_58ck111 FIND v(dout1_58) AT=560.025n

* CHECK dout1_59 Vdout1_59ck111 = 0 time = 560
.meas tran vdout1_59ck111 FIND v(dout1_59) AT=560.025n

* CHECK dout1_60 Vdout1_60ck111 = 0 time = 560
.meas tran vdout1_60ck111 FIND v(dout1_60) AT=560.025n

* CHECK dout1_61 Vdout1_61ck111 = 0 time = 560
.meas tran vdout1_61ck111 FIND v(dout1_61) AT=560.025n

* CHECK dout1_62 Vdout1_62ck111 = 0.9 time = 560
.meas tran vdout1_62ck111 FIND v(dout1_62) AT=560.025n

* CHECK dout1_63 Vdout1_63ck111 = 0 time = 560
.meas tran vdout1_63ck111 FIND v(dout1_63) AT=560.025n

* CHECK dout1_64 Vdout1_64ck111 = 0.9 time = 560
.meas tran vdout1_64ck111 FIND v(dout1_64) AT=560.025n

* CHECK dout1_65 Vdout1_65ck111 = 0.9 time = 560
.meas tran vdout1_65ck111 FIND v(dout1_65) AT=560.025n

* CHECK dout1_66 Vdout1_66ck111 = 0 time = 560
.meas tran vdout1_66ck111 FIND v(dout1_66) AT=560.025n

* CHECK dout1_67 Vdout1_67ck111 = 0 time = 560
.meas tran vdout1_67ck111 FIND v(dout1_67) AT=560.025n

* CHECK dout1_68 Vdout1_68ck111 = 0.9 time = 560
.meas tran vdout1_68ck111 FIND v(dout1_68) AT=560.025n

* CHECK dout1_69 Vdout1_69ck111 = 0.9 time = 560
.meas tran vdout1_69ck111 FIND v(dout1_69) AT=560.025n

* CHECK dout1_70 Vdout1_70ck111 = 0 time = 560
.meas tran vdout1_70ck111 FIND v(dout1_70) AT=560.025n

* CHECK dout1_71 Vdout1_71ck111 = 0 time = 560
.meas tran vdout1_71ck111 FIND v(dout1_71) AT=560.025n

* CHECK dout1_0 Vdout1_0ck114 = 0.9 time = 575
.meas tran vdout1_0ck114 FIND v(dout1_0) AT=575.025n

* CHECK dout1_1 Vdout1_1ck114 = 0 time = 575
.meas tran vdout1_1ck114 FIND v(dout1_1) AT=575.025n

* CHECK dout1_2 Vdout1_2ck114 = 0.9 time = 575
.meas tran vdout1_2ck114 FIND v(dout1_2) AT=575.025n

* CHECK dout1_3 Vdout1_3ck114 = 0.9 time = 575
.meas tran vdout1_3ck114 FIND v(dout1_3) AT=575.025n

* CHECK dout1_4 Vdout1_4ck114 = 0 time = 575
.meas tran vdout1_4ck114 FIND v(dout1_4) AT=575.025n

* CHECK dout1_5 Vdout1_5ck114 = 0 time = 575
.meas tran vdout1_5ck114 FIND v(dout1_5) AT=575.025n

* CHECK dout1_6 Vdout1_6ck114 = 0 time = 575
.meas tran vdout1_6ck114 FIND v(dout1_6) AT=575.025n

* CHECK dout1_7 Vdout1_7ck114 = 0.9 time = 575
.meas tran vdout1_7ck114 FIND v(dout1_7) AT=575.025n

* CHECK dout1_8 Vdout1_8ck114 = 0 time = 575
.meas tran vdout1_8ck114 FIND v(dout1_8) AT=575.025n

* CHECK dout1_9 Vdout1_9ck114 = 0 time = 575
.meas tran vdout1_9ck114 FIND v(dout1_9) AT=575.025n

* CHECK dout1_10 Vdout1_10ck114 = 0 time = 575
.meas tran vdout1_10ck114 FIND v(dout1_10) AT=575.025n

* CHECK dout1_11 Vdout1_11ck114 = 0.9 time = 575
.meas tran vdout1_11ck114 FIND v(dout1_11) AT=575.025n

* CHECK dout1_12 Vdout1_12ck114 = 0.9 time = 575
.meas tran vdout1_12ck114 FIND v(dout1_12) AT=575.025n

* CHECK dout1_13 Vdout1_13ck114 = 0.9 time = 575
.meas tran vdout1_13ck114 FIND v(dout1_13) AT=575.025n

* CHECK dout1_14 Vdout1_14ck114 = 0.9 time = 575
.meas tran vdout1_14ck114 FIND v(dout1_14) AT=575.025n

* CHECK dout1_15 Vdout1_15ck114 = 0.9 time = 575
.meas tran vdout1_15ck114 FIND v(dout1_15) AT=575.025n

* CHECK dout1_16 Vdout1_16ck114 = 0.9 time = 575
.meas tran vdout1_16ck114 FIND v(dout1_16) AT=575.025n

* CHECK dout1_17 Vdout1_17ck114 = 0.9 time = 575
.meas tran vdout1_17ck114 FIND v(dout1_17) AT=575.025n

* CHECK dout1_18 Vdout1_18ck114 = 0.9 time = 575
.meas tran vdout1_18ck114 FIND v(dout1_18) AT=575.025n

* CHECK dout1_19 Vdout1_19ck114 = 0 time = 575
.meas tran vdout1_19ck114 FIND v(dout1_19) AT=575.025n

* CHECK dout1_20 Vdout1_20ck114 = 0 time = 575
.meas tran vdout1_20ck114 FIND v(dout1_20) AT=575.025n

* CHECK dout1_21 Vdout1_21ck114 = 0 time = 575
.meas tran vdout1_21ck114 FIND v(dout1_21) AT=575.025n

* CHECK dout1_22 Vdout1_22ck114 = 0 time = 575
.meas tran vdout1_22ck114 FIND v(dout1_22) AT=575.025n

* CHECK dout1_23 Vdout1_23ck114 = 0 time = 575
.meas tran vdout1_23ck114 FIND v(dout1_23) AT=575.025n

* CHECK dout1_24 Vdout1_24ck114 = 0 time = 575
.meas tran vdout1_24ck114 FIND v(dout1_24) AT=575.025n

* CHECK dout1_25 Vdout1_25ck114 = 0.9 time = 575
.meas tran vdout1_25ck114 FIND v(dout1_25) AT=575.025n

* CHECK dout1_26 Vdout1_26ck114 = 0.9 time = 575
.meas tran vdout1_26ck114 FIND v(dout1_26) AT=575.025n

* CHECK dout1_27 Vdout1_27ck114 = 0.9 time = 575
.meas tran vdout1_27ck114 FIND v(dout1_27) AT=575.025n

* CHECK dout1_28 Vdout1_28ck114 = 0.9 time = 575
.meas tran vdout1_28ck114 FIND v(dout1_28) AT=575.025n

* CHECK dout1_29 Vdout1_29ck114 = 0 time = 575
.meas tran vdout1_29ck114 FIND v(dout1_29) AT=575.025n

* CHECK dout1_30 Vdout1_30ck114 = 0.9 time = 575
.meas tran vdout1_30ck114 FIND v(dout1_30) AT=575.025n

* CHECK dout1_31 Vdout1_31ck114 = 0.9 time = 575
.meas tran vdout1_31ck114 FIND v(dout1_31) AT=575.025n

* CHECK dout1_32 Vdout1_32ck114 = 0.9 time = 575
.meas tran vdout1_32ck114 FIND v(dout1_32) AT=575.025n

* CHECK dout1_33 Vdout1_33ck114 = 0 time = 575
.meas tran vdout1_33ck114 FIND v(dout1_33) AT=575.025n

* CHECK dout1_34 Vdout1_34ck114 = 0 time = 575
.meas tran vdout1_34ck114 FIND v(dout1_34) AT=575.025n

* CHECK dout1_35 Vdout1_35ck114 = 0 time = 575
.meas tran vdout1_35ck114 FIND v(dout1_35) AT=575.025n

* CHECK dout1_36 Vdout1_36ck114 = 0 time = 575
.meas tran vdout1_36ck114 FIND v(dout1_36) AT=575.025n

* CHECK dout1_37 Vdout1_37ck114 = 0.9 time = 575
.meas tran vdout1_37ck114 FIND v(dout1_37) AT=575.025n

* CHECK dout1_38 Vdout1_38ck114 = 0 time = 575
.meas tran vdout1_38ck114 FIND v(dout1_38) AT=575.025n

* CHECK dout1_39 Vdout1_39ck114 = 0 time = 575
.meas tran vdout1_39ck114 FIND v(dout1_39) AT=575.025n

* CHECK dout1_40 Vdout1_40ck114 = 0 time = 575
.meas tran vdout1_40ck114 FIND v(dout1_40) AT=575.025n

* CHECK dout1_41 Vdout1_41ck114 = 0 time = 575
.meas tran vdout1_41ck114 FIND v(dout1_41) AT=575.025n

* CHECK dout1_42 Vdout1_42ck114 = 0 time = 575
.meas tran vdout1_42ck114 FIND v(dout1_42) AT=575.025n

* CHECK dout1_43 Vdout1_43ck114 = 0 time = 575
.meas tran vdout1_43ck114 FIND v(dout1_43) AT=575.025n

* CHECK dout1_44 Vdout1_44ck114 = 0 time = 575
.meas tran vdout1_44ck114 FIND v(dout1_44) AT=575.025n

* CHECK dout1_45 Vdout1_45ck114 = 0.9 time = 575
.meas tran vdout1_45ck114 FIND v(dout1_45) AT=575.025n

* CHECK dout1_46 Vdout1_46ck114 = 0 time = 575
.meas tran vdout1_46ck114 FIND v(dout1_46) AT=575.025n

* CHECK dout1_47 Vdout1_47ck114 = 0.9 time = 575
.meas tran vdout1_47ck114 FIND v(dout1_47) AT=575.025n

* CHECK dout1_48 Vdout1_48ck114 = 0.9 time = 575
.meas tran vdout1_48ck114 FIND v(dout1_48) AT=575.025n

* CHECK dout1_49 Vdout1_49ck114 = 0.9 time = 575
.meas tran vdout1_49ck114 FIND v(dout1_49) AT=575.025n

* CHECK dout1_50 Vdout1_50ck114 = 0.9 time = 575
.meas tran vdout1_50ck114 FIND v(dout1_50) AT=575.025n

* CHECK dout1_51 Vdout1_51ck114 = 0 time = 575
.meas tran vdout1_51ck114 FIND v(dout1_51) AT=575.025n

* CHECK dout1_52 Vdout1_52ck114 = 0 time = 575
.meas tran vdout1_52ck114 FIND v(dout1_52) AT=575.025n

* CHECK dout1_53 Vdout1_53ck114 = 0.9 time = 575
.meas tran vdout1_53ck114 FIND v(dout1_53) AT=575.025n

* CHECK dout1_54 Vdout1_54ck114 = 0 time = 575
.meas tran vdout1_54ck114 FIND v(dout1_54) AT=575.025n

* CHECK dout1_55 Vdout1_55ck114 = 0 time = 575
.meas tran vdout1_55ck114 FIND v(dout1_55) AT=575.025n

* CHECK dout1_56 Vdout1_56ck114 = 0 time = 575
.meas tran vdout1_56ck114 FIND v(dout1_56) AT=575.025n

* CHECK dout1_57 Vdout1_57ck114 = 0.9 time = 575
.meas tran vdout1_57ck114 FIND v(dout1_57) AT=575.025n

* CHECK dout1_58 Vdout1_58ck114 = 0 time = 575
.meas tran vdout1_58ck114 FIND v(dout1_58) AT=575.025n

* CHECK dout1_59 Vdout1_59ck114 = 0 time = 575
.meas tran vdout1_59ck114 FIND v(dout1_59) AT=575.025n

* CHECK dout1_60 Vdout1_60ck114 = 0.9 time = 575
.meas tran vdout1_60ck114 FIND v(dout1_60) AT=575.025n

* CHECK dout1_61 Vdout1_61ck114 = 0.9 time = 575
.meas tran vdout1_61ck114 FIND v(dout1_61) AT=575.025n

* CHECK dout1_62 Vdout1_62ck114 = 0.9 time = 575
.meas tran vdout1_62ck114 FIND v(dout1_62) AT=575.025n

* CHECK dout1_63 Vdout1_63ck114 = 0.9 time = 575
.meas tran vdout1_63ck114 FIND v(dout1_63) AT=575.025n

* CHECK dout1_64 Vdout1_64ck114 = 0.9 time = 575
.meas tran vdout1_64ck114 FIND v(dout1_64) AT=575.025n

* CHECK dout1_65 Vdout1_65ck114 = 0.9 time = 575
.meas tran vdout1_65ck114 FIND v(dout1_65) AT=575.025n

* CHECK dout1_66 Vdout1_66ck114 = 0.9 time = 575
.meas tran vdout1_66ck114 FIND v(dout1_66) AT=575.025n

* CHECK dout1_67 Vdout1_67ck114 = 0 time = 575
.meas tran vdout1_67ck114 FIND v(dout1_67) AT=575.025n

* CHECK dout1_68 Vdout1_68ck114 = 0 time = 575
.meas tran vdout1_68ck114 FIND v(dout1_68) AT=575.025n

* CHECK dout1_69 Vdout1_69ck114 = 0.9 time = 575
.meas tran vdout1_69ck114 FIND v(dout1_69) AT=575.025n

* CHECK dout1_70 Vdout1_70ck114 = 0.9 time = 575
.meas tran vdout1_70ck114 FIND v(dout1_70) AT=575.025n

* CHECK dout1_71 Vdout1_71ck114 = 0.9 time = 575
.meas tran vdout1_71ck114 FIND v(dout1_71) AT=575.025n

* CHECK dout1_0 Vdout1_0ck115 = 0.9 time = 580
.meas tran vdout1_0ck115 FIND v(dout1_0) AT=580.025n

* CHECK dout1_1 Vdout1_1ck115 = 0 time = 580
.meas tran vdout1_1ck115 FIND v(dout1_1) AT=580.025n

* CHECK dout1_2 Vdout1_2ck115 = 0.9 time = 580
.meas tran vdout1_2ck115 FIND v(dout1_2) AT=580.025n

* CHECK dout1_3 Vdout1_3ck115 = 0.9 time = 580
.meas tran vdout1_3ck115 FIND v(dout1_3) AT=580.025n

* CHECK dout1_4 Vdout1_4ck115 = 0 time = 580
.meas tran vdout1_4ck115 FIND v(dout1_4) AT=580.025n

* CHECK dout1_5 Vdout1_5ck115 = 0.9 time = 580
.meas tran vdout1_5ck115 FIND v(dout1_5) AT=580.025n

* CHECK dout1_6 Vdout1_6ck115 = 0.9 time = 580
.meas tran vdout1_6ck115 FIND v(dout1_6) AT=580.025n

* CHECK dout1_7 Vdout1_7ck115 = 0.9 time = 580
.meas tran vdout1_7ck115 FIND v(dout1_7) AT=580.025n

* CHECK dout1_8 Vdout1_8ck115 = 0 time = 580
.meas tran vdout1_8ck115 FIND v(dout1_8) AT=580.025n

* CHECK dout1_9 Vdout1_9ck115 = 0 time = 580
.meas tran vdout1_9ck115 FIND v(dout1_9) AT=580.025n

* CHECK dout1_10 Vdout1_10ck115 = 0 time = 580
.meas tran vdout1_10ck115 FIND v(dout1_10) AT=580.025n

* CHECK dout1_11 Vdout1_11ck115 = 0 time = 580
.meas tran vdout1_11ck115 FIND v(dout1_11) AT=580.025n

* CHECK dout1_12 Vdout1_12ck115 = 0.9 time = 580
.meas tran vdout1_12ck115 FIND v(dout1_12) AT=580.025n

* CHECK dout1_13 Vdout1_13ck115 = 0.9 time = 580
.meas tran vdout1_13ck115 FIND v(dout1_13) AT=580.025n

* CHECK dout1_14 Vdout1_14ck115 = 0 time = 580
.meas tran vdout1_14ck115 FIND v(dout1_14) AT=580.025n

* CHECK dout1_15 Vdout1_15ck115 = 0 time = 580
.meas tran vdout1_15ck115 FIND v(dout1_15) AT=580.025n

* CHECK dout1_16 Vdout1_16ck115 = 0.9 time = 580
.meas tran vdout1_16ck115 FIND v(dout1_16) AT=580.025n

* CHECK dout1_17 Vdout1_17ck115 = 0.9 time = 580
.meas tran vdout1_17ck115 FIND v(dout1_17) AT=580.025n

* CHECK dout1_18 Vdout1_18ck115 = 0 time = 580
.meas tran vdout1_18ck115 FIND v(dout1_18) AT=580.025n

* CHECK dout1_19 Vdout1_19ck115 = 0.9 time = 580
.meas tran vdout1_19ck115 FIND v(dout1_19) AT=580.025n

* CHECK dout1_20 Vdout1_20ck115 = 0.9 time = 580
.meas tran vdout1_20ck115 FIND v(dout1_20) AT=580.025n

* CHECK dout1_21 Vdout1_21ck115 = 0 time = 580
.meas tran vdout1_21ck115 FIND v(dout1_21) AT=580.025n

* CHECK dout1_22 Vdout1_22ck115 = 0 time = 580
.meas tran vdout1_22ck115 FIND v(dout1_22) AT=580.025n

* CHECK dout1_23 Vdout1_23ck115 = 0.9 time = 580
.meas tran vdout1_23ck115 FIND v(dout1_23) AT=580.025n

* CHECK dout1_24 Vdout1_24ck115 = 0 time = 580
.meas tran vdout1_24ck115 FIND v(dout1_24) AT=580.025n

* CHECK dout1_25 Vdout1_25ck115 = 0 time = 580
.meas tran vdout1_25ck115 FIND v(dout1_25) AT=580.025n

* CHECK dout1_26 Vdout1_26ck115 = 0.9 time = 580
.meas tran vdout1_26ck115 FIND v(dout1_26) AT=580.025n

* CHECK dout1_27 Vdout1_27ck115 = 0 time = 580
.meas tran vdout1_27ck115 FIND v(dout1_27) AT=580.025n

* CHECK dout1_28 Vdout1_28ck115 = 0.9 time = 580
.meas tran vdout1_28ck115 FIND v(dout1_28) AT=580.025n

* CHECK dout1_29 Vdout1_29ck115 = 0.9 time = 580
.meas tran vdout1_29ck115 FIND v(dout1_29) AT=580.025n

* CHECK dout1_30 Vdout1_30ck115 = 0 time = 580
.meas tran vdout1_30ck115 FIND v(dout1_30) AT=580.025n

* CHECK dout1_31 Vdout1_31ck115 = 0.9 time = 580
.meas tran vdout1_31ck115 FIND v(dout1_31) AT=580.025n

* CHECK dout1_32 Vdout1_32ck115 = 0.9 time = 580
.meas tran vdout1_32ck115 FIND v(dout1_32) AT=580.025n

* CHECK dout1_33 Vdout1_33ck115 = 0 time = 580
.meas tran vdout1_33ck115 FIND v(dout1_33) AT=580.025n

* CHECK dout1_34 Vdout1_34ck115 = 0.9 time = 580
.meas tran vdout1_34ck115 FIND v(dout1_34) AT=580.025n

* CHECK dout1_35 Vdout1_35ck115 = 0.9 time = 580
.meas tran vdout1_35ck115 FIND v(dout1_35) AT=580.025n

* CHECK dout1_36 Vdout1_36ck115 = 0.9 time = 580
.meas tran vdout1_36ck115 FIND v(dout1_36) AT=580.025n

* CHECK dout1_37 Vdout1_37ck115 = 0 time = 580
.meas tran vdout1_37ck115 FIND v(dout1_37) AT=580.025n

* CHECK dout1_38 Vdout1_38ck115 = 0.9 time = 580
.meas tran vdout1_38ck115 FIND v(dout1_38) AT=580.025n

* CHECK dout1_39 Vdout1_39ck115 = 0.9 time = 580
.meas tran vdout1_39ck115 FIND v(dout1_39) AT=580.025n

* CHECK dout1_40 Vdout1_40ck115 = 0.9 time = 580
.meas tran vdout1_40ck115 FIND v(dout1_40) AT=580.025n

* CHECK dout1_41 Vdout1_41ck115 = 0 time = 580
.meas tran vdout1_41ck115 FIND v(dout1_41) AT=580.025n

* CHECK dout1_42 Vdout1_42ck115 = 0 time = 580
.meas tran vdout1_42ck115 FIND v(dout1_42) AT=580.025n

* CHECK dout1_43 Vdout1_43ck115 = 0.9 time = 580
.meas tran vdout1_43ck115 FIND v(dout1_43) AT=580.025n

* CHECK dout1_44 Vdout1_44ck115 = 0.9 time = 580
.meas tran vdout1_44ck115 FIND v(dout1_44) AT=580.025n

* CHECK dout1_45 Vdout1_45ck115 = 0.9 time = 580
.meas tran vdout1_45ck115 FIND v(dout1_45) AT=580.025n

* CHECK dout1_46 Vdout1_46ck115 = 0.9 time = 580
.meas tran vdout1_46ck115 FIND v(dout1_46) AT=580.025n

* CHECK dout1_47 Vdout1_47ck115 = 0.9 time = 580
.meas tran vdout1_47ck115 FIND v(dout1_47) AT=580.025n

* CHECK dout1_48 Vdout1_48ck115 = 0.9 time = 580
.meas tran vdout1_48ck115 FIND v(dout1_48) AT=580.025n

* CHECK dout1_49 Vdout1_49ck115 = 0 time = 580
.meas tran vdout1_49ck115 FIND v(dout1_49) AT=580.025n

* CHECK dout1_50 Vdout1_50ck115 = 0 time = 580
.meas tran vdout1_50ck115 FIND v(dout1_50) AT=580.025n

* CHECK dout1_51 Vdout1_51ck115 = 0.9 time = 580
.meas tran vdout1_51ck115 FIND v(dout1_51) AT=580.025n

* CHECK dout1_52 Vdout1_52ck115 = 0.9 time = 580
.meas tran vdout1_52ck115 FIND v(dout1_52) AT=580.025n

* CHECK dout1_53 Vdout1_53ck115 = 0.9 time = 580
.meas tran vdout1_53ck115 FIND v(dout1_53) AT=580.025n

* CHECK dout1_54 Vdout1_54ck115 = 0.9 time = 580
.meas tran vdout1_54ck115 FIND v(dout1_54) AT=580.025n

* CHECK dout1_55 Vdout1_55ck115 = 0 time = 580
.meas tran vdout1_55ck115 FIND v(dout1_55) AT=580.025n

* CHECK dout1_56 Vdout1_56ck115 = 0.9 time = 580
.meas tran vdout1_56ck115 FIND v(dout1_56) AT=580.025n

* CHECK dout1_57 Vdout1_57ck115 = 0.9 time = 580
.meas tran vdout1_57ck115 FIND v(dout1_57) AT=580.025n

* CHECK dout1_58 Vdout1_58ck115 = 0.9 time = 580
.meas tran vdout1_58ck115 FIND v(dout1_58) AT=580.025n

* CHECK dout1_59 Vdout1_59ck115 = 0 time = 580
.meas tran vdout1_59ck115 FIND v(dout1_59) AT=580.025n

* CHECK dout1_60 Vdout1_60ck115 = 0 time = 580
.meas tran vdout1_60ck115 FIND v(dout1_60) AT=580.025n

* CHECK dout1_61 Vdout1_61ck115 = 0.9 time = 580
.meas tran vdout1_61ck115 FIND v(dout1_61) AT=580.025n

* CHECK dout1_62 Vdout1_62ck115 = 0.9 time = 580
.meas tran vdout1_62ck115 FIND v(dout1_62) AT=580.025n

* CHECK dout1_63 Vdout1_63ck115 = 0 time = 580
.meas tran vdout1_63ck115 FIND v(dout1_63) AT=580.025n

* CHECK dout1_64 Vdout1_64ck115 = 0.9 time = 580
.meas tran vdout1_64ck115 FIND v(dout1_64) AT=580.025n

* CHECK dout1_65 Vdout1_65ck115 = 0.9 time = 580
.meas tran vdout1_65ck115 FIND v(dout1_65) AT=580.025n

* CHECK dout1_66 Vdout1_66ck115 = 0.9 time = 580
.meas tran vdout1_66ck115 FIND v(dout1_66) AT=580.025n

* CHECK dout1_67 Vdout1_67ck115 = 0.9 time = 580
.meas tran vdout1_67ck115 FIND v(dout1_67) AT=580.025n

* CHECK dout1_68 Vdout1_68ck115 = 0.9 time = 580
.meas tran vdout1_68ck115 FIND v(dout1_68) AT=580.025n

* CHECK dout1_69 Vdout1_69ck115 = 0 time = 580
.meas tran vdout1_69ck115 FIND v(dout1_69) AT=580.025n

* CHECK dout1_70 Vdout1_70ck115 = 0.9 time = 580
.meas tran vdout1_70ck115 FIND v(dout1_70) AT=580.025n

* CHECK dout1_71 Vdout1_71ck115 = 0.9 time = 580
.meas tran vdout1_71ck115 FIND v(dout1_71) AT=580.025n

* CHECK dout1_0 Vdout1_0ck116 = 0.9 time = 585
.meas tran vdout1_0ck116 FIND v(dout1_0) AT=585.025n

* CHECK dout1_1 Vdout1_1ck116 = 0 time = 585
.meas tran vdout1_1ck116 FIND v(dout1_1) AT=585.025n

* CHECK dout1_2 Vdout1_2ck116 = 0.9 time = 585
.meas tran vdout1_2ck116 FIND v(dout1_2) AT=585.025n

* CHECK dout1_3 Vdout1_3ck116 = 0.9 time = 585
.meas tran vdout1_3ck116 FIND v(dout1_3) AT=585.025n

* CHECK dout1_4 Vdout1_4ck116 = 0 time = 585
.meas tran vdout1_4ck116 FIND v(dout1_4) AT=585.025n

* CHECK dout1_5 Vdout1_5ck116 = 0.9 time = 585
.meas tran vdout1_5ck116 FIND v(dout1_5) AT=585.025n

* CHECK dout1_6 Vdout1_6ck116 = 0.9 time = 585
.meas tran vdout1_6ck116 FIND v(dout1_6) AT=585.025n

* CHECK dout1_7 Vdout1_7ck116 = 0.9 time = 585
.meas tran vdout1_7ck116 FIND v(dout1_7) AT=585.025n

* CHECK dout1_8 Vdout1_8ck116 = 0 time = 585
.meas tran vdout1_8ck116 FIND v(dout1_8) AT=585.025n

* CHECK dout1_9 Vdout1_9ck116 = 0 time = 585
.meas tran vdout1_9ck116 FIND v(dout1_9) AT=585.025n

* CHECK dout1_10 Vdout1_10ck116 = 0 time = 585
.meas tran vdout1_10ck116 FIND v(dout1_10) AT=585.025n

* CHECK dout1_11 Vdout1_11ck116 = 0 time = 585
.meas tran vdout1_11ck116 FIND v(dout1_11) AT=585.025n

* CHECK dout1_12 Vdout1_12ck116 = 0.9 time = 585
.meas tran vdout1_12ck116 FIND v(dout1_12) AT=585.025n

* CHECK dout1_13 Vdout1_13ck116 = 0.9 time = 585
.meas tran vdout1_13ck116 FIND v(dout1_13) AT=585.025n

* CHECK dout1_14 Vdout1_14ck116 = 0 time = 585
.meas tran vdout1_14ck116 FIND v(dout1_14) AT=585.025n

* CHECK dout1_15 Vdout1_15ck116 = 0 time = 585
.meas tran vdout1_15ck116 FIND v(dout1_15) AT=585.025n

* CHECK dout1_16 Vdout1_16ck116 = 0.9 time = 585
.meas tran vdout1_16ck116 FIND v(dout1_16) AT=585.025n

* CHECK dout1_17 Vdout1_17ck116 = 0.9 time = 585
.meas tran vdout1_17ck116 FIND v(dout1_17) AT=585.025n

* CHECK dout1_18 Vdout1_18ck116 = 0 time = 585
.meas tran vdout1_18ck116 FIND v(dout1_18) AT=585.025n

* CHECK dout1_19 Vdout1_19ck116 = 0.9 time = 585
.meas tran vdout1_19ck116 FIND v(dout1_19) AT=585.025n

* CHECK dout1_20 Vdout1_20ck116 = 0.9 time = 585
.meas tran vdout1_20ck116 FIND v(dout1_20) AT=585.025n

* CHECK dout1_21 Vdout1_21ck116 = 0 time = 585
.meas tran vdout1_21ck116 FIND v(dout1_21) AT=585.025n

* CHECK dout1_22 Vdout1_22ck116 = 0 time = 585
.meas tran vdout1_22ck116 FIND v(dout1_22) AT=585.025n

* CHECK dout1_23 Vdout1_23ck116 = 0.9 time = 585
.meas tran vdout1_23ck116 FIND v(dout1_23) AT=585.025n

* CHECK dout1_24 Vdout1_24ck116 = 0 time = 585
.meas tran vdout1_24ck116 FIND v(dout1_24) AT=585.025n

* CHECK dout1_25 Vdout1_25ck116 = 0 time = 585
.meas tran vdout1_25ck116 FIND v(dout1_25) AT=585.025n

* CHECK dout1_26 Vdout1_26ck116 = 0.9 time = 585
.meas tran vdout1_26ck116 FIND v(dout1_26) AT=585.025n

* CHECK dout1_27 Vdout1_27ck116 = 0 time = 585
.meas tran vdout1_27ck116 FIND v(dout1_27) AT=585.025n

* CHECK dout1_28 Vdout1_28ck116 = 0.9 time = 585
.meas tran vdout1_28ck116 FIND v(dout1_28) AT=585.025n

* CHECK dout1_29 Vdout1_29ck116 = 0.9 time = 585
.meas tran vdout1_29ck116 FIND v(dout1_29) AT=585.025n

* CHECK dout1_30 Vdout1_30ck116 = 0 time = 585
.meas tran vdout1_30ck116 FIND v(dout1_30) AT=585.025n

* CHECK dout1_31 Vdout1_31ck116 = 0.9 time = 585
.meas tran vdout1_31ck116 FIND v(dout1_31) AT=585.025n

* CHECK dout1_32 Vdout1_32ck116 = 0.9 time = 585
.meas tran vdout1_32ck116 FIND v(dout1_32) AT=585.025n

* CHECK dout1_33 Vdout1_33ck116 = 0 time = 585
.meas tran vdout1_33ck116 FIND v(dout1_33) AT=585.025n

* CHECK dout1_34 Vdout1_34ck116 = 0.9 time = 585
.meas tran vdout1_34ck116 FIND v(dout1_34) AT=585.025n

* CHECK dout1_35 Vdout1_35ck116 = 0.9 time = 585
.meas tran vdout1_35ck116 FIND v(dout1_35) AT=585.025n

* CHECK dout1_36 Vdout1_36ck116 = 0.9 time = 585
.meas tran vdout1_36ck116 FIND v(dout1_36) AT=585.025n

* CHECK dout1_37 Vdout1_37ck116 = 0 time = 585
.meas tran vdout1_37ck116 FIND v(dout1_37) AT=585.025n

* CHECK dout1_38 Vdout1_38ck116 = 0.9 time = 585
.meas tran vdout1_38ck116 FIND v(dout1_38) AT=585.025n

* CHECK dout1_39 Vdout1_39ck116 = 0.9 time = 585
.meas tran vdout1_39ck116 FIND v(dout1_39) AT=585.025n

* CHECK dout1_40 Vdout1_40ck116 = 0.9 time = 585
.meas tran vdout1_40ck116 FIND v(dout1_40) AT=585.025n

* CHECK dout1_41 Vdout1_41ck116 = 0 time = 585
.meas tran vdout1_41ck116 FIND v(dout1_41) AT=585.025n

* CHECK dout1_42 Vdout1_42ck116 = 0 time = 585
.meas tran vdout1_42ck116 FIND v(dout1_42) AT=585.025n

* CHECK dout1_43 Vdout1_43ck116 = 0.9 time = 585
.meas tran vdout1_43ck116 FIND v(dout1_43) AT=585.025n

* CHECK dout1_44 Vdout1_44ck116 = 0.9 time = 585
.meas tran vdout1_44ck116 FIND v(dout1_44) AT=585.025n

* CHECK dout1_45 Vdout1_45ck116 = 0.9 time = 585
.meas tran vdout1_45ck116 FIND v(dout1_45) AT=585.025n

* CHECK dout1_46 Vdout1_46ck116 = 0.9 time = 585
.meas tran vdout1_46ck116 FIND v(dout1_46) AT=585.025n

* CHECK dout1_47 Vdout1_47ck116 = 0.9 time = 585
.meas tran vdout1_47ck116 FIND v(dout1_47) AT=585.025n

* CHECK dout1_48 Vdout1_48ck116 = 0.9 time = 585
.meas tran vdout1_48ck116 FIND v(dout1_48) AT=585.025n

* CHECK dout1_49 Vdout1_49ck116 = 0 time = 585
.meas tran vdout1_49ck116 FIND v(dout1_49) AT=585.025n

* CHECK dout1_50 Vdout1_50ck116 = 0 time = 585
.meas tran vdout1_50ck116 FIND v(dout1_50) AT=585.025n

* CHECK dout1_51 Vdout1_51ck116 = 0.9 time = 585
.meas tran vdout1_51ck116 FIND v(dout1_51) AT=585.025n

* CHECK dout1_52 Vdout1_52ck116 = 0.9 time = 585
.meas tran vdout1_52ck116 FIND v(dout1_52) AT=585.025n

* CHECK dout1_53 Vdout1_53ck116 = 0.9 time = 585
.meas tran vdout1_53ck116 FIND v(dout1_53) AT=585.025n

* CHECK dout1_54 Vdout1_54ck116 = 0.9 time = 585
.meas tran vdout1_54ck116 FIND v(dout1_54) AT=585.025n

* CHECK dout1_55 Vdout1_55ck116 = 0 time = 585
.meas tran vdout1_55ck116 FIND v(dout1_55) AT=585.025n

* CHECK dout1_56 Vdout1_56ck116 = 0.9 time = 585
.meas tran vdout1_56ck116 FIND v(dout1_56) AT=585.025n

* CHECK dout1_57 Vdout1_57ck116 = 0.9 time = 585
.meas tran vdout1_57ck116 FIND v(dout1_57) AT=585.025n

* CHECK dout1_58 Vdout1_58ck116 = 0.9 time = 585
.meas tran vdout1_58ck116 FIND v(dout1_58) AT=585.025n

* CHECK dout1_59 Vdout1_59ck116 = 0 time = 585
.meas tran vdout1_59ck116 FIND v(dout1_59) AT=585.025n

* CHECK dout1_60 Vdout1_60ck116 = 0 time = 585
.meas tran vdout1_60ck116 FIND v(dout1_60) AT=585.025n

* CHECK dout1_61 Vdout1_61ck116 = 0.9 time = 585
.meas tran vdout1_61ck116 FIND v(dout1_61) AT=585.025n

* CHECK dout1_62 Vdout1_62ck116 = 0.9 time = 585
.meas tran vdout1_62ck116 FIND v(dout1_62) AT=585.025n

* CHECK dout1_63 Vdout1_63ck116 = 0 time = 585
.meas tran vdout1_63ck116 FIND v(dout1_63) AT=585.025n

* CHECK dout1_64 Vdout1_64ck116 = 0.9 time = 585
.meas tran vdout1_64ck116 FIND v(dout1_64) AT=585.025n

* CHECK dout1_65 Vdout1_65ck116 = 0.9 time = 585
.meas tran vdout1_65ck116 FIND v(dout1_65) AT=585.025n

* CHECK dout1_66 Vdout1_66ck116 = 0.9 time = 585
.meas tran vdout1_66ck116 FIND v(dout1_66) AT=585.025n

* CHECK dout1_67 Vdout1_67ck116 = 0.9 time = 585
.meas tran vdout1_67ck116 FIND v(dout1_67) AT=585.025n

* CHECK dout1_68 Vdout1_68ck116 = 0.9 time = 585
.meas tran vdout1_68ck116 FIND v(dout1_68) AT=585.025n

* CHECK dout1_69 Vdout1_69ck116 = 0 time = 585
.meas tran vdout1_69ck116 FIND v(dout1_69) AT=585.025n

* CHECK dout1_70 Vdout1_70ck116 = 0.9 time = 585
.meas tran vdout1_70ck116 FIND v(dout1_70) AT=585.025n

* CHECK dout1_71 Vdout1_71ck116 = 0.9 time = 585
.meas tran vdout1_71ck116 FIND v(dout1_71) AT=585.025n

* CHECK dout1_0 Vdout1_0ck117 = 0.9 time = 590
.meas tran vdout1_0ck117 FIND v(dout1_0) AT=590.025n

* CHECK dout1_1 Vdout1_1ck117 = 0 time = 590
.meas tran vdout1_1ck117 FIND v(dout1_1) AT=590.025n

* CHECK dout1_2 Vdout1_2ck117 = 0.9 time = 590
.meas tran vdout1_2ck117 FIND v(dout1_2) AT=590.025n

* CHECK dout1_3 Vdout1_3ck117 = 0.9 time = 590
.meas tran vdout1_3ck117 FIND v(dout1_3) AT=590.025n

* CHECK dout1_4 Vdout1_4ck117 = 0 time = 590
.meas tran vdout1_4ck117 FIND v(dout1_4) AT=590.025n

* CHECK dout1_5 Vdout1_5ck117 = 0 time = 590
.meas tran vdout1_5ck117 FIND v(dout1_5) AT=590.025n

* CHECK dout1_6 Vdout1_6ck117 = 0 time = 590
.meas tran vdout1_6ck117 FIND v(dout1_6) AT=590.025n

* CHECK dout1_7 Vdout1_7ck117 = 0.9 time = 590
.meas tran vdout1_7ck117 FIND v(dout1_7) AT=590.025n

* CHECK dout1_8 Vdout1_8ck117 = 0 time = 590
.meas tran vdout1_8ck117 FIND v(dout1_8) AT=590.025n

* CHECK dout1_9 Vdout1_9ck117 = 0 time = 590
.meas tran vdout1_9ck117 FIND v(dout1_9) AT=590.025n

* CHECK dout1_10 Vdout1_10ck117 = 0 time = 590
.meas tran vdout1_10ck117 FIND v(dout1_10) AT=590.025n

* CHECK dout1_11 Vdout1_11ck117 = 0.9 time = 590
.meas tran vdout1_11ck117 FIND v(dout1_11) AT=590.025n

* CHECK dout1_12 Vdout1_12ck117 = 0.9 time = 590
.meas tran vdout1_12ck117 FIND v(dout1_12) AT=590.025n

* CHECK dout1_13 Vdout1_13ck117 = 0.9 time = 590
.meas tran vdout1_13ck117 FIND v(dout1_13) AT=590.025n

* CHECK dout1_14 Vdout1_14ck117 = 0.9 time = 590
.meas tran vdout1_14ck117 FIND v(dout1_14) AT=590.025n

* CHECK dout1_15 Vdout1_15ck117 = 0.9 time = 590
.meas tran vdout1_15ck117 FIND v(dout1_15) AT=590.025n

* CHECK dout1_16 Vdout1_16ck117 = 0.9 time = 590
.meas tran vdout1_16ck117 FIND v(dout1_16) AT=590.025n

* CHECK dout1_17 Vdout1_17ck117 = 0.9 time = 590
.meas tran vdout1_17ck117 FIND v(dout1_17) AT=590.025n

* CHECK dout1_18 Vdout1_18ck117 = 0.9 time = 590
.meas tran vdout1_18ck117 FIND v(dout1_18) AT=590.025n

* CHECK dout1_19 Vdout1_19ck117 = 0 time = 590
.meas tran vdout1_19ck117 FIND v(dout1_19) AT=590.025n

* CHECK dout1_20 Vdout1_20ck117 = 0 time = 590
.meas tran vdout1_20ck117 FIND v(dout1_20) AT=590.025n

* CHECK dout1_21 Vdout1_21ck117 = 0 time = 590
.meas tran vdout1_21ck117 FIND v(dout1_21) AT=590.025n

* CHECK dout1_22 Vdout1_22ck117 = 0 time = 590
.meas tran vdout1_22ck117 FIND v(dout1_22) AT=590.025n

* CHECK dout1_23 Vdout1_23ck117 = 0 time = 590
.meas tran vdout1_23ck117 FIND v(dout1_23) AT=590.025n

* CHECK dout1_24 Vdout1_24ck117 = 0 time = 590
.meas tran vdout1_24ck117 FIND v(dout1_24) AT=590.025n

* CHECK dout1_25 Vdout1_25ck117 = 0.9 time = 590
.meas tran vdout1_25ck117 FIND v(dout1_25) AT=590.025n

* CHECK dout1_26 Vdout1_26ck117 = 0.9 time = 590
.meas tran vdout1_26ck117 FIND v(dout1_26) AT=590.025n

* CHECK dout1_27 Vdout1_27ck117 = 0.9 time = 590
.meas tran vdout1_27ck117 FIND v(dout1_27) AT=590.025n

* CHECK dout1_28 Vdout1_28ck117 = 0.9 time = 590
.meas tran vdout1_28ck117 FIND v(dout1_28) AT=590.025n

* CHECK dout1_29 Vdout1_29ck117 = 0 time = 590
.meas tran vdout1_29ck117 FIND v(dout1_29) AT=590.025n

* CHECK dout1_30 Vdout1_30ck117 = 0.9 time = 590
.meas tran vdout1_30ck117 FIND v(dout1_30) AT=590.025n

* CHECK dout1_31 Vdout1_31ck117 = 0.9 time = 590
.meas tran vdout1_31ck117 FIND v(dout1_31) AT=590.025n

* CHECK dout1_32 Vdout1_32ck117 = 0.9 time = 590
.meas tran vdout1_32ck117 FIND v(dout1_32) AT=590.025n

* CHECK dout1_33 Vdout1_33ck117 = 0 time = 590
.meas tran vdout1_33ck117 FIND v(dout1_33) AT=590.025n

* CHECK dout1_34 Vdout1_34ck117 = 0 time = 590
.meas tran vdout1_34ck117 FIND v(dout1_34) AT=590.025n

* CHECK dout1_35 Vdout1_35ck117 = 0 time = 590
.meas tran vdout1_35ck117 FIND v(dout1_35) AT=590.025n

* CHECK dout1_36 Vdout1_36ck117 = 0 time = 590
.meas tran vdout1_36ck117 FIND v(dout1_36) AT=590.025n

* CHECK dout1_37 Vdout1_37ck117 = 0.9 time = 590
.meas tran vdout1_37ck117 FIND v(dout1_37) AT=590.025n

* CHECK dout1_38 Vdout1_38ck117 = 0 time = 590
.meas tran vdout1_38ck117 FIND v(dout1_38) AT=590.025n

* CHECK dout1_39 Vdout1_39ck117 = 0 time = 590
.meas tran vdout1_39ck117 FIND v(dout1_39) AT=590.025n

* CHECK dout1_40 Vdout1_40ck117 = 0 time = 590
.meas tran vdout1_40ck117 FIND v(dout1_40) AT=590.025n

* CHECK dout1_41 Vdout1_41ck117 = 0 time = 590
.meas tran vdout1_41ck117 FIND v(dout1_41) AT=590.025n

* CHECK dout1_42 Vdout1_42ck117 = 0 time = 590
.meas tran vdout1_42ck117 FIND v(dout1_42) AT=590.025n

* CHECK dout1_43 Vdout1_43ck117 = 0 time = 590
.meas tran vdout1_43ck117 FIND v(dout1_43) AT=590.025n

* CHECK dout1_44 Vdout1_44ck117 = 0 time = 590
.meas tran vdout1_44ck117 FIND v(dout1_44) AT=590.025n

* CHECK dout1_45 Vdout1_45ck117 = 0.9 time = 590
.meas tran vdout1_45ck117 FIND v(dout1_45) AT=590.025n

* CHECK dout1_46 Vdout1_46ck117 = 0 time = 590
.meas tran vdout1_46ck117 FIND v(dout1_46) AT=590.025n

* CHECK dout1_47 Vdout1_47ck117 = 0.9 time = 590
.meas tran vdout1_47ck117 FIND v(dout1_47) AT=590.025n

* CHECK dout1_48 Vdout1_48ck117 = 0.9 time = 590
.meas tran vdout1_48ck117 FIND v(dout1_48) AT=590.025n

* CHECK dout1_49 Vdout1_49ck117 = 0.9 time = 590
.meas tran vdout1_49ck117 FIND v(dout1_49) AT=590.025n

* CHECK dout1_50 Vdout1_50ck117 = 0.9 time = 590
.meas tran vdout1_50ck117 FIND v(dout1_50) AT=590.025n

* CHECK dout1_51 Vdout1_51ck117 = 0 time = 590
.meas tran vdout1_51ck117 FIND v(dout1_51) AT=590.025n

* CHECK dout1_52 Vdout1_52ck117 = 0 time = 590
.meas tran vdout1_52ck117 FIND v(dout1_52) AT=590.025n

* CHECK dout1_53 Vdout1_53ck117 = 0.9 time = 590
.meas tran vdout1_53ck117 FIND v(dout1_53) AT=590.025n

* CHECK dout1_54 Vdout1_54ck117 = 0 time = 590
.meas tran vdout1_54ck117 FIND v(dout1_54) AT=590.025n

* CHECK dout1_55 Vdout1_55ck117 = 0 time = 590
.meas tran vdout1_55ck117 FIND v(dout1_55) AT=590.025n

* CHECK dout1_56 Vdout1_56ck117 = 0 time = 590
.meas tran vdout1_56ck117 FIND v(dout1_56) AT=590.025n

* CHECK dout1_57 Vdout1_57ck117 = 0.9 time = 590
.meas tran vdout1_57ck117 FIND v(dout1_57) AT=590.025n

* CHECK dout1_58 Vdout1_58ck117 = 0 time = 590
.meas tran vdout1_58ck117 FIND v(dout1_58) AT=590.025n

* CHECK dout1_59 Vdout1_59ck117 = 0 time = 590
.meas tran vdout1_59ck117 FIND v(dout1_59) AT=590.025n

* CHECK dout1_60 Vdout1_60ck117 = 0.9 time = 590
.meas tran vdout1_60ck117 FIND v(dout1_60) AT=590.025n

* CHECK dout1_61 Vdout1_61ck117 = 0.9 time = 590
.meas tran vdout1_61ck117 FIND v(dout1_61) AT=590.025n

* CHECK dout1_62 Vdout1_62ck117 = 0.9 time = 590
.meas tran vdout1_62ck117 FIND v(dout1_62) AT=590.025n

* CHECK dout1_63 Vdout1_63ck117 = 0.9 time = 590
.meas tran vdout1_63ck117 FIND v(dout1_63) AT=590.025n

* CHECK dout1_64 Vdout1_64ck117 = 0.9 time = 590
.meas tran vdout1_64ck117 FIND v(dout1_64) AT=590.025n

* CHECK dout1_65 Vdout1_65ck117 = 0.9 time = 590
.meas tran vdout1_65ck117 FIND v(dout1_65) AT=590.025n

* CHECK dout1_66 Vdout1_66ck117 = 0.9 time = 590
.meas tran vdout1_66ck117 FIND v(dout1_66) AT=590.025n

* CHECK dout1_67 Vdout1_67ck117 = 0 time = 590
.meas tran vdout1_67ck117 FIND v(dout1_67) AT=590.025n

* CHECK dout1_68 Vdout1_68ck117 = 0 time = 590
.meas tran vdout1_68ck117 FIND v(dout1_68) AT=590.025n

* CHECK dout1_69 Vdout1_69ck117 = 0.9 time = 590
.meas tran vdout1_69ck117 FIND v(dout1_69) AT=590.025n

* CHECK dout1_70 Vdout1_70ck117 = 0.9 time = 590
.meas tran vdout1_70ck117 FIND v(dout1_70) AT=590.025n

* CHECK dout1_71 Vdout1_71ck117 = 0.9 time = 590
.meas tran vdout1_71ck117 FIND v(dout1_71) AT=590.025n

* CHECK dout1_0 Vdout1_0ck122 = 0.9 time = 615
.meas tran vdout1_0ck122 FIND v(dout1_0) AT=615.025n

* CHECK dout1_1 Vdout1_1ck122 = 0.9 time = 615
.meas tran vdout1_1ck122 FIND v(dout1_1) AT=615.025n

* CHECK dout1_2 Vdout1_2ck122 = 0 time = 615
.meas tran vdout1_2ck122 FIND v(dout1_2) AT=615.025n

* CHECK dout1_3 Vdout1_3ck122 = 0 time = 615
.meas tran vdout1_3ck122 FIND v(dout1_3) AT=615.025n

* CHECK dout1_4 Vdout1_4ck122 = 0 time = 615
.meas tran vdout1_4ck122 FIND v(dout1_4) AT=615.025n

* CHECK dout1_5 Vdout1_5ck122 = 0.9 time = 615
.meas tran vdout1_5ck122 FIND v(dout1_5) AT=615.025n

* CHECK dout1_6 Vdout1_6ck122 = 0 time = 615
.meas tran vdout1_6ck122 FIND v(dout1_6) AT=615.025n

* CHECK dout1_7 Vdout1_7ck122 = 0 time = 615
.meas tran vdout1_7ck122 FIND v(dout1_7) AT=615.025n

* CHECK dout1_8 Vdout1_8ck122 = 0 time = 615
.meas tran vdout1_8ck122 FIND v(dout1_8) AT=615.025n

* CHECK dout1_9 Vdout1_9ck122 = 0 time = 615
.meas tran vdout1_9ck122 FIND v(dout1_9) AT=615.025n

* CHECK dout1_10 Vdout1_10ck122 = 0 time = 615
.meas tran vdout1_10ck122 FIND v(dout1_10) AT=615.025n

* CHECK dout1_11 Vdout1_11ck122 = 0.9 time = 615
.meas tran vdout1_11ck122 FIND v(dout1_11) AT=615.025n

* CHECK dout1_12 Vdout1_12ck122 = 0.9 time = 615
.meas tran vdout1_12ck122 FIND v(dout1_12) AT=615.025n

* CHECK dout1_13 Vdout1_13ck122 = 0 time = 615
.meas tran vdout1_13ck122 FIND v(dout1_13) AT=615.025n

* CHECK dout1_14 Vdout1_14ck122 = 0.9 time = 615
.meas tran vdout1_14ck122 FIND v(dout1_14) AT=615.025n

* CHECK dout1_15 Vdout1_15ck122 = 0.9 time = 615
.meas tran vdout1_15ck122 FIND v(dout1_15) AT=615.025n

* CHECK dout1_16 Vdout1_16ck122 = 0 time = 615
.meas tran vdout1_16ck122 FIND v(dout1_16) AT=615.025n

* CHECK dout1_17 Vdout1_17ck122 = 0 time = 615
.meas tran vdout1_17ck122 FIND v(dout1_17) AT=615.025n

* CHECK dout1_18 Vdout1_18ck122 = 0 time = 615
.meas tran vdout1_18ck122 FIND v(dout1_18) AT=615.025n

* CHECK dout1_19 Vdout1_19ck122 = 0.9 time = 615
.meas tran vdout1_19ck122 FIND v(dout1_19) AT=615.025n

* CHECK dout1_20 Vdout1_20ck122 = 0 time = 615
.meas tran vdout1_20ck122 FIND v(dout1_20) AT=615.025n

* CHECK dout1_21 Vdout1_21ck122 = 0.9 time = 615
.meas tran vdout1_21ck122 FIND v(dout1_21) AT=615.025n

* CHECK dout1_22 Vdout1_22ck122 = 0 time = 615
.meas tran vdout1_22ck122 FIND v(dout1_22) AT=615.025n

* CHECK dout1_23 Vdout1_23ck122 = 0.9 time = 615
.meas tran vdout1_23ck122 FIND v(dout1_23) AT=615.025n

* CHECK dout1_24 Vdout1_24ck122 = 0.9 time = 615
.meas tran vdout1_24ck122 FIND v(dout1_24) AT=615.025n

* CHECK dout1_25 Vdout1_25ck122 = 0 time = 615
.meas tran vdout1_25ck122 FIND v(dout1_25) AT=615.025n

* CHECK dout1_26 Vdout1_26ck122 = 0 time = 615
.meas tran vdout1_26ck122 FIND v(dout1_26) AT=615.025n

* CHECK dout1_27 Vdout1_27ck122 = 0 time = 615
.meas tran vdout1_27ck122 FIND v(dout1_27) AT=615.025n

* CHECK dout1_28 Vdout1_28ck122 = 0.9 time = 615
.meas tran vdout1_28ck122 FIND v(dout1_28) AT=615.025n

* CHECK dout1_29 Vdout1_29ck122 = 0 time = 615
.meas tran vdout1_29ck122 FIND v(dout1_29) AT=615.025n

* CHECK dout1_30 Vdout1_30ck122 = 0 time = 615
.meas tran vdout1_30ck122 FIND v(dout1_30) AT=615.025n

* CHECK dout1_31 Vdout1_31ck122 = 0.9 time = 615
.meas tran vdout1_31ck122 FIND v(dout1_31) AT=615.025n

* CHECK dout1_32 Vdout1_32ck122 = 0 time = 615
.meas tran vdout1_32ck122 FIND v(dout1_32) AT=615.025n

* CHECK dout1_33 Vdout1_33ck122 = 0.9 time = 615
.meas tran vdout1_33ck122 FIND v(dout1_33) AT=615.025n

* CHECK dout1_34 Vdout1_34ck122 = 0.9 time = 615
.meas tran vdout1_34ck122 FIND v(dout1_34) AT=615.025n

* CHECK dout1_35 Vdout1_35ck122 = 0 time = 615
.meas tran vdout1_35ck122 FIND v(dout1_35) AT=615.025n

* CHECK dout1_36 Vdout1_36ck122 = 0 time = 615
.meas tran vdout1_36ck122 FIND v(dout1_36) AT=615.025n

* CHECK dout1_37 Vdout1_37ck122 = 0.9 time = 615
.meas tran vdout1_37ck122 FIND v(dout1_37) AT=615.025n

* CHECK dout1_38 Vdout1_38ck122 = 0.9 time = 615
.meas tran vdout1_38ck122 FIND v(dout1_38) AT=615.025n

* CHECK dout1_39 Vdout1_39ck122 = 0.9 time = 615
.meas tran vdout1_39ck122 FIND v(dout1_39) AT=615.025n

* CHECK dout1_40 Vdout1_40ck122 = 0 time = 615
.meas tran vdout1_40ck122 FIND v(dout1_40) AT=615.025n

* CHECK dout1_41 Vdout1_41ck122 = 0.9 time = 615
.meas tran vdout1_41ck122 FIND v(dout1_41) AT=615.025n

* CHECK dout1_42 Vdout1_42ck122 = 0 time = 615
.meas tran vdout1_42ck122 FIND v(dout1_42) AT=615.025n

* CHECK dout1_43 Vdout1_43ck122 = 0.9 time = 615
.meas tran vdout1_43ck122 FIND v(dout1_43) AT=615.025n

* CHECK dout1_44 Vdout1_44ck122 = 0.9 time = 615
.meas tran vdout1_44ck122 FIND v(dout1_44) AT=615.025n

* CHECK dout1_45 Vdout1_45ck122 = 0.9 time = 615
.meas tran vdout1_45ck122 FIND v(dout1_45) AT=615.025n

* CHECK dout1_46 Vdout1_46ck122 = 0.9 time = 615
.meas tran vdout1_46ck122 FIND v(dout1_46) AT=615.025n

* CHECK dout1_47 Vdout1_47ck122 = 0 time = 615
.meas tran vdout1_47ck122 FIND v(dout1_47) AT=615.025n

* CHECK dout1_48 Vdout1_48ck122 = 0 time = 615
.meas tran vdout1_48ck122 FIND v(dout1_48) AT=615.025n

* CHECK dout1_49 Vdout1_49ck122 = 0 time = 615
.meas tran vdout1_49ck122 FIND v(dout1_49) AT=615.025n

* CHECK dout1_50 Vdout1_50ck122 = 0 time = 615
.meas tran vdout1_50ck122 FIND v(dout1_50) AT=615.025n

* CHECK dout1_51 Vdout1_51ck122 = 0 time = 615
.meas tran vdout1_51ck122 FIND v(dout1_51) AT=615.025n

* CHECK dout1_52 Vdout1_52ck122 = 0.9 time = 615
.meas tran vdout1_52ck122 FIND v(dout1_52) AT=615.025n

* CHECK dout1_53 Vdout1_53ck122 = 0 time = 615
.meas tran vdout1_53ck122 FIND v(dout1_53) AT=615.025n

* CHECK dout1_54 Vdout1_54ck122 = 0 time = 615
.meas tran vdout1_54ck122 FIND v(dout1_54) AT=615.025n

* CHECK dout1_55 Vdout1_55ck122 = 0.9 time = 615
.meas tran vdout1_55ck122 FIND v(dout1_55) AT=615.025n

* CHECK dout1_56 Vdout1_56ck122 = 0 time = 615
.meas tran vdout1_56ck122 FIND v(dout1_56) AT=615.025n

* CHECK dout1_57 Vdout1_57ck122 = 0.9 time = 615
.meas tran vdout1_57ck122 FIND v(dout1_57) AT=615.025n

* CHECK dout1_58 Vdout1_58ck122 = 0.9 time = 615
.meas tran vdout1_58ck122 FIND v(dout1_58) AT=615.025n

* CHECK dout1_59 Vdout1_59ck122 = 0 time = 615
.meas tran vdout1_59ck122 FIND v(dout1_59) AT=615.025n

* CHECK dout1_60 Vdout1_60ck122 = 0.9 time = 615
.meas tran vdout1_60ck122 FIND v(dout1_60) AT=615.025n

* CHECK dout1_61 Vdout1_61ck122 = 0.9 time = 615
.meas tran vdout1_61ck122 FIND v(dout1_61) AT=615.025n

* CHECK dout1_62 Vdout1_62ck122 = 0 time = 615
.meas tran vdout1_62ck122 FIND v(dout1_62) AT=615.025n

* CHECK dout1_63 Vdout1_63ck122 = 0 time = 615
.meas tran vdout1_63ck122 FIND v(dout1_63) AT=615.025n

* CHECK dout1_64 Vdout1_64ck122 = 0.9 time = 615
.meas tran vdout1_64ck122 FIND v(dout1_64) AT=615.025n

* CHECK dout1_65 Vdout1_65ck122 = 0 time = 615
.meas tran vdout1_65ck122 FIND v(dout1_65) AT=615.025n

* CHECK dout1_66 Vdout1_66ck122 = 0 time = 615
.meas tran vdout1_66ck122 FIND v(dout1_66) AT=615.025n

* CHECK dout1_67 Vdout1_67ck122 = 0.9 time = 615
.meas tran vdout1_67ck122 FIND v(dout1_67) AT=615.025n

* CHECK dout1_68 Vdout1_68ck122 = 0 time = 615
.meas tran vdout1_68ck122 FIND v(dout1_68) AT=615.025n

* CHECK dout1_69 Vdout1_69ck122 = 0.9 time = 615
.meas tran vdout1_69ck122 FIND v(dout1_69) AT=615.025n

* CHECK dout1_70 Vdout1_70ck122 = 0.9 time = 615
.meas tran vdout1_70ck122 FIND v(dout1_70) AT=615.025n

* CHECK dout1_71 Vdout1_71ck122 = 0 time = 615
.meas tran vdout1_71ck122 FIND v(dout1_71) AT=615.025n

* CHECK dout1_0 Vdout1_0ck127 = 0 time = 640
.meas tran vdout1_0ck127 FIND v(dout1_0) AT=640.025n

* CHECK dout1_1 Vdout1_1ck127 = 0 time = 640
.meas tran vdout1_1ck127 FIND v(dout1_1) AT=640.025n

* CHECK dout1_2 Vdout1_2ck127 = 0 time = 640
.meas tran vdout1_2ck127 FIND v(dout1_2) AT=640.025n

* CHECK dout1_3 Vdout1_3ck127 = 0.9 time = 640
.meas tran vdout1_3ck127 FIND v(dout1_3) AT=640.025n

* CHECK dout1_4 Vdout1_4ck127 = 0 time = 640
.meas tran vdout1_4ck127 FIND v(dout1_4) AT=640.025n

* CHECK dout1_5 Vdout1_5ck127 = 0.9 time = 640
.meas tran vdout1_5ck127 FIND v(dout1_5) AT=640.025n

* CHECK dout1_6 Vdout1_6ck127 = 0 time = 640
.meas tran vdout1_6ck127 FIND v(dout1_6) AT=640.025n

* CHECK dout1_7 Vdout1_7ck127 = 0.9 time = 640
.meas tran vdout1_7ck127 FIND v(dout1_7) AT=640.025n

* CHECK dout1_8 Vdout1_8ck127 = 0.9 time = 640
.meas tran vdout1_8ck127 FIND v(dout1_8) AT=640.025n

* CHECK dout1_9 Vdout1_9ck127 = 0 time = 640
.meas tran vdout1_9ck127 FIND v(dout1_9) AT=640.025n

* CHECK dout1_10 Vdout1_10ck127 = 0.9 time = 640
.meas tran vdout1_10ck127 FIND v(dout1_10) AT=640.025n

* CHECK dout1_11 Vdout1_11ck127 = 0 time = 640
.meas tran vdout1_11ck127 FIND v(dout1_11) AT=640.025n

* CHECK dout1_12 Vdout1_12ck127 = 0.9 time = 640
.meas tran vdout1_12ck127 FIND v(dout1_12) AT=640.025n

* CHECK dout1_13 Vdout1_13ck127 = 0.9 time = 640
.meas tran vdout1_13ck127 FIND v(dout1_13) AT=640.025n

* CHECK dout1_14 Vdout1_14ck127 = 0 time = 640
.meas tran vdout1_14ck127 FIND v(dout1_14) AT=640.025n

* CHECK dout1_15 Vdout1_15ck127 = 0 time = 640
.meas tran vdout1_15ck127 FIND v(dout1_15) AT=640.025n

* CHECK dout1_16 Vdout1_16ck127 = 0.9 time = 640
.meas tran vdout1_16ck127 FIND v(dout1_16) AT=640.025n

* CHECK dout1_17 Vdout1_17ck127 = 0.9 time = 640
.meas tran vdout1_17ck127 FIND v(dout1_17) AT=640.025n

* CHECK dout1_18 Vdout1_18ck127 = 0.9 time = 640
.meas tran vdout1_18ck127 FIND v(dout1_18) AT=640.025n

* CHECK dout1_19 Vdout1_19ck127 = 0.9 time = 640
.meas tran vdout1_19ck127 FIND v(dout1_19) AT=640.025n

* CHECK dout1_20 Vdout1_20ck127 = 0.9 time = 640
.meas tran vdout1_20ck127 FIND v(dout1_20) AT=640.025n

* CHECK dout1_21 Vdout1_21ck127 = 0.9 time = 640
.meas tran vdout1_21ck127 FIND v(dout1_21) AT=640.025n

* CHECK dout1_22 Vdout1_22ck127 = 0 time = 640
.meas tran vdout1_22ck127 FIND v(dout1_22) AT=640.025n

* CHECK dout1_23 Vdout1_23ck127 = 0.9 time = 640
.meas tran vdout1_23ck127 FIND v(dout1_23) AT=640.025n

* CHECK dout1_24 Vdout1_24ck127 = 0.9 time = 640
.meas tran vdout1_24ck127 FIND v(dout1_24) AT=640.025n

* CHECK dout1_25 Vdout1_25ck127 = 0 time = 640
.meas tran vdout1_25ck127 FIND v(dout1_25) AT=640.025n

* CHECK dout1_26 Vdout1_26ck127 = 0.9 time = 640
.meas tran vdout1_26ck127 FIND v(dout1_26) AT=640.025n

* CHECK dout1_27 Vdout1_27ck127 = 0 time = 640
.meas tran vdout1_27ck127 FIND v(dout1_27) AT=640.025n

* CHECK dout1_28 Vdout1_28ck127 = 0 time = 640
.meas tran vdout1_28ck127 FIND v(dout1_28) AT=640.025n

* CHECK dout1_29 Vdout1_29ck127 = 0 time = 640
.meas tran vdout1_29ck127 FIND v(dout1_29) AT=640.025n

* CHECK dout1_30 Vdout1_30ck127 = 0 time = 640
.meas tran vdout1_30ck127 FIND v(dout1_30) AT=640.025n

* CHECK dout1_31 Vdout1_31ck127 = 0 time = 640
.meas tran vdout1_31ck127 FIND v(dout1_31) AT=640.025n

* CHECK dout1_32 Vdout1_32ck127 = 0.9 time = 640
.meas tran vdout1_32ck127 FIND v(dout1_32) AT=640.025n

* CHECK dout1_33 Vdout1_33ck127 = 0.9 time = 640
.meas tran vdout1_33ck127 FIND v(dout1_33) AT=640.025n

* CHECK dout1_34 Vdout1_34ck127 = 0 time = 640
.meas tran vdout1_34ck127 FIND v(dout1_34) AT=640.025n

* CHECK dout1_35 Vdout1_35ck127 = 0 time = 640
.meas tran vdout1_35ck127 FIND v(dout1_35) AT=640.025n

* CHECK dout1_36 Vdout1_36ck127 = 0.9 time = 640
.meas tran vdout1_36ck127 FIND v(dout1_36) AT=640.025n

* CHECK dout1_37 Vdout1_37ck127 = 0 time = 640
.meas tran vdout1_37ck127 FIND v(dout1_37) AT=640.025n

* CHECK dout1_38 Vdout1_38ck127 = 0 time = 640
.meas tran vdout1_38ck127 FIND v(dout1_38) AT=640.025n

* CHECK dout1_39 Vdout1_39ck127 = 0 time = 640
.meas tran vdout1_39ck127 FIND v(dout1_39) AT=640.025n

* CHECK dout1_40 Vdout1_40ck127 = 0.9 time = 640
.meas tran vdout1_40ck127 FIND v(dout1_40) AT=640.025n

* CHECK dout1_41 Vdout1_41ck127 = 0 time = 640
.meas tran vdout1_41ck127 FIND v(dout1_41) AT=640.025n

* CHECK dout1_42 Vdout1_42ck127 = 0 time = 640
.meas tran vdout1_42ck127 FIND v(dout1_42) AT=640.025n

* CHECK dout1_43 Vdout1_43ck127 = 0 time = 640
.meas tran vdout1_43ck127 FIND v(dout1_43) AT=640.025n

* CHECK dout1_44 Vdout1_44ck127 = 0 time = 640
.meas tran vdout1_44ck127 FIND v(dout1_44) AT=640.025n

* CHECK dout1_45 Vdout1_45ck127 = 0 time = 640
.meas tran vdout1_45ck127 FIND v(dout1_45) AT=640.025n

* CHECK dout1_46 Vdout1_46ck127 = 0.9 time = 640
.meas tran vdout1_46ck127 FIND v(dout1_46) AT=640.025n

* CHECK dout1_47 Vdout1_47ck127 = 0 time = 640
.meas tran vdout1_47ck127 FIND v(dout1_47) AT=640.025n

* CHECK dout1_48 Vdout1_48ck127 = 0.9 time = 640
.meas tran vdout1_48ck127 FIND v(dout1_48) AT=640.025n

* CHECK dout1_49 Vdout1_49ck127 = 0 time = 640
.meas tran vdout1_49ck127 FIND v(dout1_49) AT=640.025n

* CHECK dout1_50 Vdout1_50ck127 = 0 time = 640
.meas tran vdout1_50ck127 FIND v(dout1_50) AT=640.025n

* CHECK dout1_51 Vdout1_51ck127 = 0.9 time = 640
.meas tran vdout1_51ck127 FIND v(dout1_51) AT=640.025n

* CHECK dout1_52 Vdout1_52ck127 = 0.9 time = 640
.meas tran vdout1_52ck127 FIND v(dout1_52) AT=640.025n

* CHECK dout1_53 Vdout1_53ck127 = 0.9 time = 640
.meas tran vdout1_53ck127 FIND v(dout1_53) AT=640.025n

* CHECK dout1_54 Vdout1_54ck127 = 0.9 time = 640
.meas tran vdout1_54ck127 FIND v(dout1_54) AT=640.025n

* CHECK dout1_55 Vdout1_55ck127 = 0 time = 640
.meas tran vdout1_55ck127 FIND v(dout1_55) AT=640.025n

* CHECK dout1_56 Vdout1_56ck127 = 0 time = 640
.meas tran vdout1_56ck127 FIND v(dout1_56) AT=640.025n

* CHECK dout1_57 Vdout1_57ck127 = 0.9 time = 640
.meas tran vdout1_57ck127 FIND v(dout1_57) AT=640.025n

* CHECK dout1_58 Vdout1_58ck127 = 0 time = 640
.meas tran vdout1_58ck127 FIND v(dout1_58) AT=640.025n

* CHECK dout1_59 Vdout1_59ck127 = 0 time = 640
.meas tran vdout1_59ck127 FIND v(dout1_59) AT=640.025n

* CHECK dout1_60 Vdout1_60ck127 = 0.9 time = 640
.meas tran vdout1_60ck127 FIND v(dout1_60) AT=640.025n

* CHECK dout1_61 Vdout1_61ck127 = 0.9 time = 640
.meas tran vdout1_61ck127 FIND v(dout1_61) AT=640.025n

* CHECK dout1_62 Vdout1_62ck127 = 0 time = 640
.meas tran vdout1_62ck127 FIND v(dout1_62) AT=640.025n

* CHECK dout1_63 Vdout1_63ck127 = 0.9 time = 640
.meas tran vdout1_63ck127 FIND v(dout1_63) AT=640.025n

* CHECK dout1_64 Vdout1_64ck127 = 0 time = 640
.meas tran vdout1_64ck127 FIND v(dout1_64) AT=640.025n

* CHECK dout1_65 Vdout1_65ck127 = 0.9 time = 640
.meas tran vdout1_65ck127 FIND v(dout1_65) AT=640.025n

* CHECK dout1_66 Vdout1_66ck127 = 0.9 time = 640
.meas tran vdout1_66ck127 FIND v(dout1_66) AT=640.025n

* CHECK dout1_67 Vdout1_67ck127 = 0.9 time = 640
.meas tran vdout1_67ck127 FIND v(dout1_67) AT=640.025n

* CHECK dout1_68 Vdout1_68ck127 = 0 time = 640
.meas tran vdout1_68ck127 FIND v(dout1_68) AT=640.025n

* CHECK dout1_69 Vdout1_69ck127 = 0.9 time = 640
.meas tran vdout1_69ck127 FIND v(dout1_69) AT=640.025n

* CHECK dout1_70 Vdout1_70ck127 = 0 time = 640
.meas tran vdout1_70ck127 FIND v(dout1_70) AT=640.025n

* CHECK dout1_71 Vdout1_71ck127 = 0.9 time = 640
.meas tran vdout1_71ck127 FIND v(dout1_71) AT=640.025n

* CHECK dout1_0 Vdout1_0ck130 = 0.9 time = 655
.meas tran vdout1_0ck130 FIND v(dout1_0) AT=655.025n

* CHECK dout1_1 Vdout1_1ck130 = 0 time = 655
.meas tran vdout1_1ck130 FIND v(dout1_1) AT=655.025n

* CHECK dout1_2 Vdout1_2ck130 = 0.9 time = 655
.meas tran vdout1_2ck130 FIND v(dout1_2) AT=655.025n

* CHECK dout1_3 Vdout1_3ck130 = 0 time = 655
.meas tran vdout1_3ck130 FIND v(dout1_3) AT=655.025n

* CHECK dout1_4 Vdout1_4ck130 = 0.9 time = 655
.meas tran vdout1_4ck130 FIND v(dout1_4) AT=655.025n

* CHECK dout1_5 Vdout1_5ck130 = 0.9 time = 655
.meas tran vdout1_5ck130 FIND v(dout1_5) AT=655.025n

* CHECK dout1_6 Vdout1_6ck130 = 0 time = 655
.meas tran vdout1_6ck130 FIND v(dout1_6) AT=655.025n

* CHECK dout1_7 Vdout1_7ck130 = 0 time = 655
.meas tran vdout1_7ck130 FIND v(dout1_7) AT=655.025n

* CHECK dout1_8 Vdout1_8ck130 = 0 time = 655
.meas tran vdout1_8ck130 FIND v(dout1_8) AT=655.025n

* CHECK dout1_9 Vdout1_9ck130 = 0.9 time = 655
.meas tran vdout1_9ck130 FIND v(dout1_9) AT=655.025n

* CHECK dout1_10 Vdout1_10ck130 = 0.9 time = 655
.meas tran vdout1_10ck130 FIND v(dout1_10) AT=655.025n

* CHECK dout1_11 Vdout1_11ck130 = 0.9 time = 655
.meas tran vdout1_11ck130 FIND v(dout1_11) AT=655.025n

* CHECK dout1_12 Vdout1_12ck130 = 0.9 time = 655
.meas tran vdout1_12ck130 FIND v(dout1_12) AT=655.025n

* CHECK dout1_13 Vdout1_13ck130 = 0.9 time = 655
.meas tran vdout1_13ck130 FIND v(dout1_13) AT=655.025n

* CHECK dout1_14 Vdout1_14ck130 = 0 time = 655
.meas tran vdout1_14ck130 FIND v(dout1_14) AT=655.025n

* CHECK dout1_15 Vdout1_15ck130 = 0.9 time = 655
.meas tran vdout1_15ck130 FIND v(dout1_15) AT=655.025n

* CHECK dout1_16 Vdout1_16ck130 = 0.9 time = 655
.meas tran vdout1_16ck130 FIND v(dout1_16) AT=655.025n

* CHECK dout1_17 Vdout1_17ck130 = 0 time = 655
.meas tran vdout1_17ck130 FIND v(dout1_17) AT=655.025n

* CHECK dout1_18 Vdout1_18ck130 = 0 time = 655
.meas tran vdout1_18ck130 FIND v(dout1_18) AT=655.025n

* CHECK dout1_19 Vdout1_19ck130 = 0.9 time = 655
.meas tran vdout1_19ck130 FIND v(dout1_19) AT=655.025n

* CHECK dout1_20 Vdout1_20ck130 = 0 time = 655
.meas tran vdout1_20ck130 FIND v(dout1_20) AT=655.025n

* CHECK dout1_21 Vdout1_21ck130 = 0.9 time = 655
.meas tran vdout1_21ck130 FIND v(dout1_21) AT=655.025n

* CHECK dout1_22 Vdout1_22ck130 = 0.9 time = 655
.meas tran vdout1_22ck130 FIND v(dout1_22) AT=655.025n

* CHECK dout1_23 Vdout1_23ck130 = 0 time = 655
.meas tran vdout1_23ck130 FIND v(dout1_23) AT=655.025n

* CHECK dout1_24 Vdout1_24ck130 = 0.9 time = 655
.meas tran vdout1_24ck130 FIND v(dout1_24) AT=655.025n

* CHECK dout1_25 Vdout1_25ck130 = 0.9 time = 655
.meas tran vdout1_25ck130 FIND v(dout1_25) AT=655.025n

* CHECK dout1_26 Vdout1_26ck130 = 0 time = 655
.meas tran vdout1_26ck130 FIND v(dout1_26) AT=655.025n

* CHECK dout1_27 Vdout1_27ck130 = 0 time = 655
.meas tran vdout1_27ck130 FIND v(dout1_27) AT=655.025n

* CHECK dout1_28 Vdout1_28ck130 = 0 time = 655
.meas tran vdout1_28ck130 FIND v(dout1_28) AT=655.025n

* CHECK dout1_29 Vdout1_29ck130 = 0.9 time = 655
.meas tran vdout1_29ck130 FIND v(dout1_29) AT=655.025n

* CHECK dout1_30 Vdout1_30ck130 = 0 time = 655
.meas tran vdout1_30ck130 FIND v(dout1_30) AT=655.025n

* CHECK dout1_31 Vdout1_31ck130 = 0.9 time = 655
.meas tran vdout1_31ck130 FIND v(dout1_31) AT=655.025n

* CHECK dout1_32 Vdout1_32ck130 = 0.9 time = 655
.meas tran vdout1_32ck130 FIND v(dout1_32) AT=655.025n

* CHECK dout1_33 Vdout1_33ck130 = 0.9 time = 655
.meas tran vdout1_33ck130 FIND v(dout1_33) AT=655.025n

* CHECK dout1_34 Vdout1_34ck130 = 0 time = 655
.meas tran vdout1_34ck130 FIND v(dout1_34) AT=655.025n

* CHECK dout1_35 Vdout1_35ck130 = 0.9 time = 655
.meas tran vdout1_35ck130 FIND v(dout1_35) AT=655.025n

* CHECK dout1_36 Vdout1_36ck130 = 0 time = 655
.meas tran vdout1_36ck130 FIND v(dout1_36) AT=655.025n

* CHECK dout1_37 Vdout1_37ck130 = 0 time = 655
.meas tran vdout1_37ck130 FIND v(dout1_37) AT=655.025n

* CHECK dout1_38 Vdout1_38ck130 = 0 time = 655
.meas tran vdout1_38ck130 FIND v(dout1_38) AT=655.025n

* CHECK dout1_39 Vdout1_39ck130 = 0.9 time = 655
.meas tran vdout1_39ck130 FIND v(dout1_39) AT=655.025n

* CHECK dout1_40 Vdout1_40ck130 = 0.9 time = 655
.meas tran vdout1_40ck130 FIND v(dout1_40) AT=655.025n

* CHECK dout1_41 Vdout1_41ck130 = 0.9 time = 655
.meas tran vdout1_41ck130 FIND v(dout1_41) AT=655.025n

* CHECK dout1_42 Vdout1_42ck130 = 0.9 time = 655
.meas tran vdout1_42ck130 FIND v(dout1_42) AT=655.025n

* CHECK dout1_43 Vdout1_43ck130 = 0 time = 655
.meas tran vdout1_43ck130 FIND v(dout1_43) AT=655.025n

* CHECK dout1_44 Vdout1_44ck130 = 0.9 time = 655
.meas tran vdout1_44ck130 FIND v(dout1_44) AT=655.025n

* CHECK dout1_45 Vdout1_45ck130 = 0.9 time = 655
.meas tran vdout1_45ck130 FIND v(dout1_45) AT=655.025n

* CHECK dout1_46 Vdout1_46ck130 = 0 time = 655
.meas tran vdout1_46ck130 FIND v(dout1_46) AT=655.025n

* CHECK dout1_47 Vdout1_47ck130 = 0 time = 655
.meas tran vdout1_47ck130 FIND v(dout1_47) AT=655.025n

* CHECK dout1_48 Vdout1_48ck130 = 0.9 time = 655
.meas tran vdout1_48ck130 FIND v(dout1_48) AT=655.025n

* CHECK dout1_49 Vdout1_49ck130 = 0 time = 655
.meas tran vdout1_49ck130 FIND v(dout1_49) AT=655.025n

* CHECK dout1_50 Vdout1_50ck130 = 0 time = 655
.meas tran vdout1_50ck130 FIND v(dout1_50) AT=655.025n

* CHECK dout1_51 Vdout1_51ck130 = 0 time = 655
.meas tran vdout1_51ck130 FIND v(dout1_51) AT=655.025n

* CHECK dout1_52 Vdout1_52ck130 = 0.9 time = 655
.meas tran vdout1_52ck130 FIND v(dout1_52) AT=655.025n

* CHECK dout1_53 Vdout1_53ck130 = 0.9 time = 655
.meas tran vdout1_53ck130 FIND v(dout1_53) AT=655.025n

* CHECK dout1_54 Vdout1_54ck130 = 0 time = 655
.meas tran vdout1_54ck130 FIND v(dout1_54) AT=655.025n

* CHECK dout1_55 Vdout1_55ck130 = 0.9 time = 655
.meas tran vdout1_55ck130 FIND v(dout1_55) AT=655.025n

* CHECK dout1_56 Vdout1_56ck130 = 0 time = 655
.meas tran vdout1_56ck130 FIND v(dout1_56) AT=655.025n

* CHECK dout1_57 Vdout1_57ck130 = 0 time = 655
.meas tran vdout1_57ck130 FIND v(dout1_57) AT=655.025n

* CHECK dout1_58 Vdout1_58ck130 = 0 time = 655
.meas tran vdout1_58ck130 FIND v(dout1_58) AT=655.025n

* CHECK dout1_59 Vdout1_59ck130 = 0.9 time = 655
.meas tran vdout1_59ck130 FIND v(dout1_59) AT=655.025n

* CHECK dout1_60 Vdout1_60ck130 = 0 time = 655
.meas tran vdout1_60ck130 FIND v(dout1_60) AT=655.025n

* CHECK dout1_61 Vdout1_61ck130 = 0 time = 655
.meas tran vdout1_61ck130 FIND v(dout1_61) AT=655.025n

* CHECK dout1_62 Vdout1_62ck130 = 0.9 time = 655
.meas tran vdout1_62ck130 FIND v(dout1_62) AT=655.025n

* CHECK dout1_63 Vdout1_63ck130 = 0 time = 655
.meas tran vdout1_63ck130 FIND v(dout1_63) AT=655.025n

* CHECK dout1_64 Vdout1_64ck130 = 0.9 time = 655
.meas tran vdout1_64ck130 FIND v(dout1_64) AT=655.025n

* CHECK dout1_65 Vdout1_65ck130 = 0 time = 655
.meas tran vdout1_65ck130 FIND v(dout1_65) AT=655.025n

* CHECK dout1_66 Vdout1_66ck130 = 0 time = 655
.meas tran vdout1_66ck130 FIND v(dout1_66) AT=655.025n

* CHECK dout1_67 Vdout1_67ck130 = 0.9 time = 655
.meas tran vdout1_67ck130 FIND v(dout1_67) AT=655.025n

* CHECK dout1_68 Vdout1_68ck130 = 0 time = 655
.meas tran vdout1_68ck130 FIND v(dout1_68) AT=655.025n

* CHECK dout1_69 Vdout1_69ck130 = 0 time = 655
.meas tran vdout1_69ck130 FIND v(dout1_69) AT=655.025n

* CHECK dout1_70 Vdout1_70ck130 = 0.9 time = 655
.meas tran vdout1_70ck130 FIND v(dout1_70) AT=655.025n

* CHECK dout1_71 Vdout1_71ck130 = 0 time = 655
.meas tran vdout1_71ck130 FIND v(dout1_71) AT=655.025n

* CHECK dout1_0 Vdout1_0ck137 = 0.9 time = 690
.meas tran vdout1_0ck137 FIND v(dout1_0) AT=690.025n

* CHECK dout1_1 Vdout1_1ck137 = 0 time = 690
.meas tran vdout1_1ck137 FIND v(dout1_1) AT=690.025n

* CHECK dout1_2 Vdout1_2ck137 = 0 time = 690
.meas tran vdout1_2ck137 FIND v(dout1_2) AT=690.025n

* CHECK dout1_3 Vdout1_3ck137 = 0 time = 690
.meas tran vdout1_3ck137 FIND v(dout1_3) AT=690.025n

* CHECK dout1_4 Vdout1_4ck137 = 0 time = 690
.meas tran vdout1_4ck137 FIND v(dout1_4) AT=690.025n

* CHECK dout1_5 Vdout1_5ck137 = 0 time = 690
.meas tran vdout1_5ck137 FIND v(dout1_5) AT=690.025n

* CHECK dout1_6 Vdout1_6ck137 = 0 time = 690
.meas tran vdout1_6ck137 FIND v(dout1_6) AT=690.025n

* CHECK dout1_7 Vdout1_7ck137 = 0.9 time = 690
.meas tran vdout1_7ck137 FIND v(dout1_7) AT=690.025n

* CHECK dout1_8 Vdout1_8ck137 = 0.9 time = 690
.meas tran vdout1_8ck137 FIND v(dout1_8) AT=690.025n

* CHECK dout1_9 Vdout1_9ck137 = 0.9 time = 690
.meas tran vdout1_9ck137 FIND v(dout1_9) AT=690.025n

* CHECK dout1_10 Vdout1_10ck137 = 0.9 time = 690
.meas tran vdout1_10ck137 FIND v(dout1_10) AT=690.025n

* CHECK dout1_11 Vdout1_11ck137 = 0 time = 690
.meas tran vdout1_11ck137 FIND v(dout1_11) AT=690.025n

* CHECK dout1_12 Vdout1_12ck137 = 0.9 time = 690
.meas tran vdout1_12ck137 FIND v(dout1_12) AT=690.025n

* CHECK dout1_13 Vdout1_13ck137 = 0 time = 690
.meas tran vdout1_13ck137 FIND v(dout1_13) AT=690.025n

* CHECK dout1_14 Vdout1_14ck137 = 0.9 time = 690
.meas tran vdout1_14ck137 FIND v(dout1_14) AT=690.025n

* CHECK dout1_15 Vdout1_15ck137 = 0.9 time = 690
.meas tran vdout1_15ck137 FIND v(dout1_15) AT=690.025n

* CHECK dout1_16 Vdout1_16ck137 = 0 time = 690
.meas tran vdout1_16ck137 FIND v(dout1_16) AT=690.025n

* CHECK dout1_17 Vdout1_17ck137 = 0 time = 690
.meas tran vdout1_17ck137 FIND v(dout1_17) AT=690.025n

* CHECK dout1_18 Vdout1_18ck137 = 0 time = 690
.meas tran vdout1_18ck137 FIND v(dout1_18) AT=690.025n

* CHECK dout1_19 Vdout1_19ck137 = 0.9 time = 690
.meas tran vdout1_19ck137 FIND v(dout1_19) AT=690.025n

* CHECK dout1_20 Vdout1_20ck137 = 0.9 time = 690
.meas tran vdout1_20ck137 FIND v(dout1_20) AT=690.025n

* CHECK dout1_21 Vdout1_21ck137 = 0 time = 690
.meas tran vdout1_21ck137 FIND v(dout1_21) AT=690.025n

* CHECK dout1_22 Vdout1_22ck137 = 0 time = 690
.meas tran vdout1_22ck137 FIND v(dout1_22) AT=690.025n

* CHECK dout1_23 Vdout1_23ck137 = 0 time = 690
.meas tran vdout1_23ck137 FIND v(dout1_23) AT=690.025n

* CHECK dout1_24 Vdout1_24ck137 = 0 time = 690
.meas tran vdout1_24ck137 FIND v(dout1_24) AT=690.025n

* CHECK dout1_25 Vdout1_25ck137 = 0 time = 690
.meas tran vdout1_25ck137 FIND v(dout1_25) AT=690.025n

* CHECK dout1_26 Vdout1_26ck137 = 0 time = 690
.meas tran vdout1_26ck137 FIND v(dout1_26) AT=690.025n

* CHECK dout1_27 Vdout1_27ck137 = 0 time = 690
.meas tran vdout1_27ck137 FIND v(dout1_27) AT=690.025n

* CHECK dout1_28 Vdout1_28ck137 = 0.9 time = 690
.meas tran vdout1_28ck137 FIND v(dout1_28) AT=690.025n

* CHECK dout1_29 Vdout1_29ck137 = 0.9 time = 690
.meas tran vdout1_29ck137 FIND v(dout1_29) AT=690.025n

* CHECK dout1_30 Vdout1_30ck137 = 0.9 time = 690
.meas tran vdout1_30ck137 FIND v(dout1_30) AT=690.025n

* CHECK dout1_31 Vdout1_31ck137 = 0.9 time = 690
.meas tran vdout1_31ck137 FIND v(dout1_31) AT=690.025n

* CHECK dout1_32 Vdout1_32ck137 = 0.9 time = 690
.meas tran vdout1_32ck137 FIND v(dout1_32) AT=690.025n

* CHECK dout1_33 Vdout1_33ck137 = 0.9 time = 690
.meas tran vdout1_33ck137 FIND v(dout1_33) AT=690.025n

* CHECK dout1_34 Vdout1_34ck137 = 0.9 time = 690
.meas tran vdout1_34ck137 FIND v(dout1_34) AT=690.025n

* CHECK dout1_35 Vdout1_35ck137 = 0.9 time = 690
.meas tran vdout1_35ck137 FIND v(dout1_35) AT=690.025n

* CHECK dout1_36 Vdout1_36ck137 = 0.9 time = 690
.meas tran vdout1_36ck137 FIND v(dout1_36) AT=690.025n

* CHECK dout1_37 Vdout1_37ck137 = 0 time = 690
.meas tran vdout1_37ck137 FIND v(dout1_37) AT=690.025n

* CHECK dout1_38 Vdout1_38ck137 = 0.9 time = 690
.meas tran vdout1_38ck137 FIND v(dout1_38) AT=690.025n

* CHECK dout1_39 Vdout1_39ck137 = 0.9 time = 690
.meas tran vdout1_39ck137 FIND v(dout1_39) AT=690.025n

* CHECK dout1_40 Vdout1_40ck137 = 0.9 time = 690
.meas tran vdout1_40ck137 FIND v(dout1_40) AT=690.025n

* CHECK dout1_41 Vdout1_41ck137 = 0 time = 690
.meas tran vdout1_41ck137 FIND v(dout1_41) AT=690.025n

* CHECK dout1_42 Vdout1_42ck137 = 0.9 time = 690
.meas tran vdout1_42ck137 FIND v(dout1_42) AT=690.025n

* CHECK dout1_43 Vdout1_43ck137 = 0 time = 690
.meas tran vdout1_43ck137 FIND v(dout1_43) AT=690.025n

* CHECK dout1_44 Vdout1_44ck137 = 0 time = 690
.meas tran vdout1_44ck137 FIND v(dout1_44) AT=690.025n

* CHECK dout1_45 Vdout1_45ck137 = 0 time = 690
.meas tran vdout1_45ck137 FIND v(dout1_45) AT=690.025n

* CHECK dout1_46 Vdout1_46ck137 = 0 time = 690
.meas tran vdout1_46ck137 FIND v(dout1_46) AT=690.025n

* CHECK dout1_47 Vdout1_47ck137 = 0.9 time = 690
.meas tran vdout1_47ck137 FIND v(dout1_47) AT=690.025n

* CHECK dout1_48 Vdout1_48ck137 = 0.9 time = 690
.meas tran vdout1_48ck137 FIND v(dout1_48) AT=690.025n

* CHECK dout1_49 Vdout1_49ck137 = 0.9 time = 690
.meas tran vdout1_49ck137 FIND v(dout1_49) AT=690.025n

* CHECK dout1_50 Vdout1_50ck137 = 0.9 time = 690
.meas tran vdout1_50ck137 FIND v(dout1_50) AT=690.025n

* CHECK dout1_51 Vdout1_51ck137 = 0 time = 690
.meas tran vdout1_51ck137 FIND v(dout1_51) AT=690.025n

* CHECK dout1_52 Vdout1_52ck137 = 0.9 time = 690
.meas tran vdout1_52ck137 FIND v(dout1_52) AT=690.025n

* CHECK dout1_53 Vdout1_53ck137 = 0 time = 690
.meas tran vdout1_53ck137 FIND v(dout1_53) AT=690.025n

* CHECK dout1_54 Vdout1_54ck137 = 0.9 time = 690
.meas tran vdout1_54ck137 FIND v(dout1_54) AT=690.025n

* CHECK dout1_55 Vdout1_55ck137 = 0 time = 690
.meas tran vdout1_55ck137 FIND v(dout1_55) AT=690.025n

* CHECK dout1_56 Vdout1_56ck137 = 0 time = 690
.meas tran vdout1_56ck137 FIND v(dout1_56) AT=690.025n

* CHECK dout1_57 Vdout1_57ck137 = 0.9 time = 690
.meas tran vdout1_57ck137 FIND v(dout1_57) AT=690.025n

* CHECK dout1_58 Vdout1_58ck137 = 0.9 time = 690
.meas tran vdout1_58ck137 FIND v(dout1_58) AT=690.025n

* CHECK dout1_59 Vdout1_59ck137 = 0 time = 690
.meas tran vdout1_59ck137 FIND v(dout1_59) AT=690.025n

* CHECK dout1_60 Vdout1_60ck137 = 0.9 time = 690
.meas tran vdout1_60ck137 FIND v(dout1_60) AT=690.025n

* CHECK dout1_61 Vdout1_61ck137 = 0 time = 690
.meas tran vdout1_61ck137 FIND v(dout1_61) AT=690.025n

* CHECK dout1_62 Vdout1_62ck137 = 0.9 time = 690
.meas tran vdout1_62ck137 FIND v(dout1_62) AT=690.025n

* CHECK dout1_63 Vdout1_63ck137 = 0 time = 690
.meas tran vdout1_63ck137 FIND v(dout1_63) AT=690.025n

* CHECK dout1_64 Vdout1_64ck137 = 0 time = 690
.meas tran vdout1_64ck137 FIND v(dout1_64) AT=690.025n

* CHECK dout1_65 Vdout1_65ck137 = 0 time = 690
.meas tran vdout1_65ck137 FIND v(dout1_65) AT=690.025n

* CHECK dout1_66 Vdout1_66ck137 = 0.9 time = 690
.meas tran vdout1_66ck137 FIND v(dout1_66) AT=690.025n

* CHECK dout1_67 Vdout1_67ck137 = 0.9 time = 690
.meas tran vdout1_67ck137 FIND v(dout1_67) AT=690.025n

* CHECK dout1_68 Vdout1_68ck137 = 0.9 time = 690
.meas tran vdout1_68ck137 FIND v(dout1_68) AT=690.025n

* CHECK dout1_69 Vdout1_69ck137 = 0 time = 690
.meas tran vdout1_69ck137 FIND v(dout1_69) AT=690.025n

* CHECK dout1_70 Vdout1_70ck137 = 0.9 time = 690
.meas tran vdout1_70ck137 FIND v(dout1_70) AT=690.025n

* CHECK dout1_71 Vdout1_71ck137 = 0.9 time = 690
.meas tran vdout1_71ck137 FIND v(dout1_71) AT=690.025n

* CHECK dout1_0 Vdout1_0ck138 = 0 time = 695
.meas tran vdout1_0ck138 FIND v(dout1_0) AT=695.025n

* CHECK dout1_1 Vdout1_1ck138 = 0 time = 695
.meas tran vdout1_1ck138 FIND v(dout1_1) AT=695.025n

* CHECK dout1_2 Vdout1_2ck138 = 0 time = 695
.meas tran vdout1_2ck138 FIND v(dout1_2) AT=695.025n

* CHECK dout1_3 Vdout1_3ck138 = 0 time = 695
.meas tran vdout1_3ck138 FIND v(dout1_3) AT=695.025n

* CHECK dout1_4 Vdout1_4ck138 = 0.9 time = 695
.meas tran vdout1_4ck138 FIND v(dout1_4) AT=695.025n

* CHECK dout1_5 Vdout1_5ck138 = 0 time = 695
.meas tran vdout1_5ck138 FIND v(dout1_5) AT=695.025n

* CHECK dout1_6 Vdout1_6ck138 = 0 time = 695
.meas tran vdout1_6ck138 FIND v(dout1_6) AT=695.025n

* CHECK dout1_7 Vdout1_7ck138 = 0.9 time = 695
.meas tran vdout1_7ck138 FIND v(dout1_7) AT=695.025n

* CHECK dout1_8 Vdout1_8ck138 = 0.9 time = 695
.meas tran vdout1_8ck138 FIND v(dout1_8) AT=695.025n

* CHECK dout1_9 Vdout1_9ck138 = 0.9 time = 695
.meas tran vdout1_9ck138 FIND v(dout1_9) AT=695.025n

* CHECK dout1_10 Vdout1_10ck138 = 0.9 time = 695
.meas tran vdout1_10ck138 FIND v(dout1_10) AT=695.025n

* CHECK dout1_11 Vdout1_11ck138 = 0.9 time = 695
.meas tran vdout1_11ck138 FIND v(dout1_11) AT=695.025n

* CHECK dout1_12 Vdout1_12ck138 = 0 time = 695
.meas tran vdout1_12ck138 FIND v(dout1_12) AT=695.025n

* CHECK dout1_13 Vdout1_13ck138 = 0 time = 695
.meas tran vdout1_13ck138 FIND v(dout1_13) AT=695.025n

* CHECK dout1_14 Vdout1_14ck138 = 0 time = 695
.meas tran vdout1_14ck138 FIND v(dout1_14) AT=695.025n

* CHECK dout1_15 Vdout1_15ck138 = 0.9 time = 695
.meas tran vdout1_15ck138 FIND v(dout1_15) AT=695.025n

* CHECK dout1_16 Vdout1_16ck138 = 0 time = 695
.meas tran vdout1_16ck138 FIND v(dout1_16) AT=695.025n

* CHECK dout1_17 Vdout1_17ck138 = 0 time = 695
.meas tran vdout1_17ck138 FIND v(dout1_17) AT=695.025n

* CHECK dout1_18 Vdout1_18ck138 = 0 time = 695
.meas tran vdout1_18ck138 FIND v(dout1_18) AT=695.025n

* CHECK dout1_19 Vdout1_19ck138 = 0 time = 695
.meas tran vdout1_19ck138 FIND v(dout1_19) AT=695.025n

* CHECK dout1_20 Vdout1_20ck138 = 0.9 time = 695
.meas tran vdout1_20ck138 FIND v(dout1_20) AT=695.025n

* CHECK dout1_21 Vdout1_21ck138 = 0 time = 695
.meas tran vdout1_21ck138 FIND v(dout1_21) AT=695.025n

* CHECK dout1_22 Vdout1_22ck138 = 0.9 time = 695
.meas tran vdout1_22ck138 FIND v(dout1_22) AT=695.025n

* CHECK dout1_23 Vdout1_23ck138 = 0 time = 695
.meas tran vdout1_23ck138 FIND v(dout1_23) AT=695.025n

* CHECK dout1_24 Vdout1_24ck138 = 0.9 time = 695
.meas tran vdout1_24ck138 FIND v(dout1_24) AT=695.025n

* CHECK dout1_25 Vdout1_25ck138 = 0 time = 695
.meas tran vdout1_25ck138 FIND v(dout1_25) AT=695.025n

* CHECK dout1_26 Vdout1_26ck138 = 0 time = 695
.meas tran vdout1_26ck138 FIND v(dout1_26) AT=695.025n

* CHECK dout1_27 Vdout1_27ck138 = 0.9 time = 695
.meas tran vdout1_27ck138 FIND v(dout1_27) AT=695.025n

* CHECK dout1_28 Vdout1_28ck138 = 0 time = 695
.meas tran vdout1_28ck138 FIND v(dout1_28) AT=695.025n

* CHECK dout1_29 Vdout1_29ck138 = 0.9 time = 695
.meas tran vdout1_29ck138 FIND v(dout1_29) AT=695.025n

* CHECK dout1_30 Vdout1_30ck138 = 0.9 time = 695
.meas tran vdout1_30ck138 FIND v(dout1_30) AT=695.025n

* CHECK dout1_31 Vdout1_31ck138 = 0 time = 695
.meas tran vdout1_31ck138 FIND v(dout1_31) AT=695.025n

* CHECK dout1_32 Vdout1_32ck138 = 0 time = 695
.meas tran vdout1_32ck138 FIND v(dout1_32) AT=695.025n

* CHECK dout1_33 Vdout1_33ck138 = 0.9 time = 695
.meas tran vdout1_33ck138 FIND v(dout1_33) AT=695.025n

* CHECK dout1_34 Vdout1_34ck138 = 0.9 time = 695
.meas tran vdout1_34ck138 FIND v(dout1_34) AT=695.025n

* CHECK dout1_35 Vdout1_35ck138 = 0.9 time = 695
.meas tran vdout1_35ck138 FIND v(dout1_35) AT=695.025n

* CHECK dout1_36 Vdout1_36ck138 = 0 time = 695
.meas tran vdout1_36ck138 FIND v(dout1_36) AT=695.025n

* CHECK dout1_37 Vdout1_37ck138 = 0.9 time = 695
.meas tran vdout1_37ck138 FIND v(dout1_37) AT=695.025n

* CHECK dout1_38 Vdout1_38ck138 = 0 time = 695
.meas tran vdout1_38ck138 FIND v(dout1_38) AT=695.025n

* CHECK dout1_39 Vdout1_39ck138 = 0 time = 695
.meas tran vdout1_39ck138 FIND v(dout1_39) AT=695.025n

* CHECK dout1_40 Vdout1_40ck138 = 0.9 time = 695
.meas tran vdout1_40ck138 FIND v(dout1_40) AT=695.025n

* CHECK dout1_41 Vdout1_41ck138 = 0 time = 695
.meas tran vdout1_41ck138 FIND v(dout1_41) AT=695.025n

* CHECK dout1_42 Vdout1_42ck138 = 0 time = 695
.meas tran vdout1_42ck138 FIND v(dout1_42) AT=695.025n

* CHECK dout1_43 Vdout1_43ck138 = 0 time = 695
.meas tran vdout1_43ck138 FIND v(dout1_43) AT=695.025n

* CHECK dout1_44 Vdout1_44ck138 = 0.9 time = 695
.meas tran vdout1_44ck138 FIND v(dout1_44) AT=695.025n

* CHECK dout1_45 Vdout1_45ck138 = 0.9 time = 695
.meas tran vdout1_45ck138 FIND v(dout1_45) AT=695.025n

* CHECK dout1_46 Vdout1_46ck138 = 0.9 time = 695
.meas tran vdout1_46ck138 FIND v(dout1_46) AT=695.025n

* CHECK dout1_47 Vdout1_47ck138 = 0.9 time = 695
.meas tran vdout1_47ck138 FIND v(dout1_47) AT=695.025n

* CHECK dout1_48 Vdout1_48ck138 = 0.9 time = 695
.meas tran vdout1_48ck138 FIND v(dout1_48) AT=695.025n

* CHECK dout1_49 Vdout1_49ck138 = 0 time = 695
.meas tran vdout1_49ck138 FIND v(dout1_49) AT=695.025n

* CHECK dout1_50 Vdout1_50ck138 = 0 time = 695
.meas tran vdout1_50ck138 FIND v(dout1_50) AT=695.025n

* CHECK dout1_51 Vdout1_51ck138 = 0.9 time = 695
.meas tran vdout1_51ck138 FIND v(dout1_51) AT=695.025n

* CHECK dout1_52 Vdout1_52ck138 = 0.9 time = 695
.meas tran vdout1_52ck138 FIND v(dout1_52) AT=695.025n

* CHECK dout1_53 Vdout1_53ck138 = 0 time = 695
.meas tran vdout1_53ck138 FIND v(dout1_53) AT=695.025n

* CHECK dout1_54 Vdout1_54ck138 = 0 time = 695
.meas tran vdout1_54ck138 FIND v(dout1_54) AT=695.025n

* CHECK dout1_55 Vdout1_55ck138 = 0.9 time = 695
.meas tran vdout1_55ck138 FIND v(dout1_55) AT=695.025n

* CHECK dout1_56 Vdout1_56ck138 = 0.9 time = 695
.meas tran vdout1_56ck138 FIND v(dout1_56) AT=695.025n

* CHECK dout1_57 Vdout1_57ck138 = 0 time = 695
.meas tran vdout1_57ck138 FIND v(dout1_57) AT=695.025n

* CHECK dout1_58 Vdout1_58ck138 = 0 time = 695
.meas tran vdout1_58ck138 FIND v(dout1_58) AT=695.025n

* CHECK dout1_59 Vdout1_59ck138 = 0 time = 695
.meas tran vdout1_59ck138 FIND v(dout1_59) AT=695.025n

* CHECK dout1_60 Vdout1_60ck138 = 0 time = 695
.meas tran vdout1_60ck138 FIND v(dout1_60) AT=695.025n

* CHECK dout1_61 Vdout1_61ck138 = 0 time = 695
.meas tran vdout1_61ck138 FIND v(dout1_61) AT=695.025n

* CHECK dout1_62 Vdout1_62ck138 = 0.9 time = 695
.meas tran vdout1_62ck138 FIND v(dout1_62) AT=695.025n

* CHECK dout1_63 Vdout1_63ck138 = 0 time = 695
.meas tran vdout1_63ck138 FIND v(dout1_63) AT=695.025n

* CHECK dout1_64 Vdout1_64ck138 = 0.9 time = 695
.meas tran vdout1_64ck138 FIND v(dout1_64) AT=695.025n

* CHECK dout1_65 Vdout1_65ck138 = 0.9 time = 695
.meas tran vdout1_65ck138 FIND v(dout1_65) AT=695.025n

* CHECK dout1_66 Vdout1_66ck138 = 0.9 time = 695
.meas tran vdout1_66ck138 FIND v(dout1_66) AT=695.025n

* CHECK dout1_67 Vdout1_67ck138 = 0 time = 695
.meas tran vdout1_67ck138 FIND v(dout1_67) AT=695.025n

* CHECK dout1_68 Vdout1_68ck138 = 0 time = 695
.meas tran vdout1_68ck138 FIND v(dout1_68) AT=695.025n

* CHECK dout1_69 Vdout1_69ck138 = 0.9 time = 695
.meas tran vdout1_69ck138 FIND v(dout1_69) AT=695.025n

* CHECK dout1_70 Vdout1_70ck138 = 0.9 time = 695
.meas tran vdout1_70ck138 FIND v(dout1_70) AT=695.025n

* CHECK dout1_71 Vdout1_71ck138 = 0.9 time = 695
.meas tran vdout1_71ck138 FIND v(dout1_71) AT=695.025n

* CHECK dout1_0 Vdout1_0ck140 = 0.9 time = 705
.meas tran vdout1_0ck140 FIND v(dout1_0) AT=705.025n

* CHECK dout1_1 Vdout1_1ck140 = 0 time = 705
.meas tran vdout1_1ck140 FIND v(dout1_1) AT=705.025n

* CHECK dout1_2 Vdout1_2ck140 = 0 time = 705
.meas tran vdout1_2ck140 FIND v(dout1_2) AT=705.025n

* CHECK dout1_3 Vdout1_3ck140 = 0 time = 705
.meas tran vdout1_3ck140 FIND v(dout1_3) AT=705.025n

* CHECK dout1_4 Vdout1_4ck140 = 0 time = 705
.meas tran vdout1_4ck140 FIND v(dout1_4) AT=705.025n

* CHECK dout1_5 Vdout1_5ck140 = 0 time = 705
.meas tran vdout1_5ck140 FIND v(dout1_5) AT=705.025n

* CHECK dout1_6 Vdout1_6ck140 = 0 time = 705
.meas tran vdout1_6ck140 FIND v(dout1_6) AT=705.025n

* CHECK dout1_7 Vdout1_7ck140 = 0.9 time = 705
.meas tran vdout1_7ck140 FIND v(dout1_7) AT=705.025n

* CHECK dout1_8 Vdout1_8ck140 = 0.9 time = 705
.meas tran vdout1_8ck140 FIND v(dout1_8) AT=705.025n

* CHECK dout1_9 Vdout1_9ck140 = 0.9 time = 705
.meas tran vdout1_9ck140 FIND v(dout1_9) AT=705.025n

* CHECK dout1_10 Vdout1_10ck140 = 0.9 time = 705
.meas tran vdout1_10ck140 FIND v(dout1_10) AT=705.025n

* CHECK dout1_11 Vdout1_11ck140 = 0 time = 705
.meas tran vdout1_11ck140 FIND v(dout1_11) AT=705.025n

* CHECK dout1_12 Vdout1_12ck140 = 0.9 time = 705
.meas tran vdout1_12ck140 FIND v(dout1_12) AT=705.025n

* CHECK dout1_13 Vdout1_13ck140 = 0 time = 705
.meas tran vdout1_13ck140 FIND v(dout1_13) AT=705.025n

* CHECK dout1_14 Vdout1_14ck140 = 0.9 time = 705
.meas tran vdout1_14ck140 FIND v(dout1_14) AT=705.025n

* CHECK dout1_15 Vdout1_15ck140 = 0.9 time = 705
.meas tran vdout1_15ck140 FIND v(dout1_15) AT=705.025n

* CHECK dout1_16 Vdout1_16ck140 = 0 time = 705
.meas tran vdout1_16ck140 FIND v(dout1_16) AT=705.025n

* CHECK dout1_17 Vdout1_17ck140 = 0 time = 705
.meas tran vdout1_17ck140 FIND v(dout1_17) AT=705.025n

* CHECK dout1_18 Vdout1_18ck140 = 0 time = 705
.meas tran vdout1_18ck140 FIND v(dout1_18) AT=705.025n

* CHECK dout1_19 Vdout1_19ck140 = 0.9 time = 705
.meas tran vdout1_19ck140 FIND v(dout1_19) AT=705.025n

* CHECK dout1_20 Vdout1_20ck140 = 0.9 time = 705
.meas tran vdout1_20ck140 FIND v(dout1_20) AT=705.025n

* CHECK dout1_21 Vdout1_21ck140 = 0 time = 705
.meas tran vdout1_21ck140 FIND v(dout1_21) AT=705.025n

* CHECK dout1_22 Vdout1_22ck140 = 0 time = 705
.meas tran vdout1_22ck140 FIND v(dout1_22) AT=705.025n

* CHECK dout1_23 Vdout1_23ck140 = 0 time = 705
.meas tran vdout1_23ck140 FIND v(dout1_23) AT=705.025n

* CHECK dout1_24 Vdout1_24ck140 = 0 time = 705
.meas tran vdout1_24ck140 FIND v(dout1_24) AT=705.025n

* CHECK dout1_25 Vdout1_25ck140 = 0 time = 705
.meas tran vdout1_25ck140 FIND v(dout1_25) AT=705.025n

* CHECK dout1_26 Vdout1_26ck140 = 0 time = 705
.meas tran vdout1_26ck140 FIND v(dout1_26) AT=705.025n

* CHECK dout1_27 Vdout1_27ck140 = 0 time = 705
.meas tran vdout1_27ck140 FIND v(dout1_27) AT=705.025n

* CHECK dout1_28 Vdout1_28ck140 = 0.9 time = 705
.meas tran vdout1_28ck140 FIND v(dout1_28) AT=705.025n

* CHECK dout1_29 Vdout1_29ck140 = 0.9 time = 705
.meas tran vdout1_29ck140 FIND v(dout1_29) AT=705.025n

* CHECK dout1_30 Vdout1_30ck140 = 0.9 time = 705
.meas tran vdout1_30ck140 FIND v(dout1_30) AT=705.025n

* CHECK dout1_31 Vdout1_31ck140 = 0.9 time = 705
.meas tran vdout1_31ck140 FIND v(dout1_31) AT=705.025n

* CHECK dout1_32 Vdout1_32ck140 = 0.9 time = 705
.meas tran vdout1_32ck140 FIND v(dout1_32) AT=705.025n

* CHECK dout1_33 Vdout1_33ck140 = 0.9 time = 705
.meas tran vdout1_33ck140 FIND v(dout1_33) AT=705.025n

* CHECK dout1_34 Vdout1_34ck140 = 0.9 time = 705
.meas tran vdout1_34ck140 FIND v(dout1_34) AT=705.025n

* CHECK dout1_35 Vdout1_35ck140 = 0.9 time = 705
.meas tran vdout1_35ck140 FIND v(dout1_35) AT=705.025n

* CHECK dout1_36 Vdout1_36ck140 = 0.9 time = 705
.meas tran vdout1_36ck140 FIND v(dout1_36) AT=705.025n

* CHECK dout1_37 Vdout1_37ck140 = 0 time = 705
.meas tran vdout1_37ck140 FIND v(dout1_37) AT=705.025n

* CHECK dout1_38 Vdout1_38ck140 = 0.9 time = 705
.meas tran vdout1_38ck140 FIND v(dout1_38) AT=705.025n

* CHECK dout1_39 Vdout1_39ck140 = 0.9 time = 705
.meas tran vdout1_39ck140 FIND v(dout1_39) AT=705.025n

* CHECK dout1_40 Vdout1_40ck140 = 0.9 time = 705
.meas tran vdout1_40ck140 FIND v(dout1_40) AT=705.025n

* CHECK dout1_41 Vdout1_41ck140 = 0 time = 705
.meas tran vdout1_41ck140 FIND v(dout1_41) AT=705.025n

* CHECK dout1_42 Vdout1_42ck140 = 0.9 time = 705
.meas tran vdout1_42ck140 FIND v(dout1_42) AT=705.025n

* CHECK dout1_43 Vdout1_43ck140 = 0 time = 705
.meas tran vdout1_43ck140 FIND v(dout1_43) AT=705.025n

* CHECK dout1_44 Vdout1_44ck140 = 0 time = 705
.meas tran vdout1_44ck140 FIND v(dout1_44) AT=705.025n

* CHECK dout1_45 Vdout1_45ck140 = 0 time = 705
.meas tran vdout1_45ck140 FIND v(dout1_45) AT=705.025n

* CHECK dout1_46 Vdout1_46ck140 = 0 time = 705
.meas tran vdout1_46ck140 FIND v(dout1_46) AT=705.025n

* CHECK dout1_47 Vdout1_47ck140 = 0.9 time = 705
.meas tran vdout1_47ck140 FIND v(dout1_47) AT=705.025n

* CHECK dout1_48 Vdout1_48ck140 = 0.9 time = 705
.meas tran vdout1_48ck140 FIND v(dout1_48) AT=705.025n

* CHECK dout1_49 Vdout1_49ck140 = 0.9 time = 705
.meas tran vdout1_49ck140 FIND v(dout1_49) AT=705.025n

* CHECK dout1_50 Vdout1_50ck140 = 0.9 time = 705
.meas tran vdout1_50ck140 FIND v(dout1_50) AT=705.025n

* CHECK dout1_51 Vdout1_51ck140 = 0 time = 705
.meas tran vdout1_51ck140 FIND v(dout1_51) AT=705.025n

* CHECK dout1_52 Vdout1_52ck140 = 0.9 time = 705
.meas tran vdout1_52ck140 FIND v(dout1_52) AT=705.025n

* CHECK dout1_53 Vdout1_53ck140 = 0 time = 705
.meas tran vdout1_53ck140 FIND v(dout1_53) AT=705.025n

* CHECK dout1_54 Vdout1_54ck140 = 0.9 time = 705
.meas tran vdout1_54ck140 FIND v(dout1_54) AT=705.025n

* CHECK dout1_55 Vdout1_55ck140 = 0 time = 705
.meas tran vdout1_55ck140 FIND v(dout1_55) AT=705.025n

* CHECK dout1_56 Vdout1_56ck140 = 0 time = 705
.meas tran vdout1_56ck140 FIND v(dout1_56) AT=705.025n

* CHECK dout1_57 Vdout1_57ck140 = 0.9 time = 705
.meas tran vdout1_57ck140 FIND v(dout1_57) AT=705.025n

* CHECK dout1_58 Vdout1_58ck140 = 0.9 time = 705
.meas tran vdout1_58ck140 FIND v(dout1_58) AT=705.025n

* CHECK dout1_59 Vdout1_59ck140 = 0 time = 705
.meas tran vdout1_59ck140 FIND v(dout1_59) AT=705.025n

* CHECK dout1_60 Vdout1_60ck140 = 0.9 time = 705
.meas tran vdout1_60ck140 FIND v(dout1_60) AT=705.025n

* CHECK dout1_61 Vdout1_61ck140 = 0 time = 705
.meas tran vdout1_61ck140 FIND v(dout1_61) AT=705.025n

* CHECK dout1_62 Vdout1_62ck140 = 0.9 time = 705
.meas tran vdout1_62ck140 FIND v(dout1_62) AT=705.025n

* CHECK dout1_63 Vdout1_63ck140 = 0 time = 705
.meas tran vdout1_63ck140 FIND v(dout1_63) AT=705.025n

* CHECK dout1_64 Vdout1_64ck140 = 0 time = 705
.meas tran vdout1_64ck140 FIND v(dout1_64) AT=705.025n

* CHECK dout1_65 Vdout1_65ck140 = 0 time = 705
.meas tran vdout1_65ck140 FIND v(dout1_65) AT=705.025n

* CHECK dout1_66 Vdout1_66ck140 = 0.9 time = 705
.meas tran vdout1_66ck140 FIND v(dout1_66) AT=705.025n

* CHECK dout1_67 Vdout1_67ck140 = 0.9 time = 705
.meas tran vdout1_67ck140 FIND v(dout1_67) AT=705.025n

* CHECK dout1_68 Vdout1_68ck140 = 0.9 time = 705
.meas tran vdout1_68ck140 FIND v(dout1_68) AT=705.025n

* CHECK dout1_69 Vdout1_69ck140 = 0 time = 705
.meas tran vdout1_69ck140 FIND v(dout1_69) AT=705.025n

* CHECK dout1_70 Vdout1_70ck140 = 0.9 time = 705
.meas tran vdout1_70ck140 FIND v(dout1_70) AT=705.025n

* CHECK dout1_71 Vdout1_71ck140 = 0.9 time = 705
.meas tran vdout1_71ck140 FIND v(dout1_71) AT=705.025n

* CHECK dout1_0 Vdout1_0ck145 = 0 time = 730
.meas tran vdout1_0ck145 FIND v(dout1_0) AT=730.025n

* CHECK dout1_1 Vdout1_1ck145 = 0.9 time = 730
.meas tran vdout1_1ck145 FIND v(dout1_1) AT=730.025n

* CHECK dout1_2 Vdout1_2ck145 = 0.9 time = 730
.meas tran vdout1_2ck145 FIND v(dout1_2) AT=730.025n

* CHECK dout1_3 Vdout1_3ck145 = 0 time = 730
.meas tran vdout1_3ck145 FIND v(dout1_3) AT=730.025n

* CHECK dout1_4 Vdout1_4ck145 = 0.9 time = 730
.meas tran vdout1_4ck145 FIND v(dout1_4) AT=730.025n

* CHECK dout1_5 Vdout1_5ck145 = 0.9 time = 730
.meas tran vdout1_5ck145 FIND v(dout1_5) AT=730.025n

* CHECK dout1_6 Vdout1_6ck145 = 0 time = 730
.meas tran vdout1_6ck145 FIND v(dout1_6) AT=730.025n

* CHECK dout1_7 Vdout1_7ck145 = 0.9 time = 730
.meas tran vdout1_7ck145 FIND v(dout1_7) AT=730.025n

* CHECK dout1_8 Vdout1_8ck145 = 0.9 time = 730
.meas tran vdout1_8ck145 FIND v(dout1_8) AT=730.025n

* CHECK dout1_9 Vdout1_9ck145 = 0 time = 730
.meas tran vdout1_9ck145 FIND v(dout1_9) AT=730.025n

* CHECK dout1_10 Vdout1_10ck145 = 0 time = 730
.meas tran vdout1_10ck145 FIND v(dout1_10) AT=730.025n

* CHECK dout1_11 Vdout1_11ck145 = 0 time = 730
.meas tran vdout1_11ck145 FIND v(dout1_11) AT=730.025n

* CHECK dout1_12 Vdout1_12ck145 = 0.9 time = 730
.meas tran vdout1_12ck145 FIND v(dout1_12) AT=730.025n

* CHECK dout1_13 Vdout1_13ck145 = 0.9 time = 730
.meas tran vdout1_13ck145 FIND v(dout1_13) AT=730.025n

* CHECK dout1_14 Vdout1_14ck145 = 0 time = 730
.meas tran vdout1_14ck145 FIND v(dout1_14) AT=730.025n

* CHECK dout1_15 Vdout1_15ck145 = 0.9 time = 730
.meas tran vdout1_15ck145 FIND v(dout1_15) AT=730.025n

* CHECK dout1_16 Vdout1_16ck145 = 0.9 time = 730
.meas tran vdout1_16ck145 FIND v(dout1_16) AT=730.025n

* CHECK dout1_17 Vdout1_17ck145 = 0.9 time = 730
.meas tran vdout1_17ck145 FIND v(dout1_17) AT=730.025n

* CHECK dout1_18 Vdout1_18ck145 = 0.9 time = 730
.meas tran vdout1_18ck145 FIND v(dout1_18) AT=730.025n

* CHECK dout1_19 Vdout1_19ck145 = 0 time = 730
.meas tran vdout1_19ck145 FIND v(dout1_19) AT=730.025n

* CHECK dout1_20 Vdout1_20ck145 = 0.9 time = 730
.meas tran vdout1_20ck145 FIND v(dout1_20) AT=730.025n

* CHECK dout1_21 Vdout1_21ck145 = 0.9 time = 730
.meas tran vdout1_21ck145 FIND v(dout1_21) AT=730.025n

* CHECK dout1_22 Vdout1_22ck145 = 0 time = 730
.meas tran vdout1_22ck145 FIND v(dout1_22) AT=730.025n

* CHECK dout1_23 Vdout1_23ck145 = 0.9 time = 730
.meas tran vdout1_23ck145 FIND v(dout1_23) AT=730.025n

* CHECK dout1_24 Vdout1_24ck145 = 0 time = 730
.meas tran vdout1_24ck145 FIND v(dout1_24) AT=730.025n

* CHECK dout1_25 Vdout1_25ck145 = 0.9 time = 730
.meas tran vdout1_25ck145 FIND v(dout1_25) AT=730.025n

* CHECK dout1_26 Vdout1_26ck145 = 0 time = 730
.meas tran vdout1_26ck145 FIND v(dout1_26) AT=730.025n

* CHECK dout1_27 Vdout1_27ck145 = 0.9 time = 730
.meas tran vdout1_27ck145 FIND v(dout1_27) AT=730.025n

* CHECK dout1_28 Vdout1_28ck145 = 0 time = 730
.meas tran vdout1_28ck145 FIND v(dout1_28) AT=730.025n

* CHECK dout1_29 Vdout1_29ck145 = 0 time = 730
.meas tran vdout1_29ck145 FIND v(dout1_29) AT=730.025n

* CHECK dout1_30 Vdout1_30ck145 = 0 time = 730
.meas tran vdout1_30ck145 FIND v(dout1_30) AT=730.025n

* CHECK dout1_31 Vdout1_31ck145 = 0 time = 730
.meas tran vdout1_31ck145 FIND v(dout1_31) AT=730.025n

* CHECK dout1_32 Vdout1_32ck145 = 0.9 time = 730
.meas tran vdout1_32ck145 FIND v(dout1_32) AT=730.025n

* CHECK dout1_33 Vdout1_33ck145 = 0.9 time = 730
.meas tran vdout1_33ck145 FIND v(dout1_33) AT=730.025n

* CHECK dout1_34 Vdout1_34ck145 = 0.9 time = 730
.meas tran vdout1_34ck145 FIND v(dout1_34) AT=730.025n

* CHECK dout1_35 Vdout1_35ck145 = 0 time = 730
.meas tran vdout1_35ck145 FIND v(dout1_35) AT=730.025n

* CHECK dout1_36 Vdout1_36ck145 = 0 time = 730
.meas tran vdout1_36ck145 FIND v(dout1_36) AT=730.025n

* CHECK dout1_37 Vdout1_37ck145 = 0.9 time = 730
.meas tran vdout1_37ck145 FIND v(dout1_37) AT=730.025n

* CHECK dout1_38 Vdout1_38ck145 = 0 time = 730
.meas tran vdout1_38ck145 FIND v(dout1_38) AT=730.025n

* CHECK dout1_39 Vdout1_39ck145 = 0 time = 730
.meas tran vdout1_39ck145 FIND v(dout1_39) AT=730.025n

* CHECK dout1_40 Vdout1_40ck145 = 0 time = 730
.meas tran vdout1_40ck145 FIND v(dout1_40) AT=730.025n

* CHECK dout1_41 Vdout1_41ck145 = 0.9 time = 730
.meas tran vdout1_41ck145 FIND v(dout1_41) AT=730.025n

* CHECK dout1_42 Vdout1_42ck145 = 0.9 time = 730
.meas tran vdout1_42ck145 FIND v(dout1_42) AT=730.025n

* CHECK dout1_43 Vdout1_43ck145 = 0.9 time = 730
.meas tran vdout1_43ck145 FIND v(dout1_43) AT=730.025n

* CHECK dout1_44 Vdout1_44ck145 = 0 time = 730
.meas tran vdout1_44ck145 FIND v(dout1_44) AT=730.025n

* CHECK dout1_45 Vdout1_45ck145 = 0 time = 730
.meas tran vdout1_45ck145 FIND v(dout1_45) AT=730.025n

* CHECK dout1_46 Vdout1_46ck145 = 0.9 time = 730
.meas tran vdout1_46ck145 FIND v(dout1_46) AT=730.025n

* CHECK dout1_47 Vdout1_47ck145 = 0.9 time = 730
.meas tran vdout1_47ck145 FIND v(dout1_47) AT=730.025n

* CHECK dout1_48 Vdout1_48ck145 = 0 time = 730
.meas tran vdout1_48ck145 FIND v(dout1_48) AT=730.025n

* CHECK dout1_49 Vdout1_49ck145 = 0.9 time = 730
.meas tran vdout1_49ck145 FIND v(dout1_49) AT=730.025n

* CHECK dout1_50 Vdout1_50ck145 = 0.9 time = 730
.meas tran vdout1_50ck145 FIND v(dout1_50) AT=730.025n

* CHECK dout1_51 Vdout1_51ck145 = 0.9 time = 730
.meas tran vdout1_51ck145 FIND v(dout1_51) AT=730.025n

* CHECK dout1_52 Vdout1_52ck145 = 0.9 time = 730
.meas tran vdout1_52ck145 FIND v(dout1_52) AT=730.025n

* CHECK dout1_53 Vdout1_53ck145 = 0 time = 730
.meas tran vdout1_53ck145 FIND v(dout1_53) AT=730.025n

* CHECK dout1_54 Vdout1_54ck145 = 0 time = 730
.meas tran vdout1_54ck145 FIND v(dout1_54) AT=730.025n

* CHECK dout1_55 Vdout1_55ck145 = 0 time = 730
.meas tran vdout1_55ck145 FIND v(dout1_55) AT=730.025n

* CHECK dout1_56 Vdout1_56ck145 = 0 time = 730
.meas tran vdout1_56ck145 FIND v(dout1_56) AT=730.025n

* CHECK dout1_57 Vdout1_57ck145 = 0.9 time = 730
.meas tran vdout1_57ck145 FIND v(dout1_57) AT=730.025n

* CHECK dout1_58 Vdout1_58ck145 = 0 time = 730
.meas tran vdout1_58ck145 FIND v(dout1_58) AT=730.025n

* CHECK dout1_59 Vdout1_59ck145 = 0.9 time = 730
.meas tran vdout1_59ck145 FIND v(dout1_59) AT=730.025n

* CHECK dout1_60 Vdout1_60ck145 = 0.9 time = 730
.meas tran vdout1_60ck145 FIND v(dout1_60) AT=730.025n

* CHECK dout1_61 Vdout1_61ck145 = 0.9 time = 730
.meas tran vdout1_61ck145 FIND v(dout1_61) AT=730.025n

* CHECK dout1_62 Vdout1_62ck145 = 0.9 time = 730
.meas tran vdout1_62ck145 FIND v(dout1_62) AT=730.025n

* CHECK dout1_63 Vdout1_63ck145 = 0.9 time = 730
.meas tran vdout1_63ck145 FIND v(dout1_63) AT=730.025n

* CHECK dout1_64 Vdout1_64ck145 = 0.9 time = 730
.meas tran vdout1_64ck145 FIND v(dout1_64) AT=730.025n

* CHECK dout1_65 Vdout1_65ck145 = 0 time = 730
.meas tran vdout1_65ck145 FIND v(dout1_65) AT=730.025n

* CHECK dout1_66 Vdout1_66ck145 = 0.9 time = 730
.meas tran vdout1_66ck145 FIND v(dout1_66) AT=730.025n

* CHECK dout1_67 Vdout1_67ck145 = 0 time = 730
.meas tran vdout1_67ck145 FIND v(dout1_67) AT=730.025n

* CHECK dout1_68 Vdout1_68ck145 = 0.9 time = 730
.meas tran vdout1_68ck145 FIND v(dout1_68) AT=730.025n

* CHECK dout1_69 Vdout1_69ck145 = 0.9 time = 730
.meas tran vdout1_69ck145 FIND v(dout1_69) AT=730.025n

* CHECK dout1_70 Vdout1_70ck145 = 0 time = 730
.meas tran vdout1_70ck145 FIND v(dout1_70) AT=730.025n

* CHECK dout1_71 Vdout1_71ck145 = 0.9 time = 730
.meas tran vdout1_71ck145 FIND v(dout1_71) AT=730.025n

* CHECK dout1_0 Vdout1_0ck146 = 0.9 time = 735
.meas tran vdout1_0ck146 FIND v(dout1_0) AT=735.025n

* CHECK dout1_1 Vdout1_1ck146 = 0 time = 735
.meas tran vdout1_1ck146 FIND v(dout1_1) AT=735.025n

* CHECK dout1_2 Vdout1_2ck146 = 0.9 time = 735
.meas tran vdout1_2ck146 FIND v(dout1_2) AT=735.025n

* CHECK dout1_3 Vdout1_3ck146 = 0.9 time = 735
.meas tran vdout1_3ck146 FIND v(dout1_3) AT=735.025n

* CHECK dout1_4 Vdout1_4ck146 = 0.9 time = 735
.meas tran vdout1_4ck146 FIND v(dout1_4) AT=735.025n

* CHECK dout1_5 Vdout1_5ck146 = 0.9 time = 735
.meas tran vdout1_5ck146 FIND v(dout1_5) AT=735.025n

* CHECK dout1_6 Vdout1_6ck146 = 0.9 time = 735
.meas tran vdout1_6ck146 FIND v(dout1_6) AT=735.025n

* CHECK dout1_7 Vdout1_7ck146 = 0 time = 735
.meas tran vdout1_7ck146 FIND v(dout1_7) AT=735.025n

* CHECK dout1_8 Vdout1_8ck146 = 0.9 time = 735
.meas tran vdout1_8ck146 FIND v(dout1_8) AT=735.025n

* CHECK dout1_9 Vdout1_9ck146 = 0.9 time = 735
.meas tran vdout1_9ck146 FIND v(dout1_9) AT=735.025n

* CHECK dout1_10 Vdout1_10ck146 = 0.9 time = 735
.meas tran vdout1_10ck146 FIND v(dout1_10) AT=735.025n

* CHECK dout1_11 Vdout1_11ck146 = 0 time = 735
.meas tran vdout1_11ck146 FIND v(dout1_11) AT=735.025n

* CHECK dout1_12 Vdout1_12ck146 = 0.9 time = 735
.meas tran vdout1_12ck146 FIND v(dout1_12) AT=735.025n

* CHECK dout1_13 Vdout1_13ck146 = 0.9 time = 735
.meas tran vdout1_13ck146 FIND v(dout1_13) AT=735.025n

* CHECK dout1_14 Vdout1_14ck146 = 0 time = 735
.meas tran vdout1_14ck146 FIND v(dout1_14) AT=735.025n

* CHECK dout1_15 Vdout1_15ck146 = 0 time = 735
.meas tran vdout1_15ck146 FIND v(dout1_15) AT=735.025n

* CHECK dout1_16 Vdout1_16ck146 = 0 time = 735
.meas tran vdout1_16ck146 FIND v(dout1_16) AT=735.025n

* CHECK dout1_17 Vdout1_17ck146 = 0.9 time = 735
.meas tran vdout1_17ck146 FIND v(dout1_17) AT=735.025n

* CHECK dout1_18 Vdout1_18ck146 = 0.9 time = 735
.meas tran vdout1_18ck146 FIND v(dout1_18) AT=735.025n

* CHECK dout1_19 Vdout1_19ck146 = 0 time = 735
.meas tran vdout1_19ck146 FIND v(dout1_19) AT=735.025n

* CHECK dout1_20 Vdout1_20ck146 = 0 time = 735
.meas tran vdout1_20ck146 FIND v(dout1_20) AT=735.025n

* CHECK dout1_21 Vdout1_21ck146 = 0.9 time = 735
.meas tran vdout1_21ck146 FIND v(dout1_21) AT=735.025n

* CHECK dout1_22 Vdout1_22ck146 = 0.9 time = 735
.meas tran vdout1_22ck146 FIND v(dout1_22) AT=735.025n

* CHECK dout1_23 Vdout1_23ck146 = 0.9 time = 735
.meas tran vdout1_23ck146 FIND v(dout1_23) AT=735.025n

* CHECK dout1_24 Vdout1_24ck146 = 0 time = 735
.meas tran vdout1_24ck146 FIND v(dout1_24) AT=735.025n

* CHECK dout1_25 Vdout1_25ck146 = 0 time = 735
.meas tran vdout1_25ck146 FIND v(dout1_25) AT=735.025n

* CHECK dout1_26 Vdout1_26ck146 = 0 time = 735
.meas tran vdout1_26ck146 FIND v(dout1_26) AT=735.025n

* CHECK dout1_27 Vdout1_27ck146 = 0 time = 735
.meas tran vdout1_27ck146 FIND v(dout1_27) AT=735.025n

* CHECK dout1_28 Vdout1_28ck146 = 0 time = 735
.meas tran vdout1_28ck146 FIND v(dout1_28) AT=735.025n

* CHECK dout1_29 Vdout1_29ck146 = 0.9 time = 735
.meas tran vdout1_29ck146 FIND v(dout1_29) AT=735.025n

* CHECK dout1_30 Vdout1_30ck146 = 0.9 time = 735
.meas tran vdout1_30ck146 FIND v(dout1_30) AT=735.025n

* CHECK dout1_31 Vdout1_31ck146 = 0 time = 735
.meas tran vdout1_31ck146 FIND v(dout1_31) AT=735.025n

* CHECK dout1_32 Vdout1_32ck146 = 0 time = 735
.meas tran vdout1_32ck146 FIND v(dout1_32) AT=735.025n

* CHECK dout1_33 Vdout1_33ck146 = 0 time = 735
.meas tran vdout1_33ck146 FIND v(dout1_33) AT=735.025n

* CHECK dout1_34 Vdout1_34ck146 = 0 time = 735
.meas tran vdout1_34ck146 FIND v(dout1_34) AT=735.025n

* CHECK dout1_35 Vdout1_35ck146 = 0.9 time = 735
.meas tran vdout1_35ck146 FIND v(dout1_35) AT=735.025n

* CHECK dout1_36 Vdout1_36ck146 = 0 time = 735
.meas tran vdout1_36ck146 FIND v(dout1_36) AT=735.025n

* CHECK dout1_37 Vdout1_37ck146 = 0 time = 735
.meas tran vdout1_37ck146 FIND v(dout1_37) AT=735.025n

* CHECK dout1_38 Vdout1_38ck146 = 0.9 time = 735
.meas tran vdout1_38ck146 FIND v(dout1_38) AT=735.025n

* CHECK dout1_39 Vdout1_39ck146 = 0.9 time = 735
.meas tran vdout1_39ck146 FIND v(dout1_39) AT=735.025n

* CHECK dout1_40 Vdout1_40ck146 = 0.9 time = 735
.meas tran vdout1_40ck146 FIND v(dout1_40) AT=735.025n

* CHECK dout1_41 Vdout1_41ck146 = 0 time = 735
.meas tran vdout1_41ck146 FIND v(dout1_41) AT=735.025n

* CHECK dout1_42 Vdout1_42ck146 = 0.9 time = 735
.meas tran vdout1_42ck146 FIND v(dout1_42) AT=735.025n

* CHECK dout1_43 Vdout1_43ck146 = 0 time = 735
.meas tran vdout1_43ck146 FIND v(dout1_43) AT=735.025n

* CHECK dout1_44 Vdout1_44ck146 = 0 time = 735
.meas tran vdout1_44ck146 FIND v(dout1_44) AT=735.025n

* CHECK dout1_45 Vdout1_45ck146 = 0 time = 735
.meas tran vdout1_45ck146 FIND v(dout1_45) AT=735.025n

* CHECK dout1_46 Vdout1_46ck146 = 0.9 time = 735
.meas tran vdout1_46ck146 FIND v(dout1_46) AT=735.025n

* CHECK dout1_47 Vdout1_47ck146 = 0.9 time = 735
.meas tran vdout1_47ck146 FIND v(dout1_47) AT=735.025n

* CHECK dout1_48 Vdout1_48ck146 = 0 time = 735
.meas tran vdout1_48ck146 FIND v(dout1_48) AT=735.025n

* CHECK dout1_49 Vdout1_49ck146 = 0 time = 735
.meas tran vdout1_49ck146 FIND v(dout1_49) AT=735.025n

* CHECK dout1_50 Vdout1_50ck146 = 0.9 time = 735
.meas tran vdout1_50ck146 FIND v(dout1_50) AT=735.025n

* CHECK dout1_51 Vdout1_51ck146 = 0 time = 735
.meas tran vdout1_51ck146 FIND v(dout1_51) AT=735.025n

* CHECK dout1_52 Vdout1_52ck146 = 0.9 time = 735
.meas tran vdout1_52ck146 FIND v(dout1_52) AT=735.025n

* CHECK dout1_53 Vdout1_53ck146 = 0 time = 735
.meas tran vdout1_53ck146 FIND v(dout1_53) AT=735.025n

* CHECK dout1_54 Vdout1_54ck146 = 0.9 time = 735
.meas tran vdout1_54ck146 FIND v(dout1_54) AT=735.025n

* CHECK dout1_55 Vdout1_55ck146 = 0 time = 735
.meas tran vdout1_55ck146 FIND v(dout1_55) AT=735.025n

* CHECK dout1_56 Vdout1_56ck146 = 0.9 time = 735
.meas tran vdout1_56ck146 FIND v(dout1_56) AT=735.025n

* CHECK dout1_57 Vdout1_57ck146 = 0 time = 735
.meas tran vdout1_57ck146 FIND v(dout1_57) AT=735.025n

* CHECK dout1_58 Vdout1_58ck146 = 0.9 time = 735
.meas tran vdout1_58ck146 FIND v(dout1_58) AT=735.025n

* CHECK dout1_59 Vdout1_59ck146 = 0 time = 735
.meas tran vdout1_59ck146 FIND v(dout1_59) AT=735.025n

* CHECK dout1_60 Vdout1_60ck146 = 0 time = 735
.meas tran vdout1_60ck146 FIND v(dout1_60) AT=735.025n

* CHECK dout1_61 Vdout1_61ck146 = 0.9 time = 735
.meas tran vdout1_61ck146 FIND v(dout1_61) AT=735.025n

* CHECK dout1_62 Vdout1_62ck146 = 0 time = 735
.meas tran vdout1_62ck146 FIND v(dout1_62) AT=735.025n

* CHECK dout1_63 Vdout1_63ck146 = 0 time = 735
.meas tran vdout1_63ck146 FIND v(dout1_63) AT=735.025n

* CHECK dout1_64 Vdout1_64ck146 = 0 time = 735
.meas tran vdout1_64ck146 FIND v(dout1_64) AT=735.025n

* CHECK dout1_65 Vdout1_65ck146 = 0 time = 735
.meas tran vdout1_65ck146 FIND v(dout1_65) AT=735.025n

* CHECK dout1_66 Vdout1_66ck146 = 0 time = 735
.meas tran vdout1_66ck146 FIND v(dout1_66) AT=735.025n

* CHECK dout1_67 Vdout1_67ck146 = 0.9 time = 735
.meas tran vdout1_67ck146 FIND v(dout1_67) AT=735.025n

* CHECK dout1_68 Vdout1_68ck146 = 0 time = 735
.meas tran vdout1_68ck146 FIND v(dout1_68) AT=735.025n

* CHECK dout1_69 Vdout1_69ck146 = 0 time = 735
.meas tran vdout1_69ck146 FIND v(dout1_69) AT=735.025n

* CHECK dout1_70 Vdout1_70ck146 = 0.9 time = 735
.meas tran vdout1_70ck146 FIND v(dout1_70) AT=735.025n

* CHECK dout1_71 Vdout1_71ck146 = 0.9 time = 735
.meas tran vdout1_71ck146 FIND v(dout1_71) AT=735.025n

* CHECK dout1_0 Vdout1_0ck147 = 0 time = 740
.meas tran vdout1_0ck147 FIND v(dout1_0) AT=740.025n

* CHECK dout1_1 Vdout1_1ck147 = 0.9 time = 740
.meas tran vdout1_1ck147 FIND v(dout1_1) AT=740.025n

* CHECK dout1_2 Vdout1_2ck147 = 0.9 time = 740
.meas tran vdout1_2ck147 FIND v(dout1_2) AT=740.025n

* CHECK dout1_3 Vdout1_3ck147 = 0 time = 740
.meas tran vdout1_3ck147 FIND v(dout1_3) AT=740.025n

* CHECK dout1_4 Vdout1_4ck147 = 0.9 time = 740
.meas tran vdout1_4ck147 FIND v(dout1_4) AT=740.025n

* CHECK dout1_5 Vdout1_5ck147 = 0.9 time = 740
.meas tran vdout1_5ck147 FIND v(dout1_5) AT=740.025n

* CHECK dout1_6 Vdout1_6ck147 = 0 time = 740
.meas tran vdout1_6ck147 FIND v(dout1_6) AT=740.025n

* CHECK dout1_7 Vdout1_7ck147 = 0.9 time = 740
.meas tran vdout1_7ck147 FIND v(dout1_7) AT=740.025n

* CHECK dout1_8 Vdout1_8ck147 = 0.9 time = 740
.meas tran vdout1_8ck147 FIND v(dout1_8) AT=740.025n

* CHECK dout1_9 Vdout1_9ck147 = 0 time = 740
.meas tran vdout1_9ck147 FIND v(dout1_9) AT=740.025n

* CHECK dout1_10 Vdout1_10ck147 = 0 time = 740
.meas tran vdout1_10ck147 FIND v(dout1_10) AT=740.025n

* CHECK dout1_11 Vdout1_11ck147 = 0 time = 740
.meas tran vdout1_11ck147 FIND v(dout1_11) AT=740.025n

* CHECK dout1_12 Vdout1_12ck147 = 0.9 time = 740
.meas tran vdout1_12ck147 FIND v(dout1_12) AT=740.025n

* CHECK dout1_13 Vdout1_13ck147 = 0.9 time = 740
.meas tran vdout1_13ck147 FIND v(dout1_13) AT=740.025n

* CHECK dout1_14 Vdout1_14ck147 = 0 time = 740
.meas tran vdout1_14ck147 FIND v(dout1_14) AT=740.025n

* CHECK dout1_15 Vdout1_15ck147 = 0.9 time = 740
.meas tran vdout1_15ck147 FIND v(dout1_15) AT=740.025n

* CHECK dout1_16 Vdout1_16ck147 = 0.9 time = 740
.meas tran vdout1_16ck147 FIND v(dout1_16) AT=740.025n

* CHECK dout1_17 Vdout1_17ck147 = 0.9 time = 740
.meas tran vdout1_17ck147 FIND v(dout1_17) AT=740.025n

* CHECK dout1_18 Vdout1_18ck147 = 0.9 time = 740
.meas tran vdout1_18ck147 FIND v(dout1_18) AT=740.025n

* CHECK dout1_19 Vdout1_19ck147 = 0 time = 740
.meas tran vdout1_19ck147 FIND v(dout1_19) AT=740.025n

* CHECK dout1_20 Vdout1_20ck147 = 0.9 time = 740
.meas tran vdout1_20ck147 FIND v(dout1_20) AT=740.025n

* CHECK dout1_21 Vdout1_21ck147 = 0.9 time = 740
.meas tran vdout1_21ck147 FIND v(dout1_21) AT=740.025n

* CHECK dout1_22 Vdout1_22ck147 = 0 time = 740
.meas tran vdout1_22ck147 FIND v(dout1_22) AT=740.025n

* CHECK dout1_23 Vdout1_23ck147 = 0.9 time = 740
.meas tran vdout1_23ck147 FIND v(dout1_23) AT=740.025n

* CHECK dout1_24 Vdout1_24ck147 = 0 time = 740
.meas tran vdout1_24ck147 FIND v(dout1_24) AT=740.025n

* CHECK dout1_25 Vdout1_25ck147 = 0.9 time = 740
.meas tran vdout1_25ck147 FIND v(dout1_25) AT=740.025n

* CHECK dout1_26 Vdout1_26ck147 = 0 time = 740
.meas tran vdout1_26ck147 FIND v(dout1_26) AT=740.025n

* CHECK dout1_27 Vdout1_27ck147 = 0.9 time = 740
.meas tran vdout1_27ck147 FIND v(dout1_27) AT=740.025n

* CHECK dout1_28 Vdout1_28ck147 = 0 time = 740
.meas tran vdout1_28ck147 FIND v(dout1_28) AT=740.025n

* CHECK dout1_29 Vdout1_29ck147 = 0 time = 740
.meas tran vdout1_29ck147 FIND v(dout1_29) AT=740.025n

* CHECK dout1_30 Vdout1_30ck147 = 0 time = 740
.meas tran vdout1_30ck147 FIND v(dout1_30) AT=740.025n

* CHECK dout1_31 Vdout1_31ck147 = 0 time = 740
.meas tran vdout1_31ck147 FIND v(dout1_31) AT=740.025n

* CHECK dout1_32 Vdout1_32ck147 = 0.9 time = 740
.meas tran vdout1_32ck147 FIND v(dout1_32) AT=740.025n

* CHECK dout1_33 Vdout1_33ck147 = 0.9 time = 740
.meas tran vdout1_33ck147 FIND v(dout1_33) AT=740.025n

* CHECK dout1_34 Vdout1_34ck147 = 0.9 time = 740
.meas tran vdout1_34ck147 FIND v(dout1_34) AT=740.025n

* CHECK dout1_35 Vdout1_35ck147 = 0 time = 740
.meas tran vdout1_35ck147 FIND v(dout1_35) AT=740.025n

* CHECK dout1_36 Vdout1_36ck147 = 0 time = 740
.meas tran vdout1_36ck147 FIND v(dout1_36) AT=740.025n

* CHECK dout1_37 Vdout1_37ck147 = 0.9 time = 740
.meas tran vdout1_37ck147 FIND v(dout1_37) AT=740.025n

* CHECK dout1_38 Vdout1_38ck147 = 0 time = 740
.meas tran vdout1_38ck147 FIND v(dout1_38) AT=740.025n

* CHECK dout1_39 Vdout1_39ck147 = 0 time = 740
.meas tran vdout1_39ck147 FIND v(dout1_39) AT=740.025n

* CHECK dout1_40 Vdout1_40ck147 = 0 time = 740
.meas tran vdout1_40ck147 FIND v(dout1_40) AT=740.025n

* CHECK dout1_41 Vdout1_41ck147 = 0.9 time = 740
.meas tran vdout1_41ck147 FIND v(dout1_41) AT=740.025n

* CHECK dout1_42 Vdout1_42ck147 = 0.9 time = 740
.meas tran vdout1_42ck147 FIND v(dout1_42) AT=740.025n

* CHECK dout1_43 Vdout1_43ck147 = 0.9 time = 740
.meas tran vdout1_43ck147 FIND v(dout1_43) AT=740.025n

* CHECK dout1_44 Vdout1_44ck147 = 0 time = 740
.meas tran vdout1_44ck147 FIND v(dout1_44) AT=740.025n

* CHECK dout1_45 Vdout1_45ck147 = 0 time = 740
.meas tran vdout1_45ck147 FIND v(dout1_45) AT=740.025n

* CHECK dout1_46 Vdout1_46ck147 = 0.9 time = 740
.meas tran vdout1_46ck147 FIND v(dout1_46) AT=740.025n

* CHECK dout1_47 Vdout1_47ck147 = 0.9 time = 740
.meas tran vdout1_47ck147 FIND v(dout1_47) AT=740.025n

* CHECK dout1_48 Vdout1_48ck147 = 0 time = 740
.meas tran vdout1_48ck147 FIND v(dout1_48) AT=740.025n

* CHECK dout1_49 Vdout1_49ck147 = 0.9 time = 740
.meas tran vdout1_49ck147 FIND v(dout1_49) AT=740.025n

* CHECK dout1_50 Vdout1_50ck147 = 0.9 time = 740
.meas tran vdout1_50ck147 FIND v(dout1_50) AT=740.025n

* CHECK dout1_51 Vdout1_51ck147 = 0.9 time = 740
.meas tran vdout1_51ck147 FIND v(dout1_51) AT=740.025n

* CHECK dout1_52 Vdout1_52ck147 = 0.9 time = 740
.meas tran vdout1_52ck147 FIND v(dout1_52) AT=740.025n

* CHECK dout1_53 Vdout1_53ck147 = 0 time = 740
.meas tran vdout1_53ck147 FIND v(dout1_53) AT=740.025n

* CHECK dout1_54 Vdout1_54ck147 = 0 time = 740
.meas tran vdout1_54ck147 FIND v(dout1_54) AT=740.025n

* CHECK dout1_55 Vdout1_55ck147 = 0 time = 740
.meas tran vdout1_55ck147 FIND v(dout1_55) AT=740.025n

* CHECK dout1_56 Vdout1_56ck147 = 0 time = 740
.meas tran vdout1_56ck147 FIND v(dout1_56) AT=740.025n

* CHECK dout1_57 Vdout1_57ck147 = 0.9 time = 740
.meas tran vdout1_57ck147 FIND v(dout1_57) AT=740.025n

* CHECK dout1_58 Vdout1_58ck147 = 0 time = 740
.meas tran vdout1_58ck147 FIND v(dout1_58) AT=740.025n

* CHECK dout1_59 Vdout1_59ck147 = 0.9 time = 740
.meas tran vdout1_59ck147 FIND v(dout1_59) AT=740.025n

* CHECK dout1_60 Vdout1_60ck147 = 0.9 time = 740
.meas tran vdout1_60ck147 FIND v(dout1_60) AT=740.025n

* CHECK dout1_61 Vdout1_61ck147 = 0.9 time = 740
.meas tran vdout1_61ck147 FIND v(dout1_61) AT=740.025n

* CHECK dout1_62 Vdout1_62ck147 = 0.9 time = 740
.meas tran vdout1_62ck147 FIND v(dout1_62) AT=740.025n

* CHECK dout1_63 Vdout1_63ck147 = 0.9 time = 740
.meas tran vdout1_63ck147 FIND v(dout1_63) AT=740.025n

* CHECK dout1_64 Vdout1_64ck147 = 0.9 time = 740
.meas tran vdout1_64ck147 FIND v(dout1_64) AT=740.025n

* CHECK dout1_65 Vdout1_65ck147 = 0 time = 740
.meas tran vdout1_65ck147 FIND v(dout1_65) AT=740.025n

* CHECK dout1_66 Vdout1_66ck147 = 0.9 time = 740
.meas tran vdout1_66ck147 FIND v(dout1_66) AT=740.025n

* CHECK dout1_67 Vdout1_67ck147 = 0 time = 740
.meas tran vdout1_67ck147 FIND v(dout1_67) AT=740.025n

* CHECK dout1_68 Vdout1_68ck147 = 0.9 time = 740
.meas tran vdout1_68ck147 FIND v(dout1_68) AT=740.025n

* CHECK dout1_69 Vdout1_69ck147 = 0.9 time = 740
.meas tran vdout1_69ck147 FIND v(dout1_69) AT=740.025n

* CHECK dout1_70 Vdout1_70ck147 = 0 time = 740
.meas tran vdout1_70ck147 FIND v(dout1_70) AT=740.025n

* CHECK dout1_71 Vdout1_71ck147 = 0.9 time = 740
.meas tran vdout1_71ck147 FIND v(dout1_71) AT=740.025n

* CHECK dout1_0 Vdout1_0ck150 = 0 time = 755
.meas tran vdout1_0ck150 FIND v(dout1_0) AT=755.025n

* CHECK dout1_1 Vdout1_1ck150 = 0.9 time = 755
.meas tran vdout1_1ck150 FIND v(dout1_1) AT=755.025n

* CHECK dout1_2 Vdout1_2ck150 = 0.9 time = 755
.meas tran vdout1_2ck150 FIND v(dout1_2) AT=755.025n

* CHECK dout1_3 Vdout1_3ck150 = 0 time = 755
.meas tran vdout1_3ck150 FIND v(dout1_3) AT=755.025n

* CHECK dout1_4 Vdout1_4ck150 = 0.9 time = 755
.meas tran vdout1_4ck150 FIND v(dout1_4) AT=755.025n

* CHECK dout1_5 Vdout1_5ck150 = 0.9 time = 755
.meas tran vdout1_5ck150 FIND v(dout1_5) AT=755.025n

* CHECK dout1_6 Vdout1_6ck150 = 0 time = 755
.meas tran vdout1_6ck150 FIND v(dout1_6) AT=755.025n

* CHECK dout1_7 Vdout1_7ck150 = 0.9 time = 755
.meas tran vdout1_7ck150 FIND v(dout1_7) AT=755.025n

* CHECK dout1_8 Vdout1_8ck150 = 0.9 time = 755
.meas tran vdout1_8ck150 FIND v(dout1_8) AT=755.025n

* CHECK dout1_9 Vdout1_9ck150 = 0 time = 755
.meas tran vdout1_9ck150 FIND v(dout1_9) AT=755.025n

* CHECK dout1_10 Vdout1_10ck150 = 0 time = 755
.meas tran vdout1_10ck150 FIND v(dout1_10) AT=755.025n

* CHECK dout1_11 Vdout1_11ck150 = 0 time = 755
.meas tran vdout1_11ck150 FIND v(dout1_11) AT=755.025n

* CHECK dout1_12 Vdout1_12ck150 = 0.9 time = 755
.meas tran vdout1_12ck150 FIND v(dout1_12) AT=755.025n

* CHECK dout1_13 Vdout1_13ck150 = 0.9 time = 755
.meas tran vdout1_13ck150 FIND v(dout1_13) AT=755.025n

* CHECK dout1_14 Vdout1_14ck150 = 0 time = 755
.meas tran vdout1_14ck150 FIND v(dout1_14) AT=755.025n

* CHECK dout1_15 Vdout1_15ck150 = 0.9 time = 755
.meas tran vdout1_15ck150 FIND v(dout1_15) AT=755.025n

* CHECK dout1_16 Vdout1_16ck150 = 0.9 time = 755
.meas tran vdout1_16ck150 FIND v(dout1_16) AT=755.025n

* CHECK dout1_17 Vdout1_17ck150 = 0.9 time = 755
.meas tran vdout1_17ck150 FIND v(dout1_17) AT=755.025n

* CHECK dout1_18 Vdout1_18ck150 = 0.9 time = 755
.meas tran vdout1_18ck150 FIND v(dout1_18) AT=755.025n

* CHECK dout1_19 Vdout1_19ck150 = 0 time = 755
.meas tran vdout1_19ck150 FIND v(dout1_19) AT=755.025n

* CHECK dout1_20 Vdout1_20ck150 = 0.9 time = 755
.meas tran vdout1_20ck150 FIND v(dout1_20) AT=755.025n

* CHECK dout1_21 Vdout1_21ck150 = 0.9 time = 755
.meas tran vdout1_21ck150 FIND v(dout1_21) AT=755.025n

* CHECK dout1_22 Vdout1_22ck150 = 0 time = 755
.meas tran vdout1_22ck150 FIND v(dout1_22) AT=755.025n

* CHECK dout1_23 Vdout1_23ck150 = 0.9 time = 755
.meas tran vdout1_23ck150 FIND v(dout1_23) AT=755.025n

* CHECK dout1_24 Vdout1_24ck150 = 0 time = 755
.meas tran vdout1_24ck150 FIND v(dout1_24) AT=755.025n

* CHECK dout1_25 Vdout1_25ck150 = 0.9 time = 755
.meas tran vdout1_25ck150 FIND v(dout1_25) AT=755.025n

* CHECK dout1_26 Vdout1_26ck150 = 0 time = 755
.meas tran vdout1_26ck150 FIND v(dout1_26) AT=755.025n

* CHECK dout1_27 Vdout1_27ck150 = 0.9 time = 755
.meas tran vdout1_27ck150 FIND v(dout1_27) AT=755.025n

* CHECK dout1_28 Vdout1_28ck150 = 0 time = 755
.meas tran vdout1_28ck150 FIND v(dout1_28) AT=755.025n

* CHECK dout1_29 Vdout1_29ck150 = 0 time = 755
.meas tran vdout1_29ck150 FIND v(dout1_29) AT=755.025n

* CHECK dout1_30 Vdout1_30ck150 = 0 time = 755
.meas tran vdout1_30ck150 FIND v(dout1_30) AT=755.025n

* CHECK dout1_31 Vdout1_31ck150 = 0 time = 755
.meas tran vdout1_31ck150 FIND v(dout1_31) AT=755.025n

* CHECK dout1_32 Vdout1_32ck150 = 0.9 time = 755
.meas tran vdout1_32ck150 FIND v(dout1_32) AT=755.025n

* CHECK dout1_33 Vdout1_33ck150 = 0.9 time = 755
.meas tran vdout1_33ck150 FIND v(dout1_33) AT=755.025n

* CHECK dout1_34 Vdout1_34ck150 = 0.9 time = 755
.meas tran vdout1_34ck150 FIND v(dout1_34) AT=755.025n

* CHECK dout1_35 Vdout1_35ck150 = 0 time = 755
.meas tran vdout1_35ck150 FIND v(dout1_35) AT=755.025n

* CHECK dout1_36 Vdout1_36ck150 = 0 time = 755
.meas tran vdout1_36ck150 FIND v(dout1_36) AT=755.025n

* CHECK dout1_37 Vdout1_37ck150 = 0.9 time = 755
.meas tran vdout1_37ck150 FIND v(dout1_37) AT=755.025n

* CHECK dout1_38 Vdout1_38ck150 = 0 time = 755
.meas tran vdout1_38ck150 FIND v(dout1_38) AT=755.025n

* CHECK dout1_39 Vdout1_39ck150 = 0 time = 755
.meas tran vdout1_39ck150 FIND v(dout1_39) AT=755.025n

* CHECK dout1_40 Vdout1_40ck150 = 0 time = 755
.meas tran vdout1_40ck150 FIND v(dout1_40) AT=755.025n

* CHECK dout1_41 Vdout1_41ck150 = 0.9 time = 755
.meas tran vdout1_41ck150 FIND v(dout1_41) AT=755.025n

* CHECK dout1_42 Vdout1_42ck150 = 0.9 time = 755
.meas tran vdout1_42ck150 FIND v(dout1_42) AT=755.025n

* CHECK dout1_43 Vdout1_43ck150 = 0.9 time = 755
.meas tran vdout1_43ck150 FIND v(dout1_43) AT=755.025n

* CHECK dout1_44 Vdout1_44ck150 = 0 time = 755
.meas tran vdout1_44ck150 FIND v(dout1_44) AT=755.025n

* CHECK dout1_45 Vdout1_45ck150 = 0 time = 755
.meas tran vdout1_45ck150 FIND v(dout1_45) AT=755.025n

* CHECK dout1_46 Vdout1_46ck150 = 0.9 time = 755
.meas tran vdout1_46ck150 FIND v(dout1_46) AT=755.025n

* CHECK dout1_47 Vdout1_47ck150 = 0.9 time = 755
.meas tran vdout1_47ck150 FIND v(dout1_47) AT=755.025n

* CHECK dout1_48 Vdout1_48ck150 = 0 time = 755
.meas tran vdout1_48ck150 FIND v(dout1_48) AT=755.025n

* CHECK dout1_49 Vdout1_49ck150 = 0.9 time = 755
.meas tran vdout1_49ck150 FIND v(dout1_49) AT=755.025n

* CHECK dout1_50 Vdout1_50ck150 = 0.9 time = 755
.meas tran vdout1_50ck150 FIND v(dout1_50) AT=755.025n

* CHECK dout1_51 Vdout1_51ck150 = 0.9 time = 755
.meas tran vdout1_51ck150 FIND v(dout1_51) AT=755.025n

* CHECK dout1_52 Vdout1_52ck150 = 0.9 time = 755
.meas tran vdout1_52ck150 FIND v(dout1_52) AT=755.025n

* CHECK dout1_53 Vdout1_53ck150 = 0 time = 755
.meas tran vdout1_53ck150 FIND v(dout1_53) AT=755.025n

* CHECK dout1_54 Vdout1_54ck150 = 0 time = 755
.meas tran vdout1_54ck150 FIND v(dout1_54) AT=755.025n

* CHECK dout1_55 Vdout1_55ck150 = 0 time = 755
.meas tran vdout1_55ck150 FIND v(dout1_55) AT=755.025n

* CHECK dout1_56 Vdout1_56ck150 = 0 time = 755
.meas tran vdout1_56ck150 FIND v(dout1_56) AT=755.025n

* CHECK dout1_57 Vdout1_57ck150 = 0.9 time = 755
.meas tran vdout1_57ck150 FIND v(dout1_57) AT=755.025n

* CHECK dout1_58 Vdout1_58ck150 = 0 time = 755
.meas tran vdout1_58ck150 FIND v(dout1_58) AT=755.025n

* CHECK dout1_59 Vdout1_59ck150 = 0.9 time = 755
.meas tran vdout1_59ck150 FIND v(dout1_59) AT=755.025n

* CHECK dout1_60 Vdout1_60ck150 = 0.9 time = 755
.meas tran vdout1_60ck150 FIND v(dout1_60) AT=755.025n

* CHECK dout1_61 Vdout1_61ck150 = 0.9 time = 755
.meas tran vdout1_61ck150 FIND v(dout1_61) AT=755.025n

* CHECK dout1_62 Vdout1_62ck150 = 0.9 time = 755
.meas tran vdout1_62ck150 FIND v(dout1_62) AT=755.025n

* CHECK dout1_63 Vdout1_63ck150 = 0.9 time = 755
.meas tran vdout1_63ck150 FIND v(dout1_63) AT=755.025n

* CHECK dout1_64 Vdout1_64ck150 = 0.9 time = 755
.meas tran vdout1_64ck150 FIND v(dout1_64) AT=755.025n

* CHECK dout1_65 Vdout1_65ck150 = 0 time = 755
.meas tran vdout1_65ck150 FIND v(dout1_65) AT=755.025n

* CHECK dout1_66 Vdout1_66ck150 = 0.9 time = 755
.meas tran vdout1_66ck150 FIND v(dout1_66) AT=755.025n

* CHECK dout1_67 Vdout1_67ck150 = 0 time = 755
.meas tran vdout1_67ck150 FIND v(dout1_67) AT=755.025n

* CHECK dout1_68 Vdout1_68ck150 = 0.9 time = 755
.meas tran vdout1_68ck150 FIND v(dout1_68) AT=755.025n

* CHECK dout1_69 Vdout1_69ck150 = 0.9 time = 755
.meas tran vdout1_69ck150 FIND v(dout1_69) AT=755.025n

* CHECK dout1_70 Vdout1_70ck150 = 0 time = 755
.meas tran vdout1_70ck150 FIND v(dout1_70) AT=755.025n

* CHECK dout1_71 Vdout1_71ck150 = 0.9 time = 755
.meas tran vdout1_71ck150 FIND v(dout1_71) AT=755.025n

* CHECK dout1_0 Vdout1_0ck155 = 0 time = 780
.meas tran vdout1_0ck155 FIND v(dout1_0) AT=780.025n

* CHECK dout1_1 Vdout1_1ck155 = 0.9 time = 780
.meas tran vdout1_1ck155 FIND v(dout1_1) AT=780.025n

* CHECK dout1_2 Vdout1_2ck155 = 0.9 time = 780
.meas tran vdout1_2ck155 FIND v(dout1_2) AT=780.025n

* CHECK dout1_3 Vdout1_3ck155 = 0.9 time = 780
.meas tran vdout1_3ck155 FIND v(dout1_3) AT=780.025n

* CHECK dout1_4 Vdout1_4ck155 = 0.9 time = 780
.meas tran vdout1_4ck155 FIND v(dout1_4) AT=780.025n

* CHECK dout1_5 Vdout1_5ck155 = 0 time = 780
.meas tran vdout1_5ck155 FIND v(dout1_5) AT=780.025n

* CHECK dout1_6 Vdout1_6ck155 = 0 time = 780
.meas tran vdout1_6ck155 FIND v(dout1_6) AT=780.025n

* CHECK dout1_7 Vdout1_7ck155 = 0 time = 780
.meas tran vdout1_7ck155 FIND v(dout1_7) AT=780.025n

* CHECK dout1_8 Vdout1_8ck155 = 0.9 time = 780
.meas tran vdout1_8ck155 FIND v(dout1_8) AT=780.025n

* CHECK dout1_9 Vdout1_9ck155 = 0 time = 780
.meas tran vdout1_9ck155 FIND v(dout1_9) AT=780.025n

* CHECK dout1_10 Vdout1_10ck155 = 0 time = 780
.meas tran vdout1_10ck155 FIND v(dout1_10) AT=780.025n

* CHECK dout1_11 Vdout1_11ck155 = 0 time = 780
.meas tran vdout1_11ck155 FIND v(dout1_11) AT=780.025n

* CHECK dout1_12 Vdout1_12ck155 = 0.9 time = 780
.meas tran vdout1_12ck155 FIND v(dout1_12) AT=780.025n

* CHECK dout1_13 Vdout1_13ck155 = 0 time = 780
.meas tran vdout1_13ck155 FIND v(dout1_13) AT=780.025n

* CHECK dout1_14 Vdout1_14ck155 = 0 time = 780
.meas tran vdout1_14ck155 FIND v(dout1_14) AT=780.025n

* CHECK dout1_15 Vdout1_15ck155 = 0 time = 780
.meas tran vdout1_15ck155 FIND v(dout1_15) AT=780.025n

* CHECK dout1_16 Vdout1_16ck155 = 0 time = 780
.meas tran vdout1_16ck155 FIND v(dout1_16) AT=780.025n

* CHECK dout1_17 Vdout1_17ck155 = 0 time = 780
.meas tran vdout1_17ck155 FIND v(dout1_17) AT=780.025n

* CHECK dout1_18 Vdout1_18ck155 = 0 time = 780
.meas tran vdout1_18ck155 FIND v(dout1_18) AT=780.025n

* CHECK dout1_19 Vdout1_19ck155 = 0.9 time = 780
.meas tran vdout1_19ck155 FIND v(dout1_19) AT=780.025n

* CHECK dout1_20 Vdout1_20ck155 = 0 time = 780
.meas tran vdout1_20ck155 FIND v(dout1_20) AT=780.025n

* CHECK dout1_21 Vdout1_21ck155 = 0 time = 780
.meas tran vdout1_21ck155 FIND v(dout1_21) AT=780.025n

* CHECK dout1_22 Vdout1_22ck155 = 0 time = 780
.meas tran vdout1_22ck155 FIND v(dout1_22) AT=780.025n

* CHECK dout1_23 Vdout1_23ck155 = 0 time = 780
.meas tran vdout1_23ck155 FIND v(dout1_23) AT=780.025n

* CHECK dout1_24 Vdout1_24ck155 = 0.9 time = 780
.meas tran vdout1_24ck155 FIND v(dout1_24) AT=780.025n

* CHECK dout1_25 Vdout1_25ck155 = 0.9 time = 780
.meas tran vdout1_25ck155 FIND v(dout1_25) AT=780.025n

* CHECK dout1_26 Vdout1_26ck155 = 0 time = 780
.meas tran vdout1_26ck155 FIND v(dout1_26) AT=780.025n

* CHECK dout1_27 Vdout1_27ck155 = 0 time = 780
.meas tran vdout1_27ck155 FIND v(dout1_27) AT=780.025n

* CHECK dout1_28 Vdout1_28ck155 = 0.9 time = 780
.meas tran vdout1_28ck155 FIND v(dout1_28) AT=780.025n

* CHECK dout1_29 Vdout1_29ck155 = 0 time = 780
.meas tran vdout1_29ck155 FIND v(dout1_29) AT=780.025n

* CHECK dout1_30 Vdout1_30ck155 = 0 time = 780
.meas tran vdout1_30ck155 FIND v(dout1_30) AT=780.025n

* CHECK dout1_31 Vdout1_31ck155 = 0.9 time = 780
.meas tran vdout1_31ck155 FIND v(dout1_31) AT=780.025n

* CHECK dout1_32 Vdout1_32ck155 = 0.9 time = 780
.meas tran vdout1_32ck155 FIND v(dout1_32) AT=780.025n

* CHECK dout1_33 Vdout1_33ck155 = 0.9 time = 780
.meas tran vdout1_33ck155 FIND v(dout1_33) AT=780.025n

* CHECK dout1_34 Vdout1_34ck155 = 0.9 time = 780
.meas tran vdout1_34ck155 FIND v(dout1_34) AT=780.025n

* CHECK dout1_35 Vdout1_35ck155 = 0 time = 780
.meas tran vdout1_35ck155 FIND v(dout1_35) AT=780.025n

* CHECK dout1_36 Vdout1_36ck155 = 0.9 time = 780
.meas tran vdout1_36ck155 FIND v(dout1_36) AT=780.025n

* CHECK dout1_37 Vdout1_37ck155 = 0 time = 780
.meas tran vdout1_37ck155 FIND v(dout1_37) AT=780.025n

* CHECK dout1_38 Vdout1_38ck155 = 0 time = 780
.meas tran vdout1_38ck155 FIND v(dout1_38) AT=780.025n

* CHECK dout1_39 Vdout1_39ck155 = 0.9 time = 780
.meas tran vdout1_39ck155 FIND v(dout1_39) AT=780.025n

* CHECK dout1_40 Vdout1_40ck155 = 0 time = 780
.meas tran vdout1_40ck155 FIND v(dout1_40) AT=780.025n

* CHECK dout1_41 Vdout1_41ck155 = 0 time = 780
.meas tran vdout1_41ck155 FIND v(dout1_41) AT=780.025n

* CHECK dout1_42 Vdout1_42ck155 = 0.9 time = 780
.meas tran vdout1_42ck155 FIND v(dout1_42) AT=780.025n

* CHECK dout1_43 Vdout1_43ck155 = 0 time = 780
.meas tran vdout1_43ck155 FIND v(dout1_43) AT=780.025n

* CHECK dout1_44 Vdout1_44ck155 = 0 time = 780
.meas tran vdout1_44ck155 FIND v(dout1_44) AT=780.025n

* CHECK dout1_45 Vdout1_45ck155 = 0 time = 780
.meas tran vdout1_45ck155 FIND v(dout1_45) AT=780.025n

* CHECK dout1_46 Vdout1_46ck155 = 0.9 time = 780
.meas tran vdout1_46ck155 FIND v(dout1_46) AT=780.025n

* CHECK dout1_47 Vdout1_47ck155 = 0.9 time = 780
.meas tran vdout1_47ck155 FIND v(dout1_47) AT=780.025n

* CHECK dout1_48 Vdout1_48ck155 = 0 time = 780
.meas tran vdout1_48ck155 FIND v(dout1_48) AT=780.025n

* CHECK dout1_49 Vdout1_49ck155 = 0.9 time = 780
.meas tran vdout1_49ck155 FIND v(dout1_49) AT=780.025n

* CHECK dout1_50 Vdout1_50ck155 = 0 time = 780
.meas tran vdout1_50ck155 FIND v(dout1_50) AT=780.025n

* CHECK dout1_51 Vdout1_51ck155 = 0 time = 780
.meas tran vdout1_51ck155 FIND v(dout1_51) AT=780.025n

* CHECK dout1_52 Vdout1_52ck155 = 0 time = 780
.meas tran vdout1_52ck155 FIND v(dout1_52) AT=780.025n

* CHECK dout1_53 Vdout1_53ck155 = 0 time = 780
.meas tran vdout1_53ck155 FIND v(dout1_53) AT=780.025n

* CHECK dout1_54 Vdout1_54ck155 = 0.9 time = 780
.meas tran vdout1_54ck155 FIND v(dout1_54) AT=780.025n

* CHECK dout1_55 Vdout1_55ck155 = 0.9 time = 780
.meas tran vdout1_55ck155 FIND v(dout1_55) AT=780.025n

* CHECK dout1_56 Vdout1_56ck155 = 0 time = 780
.meas tran vdout1_56ck155 FIND v(dout1_56) AT=780.025n

* CHECK dout1_57 Vdout1_57ck155 = 0 time = 780
.meas tran vdout1_57ck155 FIND v(dout1_57) AT=780.025n

* CHECK dout1_58 Vdout1_58ck155 = 0.9 time = 780
.meas tran vdout1_58ck155 FIND v(dout1_58) AT=780.025n

* CHECK dout1_59 Vdout1_59ck155 = 0.9 time = 780
.meas tran vdout1_59ck155 FIND v(dout1_59) AT=780.025n

* CHECK dout1_60 Vdout1_60ck155 = 0 time = 780
.meas tran vdout1_60ck155 FIND v(dout1_60) AT=780.025n

* CHECK dout1_61 Vdout1_61ck155 = 0 time = 780
.meas tran vdout1_61ck155 FIND v(dout1_61) AT=780.025n

* CHECK dout1_62 Vdout1_62ck155 = 0.9 time = 780
.meas tran vdout1_62ck155 FIND v(dout1_62) AT=780.025n

* CHECK dout1_63 Vdout1_63ck155 = 0 time = 780
.meas tran vdout1_63ck155 FIND v(dout1_63) AT=780.025n

* CHECK dout1_64 Vdout1_64ck155 = 0 time = 780
.meas tran vdout1_64ck155 FIND v(dout1_64) AT=780.025n

* CHECK dout1_65 Vdout1_65ck155 = 0.9 time = 780
.meas tran vdout1_65ck155 FIND v(dout1_65) AT=780.025n

* CHECK dout1_66 Vdout1_66ck155 = 0.9 time = 780
.meas tran vdout1_66ck155 FIND v(dout1_66) AT=780.025n

* CHECK dout1_67 Vdout1_67ck155 = 0.9 time = 780
.meas tran vdout1_67ck155 FIND v(dout1_67) AT=780.025n

* CHECK dout1_68 Vdout1_68ck155 = 0 time = 780
.meas tran vdout1_68ck155 FIND v(dout1_68) AT=780.025n

* CHECK dout1_69 Vdout1_69ck155 = 0.9 time = 780
.meas tran vdout1_69ck155 FIND v(dout1_69) AT=780.025n

* CHECK dout1_70 Vdout1_70ck155 = 0.9 time = 780
.meas tran vdout1_70ck155 FIND v(dout1_70) AT=780.025n

* CHECK dout1_71 Vdout1_71ck155 = 0 time = 780
.meas tran vdout1_71ck155 FIND v(dout1_71) AT=780.025n

* CHECK dout1_0 Vdout1_0ck156 = 0 time = 785
.meas tran vdout1_0ck156 FIND v(dout1_0) AT=785.025n

* CHECK dout1_1 Vdout1_1ck156 = 0.9 time = 785
.meas tran vdout1_1ck156 FIND v(dout1_1) AT=785.025n

* CHECK dout1_2 Vdout1_2ck156 = 0.9 time = 785
.meas tran vdout1_2ck156 FIND v(dout1_2) AT=785.025n

* CHECK dout1_3 Vdout1_3ck156 = 0.9 time = 785
.meas tran vdout1_3ck156 FIND v(dout1_3) AT=785.025n

* CHECK dout1_4 Vdout1_4ck156 = 0.9 time = 785
.meas tran vdout1_4ck156 FIND v(dout1_4) AT=785.025n

* CHECK dout1_5 Vdout1_5ck156 = 0 time = 785
.meas tran vdout1_5ck156 FIND v(dout1_5) AT=785.025n

* CHECK dout1_6 Vdout1_6ck156 = 0 time = 785
.meas tran vdout1_6ck156 FIND v(dout1_6) AT=785.025n

* CHECK dout1_7 Vdout1_7ck156 = 0 time = 785
.meas tran vdout1_7ck156 FIND v(dout1_7) AT=785.025n

* CHECK dout1_8 Vdout1_8ck156 = 0.9 time = 785
.meas tran vdout1_8ck156 FIND v(dout1_8) AT=785.025n

* CHECK dout1_9 Vdout1_9ck156 = 0 time = 785
.meas tran vdout1_9ck156 FIND v(dout1_9) AT=785.025n

* CHECK dout1_10 Vdout1_10ck156 = 0 time = 785
.meas tran vdout1_10ck156 FIND v(dout1_10) AT=785.025n

* CHECK dout1_11 Vdout1_11ck156 = 0 time = 785
.meas tran vdout1_11ck156 FIND v(dout1_11) AT=785.025n

* CHECK dout1_12 Vdout1_12ck156 = 0.9 time = 785
.meas tran vdout1_12ck156 FIND v(dout1_12) AT=785.025n

* CHECK dout1_13 Vdout1_13ck156 = 0 time = 785
.meas tran vdout1_13ck156 FIND v(dout1_13) AT=785.025n

* CHECK dout1_14 Vdout1_14ck156 = 0 time = 785
.meas tran vdout1_14ck156 FIND v(dout1_14) AT=785.025n

* CHECK dout1_15 Vdout1_15ck156 = 0 time = 785
.meas tran vdout1_15ck156 FIND v(dout1_15) AT=785.025n

* CHECK dout1_16 Vdout1_16ck156 = 0 time = 785
.meas tran vdout1_16ck156 FIND v(dout1_16) AT=785.025n

* CHECK dout1_17 Vdout1_17ck156 = 0 time = 785
.meas tran vdout1_17ck156 FIND v(dout1_17) AT=785.025n

* CHECK dout1_18 Vdout1_18ck156 = 0 time = 785
.meas tran vdout1_18ck156 FIND v(dout1_18) AT=785.025n

* CHECK dout1_19 Vdout1_19ck156 = 0.9 time = 785
.meas tran vdout1_19ck156 FIND v(dout1_19) AT=785.025n

* CHECK dout1_20 Vdout1_20ck156 = 0 time = 785
.meas tran vdout1_20ck156 FIND v(dout1_20) AT=785.025n

* CHECK dout1_21 Vdout1_21ck156 = 0 time = 785
.meas tran vdout1_21ck156 FIND v(dout1_21) AT=785.025n

* CHECK dout1_22 Vdout1_22ck156 = 0 time = 785
.meas tran vdout1_22ck156 FIND v(dout1_22) AT=785.025n

* CHECK dout1_23 Vdout1_23ck156 = 0 time = 785
.meas tran vdout1_23ck156 FIND v(dout1_23) AT=785.025n

* CHECK dout1_24 Vdout1_24ck156 = 0.9 time = 785
.meas tran vdout1_24ck156 FIND v(dout1_24) AT=785.025n

* CHECK dout1_25 Vdout1_25ck156 = 0.9 time = 785
.meas tran vdout1_25ck156 FIND v(dout1_25) AT=785.025n

* CHECK dout1_26 Vdout1_26ck156 = 0 time = 785
.meas tran vdout1_26ck156 FIND v(dout1_26) AT=785.025n

* CHECK dout1_27 Vdout1_27ck156 = 0 time = 785
.meas tran vdout1_27ck156 FIND v(dout1_27) AT=785.025n

* CHECK dout1_28 Vdout1_28ck156 = 0.9 time = 785
.meas tran vdout1_28ck156 FIND v(dout1_28) AT=785.025n

* CHECK dout1_29 Vdout1_29ck156 = 0 time = 785
.meas tran vdout1_29ck156 FIND v(dout1_29) AT=785.025n

* CHECK dout1_30 Vdout1_30ck156 = 0 time = 785
.meas tran vdout1_30ck156 FIND v(dout1_30) AT=785.025n

* CHECK dout1_31 Vdout1_31ck156 = 0.9 time = 785
.meas tran vdout1_31ck156 FIND v(dout1_31) AT=785.025n

* CHECK dout1_32 Vdout1_32ck156 = 0.9 time = 785
.meas tran vdout1_32ck156 FIND v(dout1_32) AT=785.025n

* CHECK dout1_33 Vdout1_33ck156 = 0.9 time = 785
.meas tran vdout1_33ck156 FIND v(dout1_33) AT=785.025n

* CHECK dout1_34 Vdout1_34ck156 = 0.9 time = 785
.meas tran vdout1_34ck156 FIND v(dout1_34) AT=785.025n

* CHECK dout1_35 Vdout1_35ck156 = 0 time = 785
.meas tran vdout1_35ck156 FIND v(dout1_35) AT=785.025n

* CHECK dout1_36 Vdout1_36ck156 = 0.9 time = 785
.meas tran vdout1_36ck156 FIND v(dout1_36) AT=785.025n

* CHECK dout1_37 Vdout1_37ck156 = 0 time = 785
.meas tran vdout1_37ck156 FIND v(dout1_37) AT=785.025n

* CHECK dout1_38 Vdout1_38ck156 = 0 time = 785
.meas tran vdout1_38ck156 FIND v(dout1_38) AT=785.025n

* CHECK dout1_39 Vdout1_39ck156 = 0.9 time = 785
.meas tran vdout1_39ck156 FIND v(dout1_39) AT=785.025n

* CHECK dout1_40 Vdout1_40ck156 = 0 time = 785
.meas tran vdout1_40ck156 FIND v(dout1_40) AT=785.025n

* CHECK dout1_41 Vdout1_41ck156 = 0 time = 785
.meas tran vdout1_41ck156 FIND v(dout1_41) AT=785.025n

* CHECK dout1_42 Vdout1_42ck156 = 0.9 time = 785
.meas tran vdout1_42ck156 FIND v(dout1_42) AT=785.025n

* CHECK dout1_43 Vdout1_43ck156 = 0 time = 785
.meas tran vdout1_43ck156 FIND v(dout1_43) AT=785.025n

* CHECK dout1_44 Vdout1_44ck156 = 0 time = 785
.meas tran vdout1_44ck156 FIND v(dout1_44) AT=785.025n

* CHECK dout1_45 Vdout1_45ck156 = 0 time = 785
.meas tran vdout1_45ck156 FIND v(dout1_45) AT=785.025n

* CHECK dout1_46 Vdout1_46ck156 = 0.9 time = 785
.meas tran vdout1_46ck156 FIND v(dout1_46) AT=785.025n

* CHECK dout1_47 Vdout1_47ck156 = 0.9 time = 785
.meas tran vdout1_47ck156 FIND v(dout1_47) AT=785.025n

* CHECK dout1_48 Vdout1_48ck156 = 0 time = 785
.meas tran vdout1_48ck156 FIND v(dout1_48) AT=785.025n

* CHECK dout1_49 Vdout1_49ck156 = 0.9 time = 785
.meas tran vdout1_49ck156 FIND v(dout1_49) AT=785.025n

* CHECK dout1_50 Vdout1_50ck156 = 0 time = 785
.meas tran vdout1_50ck156 FIND v(dout1_50) AT=785.025n

* CHECK dout1_51 Vdout1_51ck156 = 0 time = 785
.meas tran vdout1_51ck156 FIND v(dout1_51) AT=785.025n

* CHECK dout1_52 Vdout1_52ck156 = 0 time = 785
.meas tran vdout1_52ck156 FIND v(dout1_52) AT=785.025n

* CHECK dout1_53 Vdout1_53ck156 = 0 time = 785
.meas tran vdout1_53ck156 FIND v(dout1_53) AT=785.025n

* CHECK dout1_54 Vdout1_54ck156 = 0.9 time = 785
.meas tran vdout1_54ck156 FIND v(dout1_54) AT=785.025n

* CHECK dout1_55 Vdout1_55ck156 = 0.9 time = 785
.meas tran vdout1_55ck156 FIND v(dout1_55) AT=785.025n

* CHECK dout1_56 Vdout1_56ck156 = 0 time = 785
.meas tran vdout1_56ck156 FIND v(dout1_56) AT=785.025n

* CHECK dout1_57 Vdout1_57ck156 = 0 time = 785
.meas tran vdout1_57ck156 FIND v(dout1_57) AT=785.025n

* CHECK dout1_58 Vdout1_58ck156 = 0.9 time = 785
.meas tran vdout1_58ck156 FIND v(dout1_58) AT=785.025n

* CHECK dout1_59 Vdout1_59ck156 = 0.9 time = 785
.meas tran vdout1_59ck156 FIND v(dout1_59) AT=785.025n

* CHECK dout1_60 Vdout1_60ck156 = 0 time = 785
.meas tran vdout1_60ck156 FIND v(dout1_60) AT=785.025n

* CHECK dout1_61 Vdout1_61ck156 = 0 time = 785
.meas tran vdout1_61ck156 FIND v(dout1_61) AT=785.025n

* CHECK dout1_62 Vdout1_62ck156 = 0.9 time = 785
.meas tran vdout1_62ck156 FIND v(dout1_62) AT=785.025n

* CHECK dout1_63 Vdout1_63ck156 = 0 time = 785
.meas tran vdout1_63ck156 FIND v(dout1_63) AT=785.025n

* CHECK dout1_64 Vdout1_64ck156 = 0 time = 785
.meas tran vdout1_64ck156 FIND v(dout1_64) AT=785.025n

* CHECK dout1_65 Vdout1_65ck156 = 0.9 time = 785
.meas tran vdout1_65ck156 FIND v(dout1_65) AT=785.025n

* CHECK dout1_66 Vdout1_66ck156 = 0.9 time = 785
.meas tran vdout1_66ck156 FIND v(dout1_66) AT=785.025n

* CHECK dout1_67 Vdout1_67ck156 = 0.9 time = 785
.meas tran vdout1_67ck156 FIND v(dout1_67) AT=785.025n

* CHECK dout1_68 Vdout1_68ck156 = 0 time = 785
.meas tran vdout1_68ck156 FIND v(dout1_68) AT=785.025n

* CHECK dout1_69 Vdout1_69ck156 = 0.9 time = 785
.meas tran vdout1_69ck156 FIND v(dout1_69) AT=785.025n

* CHECK dout1_70 Vdout1_70ck156 = 0.9 time = 785
.meas tran vdout1_70ck156 FIND v(dout1_70) AT=785.025n

* CHECK dout1_71 Vdout1_71ck156 = 0 time = 785
.meas tran vdout1_71ck156 FIND v(dout1_71) AT=785.025n

* CHECK dout1_0 Vdout1_0ck158 = 0 time = 795
.meas tran vdout1_0ck158 FIND v(dout1_0) AT=795.025n

* CHECK dout1_1 Vdout1_1ck158 = 0.9 time = 795
.meas tran vdout1_1ck158 FIND v(dout1_1) AT=795.025n

* CHECK dout1_2 Vdout1_2ck158 = 0.9 time = 795
.meas tran vdout1_2ck158 FIND v(dout1_2) AT=795.025n

* CHECK dout1_3 Vdout1_3ck158 = 0.9 time = 795
.meas tran vdout1_3ck158 FIND v(dout1_3) AT=795.025n

* CHECK dout1_4 Vdout1_4ck158 = 0.9 time = 795
.meas tran vdout1_4ck158 FIND v(dout1_4) AT=795.025n

* CHECK dout1_5 Vdout1_5ck158 = 0 time = 795
.meas tran vdout1_5ck158 FIND v(dout1_5) AT=795.025n

* CHECK dout1_6 Vdout1_6ck158 = 0 time = 795
.meas tran vdout1_6ck158 FIND v(dout1_6) AT=795.025n

* CHECK dout1_7 Vdout1_7ck158 = 0 time = 795
.meas tran vdout1_7ck158 FIND v(dout1_7) AT=795.025n

* CHECK dout1_8 Vdout1_8ck158 = 0.9 time = 795
.meas tran vdout1_8ck158 FIND v(dout1_8) AT=795.025n

* CHECK dout1_9 Vdout1_9ck158 = 0 time = 795
.meas tran vdout1_9ck158 FIND v(dout1_9) AT=795.025n

* CHECK dout1_10 Vdout1_10ck158 = 0 time = 795
.meas tran vdout1_10ck158 FIND v(dout1_10) AT=795.025n

* CHECK dout1_11 Vdout1_11ck158 = 0 time = 795
.meas tran vdout1_11ck158 FIND v(dout1_11) AT=795.025n

* CHECK dout1_12 Vdout1_12ck158 = 0.9 time = 795
.meas tran vdout1_12ck158 FIND v(dout1_12) AT=795.025n

* CHECK dout1_13 Vdout1_13ck158 = 0 time = 795
.meas tran vdout1_13ck158 FIND v(dout1_13) AT=795.025n

* CHECK dout1_14 Vdout1_14ck158 = 0 time = 795
.meas tran vdout1_14ck158 FIND v(dout1_14) AT=795.025n

* CHECK dout1_15 Vdout1_15ck158 = 0 time = 795
.meas tran vdout1_15ck158 FIND v(dout1_15) AT=795.025n

* CHECK dout1_16 Vdout1_16ck158 = 0 time = 795
.meas tran vdout1_16ck158 FIND v(dout1_16) AT=795.025n

* CHECK dout1_17 Vdout1_17ck158 = 0 time = 795
.meas tran vdout1_17ck158 FIND v(dout1_17) AT=795.025n

* CHECK dout1_18 Vdout1_18ck158 = 0 time = 795
.meas tran vdout1_18ck158 FIND v(dout1_18) AT=795.025n

* CHECK dout1_19 Vdout1_19ck158 = 0.9 time = 795
.meas tran vdout1_19ck158 FIND v(dout1_19) AT=795.025n

* CHECK dout1_20 Vdout1_20ck158 = 0 time = 795
.meas tran vdout1_20ck158 FIND v(dout1_20) AT=795.025n

* CHECK dout1_21 Vdout1_21ck158 = 0 time = 795
.meas tran vdout1_21ck158 FIND v(dout1_21) AT=795.025n

* CHECK dout1_22 Vdout1_22ck158 = 0 time = 795
.meas tran vdout1_22ck158 FIND v(dout1_22) AT=795.025n

* CHECK dout1_23 Vdout1_23ck158 = 0 time = 795
.meas tran vdout1_23ck158 FIND v(dout1_23) AT=795.025n

* CHECK dout1_24 Vdout1_24ck158 = 0.9 time = 795
.meas tran vdout1_24ck158 FIND v(dout1_24) AT=795.025n

* CHECK dout1_25 Vdout1_25ck158 = 0.9 time = 795
.meas tran vdout1_25ck158 FIND v(dout1_25) AT=795.025n

* CHECK dout1_26 Vdout1_26ck158 = 0 time = 795
.meas tran vdout1_26ck158 FIND v(dout1_26) AT=795.025n

* CHECK dout1_27 Vdout1_27ck158 = 0 time = 795
.meas tran vdout1_27ck158 FIND v(dout1_27) AT=795.025n

* CHECK dout1_28 Vdout1_28ck158 = 0.9 time = 795
.meas tran vdout1_28ck158 FIND v(dout1_28) AT=795.025n

* CHECK dout1_29 Vdout1_29ck158 = 0 time = 795
.meas tran vdout1_29ck158 FIND v(dout1_29) AT=795.025n

* CHECK dout1_30 Vdout1_30ck158 = 0 time = 795
.meas tran vdout1_30ck158 FIND v(dout1_30) AT=795.025n

* CHECK dout1_31 Vdout1_31ck158 = 0.9 time = 795
.meas tran vdout1_31ck158 FIND v(dout1_31) AT=795.025n

* CHECK dout1_32 Vdout1_32ck158 = 0.9 time = 795
.meas tran vdout1_32ck158 FIND v(dout1_32) AT=795.025n

* CHECK dout1_33 Vdout1_33ck158 = 0.9 time = 795
.meas tran vdout1_33ck158 FIND v(dout1_33) AT=795.025n

* CHECK dout1_34 Vdout1_34ck158 = 0.9 time = 795
.meas tran vdout1_34ck158 FIND v(dout1_34) AT=795.025n

* CHECK dout1_35 Vdout1_35ck158 = 0 time = 795
.meas tran vdout1_35ck158 FIND v(dout1_35) AT=795.025n

* CHECK dout1_36 Vdout1_36ck158 = 0.9 time = 795
.meas tran vdout1_36ck158 FIND v(dout1_36) AT=795.025n

* CHECK dout1_37 Vdout1_37ck158 = 0 time = 795
.meas tran vdout1_37ck158 FIND v(dout1_37) AT=795.025n

* CHECK dout1_38 Vdout1_38ck158 = 0 time = 795
.meas tran vdout1_38ck158 FIND v(dout1_38) AT=795.025n

* CHECK dout1_39 Vdout1_39ck158 = 0.9 time = 795
.meas tran vdout1_39ck158 FIND v(dout1_39) AT=795.025n

* CHECK dout1_40 Vdout1_40ck158 = 0 time = 795
.meas tran vdout1_40ck158 FIND v(dout1_40) AT=795.025n

* CHECK dout1_41 Vdout1_41ck158 = 0 time = 795
.meas tran vdout1_41ck158 FIND v(dout1_41) AT=795.025n

* CHECK dout1_42 Vdout1_42ck158 = 0.9 time = 795
.meas tran vdout1_42ck158 FIND v(dout1_42) AT=795.025n

* CHECK dout1_43 Vdout1_43ck158 = 0 time = 795
.meas tran vdout1_43ck158 FIND v(dout1_43) AT=795.025n

* CHECK dout1_44 Vdout1_44ck158 = 0 time = 795
.meas tran vdout1_44ck158 FIND v(dout1_44) AT=795.025n

* CHECK dout1_45 Vdout1_45ck158 = 0 time = 795
.meas tran vdout1_45ck158 FIND v(dout1_45) AT=795.025n

* CHECK dout1_46 Vdout1_46ck158 = 0.9 time = 795
.meas tran vdout1_46ck158 FIND v(dout1_46) AT=795.025n

* CHECK dout1_47 Vdout1_47ck158 = 0.9 time = 795
.meas tran vdout1_47ck158 FIND v(dout1_47) AT=795.025n

* CHECK dout1_48 Vdout1_48ck158 = 0 time = 795
.meas tran vdout1_48ck158 FIND v(dout1_48) AT=795.025n

* CHECK dout1_49 Vdout1_49ck158 = 0.9 time = 795
.meas tran vdout1_49ck158 FIND v(dout1_49) AT=795.025n

* CHECK dout1_50 Vdout1_50ck158 = 0 time = 795
.meas tran vdout1_50ck158 FIND v(dout1_50) AT=795.025n

* CHECK dout1_51 Vdout1_51ck158 = 0 time = 795
.meas tran vdout1_51ck158 FIND v(dout1_51) AT=795.025n

* CHECK dout1_52 Vdout1_52ck158 = 0 time = 795
.meas tran vdout1_52ck158 FIND v(dout1_52) AT=795.025n

* CHECK dout1_53 Vdout1_53ck158 = 0 time = 795
.meas tran vdout1_53ck158 FIND v(dout1_53) AT=795.025n

* CHECK dout1_54 Vdout1_54ck158 = 0.9 time = 795
.meas tran vdout1_54ck158 FIND v(dout1_54) AT=795.025n

* CHECK dout1_55 Vdout1_55ck158 = 0.9 time = 795
.meas tran vdout1_55ck158 FIND v(dout1_55) AT=795.025n

* CHECK dout1_56 Vdout1_56ck158 = 0 time = 795
.meas tran vdout1_56ck158 FIND v(dout1_56) AT=795.025n

* CHECK dout1_57 Vdout1_57ck158 = 0 time = 795
.meas tran vdout1_57ck158 FIND v(dout1_57) AT=795.025n

* CHECK dout1_58 Vdout1_58ck158 = 0.9 time = 795
.meas tran vdout1_58ck158 FIND v(dout1_58) AT=795.025n

* CHECK dout1_59 Vdout1_59ck158 = 0.9 time = 795
.meas tran vdout1_59ck158 FIND v(dout1_59) AT=795.025n

* CHECK dout1_60 Vdout1_60ck158 = 0 time = 795
.meas tran vdout1_60ck158 FIND v(dout1_60) AT=795.025n

* CHECK dout1_61 Vdout1_61ck158 = 0 time = 795
.meas tran vdout1_61ck158 FIND v(dout1_61) AT=795.025n

* CHECK dout1_62 Vdout1_62ck158 = 0.9 time = 795
.meas tran vdout1_62ck158 FIND v(dout1_62) AT=795.025n

* CHECK dout1_63 Vdout1_63ck158 = 0 time = 795
.meas tran vdout1_63ck158 FIND v(dout1_63) AT=795.025n

* CHECK dout1_64 Vdout1_64ck158 = 0 time = 795
.meas tran vdout1_64ck158 FIND v(dout1_64) AT=795.025n

* CHECK dout1_65 Vdout1_65ck158 = 0.9 time = 795
.meas tran vdout1_65ck158 FIND v(dout1_65) AT=795.025n

* CHECK dout1_66 Vdout1_66ck158 = 0.9 time = 795
.meas tran vdout1_66ck158 FIND v(dout1_66) AT=795.025n

* CHECK dout1_67 Vdout1_67ck158 = 0.9 time = 795
.meas tran vdout1_67ck158 FIND v(dout1_67) AT=795.025n

* CHECK dout1_68 Vdout1_68ck158 = 0 time = 795
.meas tran vdout1_68ck158 FIND v(dout1_68) AT=795.025n

* CHECK dout1_69 Vdout1_69ck158 = 0.9 time = 795
.meas tran vdout1_69ck158 FIND v(dout1_69) AT=795.025n

* CHECK dout1_70 Vdout1_70ck158 = 0.9 time = 795
.meas tran vdout1_70ck158 FIND v(dout1_70) AT=795.025n

* CHECK dout1_71 Vdout1_71ck158 = 0 time = 795
.meas tran vdout1_71ck158 FIND v(dout1_71) AT=795.025n

* CHECK dout1_0 Vdout1_0ck163 = 0 time = 820
.meas tran vdout1_0ck163 FIND v(dout1_0) AT=820.025n

* CHECK dout1_1 Vdout1_1ck163 = 0.9 time = 820
.meas tran vdout1_1ck163 FIND v(dout1_1) AT=820.025n

* CHECK dout1_2 Vdout1_2ck163 = 0.9 time = 820
.meas tran vdout1_2ck163 FIND v(dout1_2) AT=820.025n

* CHECK dout1_3 Vdout1_3ck163 = 0.9 time = 820
.meas tran vdout1_3ck163 FIND v(dout1_3) AT=820.025n

* CHECK dout1_4 Vdout1_4ck163 = 0.9 time = 820
.meas tran vdout1_4ck163 FIND v(dout1_4) AT=820.025n

* CHECK dout1_5 Vdout1_5ck163 = 0 time = 820
.meas tran vdout1_5ck163 FIND v(dout1_5) AT=820.025n

* CHECK dout1_6 Vdout1_6ck163 = 0 time = 820
.meas tran vdout1_6ck163 FIND v(dout1_6) AT=820.025n

* CHECK dout1_7 Vdout1_7ck163 = 0 time = 820
.meas tran vdout1_7ck163 FIND v(dout1_7) AT=820.025n

* CHECK dout1_8 Vdout1_8ck163 = 0.9 time = 820
.meas tran vdout1_8ck163 FIND v(dout1_8) AT=820.025n

* CHECK dout1_9 Vdout1_9ck163 = 0 time = 820
.meas tran vdout1_9ck163 FIND v(dout1_9) AT=820.025n

* CHECK dout1_10 Vdout1_10ck163 = 0 time = 820
.meas tran vdout1_10ck163 FIND v(dout1_10) AT=820.025n

* CHECK dout1_11 Vdout1_11ck163 = 0 time = 820
.meas tran vdout1_11ck163 FIND v(dout1_11) AT=820.025n

* CHECK dout1_12 Vdout1_12ck163 = 0.9 time = 820
.meas tran vdout1_12ck163 FIND v(dout1_12) AT=820.025n

* CHECK dout1_13 Vdout1_13ck163 = 0 time = 820
.meas tran vdout1_13ck163 FIND v(dout1_13) AT=820.025n

* CHECK dout1_14 Vdout1_14ck163 = 0 time = 820
.meas tran vdout1_14ck163 FIND v(dout1_14) AT=820.025n

* CHECK dout1_15 Vdout1_15ck163 = 0 time = 820
.meas tran vdout1_15ck163 FIND v(dout1_15) AT=820.025n

* CHECK dout1_16 Vdout1_16ck163 = 0 time = 820
.meas tran vdout1_16ck163 FIND v(dout1_16) AT=820.025n

* CHECK dout1_17 Vdout1_17ck163 = 0 time = 820
.meas tran vdout1_17ck163 FIND v(dout1_17) AT=820.025n

* CHECK dout1_18 Vdout1_18ck163 = 0 time = 820
.meas tran vdout1_18ck163 FIND v(dout1_18) AT=820.025n

* CHECK dout1_19 Vdout1_19ck163 = 0.9 time = 820
.meas tran vdout1_19ck163 FIND v(dout1_19) AT=820.025n

* CHECK dout1_20 Vdout1_20ck163 = 0 time = 820
.meas tran vdout1_20ck163 FIND v(dout1_20) AT=820.025n

* CHECK dout1_21 Vdout1_21ck163 = 0 time = 820
.meas tran vdout1_21ck163 FIND v(dout1_21) AT=820.025n

* CHECK dout1_22 Vdout1_22ck163 = 0 time = 820
.meas tran vdout1_22ck163 FIND v(dout1_22) AT=820.025n

* CHECK dout1_23 Vdout1_23ck163 = 0 time = 820
.meas tran vdout1_23ck163 FIND v(dout1_23) AT=820.025n

* CHECK dout1_24 Vdout1_24ck163 = 0.9 time = 820
.meas tran vdout1_24ck163 FIND v(dout1_24) AT=820.025n

* CHECK dout1_25 Vdout1_25ck163 = 0.9 time = 820
.meas tran vdout1_25ck163 FIND v(dout1_25) AT=820.025n

* CHECK dout1_26 Vdout1_26ck163 = 0 time = 820
.meas tran vdout1_26ck163 FIND v(dout1_26) AT=820.025n

* CHECK dout1_27 Vdout1_27ck163 = 0 time = 820
.meas tran vdout1_27ck163 FIND v(dout1_27) AT=820.025n

* CHECK dout1_28 Vdout1_28ck163 = 0.9 time = 820
.meas tran vdout1_28ck163 FIND v(dout1_28) AT=820.025n

* CHECK dout1_29 Vdout1_29ck163 = 0 time = 820
.meas tran vdout1_29ck163 FIND v(dout1_29) AT=820.025n

* CHECK dout1_30 Vdout1_30ck163 = 0 time = 820
.meas tran vdout1_30ck163 FIND v(dout1_30) AT=820.025n

* CHECK dout1_31 Vdout1_31ck163 = 0.9 time = 820
.meas tran vdout1_31ck163 FIND v(dout1_31) AT=820.025n

* CHECK dout1_32 Vdout1_32ck163 = 0.9 time = 820
.meas tran vdout1_32ck163 FIND v(dout1_32) AT=820.025n

* CHECK dout1_33 Vdout1_33ck163 = 0.9 time = 820
.meas tran vdout1_33ck163 FIND v(dout1_33) AT=820.025n

* CHECK dout1_34 Vdout1_34ck163 = 0.9 time = 820
.meas tran vdout1_34ck163 FIND v(dout1_34) AT=820.025n

* CHECK dout1_35 Vdout1_35ck163 = 0 time = 820
.meas tran vdout1_35ck163 FIND v(dout1_35) AT=820.025n

* CHECK dout1_36 Vdout1_36ck163 = 0.9 time = 820
.meas tran vdout1_36ck163 FIND v(dout1_36) AT=820.025n

* CHECK dout1_37 Vdout1_37ck163 = 0 time = 820
.meas tran vdout1_37ck163 FIND v(dout1_37) AT=820.025n

* CHECK dout1_38 Vdout1_38ck163 = 0 time = 820
.meas tran vdout1_38ck163 FIND v(dout1_38) AT=820.025n

* CHECK dout1_39 Vdout1_39ck163 = 0.9 time = 820
.meas tran vdout1_39ck163 FIND v(dout1_39) AT=820.025n

* CHECK dout1_40 Vdout1_40ck163 = 0 time = 820
.meas tran vdout1_40ck163 FIND v(dout1_40) AT=820.025n

* CHECK dout1_41 Vdout1_41ck163 = 0 time = 820
.meas tran vdout1_41ck163 FIND v(dout1_41) AT=820.025n

* CHECK dout1_42 Vdout1_42ck163 = 0.9 time = 820
.meas tran vdout1_42ck163 FIND v(dout1_42) AT=820.025n

* CHECK dout1_43 Vdout1_43ck163 = 0 time = 820
.meas tran vdout1_43ck163 FIND v(dout1_43) AT=820.025n

* CHECK dout1_44 Vdout1_44ck163 = 0 time = 820
.meas tran vdout1_44ck163 FIND v(dout1_44) AT=820.025n

* CHECK dout1_45 Vdout1_45ck163 = 0 time = 820
.meas tran vdout1_45ck163 FIND v(dout1_45) AT=820.025n

* CHECK dout1_46 Vdout1_46ck163 = 0.9 time = 820
.meas tran vdout1_46ck163 FIND v(dout1_46) AT=820.025n

* CHECK dout1_47 Vdout1_47ck163 = 0.9 time = 820
.meas tran vdout1_47ck163 FIND v(dout1_47) AT=820.025n

* CHECK dout1_48 Vdout1_48ck163 = 0 time = 820
.meas tran vdout1_48ck163 FIND v(dout1_48) AT=820.025n

* CHECK dout1_49 Vdout1_49ck163 = 0.9 time = 820
.meas tran vdout1_49ck163 FIND v(dout1_49) AT=820.025n

* CHECK dout1_50 Vdout1_50ck163 = 0 time = 820
.meas tran vdout1_50ck163 FIND v(dout1_50) AT=820.025n

* CHECK dout1_51 Vdout1_51ck163 = 0 time = 820
.meas tran vdout1_51ck163 FIND v(dout1_51) AT=820.025n

* CHECK dout1_52 Vdout1_52ck163 = 0 time = 820
.meas tran vdout1_52ck163 FIND v(dout1_52) AT=820.025n

* CHECK dout1_53 Vdout1_53ck163 = 0 time = 820
.meas tran vdout1_53ck163 FIND v(dout1_53) AT=820.025n

* CHECK dout1_54 Vdout1_54ck163 = 0.9 time = 820
.meas tran vdout1_54ck163 FIND v(dout1_54) AT=820.025n

* CHECK dout1_55 Vdout1_55ck163 = 0.9 time = 820
.meas tran vdout1_55ck163 FIND v(dout1_55) AT=820.025n

* CHECK dout1_56 Vdout1_56ck163 = 0 time = 820
.meas tran vdout1_56ck163 FIND v(dout1_56) AT=820.025n

* CHECK dout1_57 Vdout1_57ck163 = 0 time = 820
.meas tran vdout1_57ck163 FIND v(dout1_57) AT=820.025n

* CHECK dout1_58 Vdout1_58ck163 = 0.9 time = 820
.meas tran vdout1_58ck163 FIND v(dout1_58) AT=820.025n

* CHECK dout1_59 Vdout1_59ck163 = 0.9 time = 820
.meas tran vdout1_59ck163 FIND v(dout1_59) AT=820.025n

* CHECK dout1_60 Vdout1_60ck163 = 0 time = 820
.meas tran vdout1_60ck163 FIND v(dout1_60) AT=820.025n

* CHECK dout1_61 Vdout1_61ck163 = 0 time = 820
.meas tran vdout1_61ck163 FIND v(dout1_61) AT=820.025n

* CHECK dout1_62 Vdout1_62ck163 = 0.9 time = 820
.meas tran vdout1_62ck163 FIND v(dout1_62) AT=820.025n

* CHECK dout1_63 Vdout1_63ck163 = 0 time = 820
.meas tran vdout1_63ck163 FIND v(dout1_63) AT=820.025n

* CHECK dout1_64 Vdout1_64ck163 = 0 time = 820
.meas tran vdout1_64ck163 FIND v(dout1_64) AT=820.025n

* CHECK dout1_65 Vdout1_65ck163 = 0.9 time = 820
.meas tran vdout1_65ck163 FIND v(dout1_65) AT=820.025n

* CHECK dout1_66 Vdout1_66ck163 = 0.9 time = 820
.meas tran vdout1_66ck163 FIND v(dout1_66) AT=820.025n

* CHECK dout1_67 Vdout1_67ck163 = 0.9 time = 820
.meas tran vdout1_67ck163 FIND v(dout1_67) AT=820.025n

* CHECK dout1_68 Vdout1_68ck163 = 0 time = 820
.meas tran vdout1_68ck163 FIND v(dout1_68) AT=820.025n

* CHECK dout1_69 Vdout1_69ck163 = 0.9 time = 820
.meas tran vdout1_69ck163 FIND v(dout1_69) AT=820.025n

* CHECK dout1_70 Vdout1_70ck163 = 0.9 time = 820
.meas tran vdout1_70ck163 FIND v(dout1_70) AT=820.025n

* CHECK dout1_71 Vdout1_71ck163 = 0 time = 820
.meas tran vdout1_71ck163 FIND v(dout1_71) AT=820.025n

* CHECK dout1_0 Vdout1_0ck164 = 0 time = 825
.meas tran vdout1_0ck164 FIND v(dout1_0) AT=825.025n

* CHECK dout1_1 Vdout1_1ck164 = 0.9 time = 825
.meas tran vdout1_1ck164 FIND v(dout1_1) AT=825.025n

* CHECK dout1_2 Vdout1_2ck164 = 0.9 time = 825
.meas tran vdout1_2ck164 FIND v(dout1_2) AT=825.025n

* CHECK dout1_3 Vdout1_3ck164 = 0.9 time = 825
.meas tran vdout1_3ck164 FIND v(dout1_3) AT=825.025n

* CHECK dout1_4 Vdout1_4ck164 = 0.9 time = 825
.meas tran vdout1_4ck164 FIND v(dout1_4) AT=825.025n

* CHECK dout1_5 Vdout1_5ck164 = 0 time = 825
.meas tran vdout1_5ck164 FIND v(dout1_5) AT=825.025n

* CHECK dout1_6 Vdout1_6ck164 = 0 time = 825
.meas tran vdout1_6ck164 FIND v(dout1_6) AT=825.025n

* CHECK dout1_7 Vdout1_7ck164 = 0 time = 825
.meas tran vdout1_7ck164 FIND v(dout1_7) AT=825.025n

* CHECK dout1_8 Vdout1_8ck164 = 0.9 time = 825
.meas tran vdout1_8ck164 FIND v(dout1_8) AT=825.025n

* CHECK dout1_9 Vdout1_9ck164 = 0 time = 825
.meas tran vdout1_9ck164 FIND v(dout1_9) AT=825.025n

* CHECK dout1_10 Vdout1_10ck164 = 0 time = 825
.meas tran vdout1_10ck164 FIND v(dout1_10) AT=825.025n

* CHECK dout1_11 Vdout1_11ck164 = 0 time = 825
.meas tran vdout1_11ck164 FIND v(dout1_11) AT=825.025n

* CHECK dout1_12 Vdout1_12ck164 = 0.9 time = 825
.meas tran vdout1_12ck164 FIND v(dout1_12) AT=825.025n

* CHECK dout1_13 Vdout1_13ck164 = 0 time = 825
.meas tran vdout1_13ck164 FIND v(dout1_13) AT=825.025n

* CHECK dout1_14 Vdout1_14ck164 = 0 time = 825
.meas tran vdout1_14ck164 FIND v(dout1_14) AT=825.025n

* CHECK dout1_15 Vdout1_15ck164 = 0 time = 825
.meas tran vdout1_15ck164 FIND v(dout1_15) AT=825.025n

* CHECK dout1_16 Vdout1_16ck164 = 0 time = 825
.meas tran vdout1_16ck164 FIND v(dout1_16) AT=825.025n

* CHECK dout1_17 Vdout1_17ck164 = 0 time = 825
.meas tran vdout1_17ck164 FIND v(dout1_17) AT=825.025n

* CHECK dout1_18 Vdout1_18ck164 = 0 time = 825
.meas tran vdout1_18ck164 FIND v(dout1_18) AT=825.025n

* CHECK dout1_19 Vdout1_19ck164 = 0.9 time = 825
.meas tran vdout1_19ck164 FIND v(dout1_19) AT=825.025n

* CHECK dout1_20 Vdout1_20ck164 = 0 time = 825
.meas tran vdout1_20ck164 FIND v(dout1_20) AT=825.025n

* CHECK dout1_21 Vdout1_21ck164 = 0 time = 825
.meas tran vdout1_21ck164 FIND v(dout1_21) AT=825.025n

* CHECK dout1_22 Vdout1_22ck164 = 0 time = 825
.meas tran vdout1_22ck164 FIND v(dout1_22) AT=825.025n

* CHECK dout1_23 Vdout1_23ck164 = 0 time = 825
.meas tran vdout1_23ck164 FIND v(dout1_23) AT=825.025n

* CHECK dout1_24 Vdout1_24ck164 = 0.9 time = 825
.meas tran vdout1_24ck164 FIND v(dout1_24) AT=825.025n

* CHECK dout1_25 Vdout1_25ck164 = 0.9 time = 825
.meas tran vdout1_25ck164 FIND v(dout1_25) AT=825.025n

* CHECK dout1_26 Vdout1_26ck164 = 0 time = 825
.meas tran vdout1_26ck164 FIND v(dout1_26) AT=825.025n

* CHECK dout1_27 Vdout1_27ck164 = 0 time = 825
.meas tran vdout1_27ck164 FIND v(dout1_27) AT=825.025n

* CHECK dout1_28 Vdout1_28ck164 = 0.9 time = 825
.meas tran vdout1_28ck164 FIND v(dout1_28) AT=825.025n

* CHECK dout1_29 Vdout1_29ck164 = 0 time = 825
.meas tran vdout1_29ck164 FIND v(dout1_29) AT=825.025n

* CHECK dout1_30 Vdout1_30ck164 = 0 time = 825
.meas tran vdout1_30ck164 FIND v(dout1_30) AT=825.025n

* CHECK dout1_31 Vdout1_31ck164 = 0.9 time = 825
.meas tran vdout1_31ck164 FIND v(dout1_31) AT=825.025n

* CHECK dout1_32 Vdout1_32ck164 = 0.9 time = 825
.meas tran vdout1_32ck164 FIND v(dout1_32) AT=825.025n

* CHECK dout1_33 Vdout1_33ck164 = 0.9 time = 825
.meas tran vdout1_33ck164 FIND v(dout1_33) AT=825.025n

* CHECK dout1_34 Vdout1_34ck164 = 0.9 time = 825
.meas tran vdout1_34ck164 FIND v(dout1_34) AT=825.025n

* CHECK dout1_35 Vdout1_35ck164 = 0 time = 825
.meas tran vdout1_35ck164 FIND v(dout1_35) AT=825.025n

* CHECK dout1_36 Vdout1_36ck164 = 0.9 time = 825
.meas tran vdout1_36ck164 FIND v(dout1_36) AT=825.025n

* CHECK dout1_37 Vdout1_37ck164 = 0 time = 825
.meas tran vdout1_37ck164 FIND v(dout1_37) AT=825.025n

* CHECK dout1_38 Vdout1_38ck164 = 0 time = 825
.meas tran vdout1_38ck164 FIND v(dout1_38) AT=825.025n

* CHECK dout1_39 Vdout1_39ck164 = 0.9 time = 825
.meas tran vdout1_39ck164 FIND v(dout1_39) AT=825.025n

* CHECK dout1_40 Vdout1_40ck164 = 0 time = 825
.meas tran vdout1_40ck164 FIND v(dout1_40) AT=825.025n

* CHECK dout1_41 Vdout1_41ck164 = 0 time = 825
.meas tran vdout1_41ck164 FIND v(dout1_41) AT=825.025n

* CHECK dout1_42 Vdout1_42ck164 = 0.9 time = 825
.meas tran vdout1_42ck164 FIND v(dout1_42) AT=825.025n

* CHECK dout1_43 Vdout1_43ck164 = 0 time = 825
.meas tran vdout1_43ck164 FIND v(dout1_43) AT=825.025n

* CHECK dout1_44 Vdout1_44ck164 = 0 time = 825
.meas tran vdout1_44ck164 FIND v(dout1_44) AT=825.025n

* CHECK dout1_45 Vdout1_45ck164 = 0 time = 825
.meas tran vdout1_45ck164 FIND v(dout1_45) AT=825.025n

* CHECK dout1_46 Vdout1_46ck164 = 0.9 time = 825
.meas tran vdout1_46ck164 FIND v(dout1_46) AT=825.025n

* CHECK dout1_47 Vdout1_47ck164 = 0.9 time = 825
.meas tran vdout1_47ck164 FIND v(dout1_47) AT=825.025n

* CHECK dout1_48 Vdout1_48ck164 = 0 time = 825
.meas tran vdout1_48ck164 FIND v(dout1_48) AT=825.025n

* CHECK dout1_49 Vdout1_49ck164 = 0.9 time = 825
.meas tran vdout1_49ck164 FIND v(dout1_49) AT=825.025n

* CHECK dout1_50 Vdout1_50ck164 = 0 time = 825
.meas tran vdout1_50ck164 FIND v(dout1_50) AT=825.025n

* CHECK dout1_51 Vdout1_51ck164 = 0 time = 825
.meas tran vdout1_51ck164 FIND v(dout1_51) AT=825.025n

* CHECK dout1_52 Vdout1_52ck164 = 0 time = 825
.meas tran vdout1_52ck164 FIND v(dout1_52) AT=825.025n

* CHECK dout1_53 Vdout1_53ck164 = 0 time = 825
.meas tran vdout1_53ck164 FIND v(dout1_53) AT=825.025n

* CHECK dout1_54 Vdout1_54ck164 = 0.9 time = 825
.meas tran vdout1_54ck164 FIND v(dout1_54) AT=825.025n

* CHECK dout1_55 Vdout1_55ck164 = 0.9 time = 825
.meas tran vdout1_55ck164 FIND v(dout1_55) AT=825.025n

* CHECK dout1_56 Vdout1_56ck164 = 0 time = 825
.meas tran vdout1_56ck164 FIND v(dout1_56) AT=825.025n

* CHECK dout1_57 Vdout1_57ck164 = 0 time = 825
.meas tran vdout1_57ck164 FIND v(dout1_57) AT=825.025n

* CHECK dout1_58 Vdout1_58ck164 = 0.9 time = 825
.meas tran vdout1_58ck164 FIND v(dout1_58) AT=825.025n

* CHECK dout1_59 Vdout1_59ck164 = 0.9 time = 825
.meas tran vdout1_59ck164 FIND v(dout1_59) AT=825.025n

* CHECK dout1_60 Vdout1_60ck164 = 0 time = 825
.meas tran vdout1_60ck164 FIND v(dout1_60) AT=825.025n

* CHECK dout1_61 Vdout1_61ck164 = 0 time = 825
.meas tran vdout1_61ck164 FIND v(dout1_61) AT=825.025n

* CHECK dout1_62 Vdout1_62ck164 = 0.9 time = 825
.meas tran vdout1_62ck164 FIND v(dout1_62) AT=825.025n

* CHECK dout1_63 Vdout1_63ck164 = 0 time = 825
.meas tran vdout1_63ck164 FIND v(dout1_63) AT=825.025n

* CHECK dout1_64 Vdout1_64ck164 = 0 time = 825
.meas tran vdout1_64ck164 FIND v(dout1_64) AT=825.025n

* CHECK dout1_65 Vdout1_65ck164 = 0.9 time = 825
.meas tran vdout1_65ck164 FIND v(dout1_65) AT=825.025n

* CHECK dout1_66 Vdout1_66ck164 = 0.9 time = 825
.meas tran vdout1_66ck164 FIND v(dout1_66) AT=825.025n

* CHECK dout1_67 Vdout1_67ck164 = 0.9 time = 825
.meas tran vdout1_67ck164 FIND v(dout1_67) AT=825.025n

* CHECK dout1_68 Vdout1_68ck164 = 0 time = 825
.meas tran vdout1_68ck164 FIND v(dout1_68) AT=825.025n

* CHECK dout1_69 Vdout1_69ck164 = 0.9 time = 825
.meas tran vdout1_69ck164 FIND v(dout1_69) AT=825.025n

* CHECK dout1_70 Vdout1_70ck164 = 0.9 time = 825
.meas tran vdout1_70ck164 FIND v(dout1_70) AT=825.025n

* CHECK dout1_71 Vdout1_71ck164 = 0 time = 825
.meas tran vdout1_71ck164 FIND v(dout1_71) AT=825.025n

* CHECK dout1_0 Vdout1_0ck166 = 0 time = 835
.meas tran vdout1_0ck166 FIND v(dout1_0) AT=835.025n

* CHECK dout1_1 Vdout1_1ck166 = 0.9 time = 835
.meas tran vdout1_1ck166 FIND v(dout1_1) AT=835.025n

* CHECK dout1_2 Vdout1_2ck166 = 0.9 time = 835
.meas tran vdout1_2ck166 FIND v(dout1_2) AT=835.025n

* CHECK dout1_3 Vdout1_3ck166 = 0.9 time = 835
.meas tran vdout1_3ck166 FIND v(dout1_3) AT=835.025n

* CHECK dout1_4 Vdout1_4ck166 = 0.9 time = 835
.meas tran vdout1_4ck166 FIND v(dout1_4) AT=835.025n

* CHECK dout1_5 Vdout1_5ck166 = 0 time = 835
.meas tran vdout1_5ck166 FIND v(dout1_5) AT=835.025n

* CHECK dout1_6 Vdout1_6ck166 = 0 time = 835
.meas tran vdout1_6ck166 FIND v(dout1_6) AT=835.025n

* CHECK dout1_7 Vdout1_7ck166 = 0 time = 835
.meas tran vdout1_7ck166 FIND v(dout1_7) AT=835.025n

* CHECK dout1_8 Vdout1_8ck166 = 0.9 time = 835
.meas tran vdout1_8ck166 FIND v(dout1_8) AT=835.025n

* CHECK dout1_9 Vdout1_9ck166 = 0 time = 835
.meas tran vdout1_9ck166 FIND v(dout1_9) AT=835.025n

* CHECK dout1_10 Vdout1_10ck166 = 0 time = 835
.meas tran vdout1_10ck166 FIND v(dout1_10) AT=835.025n

* CHECK dout1_11 Vdout1_11ck166 = 0 time = 835
.meas tran vdout1_11ck166 FIND v(dout1_11) AT=835.025n

* CHECK dout1_12 Vdout1_12ck166 = 0.9 time = 835
.meas tran vdout1_12ck166 FIND v(dout1_12) AT=835.025n

* CHECK dout1_13 Vdout1_13ck166 = 0 time = 835
.meas tran vdout1_13ck166 FIND v(dout1_13) AT=835.025n

* CHECK dout1_14 Vdout1_14ck166 = 0 time = 835
.meas tran vdout1_14ck166 FIND v(dout1_14) AT=835.025n

* CHECK dout1_15 Vdout1_15ck166 = 0 time = 835
.meas tran vdout1_15ck166 FIND v(dout1_15) AT=835.025n

* CHECK dout1_16 Vdout1_16ck166 = 0 time = 835
.meas tran vdout1_16ck166 FIND v(dout1_16) AT=835.025n

* CHECK dout1_17 Vdout1_17ck166 = 0 time = 835
.meas tran vdout1_17ck166 FIND v(dout1_17) AT=835.025n

* CHECK dout1_18 Vdout1_18ck166 = 0 time = 835
.meas tran vdout1_18ck166 FIND v(dout1_18) AT=835.025n

* CHECK dout1_19 Vdout1_19ck166 = 0.9 time = 835
.meas tran vdout1_19ck166 FIND v(dout1_19) AT=835.025n

* CHECK dout1_20 Vdout1_20ck166 = 0 time = 835
.meas tran vdout1_20ck166 FIND v(dout1_20) AT=835.025n

* CHECK dout1_21 Vdout1_21ck166 = 0 time = 835
.meas tran vdout1_21ck166 FIND v(dout1_21) AT=835.025n

* CHECK dout1_22 Vdout1_22ck166 = 0 time = 835
.meas tran vdout1_22ck166 FIND v(dout1_22) AT=835.025n

* CHECK dout1_23 Vdout1_23ck166 = 0 time = 835
.meas tran vdout1_23ck166 FIND v(dout1_23) AT=835.025n

* CHECK dout1_24 Vdout1_24ck166 = 0.9 time = 835
.meas tran vdout1_24ck166 FIND v(dout1_24) AT=835.025n

* CHECK dout1_25 Vdout1_25ck166 = 0.9 time = 835
.meas tran vdout1_25ck166 FIND v(dout1_25) AT=835.025n

* CHECK dout1_26 Vdout1_26ck166 = 0 time = 835
.meas tran vdout1_26ck166 FIND v(dout1_26) AT=835.025n

* CHECK dout1_27 Vdout1_27ck166 = 0 time = 835
.meas tran vdout1_27ck166 FIND v(dout1_27) AT=835.025n

* CHECK dout1_28 Vdout1_28ck166 = 0.9 time = 835
.meas tran vdout1_28ck166 FIND v(dout1_28) AT=835.025n

* CHECK dout1_29 Vdout1_29ck166 = 0 time = 835
.meas tran vdout1_29ck166 FIND v(dout1_29) AT=835.025n

* CHECK dout1_30 Vdout1_30ck166 = 0 time = 835
.meas tran vdout1_30ck166 FIND v(dout1_30) AT=835.025n

* CHECK dout1_31 Vdout1_31ck166 = 0.9 time = 835
.meas tran vdout1_31ck166 FIND v(dout1_31) AT=835.025n

* CHECK dout1_32 Vdout1_32ck166 = 0.9 time = 835
.meas tran vdout1_32ck166 FIND v(dout1_32) AT=835.025n

* CHECK dout1_33 Vdout1_33ck166 = 0.9 time = 835
.meas tran vdout1_33ck166 FIND v(dout1_33) AT=835.025n

* CHECK dout1_34 Vdout1_34ck166 = 0.9 time = 835
.meas tran vdout1_34ck166 FIND v(dout1_34) AT=835.025n

* CHECK dout1_35 Vdout1_35ck166 = 0 time = 835
.meas tran vdout1_35ck166 FIND v(dout1_35) AT=835.025n

* CHECK dout1_36 Vdout1_36ck166 = 0.9 time = 835
.meas tran vdout1_36ck166 FIND v(dout1_36) AT=835.025n

* CHECK dout1_37 Vdout1_37ck166 = 0 time = 835
.meas tran vdout1_37ck166 FIND v(dout1_37) AT=835.025n

* CHECK dout1_38 Vdout1_38ck166 = 0 time = 835
.meas tran vdout1_38ck166 FIND v(dout1_38) AT=835.025n

* CHECK dout1_39 Vdout1_39ck166 = 0.9 time = 835
.meas tran vdout1_39ck166 FIND v(dout1_39) AT=835.025n

* CHECK dout1_40 Vdout1_40ck166 = 0 time = 835
.meas tran vdout1_40ck166 FIND v(dout1_40) AT=835.025n

* CHECK dout1_41 Vdout1_41ck166 = 0 time = 835
.meas tran vdout1_41ck166 FIND v(dout1_41) AT=835.025n

* CHECK dout1_42 Vdout1_42ck166 = 0.9 time = 835
.meas tran vdout1_42ck166 FIND v(dout1_42) AT=835.025n

* CHECK dout1_43 Vdout1_43ck166 = 0 time = 835
.meas tran vdout1_43ck166 FIND v(dout1_43) AT=835.025n

* CHECK dout1_44 Vdout1_44ck166 = 0 time = 835
.meas tran vdout1_44ck166 FIND v(dout1_44) AT=835.025n

* CHECK dout1_45 Vdout1_45ck166 = 0 time = 835
.meas tran vdout1_45ck166 FIND v(dout1_45) AT=835.025n

* CHECK dout1_46 Vdout1_46ck166 = 0.9 time = 835
.meas tran vdout1_46ck166 FIND v(dout1_46) AT=835.025n

* CHECK dout1_47 Vdout1_47ck166 = 0.9 time = 835
.meas tran vdout1_47ck166 FIND v(dout1_47) AT=835.025n

* CHECK dout1_48 Vdout1_48ck166 = 0 time = 835
.meas tran vdout1_48ck166 FIND v(dout1_48) AT=835.025n

* CHECK dout1_49 Vdout1_49ck166 = 0.9 time = 835
.meas tran vdout1_49ck166 FIND v(dout1_49) AT=835.025n

* CHECK dout1_50 Vdout1_50ck166 = 0 time = 835
.meas tran vdout1_50ck166 FIND v(dout1_50) AT=835.025n

* CHECK dout1_51 Vdout1_51ck166 = 0 time = 835
.meas tran vdout1_51ck166 FIND v(dout1_51) AT=835.025n

* CHECK dout1_52 Vdout1_52ck166 = 0 time = 835
.meas tran vdout1_52ck166 FIND v(dout1_52) AT=835.025n

* CHECK dout1_53 Vdout1_53ck166 = 0 time = 835
.meas tran vdout1_53ck166 FIND v(dout1_53) AT=835.025n

* CHECK dout1_54 Vdout1_54ck166 = 0.9 time = 835
.meas tran vdout1_54ck166 FIND v(dout1_54) AT=835.025n

* CHECK dout1_55 Vdout1_55ck166 = 0.9 time = 835
.meas tran vdout1_55ck166 FIND v(dout1_55) AT=835.025n

* CHECK dout1_56 Vdout1_56ck166 = 0 time = 835
.meas tran vdout1_56ck166 FIND v(dout1_56) AT=835.025n

* CHECK dout1_57 Vdout1_57ck166 = 0 time = 835
.meas tran vdout1_57ck166 FIND v(dout1_57) AT=835.025n

* CHECK dout1_58 Vdout1_58ck166 = 0.9 time = 835
.meas tran vdout1_58ck166 FIND v(dout1_58) AT=835.025n

* CHECK dout1_59 Vdout1_59ck166 = 0.9 time = 835
.meas tran vdout1_59ck166 FIND v(dout1_59) AT=835.025n

* CHECK dout1_60 Vdout1_60ck166 = 0 time = 835
.meas tran vdout1_60ck166 FIND v(dout1_60) AT=835.025n

* CHECK dout1_61 Vdout1_61ck166 = 0 time = 835
.meas tran vdout1_61ck166 FIND v(dout1_61) AT=835.025n

* CHECK dout1_62 Vdout1_62ck166 = 0.9 time = 835
.meas tran vdout1_62ck166 FIND v(dout1_62) AT=835.025n

* CHECK dout1_63 Vdout1_63ck166 = 0 time = 835
.meas tran vdout1_63ck166 FIND v(dout1_63) AT=835.025n

* CHECK dout1_64 Vdout1_64ck166 = 0 time = 835
.meas tran vdout1_64ck166 FIND v(dout1_64) AT=835.025n

* CHECK dout1_65 Vdout1_65ck166 = 0.9 time = 835
.meas tran vdout1_65ck166 FIND v(dout1_65) AT=835.025n

* CHECK dout1_66 Vdout1_66ck166 = 0.9 time = 835
.meas tran vdout1_66ck166 FIND v(dout1_66) AT=835.025n

* CHECK dout1_67 Vdout1_67ck166 = 0.9 time = 835
.meas tran vdout1_67ck166 FIND v(dout1_67) AT=835.025n

* CHECK dout1_68 Vdout1_68ck166 = 0 time = 835
.meas tran vdout1_68ck166 FIND v(dout1_68) AT=835.025n

* CHECK dout1_69 Vdout1_69ck166 = 0.9 time = 835
.meas tran vdout1_69ck166 FIND v(dout1_69) AT=835.025n

* CHECK dout1_70 Vdout1_70ck166 = 0.9 time = 835
.meas tran vdout1_70ck166 FIND v(dout1_70) AT=835.025n

* CHECK dout1_71 Vdout1_71ck166 = 0 time = 835
.meas tran vdout1_71ck166 FIND v(dout1_71) AT=835.025n

* CHECK dout1_0 Vdout1_0ck167 = 0 time = 840
.meas tran vdout1_0ck167 FIND v(dout1_0) AT=840.025n

* CHECK dout1_1 Vdout1_1ck167 = 0 time = 840
.meas tran vdout1_1ck167 FIND v(dout1_1) AT=840.025n

* CHECK dout1_2 Vdout1_2ck167 = 0.9 time = 840
.meas tran vdout1_2ck167 FIND v(dout1_2) AT=840.025n

* CHECK dout1_3 Vdout1_3ck167 = 0.9 time = 840
.meas tran vdout1_3ck167 FIND v(dout1_3) AT=840.025n

* CHECK dout1_4 Vdout1_4ck167 = 0 time = 840
.meas tran vdout1_4ck167 FIND v(dout1_4) AT=840.025n

* CHECK dout1_5 Vdout1_5ck167 = 0.9 time = 840
.meas tran vdout1_5ck167 FIND v(dout1_5) AT=840.025n

* CHECK dout1_6 Vdout1_6ck167 = 0 time = 840
.meas tran vdout1_6ck167 FIND v(dout1_6) AT=840.025n

* CHECK dout1_7 Vdout1_7ck167 = 0.9 time = 840
.meas tran vdout1_7ck167 FIND v(dout1_7) AT=840.025n

* CHECK dout1_8 Vdout1_8ck167 = 0 time = 840
.meas tran vdout1_8ck167 FIND v(dout1_8) AT=840.025n

* CHECK dout1_9 Vdout1_9ck167 = 0.9 time = 840
.meas tran vdout1_9ck167 FIND v(dout1_9) AT=840.025n

* CHECK dout1_10 Vdout1_10ck167 = 0.9 time = 840
.meas tran vdout1_10ck167 FIND v(dout1_10) AT=840.025n

* CHECK dout1_11 Vdout1_11ck167 = 0 time = 840
.meas tran vdout1_11ck167 FIND v(dout1_11) AT=840.025n

* CHECK dout1_12 Vdout1_12ck167 = 0.9 time = 840
.meas tran vdout1_12ck167 FIND v(dout1_12) AT=840.025n

* CHECK dout1_13 Vdout1_13ck167 = 0.9 time = 840
.meas tran vdout1_13ck167 FIND v(dout1_13) AT=840.025n

* CHECK dout1_14 Vdout1_14ck167 = 0.9 time = 840
.meas tran vdout1_14ck167 FIND v(dout1_14) AT=840.025n

* CHECK dout1_15 Vdout1_15ck167 = 0.9 time = 840
.meas tran vdout1_15ck167 FIND v(dout1_15) AT=840.025n

* CHECK dout1_16 Vdout1_16ck167 = 0.9 time = 840
.meas tran vdout1_16ck167 FIND v(dout1_16) AT=840.025n

* CHECK dout1_17 Vdout1_17ck167 = 0 time = 840
.meas tran vdout1_17ck167 FIND v(dout1_17) AT=840.025n

* CHECK dout1_18 Vdout1_18ck167 = 0 time = 840
.meas tran vdout1_18ck167 FIND v(dout1_18) AT=840.025n

* CHECK dout1_19 Vdout1_19ck167 = 0.9 time = 840
.meas tran vdout1_19ck167 FIND v(dout1_19) AT=840.025n

* CHECK dout1_20 Vdout1_20ck167 = 0 time = 840
.meas tran vdout1_20ck167 FIND v(dout1_20) AT=840.025n

* CHECK dout1_21 Vdout1_21ck167 = 0.9 time = 840
.meas tran vdout1_21ck167 FIND v(dout1_21) AT=840.025n

* CHECK dout1_22 Vdout1_22ck167 = 0.9 time = 840
.meas tran vdout1_22ck167 FIND v(dout1_22) AT=840.025n

* CHECK dout1_23 Vdout1_23ck167 = 0.9 time = 840
.meas tran vdout1_23ck167 FIND v(dout1_23) AT=840.025n

* CHECK dout1_24 Vdout1_24ck167 = 0 time = 840
.meas tran vdout1_24ck167 FIND v(dout1_24) AT=840.025n

* CHECK dout1_25 Vdout1_25ck167 = 0 time = 840
.meas tran vdout1_25ck167 FIND v(dout1_25) AT=840.025n

* CHECK dout1_26 Vdout1_26ck167 = 0 time = 840
.meas tran vdout1_26ck167 FIND v(dout1_26) AT=840.025n

* CHECK dout1_27 Vdout1_27ck167 = 0 time = 840
.meas tran vdout1_27ck167 FIND v(dout1_27) AT=840.025n

* CHECK dout1_28 Vdout1_28ck167 = 0 time = 840
.meas tran vdout1_28ck167 FIND v(dout1_28) AT=840.025n

* CHECK dout1_29 Vdout1_29ck167 = 0.9 time = 840
.meas tran vdout1_29ck167 FIND v(dout1_29) AT=840.025n

* CHECK dout1_30 Vdout1_30ck167 = 0.9 time = 840
.meas tran vdout1_30ck167 FIND v(dout1_30) AT=840.025n

* CHECK dout1_31 Vdout1_31ck167 = 0.9 time = 840
.meas tran vdout1_31ck167 FIND v(dout1_31) AT=840.025n

* CHECK dout1_32 Vdout1_32ck167 = 0.9 time = 840
.meas tran vdout1_32ck167 FIND v(dout1_32) AT=840.025n

* CHECK dout1_33 Vdout1_33ck167 = 0.9 time = 840
.meas tran vdout1_33ck167 FIND v(dout1_33) AT=840.025n

* CHECK dout1_34 Vdout1_34ck167 = 0.9 time = 840
.meas tran vdout1_34ck167 FIND v(dout1_34) AT=840.025n

* CHECK dout1_35 Vdout1_35ck167 = 0.9 time = 840
.meas tran vdout1_35ck167 FIND v(dout1_35) AT=840.025n

* CHECK dout1_36 Vdout1_36ck167 = 0.9 time = 840
.meas tran vdout1_36ck167 FIND v(dout1_36) AT=840.025n

* CHECK dout1_37 Vdout1_37ck167 = 0 time = 840
.meas tran vdout1_37ck167 FIND v(dout1_37) AT=840.025n

* CHECK dout1_38 Vdout1_38ck167 = 0.9 time = 840
.meas tran vdout1_38ck167 FIND v(dout1_38) AT=840.025n

* CHECK dout1_39 Vdout1_39ck167 = 0.9 time = 840
.meas tran vdout1_39ck167 FIND v(dout1_39) AT=840.025n

* CHECK dout1_40 Vdout1_40ck167 = 0 time = 840
.meas tran vdout1_40ck167 FIND v(dout1_40) AT=840.025n

* CHECK dout1_41 Vdout1_41ck167 = 0.9 time = 840
.meas tran vdout1_41ck167 FIND v(dout1_41) AT=840.025n

* CHECK dout1_42 Vdout1_42ck167 = 0 time = 840
.meas tran vdout1_42ck167 FIND v(dout1_42) AT=840.025n

* CHECK dout1_43 Vdout1_43ck167 = 0 time = 840
.meas tran vdout1_43ck167 FIND v(dout1_43) AT=840.025n

* CHECK dout1_44 Vdout1_44ck167 = 0.9 time = 840
.meas tran vdout1_44ck167 FIND v(dout1_44) AT=840.025n

* CHECK dout1_45 Vdout1_45ck167 = 0 time = 840
.meas tran vdout1_45ck167 FIND v(dout1_45) AT=840.025n

* CHECK dout1_46 Vdout1_46ck167 = 0 time = 840
.meas tran vdout1_46ck167 FIND v(dout1_46) AT=840.025n

* CHECK dout1_47 Vdout1_47ck167 = 0.9 time = 840
.meas tran vdout1_47ck167 FIND v(dout1_47) AT=840.025n

* CHECK dout1_48 Vdout1_48ck167 = 0 time = 840
.meas tran vdout1_48ck167 FIND v(dout1_48) AT=840.025n

* CHECK dout1_49 Vdout1_49ck167 = 0 time = 840
.meas tran vdout1_49ck167 FIND v(dout1_49) AT=840.025n

* CHECK dout1_50 Vdout1_50ck167 = 0 time = 840
.meas tran vdout1_50ck167 FIND v(dout1_50) AT=840.025n

* CHECK dout1_51 Vdout1_51ck167 = 0 time = 840
.meas tran vdout1_51ck167 FIND v(dout1_51) AT=840.025n

* CHECK dout1_52 Vdout1_52ck167 = 0.9 time = 840
.meas tran vdout1_52ck167 FIND v(dout1_52) AT=840.025n

* CHECK dout1_53 Vdout1_53ck167 = 0 time = 840
.meas tran vdout1_53ck167 FIND v(dout1_53) AT=840.025n

* CHECK dout1_54 Vdout1_54ck167 = 0.9 time = 840
.meas tran vdout1_54ck167 FIND v(dout1_54) AT=840.025n

* CHECK dout1_55 Vdout1_55ck167 = 0.9 time = 840
.meas tran vdout1_55ck167 FIND v(dout1_55) AT=840.025n

* CHECK dout1_56 Vdout1_56ck167 = 0.9 time = 840
.meas tran vdout1_56ck167 FIND v(dout1_56) AT=840.025n

* CHECK dout1_57 Vdout1_57ck167 = 0.9 time = 840
.meas tran vdout1_57ck167 FIND v(dout1_57) AT=840.025n

* CHECK dout1_58 Vdout1_58ck167 = 0.9 time = 840
.meas tran vdout1_58ck167 FIND v(dout1_58) AT=840.025n

* CHECK dout1_59 Vdout1_59ck167 = 0 time = 840
.meas tran vdout1_59ck167 FIND v(dout1_59) AT=840.025n

* CHECK dout1_60 Vdout1_60ck167 = 0 time = 840
.meas tran vdout1_60ck167 FIND v(dout1_60) AT=840.025n

* CHECK dout1_61 Vdout1_61ck167 = 0.9 time = 840
.meas tran vdout1_61ck167 FIND v(dout1_61) AT=840.025n

* CHECK dout1_62 Vdout1_62ck167 = 0 time = 840
.meas tran vdout1_62ck167 FIND v(dout1_62) AT=840.025n

* CHECK dout1_63 Vdout1_63ck167 = 0.9 time = 840
.meas tran vdout1_63ck167 FIND v(dout1_63) AT=840.025n

* CHECK dout1_64 Vdout1_64ck167 = 0 time = 840
.meas tran vdout1_64ck167 FIND v(dout1_64) AT=840.025n

* CHECK dout1_65 Vdout1_65ck167 = 0.9 time = 840
.meas tran vdout1_65ck167 FIND v(dout1_65) AT=840.025n

* CHECK dout1_66 Vdout1_66ck167 = 0.9 time = 840
.meas tran vdout1_66ck167 FIND v(dout1_66) AT=840.025n

* CHECK dout1_67 Vdout1_67ck167 = 0 time = 840
.meas tran vdout1_67ck167 FIND v(dout1_67) AT=840.025n

* CHECK dout1_68 Vdout1_68ck167 = 0.9 time = 840
.meas tran vdout1_68ck167 FIND v(dout1_68) AT=840.025n

* CHECK dout1_69 Vdout1_69ck167 = 0 time = 840
.meas tran vdout1_69ck167 FIND v(dout1_69) AT=840.025n

* CHECK dout1_70 Vdout1_70ck167 = 0.9 time = 840
.meas tran vdout1_70ck167 FIND v(dout1_70) AT=840.025n

* CHECK dout1_71 Vdout1_71ck167 = 0.9 time = 840
.meas tran vdout1_71ck167 FIND v(dout1_71) AT=840.025n

* CHECK dout1_0 Vdout1_0ck173 = 0.9 time = 870
.meas tran vdout1_0ck173 FIND v(dout1_0) AT=870.025n

* CHECK dout1_1 Vdout1_1ck173 = 0.9 time = 870
.meas tran vdout1_1ck173 FIND v(dout1_1) AT=870.025n

* CHECK dout1_2 Vdout1_2ck173 = 0.9 time = 870
.meas tran vdout1_2ck173 FIND v(dout1_2) AT=870.025n

* CHECK dout1_3 Vdout1_3ck173 = 0 time = 870
.meas tran vdout1_3ck173 FIND v(dout1_3) AT=870.025n

* CHECK dout1_4 Vdout1_4ck173 = 0 time = 870
.meas tran vdout1_4ck173 FIND v(dout1_4) AT=870.025n

* CHECK dout1_5 Vdout1_5ck173 = 0.9 time = 870
.meas tran vdout1_5ck173 FIND v(dout1_5) AT=870.025n

* CHECK dout1_6 Vdout1_6ck173 = 0 time = 870
.meas tran vdout1_6ck173 FIND v(dout1_6) AT=870.025n

* CHECK dout1_7 Vdout1_7ck173 = 0.9 time = 870
.meas tran vdout1_7ck173 FIND v(dout1_7) AT=870.025n

* CHECK dout1_8 Vdout1_8ck173 = 0 time = 870
.meas tran vdout1_8ck173 FIND v(dout1_8) AT=870.025n

* CHECK dout1_9 Vdout1_9ck173 = 0 time = 870
.meas tran vdout1_9ck173 FIND v(dout1_9) AT=870.025n

* CHECK dout1_10 Vdout1_10ck173 = 0 time = 870
.meas tran vdout1_10ck173 FIND v(dout1_10) AT=870.025n

* CHECK dout1_11 Vdout1_11ck173 = 0 time = 870
.meas tran vdout1_11ck173 FIND v(dout1_11) AT=870.025n

* CHECK dout1_12 Vdout1_12ck173 = 0 time = 870
.meas tran vdout1_12ck173 FIND v(dout1_12) AT=870.025n

* CHECK dout1_13 Vdout1_13ck173 = 0 time = 870
.meas tran vdout1_13ck173 FIND v(dout1_13) AT=870.025n

* CHECK dout1_14 Vdout1_14ck173 = 0 time = 870
.meas tran vdout1_14ck173 FIND v(dout1_14) AT=870.025n

* CHECK dout1_15 Vdout1_15ck173 = 0.9 time = 870
.meas tran vdout1_15ck173 FIND v(dout1_15) AT=870.025n

* CHECK dout1_16 Vdout1_16ck173 = 0 time = 870
.meas tran vdout1_16ck173 FIND v(dout1_16) AT=870.025n

* CHECK dout1_17 Vdout1_17ck173 = 0.9 time = 870
.meas tran vdout1_17ck173 FIND v(dout1_17) AT=870.025n

* CHECK dout1_18 Vdout1_18ck173 = 0.9 time = 870
.meas tran vdout1_18ck173 FIND v(dout1_18) AT=870.025n

* CHECK dout1_19 Vdout1_19ck173 = 0 time = 870
.meas tran vdout1_19ck173 FIND v(dout1_19) AT=870.025n

* CHECK dout1_20 Vdout1_20ck173 = 0.9 time = 870
.meas tran vdout1_20ck173 FIND v(dout1_20) AT=870.025n

* CHECK dout1_21 Vdout1_21ck173 = 0 time = 870
.meas tran vdout1_21ck173 FIND v(dout1_21) AT=870.025n

* CHECK dout1_22 Vdout1_22ck173 = 0 time = 870
.meas tran vdout1_22ck173 FIND v(dout1_22) AT=870.025n

* CHECK dout1_23 Vdout1_23ck173 = 0 time = 870
.meas tran vdout1_23ck173 FIND v(dout1_23) AT=870.025n

* CHECK dout1_24 Vdout1_24ck173 = 0 time = 870
.meas tran vdout1_24ck173 FIND v(dout1_24) AT=870.025n

* CHECK dout1_25 Vdout1_25ck173 = 0 time = 870
.meas tran vdout1_25ck173 FIND v(dout1_25) AT=870.025n

* CHECK dout1_26 Vdout1_26ck173 = 0 time = 870
.meas tran vdout1_26ck173 FIND v(dout1_26) AT=870.025n

* CHECK dout1_27 Vdout1_27ck173 = 0 time = 870
.meas tran vdout1_27ck173 FIND v(dout1_27) AT=870.025n

* CHECK dout1_28 Vdout1_28ck173 = 0 time = 870
.meas tran vdout1_28ck173 FIND v(dout1_28) AT=870.025n

* CHECK dout1_29 Vdout1_29ck173 = 0 time = 870
.meas tran vdout1_29ck173 FIND v(dout1_29) AT=870.025n

* CHECK dout1_30 Vdout1_30ck173 = 0 time = 870
.meas tran vdout1_30ck173 FIND v(dout1_30) AT=870.025n

* CHECK dout1_31 Vdout1_31ck173 = 0 time = 870
.meas tran vdout1_31ck173 FIND v(dout1_31) AT=870.025n

* CHECK dout1_32 Vdout1_32ck173 = 0.9 time = 870
.meas tran vdout1_32ck173 FIND v(dout1_32) AT=870.025n

* CHECK dout1_33 Vdout1_33ck173 = 0 time = 870
.meas tran vdout1_33ck173 FIND v(dout1_33) AT=870.025n

* CHECK dout1_34 Vdout1_34ck173 = 0 time = 870
.meas tran vdout1_34ck173 FIND v(dout1_34) AT=870.025n

* CHECK dout1_35 Vdout1_35ck173 = 0 time = 870
.meas tran vdout1_35ck173 FIND v(dout1_35) AT=870.025n

* CHECK dout1_36 Vdout1_36ck173 = 0.9 time = 870
.meas tran vdout1_36ck173 FIND v(dout1_36) AT=870.025n

* CHECK dout1_37 Vdout1_37ck173 = 0.9 time = 870
.meas tran vdout1_37ck173 FIND v(dout1_37) AT=870.025n

* CHECK dout1_38 Vdout1_38ck173 = 0.9 time = 870
.meas tran vdout1_38ck173 FIND v(dout1_38) AT=870.025n

* CHECK dout1_39 Vdout1_39ck173 = 0.9 time = 870
.meas tran vdout1_39ck173 FIND v(dout1_39) AT=870.025n

* CHECK dout1_40 Vdout1_40ck173 = 0 time = 870
.meas tran vdout1_40ck173 FIND v(dout1_40) AT=870.025n

* CHECK dout1_41 Vdout1_41ck173 = 0.9 time = 870
.meas tran vdout1_41ck173 FIND v(dout1_41) AT=870.025n

* CHECK dout1_42 Vdout1_42ck173 = 0 time = 870
.meas tran vdout1_42ck173 FIND v(dout1_42) AT=870.025n

* CHECK dout1_43 Vdout1_43ck173 = 0.9 time = 870
.meas tran vdout1_43ck173 FIND v(dout1_43) AT=870.025n

* CHECK dout1_44 Vdout1_44ck173 = 0.9 time = 870
.meas tran vdout1_44ck173 FIND v(dout1_44) AT=870.025n

* CHECK dout1_45 Vdout1_45ck173 = 0 time = 870
.meas tran vdout1_45ck173 FIND v(dout1_45) AT=870.025n

* CHECK dout1_46 Vdout1_46ck173 = 0 time = 870
.meas tran vdout1_46ck173 FIND v(dout1_46) AT=870.025n

* CHECK dout1_47 Vdout1_47ck173 = 0 time = 870
.meas tran vdout1_47ck173 FIND v(dout1_47) AT=870.025n

* CHECK dout1_48 Vdout1_48ck173 = 0 time = 870
.meas tran vdout1_48ck173 FIND v(dout1_48) AT=870.025n

* CHECK dout1_49 Vdout1_49ck173 = 0 time = 870
.meas tran vdout1_49ck173 FIND v(dout1_49) AT=870.025n

* CHECK dout1_50 Vdout1_50ck173 = 0.9 time = 870
.meas tran vdout1_50ck173 FIND v(dout1_50) AT=870.025n

* CHECK dout1_51 Vdout1_51ck173 = 0 time = 870
.meas tran vdout1_51ck173 FIND v(dout1_51) AT=870.025n

* CHECK dout1_52 Vdout1_52ck173 = 0.9 time = 870
.meas tran vdout1_52ck173 FIND v(dout1_52) AT=870.025n

* CHECK dout1_53 Vdout1_53ck173 = 0.9 time = 870
.meas tran vdout1_53ck173 FIND v(dout1_53) AT=870.025n

* CHECK dout1_54 Vdout1_54ck173 = 0.9 time = 870
.meas tran vdout1_54ck173 FIND v(dout1_54) AT=870.025n

* CHECK dout1_55 Vdout1_55ck173 = 0.9 time = 870
.meas tran vdout1_55ck173 FIND v(dout1_55) AT=870.025n

* CHECK dout1_56 Vdout1_56ck173 = 0 time = 870
.meas tran vdout1_56ck173 FIND v(dout1_56) AT=870.025n

* CHECK dout1_57 Vdout1_57ck173 = 0 time = 870
.meas tran vdout1_57ck173 FIND v(dout1_57) AT=870.025n

* CHECK dout1_58 Vdout1_58ck173 = 0.9 time = 870
.meas tran vdout1_58ck173 FIND v(dout1_58) AT=870.025n

* CHECK dout1_59 Vdout1_59ck173 = 0.9 time = 870
.meas tran vdout1_59ck173 FIND v(dout1_59) AT=870.025n

* CHECK dout1_60 Vdout1_60ck173 = 0 time = 870
.meas tran vdout1_60ck173 FIND v(dout1_60) AT=870.025n

* CHECK dout1_61 Vdout1_61ck173 = 0.9 time = 870
.meas tran vdout1_61ck173 FIND v(dout1_61) AT=870.025n

* CHECK dout1_62 Vdout1_62ck173 = 0.9 time = 870
.meas tran vdout1_62ck173 FIND v(dout1_62) AT=870.025n

* CHECK dout1_63 Vdout1_63ck173 = 0.9 time = 870
.meas tran vdout1_63ck173 FIND v(dout1_63) AT=870.025n

* CHECK dout1_64 Vdout1_64ck173 = 0.9 time = 870
.meas tran vdout1_64ck173 FIND v(dout1_64) AT=870.025n

* CHECK dout1_65 Vdout1_65ck173 = 0.9 time = 870
.meas tran vdout1_65ck173 FIND v(dout1_65) AT=870.025n

* CHECK dout1_66 Vdout1_66ck173 = 0.9 time = 870
.meas tran vdout1_66ck173 FIND v(dout1_66) AT=870.025n

* CHECK dout1_67 Vdout1_67ck173 = 0 time = 870
.meas tran vdout1_67ck173 FIND v(dout1_67) AT=870.025n

* CHECK dout1_68 Vdout1_68ck173 = 0.9 time = 870
.meas tran vdout1_68ck173 FIND v(dout1_68) AT=870.025n

* CHECK dout1_69 Vdout1_69ck173 = 0.9 time = 870
.meas tran vdout1_69ck173 FIND v(dout1_69) AT=870.025n

* CHECK dout1_70 Vdout1_70ck173 = 0 time = 870
.meas tran vdout1_70ck173 FIND v(dout1_70) AT=870.025n

* CHECK dout1_71 Vdout1_71ck173 = 0 time = 870
.meas tran vdout1_71ck173 FIND v(dout1_71) AT=870.025n

* CHECK dout1_0 Vdout1_0ck175 = 0.9 time = 880
.meas tran vdout1_0ck175 FIND v(dout1_0) AT=880.025n

* CHECK dout1_1 Vdout1_1ck175 = 0 time = 880
.meas tran vdout1_1ck175 FIND v(dout1_1) AT=880.025n

* CHECK dout1_2 Vdout1_2ck175 = 0.9 time = 880
.meas tran vdout1_2ck175 FIND v(dout1_2) AT=880.025n

* CHECK dout1_3 Vdout1_3ck175 = 0.9 time = 880
.meas tran vdout1_3ck175 FIND v(dout1_3) AT=880.025n

* CHECK dout1_4 Vdout1_4ck175 = 0.9 time = 880
.meas tran vdout1_4ck175 FIND v(dout1_4) AT=880.025n

* CHECK dout1_5 Vdout1_5ck175 = 0.9 time = 880
.meas tran vdout1_5ck175 FIND v(dout1_5) AT=880.025n

* CHECK dout1_6 Vdout1_6ck175 = 0 time = 880
.meas tran vdout1_6ck175 FIND v(dout1_6) AT=880.025n

* CHECK dout1_7 Vdout1_7ck175 = 0 time = 880
.meas tran vdout1_7ck175 FIND v(dout1_7) AT=880.025n

* CHECK dout1_8 Vdout1_8ck175 = 0 time = 880
.meas tran vdout1_8ck175 FIND v(dout1_8) AT=880.025n

* CHECK dout1_9 Vdout1_9ck175 = 0.9 time = 880
.meas tran vdout1_9ck175 FIND v(dout1_9) AT=880.025n

* CHECK dout1_10 Vdout1_10ck175 = 0 time = 880
.meas tran vdout1_10ck175 FIND v(dout1_10) AT=880.025n

* CHECK dout1_11 Vdout1_11ck175 = 0.9 time = 880
.meas tran vdout1_11ck175 FIND v(dout1_11) AT=880.025n

* CHECK dout1_12 Vdout1_12ck175 = 0.9 time = 880
.meas tran vdout1_12ck175 FIND v(dout1_12) AT=880.025n

* CHECK dout1_13 Vdout1_13ck175 = 0.9 time = 880
.meas tran vdout1_13ck175 FIND v(dout1_13) AT=880.025n

* CHECK dout1_14 Vdout1_14ck175 = 0 time = 880
.meas tran vdout1_14ck175 FIND v(dout1_14) AT=880.025n

* CHECK dout1_15 Vdout1_15ck175 = 0 time = 880
.meas tran vdout1_15ck175 FIND v(dout1_15) AT=880.025n

* CHECK dout1_16 Vdout1_16ck175 = 0 time = 880
.meas tran vdout1_16ck175 FIND v(dout1_16) AT=880.025n

* CHECK dout1_17 Vdout1_17ck175 = 0 time = 880
.meas tran vdout1_17ck175 FIND v(dout1_17) AT=880.025n

* CHECK dout1_18 Vdout1_18ck175 = 0 time = 880
.meas tran vdout1_18ck175 FIND v(dout1_18) AT=880.025n

* CHECK dout1_19 Vdout1_19ck175 = 0.9 time = 880
.meas tran vdout1_19ck175 FIND v(dout1_19) AT=880.025n

* CHECK dout1_20 Vdout1_20ck175 = 0 time = 880
.meas tran vdout1_20ck175 FIND v(dout1_20) AT=880.025n

* CHECK dout1_21 Vdout1_21ck175 = 0 time = 880
.meas tran vdout1_21ck175 FIND v(dout1_21) AT=880.025n

* CHECK dout1_22 Vdout1_22ck175 = 0.9 time = 880
.meas tran vdout1_22ck175 FIND v(dout1_22) AT=880.025n

* CHECK dout1_23 Vdout1_23ck175 = 0 time = 880
.meas tran vdout1_23ck175 FIND v(dout1_23) AT=880.025n

* CHECK dout1_24 Vdout1_24ck175 = 0 time = 880
.meas tran vdout1_24ck175 FIND v(dout1_24) AT=880.025n

* CHECK dout1_25 Vdout1_25ck175 = 0 time = 880
.meas tran vdout1_25ck175 FIND v(dout1_25) AT=880.025n

* CHECK dout1_26 Vdout1_26ck175 = 0 time = 880
.meas tran vdout1_26ck175 FIND v(dout1_26) AT=880.025n

* CHECK dout1_27 Vdout1_27ck175 = 0 time = 880
.meas tran vdout1_27ck175 FIND v(dout1_27) AT=880.025n

* CHECK dout1_28 Vdout1_28ck175 = 0 time = 880
.meas tran vdout1_28ck175 FIND v(dout1_28) AT=880.025n

* CHECK dout1_29 Vdout1_29ck175 = 0 time = 880
.meas tran vdout1_29ck175 FIND v(dout1_29) AT=880.025n

* CHECK dout1_30 Vdout1_30ck175 = 0.9 time = 880
.meas tran vdout1_30ck175 FIND v(dout1_30) AT=880.025n

* CHECK dout1_31 Vdout1_31ck175 = 0.9 time = 880
.meas tran vdout1_31ck175 FIND v(dout1_31) AT=880.025n

* CHECK dout1_32 Vdout1_32ck175 = 0 time = 880
.meas tran vdout1_32ck175 FIND v(dout1_32) AT=880.025n

* CHECK dout1_33 Vdout1_33ck175 = 0 time = 880
.meas tran vdout1_33ck175 FIND v(dout1_33) AT=880.025n

* CHECK dout1_34 Vdout1_34ck175 = 0 time = 880
.meas tran vdout1_34ck175 FIND v(dout1_34) AT=880.025n

* CHECK dout1_35 Vdout1_35ck175 = 0.9 time = 880
.meas tran vdout1_35ck175 FIND v(dout1_35) AT=880.025n

* CHECK dout1_36 Vdout1_36ck175 = 0 time = 880
.meas tran vdout1_36ck175 FIND v(dout1_36) AT=880.025n

* CHECK dout1_37 Vdout1_37ck175 = 0.9 time = 880
.meas tran vdout1_37ck175 FIND v(dout1_37) AT=880.025n

* CHECK dout1_38 Vdout1_38ck175 = 0.9 time = 880
.meas tran vdout1_38ck175 FIND v(dout1_38) AT=880.025n

* CHECK dout1_39 Vdout1_39ck175 = 0.9 time = 880
.meas tran vdout1_39ck175 FIND v(dout1_39) AT=880.025n

* CHECK dout1_40 Vdout1_40ck175 = 0 time = 880
.meas tran vdout1_40ck175 FIND v(dout1_40) AT=880.025n

* CHECK dout1_41 Vdout1_41ck175 = 0.9 time = 880
.meas tran vdout1_41ck175 FIND v(dout1_41) AT=880.025n

* CHECK dout1_42 Vdout1_42ck175 = 0 time = 880
.meas tran vdout1_42ck175 FIND v(dout1_42) AT=880.025n

* CHECK dout1_43 Vdout1_43ck175 = 0.9 time = 880
.meas tran vdout1_43ck175 FIND v(dout1_43) AT=880.025n

* CHECK dout1_44 Vdout1_44ck175 = 0 time = 880
.meas tran vdout1_44ck175 FIND v(dout1_44) AT=880.025n

* CHECK dout1_45 Vdout1_45ck175 = 0 time = 880
.meas tran vdout1_45ck175 FIND v(dout1_45) AT=880.025n

* CHECK dout1_46 Vdout1_46ck175 = 0.9 time = 880
.meas tran vdout1_46ck175 FIND v(dout1_46) AT=880.025n

* CHECK dout1_47 Vdout1_47ck175 = 0 time = 880
.meas tran vdout1_47ck175 FIND v(dout1_47) AT=880.025n

* CHECK dout1_48 Vdout1_48ck175 = 0 time = 880
.meas tran vdout1_48ck175 FIND v(dout1_48) AT=880.025n

* CHECK dout1_49 Vdout1_49ck175 = 0.9 time = 880
.meas tran vdout1_49ck175 FIND v(dout1_49) AT=880.025n

* CHECK dout1_50 Vdout1_50ck175 = 0 time = 880
.meas tran vdout1_50ck175 FIND v(dout1_50) AT=880.025n

* CHECK dout1_51 Vdout1_51ck175 = 0 time = 880
.meas tran vdout1_51ck175 FIND v(dout1_51) AT=880.025n

* CHECK dout1_52 Vdout1_52ck175 = 0 time = 880
.meas tran vdout1_52ck175 FIND v(dout1_52) AT=880.025n

* CHECK dout1_53 Vdout1_53ck175 = 0.9 time = 880
.meas tran vdout1_53ck175 FIND v(dout1_53) AT=880.025n

* CHECK dout1_54 Vdout1_54ck175 = 0.9 time = 880
.meas tran vdout1_54ck175 FIND v(dout1_54) AT=880.025n

* CHECK dout1_55 Vdout1_55ck175 = 0 time = 880
.meas tran vdout1_55ck175 FIND v(dout1_55) AT=880.025n

* CHECK dout1_56 Vdout1_56ck175 = 0 time = 880
.meas tran vdout1_56ck175 FIND v(dout1_56) AT=880.025n

* CHECK dout1_57 Vdout1_57ck175 = 0 time = 880
.meas tran vdout1_57ck175 FIND v(dout1_57) AT=880.025n

* CHECK dout1_58 Vdout1_58ck175 = 0 time = 880
.meas tran vdout1_58ck175 FIND v(dout1_58) AT=880.025n

* CHECK dout1_59 Vdout1_59ck175 = 0 time = 880
.meas tran vdout1_59ck175 FIND v(dout1_59) AT=880.025n

* CHECK dout1_60 Vdout1_60ck175 = 0 time = 880
.meas tran vdout1_60ck175 FIND v(dout1_60) AT=880.025n

* CHECK dout1_61 Vdout1_61ck175 = 0 time = 880
.meas tran vdout1_61ck175 FIND v(dout1_61) AT=880.025n

* CHECK dout1_62 Vdout1_62ck175 = 0.9 time = 880
.meas tran vdout1_62ck175 FIND v(dout1_62) AT=880.025n

* CHECK dout1_63 Vdout1_63ck175 = 0 time = 880
.meas tran vdout1_63ck175 FIND v(dout1_63) AT=880.025n

* CHECK dout1_64 Vdout1_64ck175 = 0 time = 880
.meas tran vdout1_64ck175 FIND v(dout1_64) AT=880.025n

* CHECK dout1_65 Vdout1_65ck175 = 0.9 time = 880
.meas tran vdout1_65ck175 FIND v(dout1_65) AT=880.025n

* CHECK dout1_66 Vdout1_66ck175 = 0.9 time = 880
.meas tran vdout1_66ck175 FIND v(dout1_66) AT=880.025n

* CHECK dout1_67 Vdout1_67ck175 = 0.9 time = 880
.meas tran vdout1_67ck175 FIND v(dout1_67) AT=880.025n

* CHECK dout1_68 Vdout1_68ck175 = 0 time = 880
.meas tran vdout1_68ck175 FIND v(dout1_68) AT=880.025n

* CHECK dout1_69 Vdout1_69ck175 = 0.9 time = 880
.meas tran vdout1_69ck175 FIND v(dout1_69) AT=880.025n

* CHECK dout1_70 Vdout1_70ck175 = 0 time = 880
.meas tran vdout1_70ck175 FIND v(dout1_70) AT=880.025n

* CHECK dout1_71 Vdout1_71ck175 = 0 time = 880
.meas tran vdout1_71ck175 FIND v(dout1_71) AT=880.025n

* CHECK dout1_0 Vdout1_0ck176 = 0 time = 885
.meas tran vdout1_0ck176 FIND v(dout1_0) AT=885.025n

* CHECK dout1_1 Vdout1_1ck176 = 0 time = 885
.meas tran vdout1_1ck176 FIND v(dout1_1) AT=885.025n

* CHECK dout1_2 Vdout1_2ck176 = 0 time = 885
.meas tran vdout1_2ck176 FIND v(dout1_2) AT=885.025n

* CHECK dout1_3 Vdout1_3ck176 = 0.9 time = 885
.meas tran vdout1_3ck176 FIND v(dout1_3) AT=885.025n

* CHECK dout1_4 Vdout1_4ck176 = 0 time = 885
.meas tran vdout1_4ck176 FIND v(dout1_4) AT=885.025n

* CHECK dout1_5 Vdout1_5ck176 = 0 time = 885
.meas tran vdout1_5ck176 FIND v(dout1_5) AT=885.025n

* CHECK dout1_6 Vdout1_6ck176 = 0.9 time = 885
.meas tran vdout1_6ck176 FIND v(dout1_6) AT=885.025n

* CHECK dout1_7 Vdout1_7ck176 = 0 time = 885
.meas tran vdout1_7ck176 FIND v(dout1_7) AT=885.025n

* CHECK dout1_8 Vdout1_8ck176 = 0 time = 885
.meas tran vdout1_8ck176 FIND v(dout1_8) AT=885.025n

* CHECK dout1_9 Vdout1_9ck176 = 0.9 time = 885
.meas tran vdout1_9ck176 FIND v(dout1_9) AT=885.025n

* CHECK dout1_10 Vdout1_10ck176 = 0.9 time = 885
.meas tran vdout1_10ck176 FIND v(dout1_10) AT=885.025n

* CHECK dout1_11 Vdout1_11ck176 = 0 time = 885
.meas tran vdout1_11ck176 FIND v(dout1_11) AT=885.025n

* CHECK dout1_12 Vdout1_12ck176 = 0 time = 885
.meas tran vdout1_12ck176 FIND v(dout1_12) AT=885.025n

* CHECK dout1_13 Vdout1_13ck176 = 0.9 time = 885
.meas tran vdout1_13ck176 FIND v(dout1_13) AT=885.025n

* CHECK dout1_14 Vdout1_14ck176 = 0 time = 885
.meas tran vdout1_14ck176 FIND v(dout1_14) AT=885.025n

* CHECK dout1_15 Vdout1_15ck176 = 0 time = 885
.meas tran vdout1_15ck176 FIND v(dout1_15) AT=885.025n

* CHECK dout1_16 Vdout1_16ck176 = 0 time = 885
.meas tran vdout1_16ck176 FIND v(dout1_16) AT=885.025n

* CHECK dout1_17 Vdout1_17ck176 = 0.9 time = 885
.meas tran vdout1_17ck176 FIND v(dout1_17) AT=885.025n

* CHECK dout1_18 Vdout1_18ck176 = 0.9 time = 885
.meas tran vdout1_18ck176 FIND v(dout1_18) AT=885.025n

* CHECK dout1_19 Vdout1_19ck176 = 0 time = 885
.meas tran vdout1_19ck176 FIND v(dout1_19) AT=885.025n

* CHECK dout1_20 Vdout1_20ck176 = 0 time = 885
.meas tran vdout1_20ck176 FIND v(dout1_20) AT=885.025n

* CHECK dout1_21 Vdout1_21ck176 = 0 time = 885
.meas tran vdout1_21ck176 FIND v(dout1_21) AT=885.025n

* CHECK dout1_22 Vdout1_22ck176 = 0 time = 885
.meas tran vdout1_22ck176 FIND v(dout1_22) AT=885.025n

* CHECK dout1_23 Vdout1_23ck176 = 0 time = 885
.meas tran vdout1_23ck176 FIND v(dout1_23) AT=885.025n

* CHECK dout1_24 Vdout1_24ck176 = 0.9 time = 885
.meas tran vdout1_24ck176 FIND v(dout1_24) AT=885.025n

* CHECK dout1_25 Vdout1_25ck176 = 0 time = 885
.meas tran vdout1_25ck176 FIND v(dout1_25) AT=885.025n

* CHECK dout1_26 Vdout1_26ck176 = 0 time = 885
.meas tran vdout1_26ck176 FIND v(dout1_26) AT=885.025n

* CHECK dout1_27 Vdout1_27ck176 = 0.9 time = 885
.meas tran vdout1_27ck176 FIND v(dout1_27) AT=885.025n

* CHECK dout1_28 Vdout1_28ck176 = 0.9 time = 885
.meas tran vdout1_28ck176 FIND v(dout1_28) AT=885.025n

* CHECK dout1_29 Vdout1_29ck176 = 0 time = 885
.meas tran vdout1_29ck176 FIND v(dout1_29) AT=885.025n

* CHECK dout1_30 Vdout1_30ck176 = 0 time = 885
.meas tran vdout1_30ck176 FIND v(dout1_30) AT=885.025n

* CHECK dout1_31 Vdout1_31ck176 = 0 time = 885
.meas tran vdout1_31ck176 FIND v(dout1_31) AT=885.025n

* CHECK dout1_32 Vdout1_32ck176 = 0.9 time = 885
.meas tran vdout1_32ck176 FIND v(dout1_32) AT=885.025n

* CHECK dout1_33 Vdout1_33ck176 = 0 time = 885
.meas tran vdout1_33ck176 FIND v(dout1_33) AT=885.025n

* CHECK dout1_34 Vdout1_34ck176 = 0.9 time = 885
.meas tran vdout1_34ck176 FIND v(dout1_34) AT=885.025n

* CHECK dout1_35 Vdout1_35ck176 = 0.9 time = 885
.meas tran vdout1_35ck176 FIND v(dout1_35) AT=885.025n

* CHECK dout1_36 Vdout1_36ck176 = 0 time = 885
.meas tran vdout1_36ck176 FIND v(dout1_36) AT=885.025n

* CHECK dout1_37 Vdout1_37ck176 = 0.9 time = 885
.meas tran vdout1_37ck176 FIND v(dout1_37) AT=885.025n

* CHECK dout1_38 Vdout1_38ck176 = 0 time = 885
.meas tran vdout1_38ck176 FIND v(dout1_38) AT=885.025n

* CHECK dout1_39 Vdout1_39ck176 = 0 time = 885
.meas tran vdout1_39ck176 FIND v(dout1_39) AT=885.025n

* CHECK dout1_40 Vdout1_40ck176 = 0 time = 885
.meas tran vdout1_40ck176 FIND v(dout1_40) AT=885.025n

* CHECK dout1_41 Vdout1_41ck176 = 0 time = 885
.meas tran vdout1_41ck176 FIND v(dout1_41) AT=885.025n

* CHECK dout1_42 Vdout1_42ck176 = 0 time = 885
.meas tran vdout1_42ck176 FIND v(dout1_42) AT=885.025n

* CHECK dout1_43 Vdout1_43ck176 = 0.9 time = 885
.meas tran vdout1_43ck176 FIND v(dout1_43) AT=885.025n

* CHECK dout1_44 Vdout1_44ck176 = 0 time = 885
.meas tran vdout1_44ck176 FIND v(dout1_44) AT=885.025n

* CHECK dout1_45 Vdout1_45ck176 = 0.9 time = 885
.meas tran vdout1_45ck176 FIND v(dout1_45) AT=885.025n

* CHECK dout1_46 Vdout1_46ck176 = 0.9 time = 885
.meas tran vdout1_46ck176 FIND v(dout1_46) AT=885.025n

* CHECK dout1_47 Vdout1_47ck176 = 0.9 time = 885
.meas tran vdout1_47ck176 FIND v(dout1_47) AT=885.025n

* CHECK dout1_48 Vdout1_48ck176 = 0.9 time = 885
.meas tran vdout1_48ck176 FIND v(dout1_48) AT=885.025n

* CHECK dout1_49 Vdout1_49ck176 = 0 time = 885
.meas tran vdout1_49ck176 FIND v(dout1_49) AT=885.025n

* CHECK dout1_50 Vdout1_50ck176 = 0 time = 885
.meas tran vdout1_50ck176 FIND v(dout1_50) AT=885.025n

* CHECK dout1_51 Vdout1_51ck176 = 0.9 time = 885
.meas tran vdout1_51ck176 FIND v(dout1_51) AT=885.025n

* CHECK dout1_52 Vdout1_52ck176 = 0 time = 885
.meas tran vdout1_52ck176 FIND v(dout1_52) AT=885.025n

* CHECK dout1_53 Vdout1_53ck176 = 0.9 time = 885
.meas tran vdout1_53ck176 FIND v(dout1_53) AT=885.025n

* CHECK dout1_54 Vdout1_54ck176 = 0.9 time = 885
.meas tran vdout1_54ck176 FIND v(dout1_54) AT=885.025n

* CHECK dout1_55 Vdout1_55ck176 = 0.9 time = 885
.meas tran vdout1_55ck176 FIND v(dout1_55) AT=885.025n

* CHECK dout1_56 Vdout1_56ck176 = 0 time = 885
.meas tran vdout1_56ck176 FIND v(dout1_56) AT=885.025n

* CHECK dout1_57 Vdout1_57ck176 = 0.9 time = 885
.meas tran vdout1_57ck176 FIND v(dout1_57) AT=885.025n

* CHECK dout1_58 Vdout1_58ck176 = 0.9 time = 885
.meas tran vdout1_58ck176 FIND v(dout1_58) AT=885.025n

* CHECK dout1_59 Vdout1_59ck176 = 0.9 time = 885
.meas tran vdout1_59ck176 FIND v(dout1_59) AT=885.025n

* CHECK dout1_60 Vdout1_60ck176 = 0 time = 885
.meas tran vdout1_60ck176 FIND v(dout1_60) AT=885.025n

* CHECK dout1_61 Vdout1_61ck176 = 0 time = 885
.meas tran vdout1_61ck176 FIND v(dout1_61) AT=885.025n

* CHECK dout1_62 Vdout1_62ck176 = 0 time = 885
.meas tran vdout1_62ck176 FIND v(dout1_62) AT=885.025n

* CHECK dout1_63 Vdout1_63ck176 = 0.9 time = 885
.meas tran vdout1_63ck176 FIND v(dout1_63) AT=885.025n

* CHECK dout1_64 Vdout1_64ck176 = 0 time = 885
.meas tran vdout1_64ck176 FIND v(dout1_64) AT=885.025n

* CHECK dout1_65 Vdout1_65ck176 = 0 time = 885
.meas tran vdout1_65ck176 FIND v(dout1_65) AT=885.025n

* CHECK dout1_66 Vdout1_66ck176 = 0 time = 885
.meas tran vdout1_66ck176 FIND v(dout1_66) AT=885.025n

* CHECK dout1_67 Vdout1_67ck176 = 0.9 time = 885
.meas tran vdout1_67ck176 FIND v(dout1_67) AT=885.025n

* CHECK dout1_68 Vdout1_68ck176 = 0 time = 885
.meas tran vdout1_68ck176 FIND v(dout1_68) AT=885.025n

* CHECK dout1_69 Vdout1_69ck176 = 0.9 time = 885
.meas tran vdout1_69ck176 FIND v(dout1_69) AT=885.025n

* CHECK dout1_70 Vdout1_70ck176 = 0 time = 885
.meas tran vdout1_70ck176 FIND v(dout1_70) AT=885.025n

* CHECK dout1_71 Vdout1_71ck176 = 0 time = 885
.meas tran vdout1_71ck176 FIND v(dout1_71) AT=885.025n

* CHECK dout1_0 Vdout1_0ck179 = 0 time = 900
.meas tran vdout1_0ck179 FIND v(dout1_0) AT=900.025n

* CHECK dout1_1 Vdout1_1ck179 = 0 time = 900
.meas tran vdout1_1ck179 FIND v(dout1_1) AT=900.025n

* CHECK dout1_2 Vdout1_2ck179 = 0 time = 900
.meas tran vdout1_2ck179 FIND v(dout1_2) AT=900.025n

* CHECK dout1_3 Vdout1_3ck179 = 0.9 time = 900
.meas tran vdout1_3ck179 FIND v(dout1_3) AT=900.025n

* CHECK dout1_4 Vdout1_4ck179 = 0 time = 900
.meas tran vdout1_4ck179 FIND v(dout1_4) AT=900.025n

* CHECK dout1_5 Vdout1_5ck179 = 0 time = 900
.meas tran vdout1_5ck179 FIND v(dout1_5) AT=900.025n

* CHECK dout1_6 Vdout1_6ck179 = 0.9 time = 900
.meas tran vdout1_6ck179 FIND v(dout1_6) AT=900.025n

* CHECK dout1_7 Vdout1_7ck179 = 0 time = 900
.meas tran vdout1_7ck179 FIND v(dout1_7) AT=900.025n

* CHECK dout1_8 Vdout1_8ck179 = 0 time = 900
.meas tran vdout1_8ck179 FIND v(dout1_8) AT=900.025n

* CHECK dout1_9 Vdout1_9ck179 = 0.9 time = 900
.meas tran vdout1_9ck179 FIND v(dout1_9) AT=900.025n

* CHECK dout1_10 Vdout1_10ck179 = 0.9 time = 900
.meas tran vdout1_10ck179 FIND v(dout1_10) AT=900.025n

* CHECK dout1_11 Vdout1_11ck179 = 0 time = 900
.meas tran vdout1_11ck179 FIND v(dout1_11) AT=900.025n

* CHECK dout1_12 Vdout1_12ck179 = 0 time = 900
.meas tran vdout1_12ck179 FIND v(dout1_12) AT=900.025n

* CHECK dout1_13 Vdout1_13ck179 = 0.9 time = 900
.meas tran vdout1_13ck179 FIND v(dout1_13) AT=900.025n

* CHECK dout1_14 Vdout1_14ck179 = 0 time = 900
.meas tran vdout1_14ck179 FIND v(dout1_14) AT=900.025n

* CHECK dout1_15 Vdout1_15ck179 = 0 time = 900
.meas tran vdout1_15ck179 FIND v(dout1_15) AT=900.025n

* CHECK dout1_16 Vdout1_16ck179 = 0 time = 900
.meas tran vdout1_16ck179 FIND v(dout1_16) AT=900.025n

* CHECK dout1_17 Vdout1_17ck179 = 0.9 time = 900
.meas tran vdout1_17ck179 FIND v(dout1_17) AT=900.025n

* CHECK dout1_18 Vdout1_18ck179 = 0.9 time = 900
.meas tran vdout1_18ck179 FIND v(dout1_18) AT=900.025n

* CHECK dout1_19 Vdout1_19ck179 = 0 time = 900
.meas tran vdout1_19ck179 FIND v(dout1_19) AT=900.025n

* CHECK dout1_20 Vdout1_20ck179 = 0 time = 900
.meas tran vdout1_20ck179 FIND v(dout1_20) AT=900.025n

* CHECK dout1_21 Vdout1_21ck179 = 0 time = 900
.meas tran vdout1_21ck179 FIND v(dout1_21) AT=900.025n

* CHECK dout1_22 Vdout1_22ck179 = 0 time = 900
.meas tran vdout1_22ck179 FIND v(dout1_22) AT=900.025n

* CHECK dout1_23 Vdout1_23ck179 = 0 time = 900
.meas tran vdout1_23ck179 FIND v(dout1_23) AT=900.025n

* CHECK dout1_24 Vdout1_24ck179 = 0.9 time = 900
.meas tran vdout1_24ck179 FIND v(dout1_24) AT=900.025n

* CHECK dout1_25 Vdout1_25ck179 = 0 time = 900
.meas tran vdout1_25ck179 FIND v(dout1_25) AT=900.025n

* CHECK dout1_26 Vdout1_26ck179 = 0 time = 900
.meas tran vdout1_26ck179 FIND v(dout1_26) AT=900.025n

* CHECK dout1_27 Vdout1_27ck179 = 0.9 time = 900
.meas tran vdout1_27ck179 FIND v(dout1_27) AT=900.025n

* CHECK dout1_28 Vdout1_28ck179 = 0.9 time = 900
.meas tran vdout1_28ck179 FIND v(dout1_28) AT=900.025n

* CHECK dout1_29 Vdout1_29ck179 = 0 time = 900
.meas tran vdout1_29ck179 FIND v(dout1_29) AT=900.025n

* CHECK dout1_30 Vdout1_30ck179 = 0 time = 900
.meas tran vdout1_30ck179 FIND v(dout1_30) AT=900.025n

* CHECK dout1_31 Vdout1_31ck179 = 0 time = 900
.meas tran vdout1_31ck179 FIND v(dout1_31) AT=900.025n

* CHECK dout1_32 Vdout1_32ck179 = 0.9 time = 900
.meas tran vdout1_32ck179 FIND v(dout1_32) AT=900.025n

* CHECK dout1_33 Vdout1_33ck179 = 0 time = 900
.meas tran vdout1_33ck179 FIND v(dout1_33) AT=900.025n

* CHECK dout1_34 Vdout1_34ck179 = 0.9 time = 900
.meas tran vdout1_34ck179 FIND v(dout1_34) AT=900.025n

* CHECK dout1_35 Vdout1_35ck179 = 0.9 time = 900
.meas tran vdout1_35ck179 FIND v(dout1_35) AT=900.025n

* CHECK dout1_36 Vdout1_36ck179 = 0 time = 900
.meas tran vdout1_36ck179 FIND v(dout1_36) AT=900.025n

* CHECK dout1_37 Vdout1_37ck179 = 0.9 time = 900
.meas tran vdout1_37ck179 FIND v(dout1_37) AT=900.025n

* CHECK dout1_38 Vdout1_38ck179 = 0 time = 900
.meas tran vdout1_38ck179 FIND v(dout1_38) AT=900.025n

* CHECK dout1_39 Vdout1_39ck179 = 0 time = 900
.meas tran vdout1_39ck179 FIND v(dout1_39) AT=900.025n

* CHECK dout1_40 Vdout1_40ck179 = 0 time = 900
.meas tran vdout1_40ck179 FIND v(dout1_40) AT=900.025n

* CHECK dout1_41 Vdout1_41ck179 = 0 time = 900
.meas tran vdout1_41ck179 FIND v(dout1_41) AT=900.025n

* CHECK dout1_42 Vdout1_42ck179 = 0 time = 900
.meas tran vdout1_42ck179 FIND v(dout1_42) AT=900.025n

* CHECK dout1_43 Vdout1_43ck179 = 0.9 time = 900
.meas tran vdout1_43ck179 FIND v(dout1_43) AT=900.025n

* CHECK dout1_44 Vdout1_44ck179 = 0 time = 900
.meas tran vdout1_44ck179 FIND v(dout1_44) AT=900.025n

* CHECK dout1_45 Vdout1_45ck179 = 0.9 time = 900
.meas tran vdout1_45ck179 FIND v(dout1_45) AT=900.025n

* CHECK dout1_46 Vdout1_46ck179 = 0.9 time = 900
.meas tran vdout1_46ck179 FIND v(dout1_46) AT=900.025n

* CHECK dout1_47 Vdout1_47ck179 = 0.9 time = 900
.meas tran vdout1_47ck179 FIND v(dout1_47) AT=900.025n

* CHECK dout1_48 Vdout1_48ck179 = 0.9 time = 900
.meas tran vdout1_48ck179 FIND v(dout1_48) AT=900.025n

* CHECK dout1_49 Vdout1_49ck179 = 0 time = 900
.meas tran vdout1_49ck179 FIND v(dout1_49) AT=900.025n

* CHECK dout1_50 Vdout1_50ck179 = 0 time = 900
.meas tran vdout1_50ck179 FIND v(dout1_50) AT=900.025n

* CHECK dout1_51 Vdout1_51ck179 = 0.9 time = 900
.meas tran vdout1_51ck179 FIND v(dout1_51) AT=900.025n

* CHECK dout1_52 Vdout1_52ck179 = 0 time = 900
.meas tran vdout1_52ck179 FIND v(dout1_52) AT=900.025n

* CHECK dout1_53 Vdout1_53ck179 = 0.9 time = 900
.meas tran vdout1_53ck179 FIND v(dout1_53) AT=900.025n

* CHECK dout1_54 Vdout1_54ck179 = 0.9 time = 900
.meas tran vdout1_54ck179 FIND v(dout1_54) AT=900.025n

* CHECK dout1_55 Vdout1_55ck179 = 0.9 time = 900
.meas tran vdout1_55ck179 FIND v(dout1_55) AT=900.025n

* CHECK dout1_56 Vdout1_56ck179 = 0 time = 900
.meas tran vdout1_56ck179 FIND v(dout1_56) AT=900.025n

* CHECK dout1_57 Vdout1_57ck179 = 0.9 time = 900
.meas tran vdout1_57ck179 FIND v(dout1_57) AT=900.025n

* CHECK dout1_58 Vdout1_58ck179 = 0.9 time = 900
.meas tran vdout1_58ck179 FIND v(dout1_58) AT=900.025n

* CHECK dout1_59 Vdout1_59ck179 = 0.9 time = 900
.meas tran vdout1_59ck179 FIND v(dout1_59) AT=900.025n

* CHECK dout1_60 Vdout1_60ck179 = 0 time = 900
.meas tran vdout1_60ck179 FIND v(dout1_60) AT=900.025n

* CHECK dout1_61 Vdout1_61ck179 = 0 time = 900
.meas tran vdout1_61ck179 FIND v(dout1_61) AT=900.025n

* CHECK dout1_62 Vdout1_62ck179 = 0 time = 900
.meas tran vdout1_62ck179 FIND v(dout1_62) AT=900.025n

* CHECK dout1_63 Vdout1_63ck179 = 0.9 time = 900
.meas tran vdout1_63ck179 FIND v(dout1_63) AT=900.025n

* CHECK dout1_64 Vdout1_64ck179 = 0 time = 900
.meas tran vdout1_64ck179 FIND v(dout1_64) AT=900.025n

* CHECK dout1_65 Vdout1_65ck179 = 0 time = 900
.meas tran vdout1_65ck179 FIND v(dout1_65) AT=900.025n

* CHECK dout1_66 Vdout1_66ck179 = 0 time = 900
.meas tran vdout1_66ck179 FIND v(dout1_66) AT=900.025n

* CHECK dout1_67 Vdout1_67ck179 = 0.9 time = 900
.meas tran vdout1_67ck179 FIND v(dout1_67) AT=900.025n

* CHECK dout1_68 Vdout1_68ck179 = 0 time = 900
.meas tran vdout1_68ck179 FIND v(dout1_68) AT=900.025n

* CHECK dout1_69 Vdout1_69ck179 = 0.9 time = 900
.meas tran vdout1_69ck179 FIND v(dout1_69) AT=900.025n

* CHECK dout1_70 Vdout1_70ck179 = 0 time = 900
.meas tran vdout1_70ck179 FIND v(dout1_70) AT=900.025n

* CHECK dout1_71 Vdout1_71ck179 = 0 time = 900
.meas tran vdout1_71ck179 FIND v(dout1_71) AT=900.025n

* CHECK dout1_0 Vdout1_0ck183 = 0 time = 920
.meas tran vdout1_0ck183 FIND v(dout1_0) AT=920.025n

* CHECK dout1_1 Vdout1_1ck183 = 0 time = 920
.meas tran vdout1_1ck183 FIND v(dout1_1) AT=920.025n

* CHECK dout1_2 Vdout1_2ck183 = 0.9 time = 920
.meas tran vdout1_2ck183 FIND v(dout1_2) AT=920.025n

* CHECK dout1_3 Vdout1_3ck183 = 0.9 time = 920
.meas tran vdout1_3ck183 FIND v(dout1_3) AT=920.025n

* CHECK dout1_4 Vdout1_4ck183 = 0 time = 920
.meas tran vdout1_4ck183 FIND v(dout1_4) AT=920.025n

* CHECK dout1_5 Vdout1_5ck183 = 0.9 time = 920
.meas tran vdout1_5ck183 FIND v(dout1_5) AT=920.025n

* CHECK dout1_6 Vdout1_6ck183 = 0.9 time = 920
.meas tran vdout1_6ck183 FIND v(dout1_6) AT=920.025n

* CHECK dout1_7 Vdout1_7ck183 = 0.9 time = 920
.meas tran vdout1_7ck183 FIND v(dout1_7) AT=920.025n

* CHECK dout1_8 Vdout1_8ck183 = 0.9 time = 920
.meas tran vdout1_8ck183 FIND v(dout1_8) AT=920.025n

* CHECK dout1_9 Vdout1_9ck183 = 0.9 time = 920
.meas tran vdout1_9ck183 FIND v(dout1_9) AT=920.025n

* CHECK dout1_10 Vdout1_10ck183 = 0 time = 920
.meas tran vdout1_10ck183 FIND v(dout1_10) AT=920.025n

* CHECK dout1_11 Vdout1_11ck183 = 0 time = 920
.meas tran vdout1_11ck183 FIND v(dout1_11) AT=920.025n

* CHECK dout1_12 Vdout1_12ck183 = 0 time = 920
.meas tran vdout1_12ck183 FIND v(dout1_12) AT=920.025n

* CHECK dout1_13 Vdout1_13ck183 = 0.9 time = 920
.meas tran vdout1_13ck183 FIND v(dout1_13) AT=920.025n

* CHECK dout1_14 Vdout1_14ck183 = 0 time = 920
.meas tran vdout1_14ck183 FIND v(dout1_14) AT=920.025n

* CHECK dout1_15 Vdout1_15ck183 = 0.9 time = 920
.meas tran vdout1_15ck183 FIND v(dout1_15) AT=920.025n

* CHECK dout1_16 Vdout1_16ck183 = 0 time = 920
.meas tran vdout1_16ck183 FIND v(dout1_16) AT=920.025n

* CHECK dout1_17 Vdout1_17ck183 = 0.9 time = 920
.meas tran vdout1_17ck183 FIND v(dout1_17) AT=920.025n

* CHECK dout1_18 Vdout1_18ck183 = 0 time = 920
.meas tran vdout1_18ck183 FIND v(dout1_18) AT=920.025n

* CHECK dout1_19 Vdout1_19ck183 = 0 time = 920
.meas tran vdout1_19ck183 FIND v(dout1_19) AT=920.025n

* CHECK dout1_20 Vdout1_20ck183 = 0 time = 920
.meas tran vdout1_20ck183 FIND v(dout1_20) AT=920.025n

* CHECK dout1_21 Vdout1_21ck183 = 0 time = 920
.meas tran vdout1_21ck183 FIND v(dout1_21) AT=920.025n

* CHECK dout1_22 Vdout1_22ck183 = 0.9 time = 920
.meas tran vdout1_22ck183 FIND v(dout1_22) AT=920.025n

* CHECK dout1_23 Vdout1_23ck183 = 0.9 time = 920
.meas tran vdout1_23ck183 FIND v(dout1_23) AT=920.025n

* CHECK dout1_24 Vdout1_24ck183 = 0 time = 920
.meas tran vdout1_24ck183 FIND v(dout1_24) AT=920.025n

* CHECK dout1_25 Vdout1_25ck183 = 0 time = 920
.meas tran vdout1_25ck183 FIND v(dout1_25) AT=920.025n

* CHECK dout1_26 Vdout1_26ck183 = 0 time = 920
.meas tran vdout1_26ck183 FIND v(dout1_26) AT=920.025n

* CHECK dout1_27 Vdout1_27ck183 = 0.9 time = 920
.meas tran vdout1_27ck183 FIND v(dout1_27) AT=920.025n

* CHECK dout1_28 Vdout1_28ck183 = 0 time = 920
.meas tran vdout1_28ck183 FIND v(dout1_28) AT=920.025n

* CHECK dout1_29 Vdout1_29ck183 = 0.9 time = 920
.meas tran vdout1_29ck183 FIND v(dout1_29) AT=920.025n

* CHECK dout1_30 Vdout1_30ck183 = 0.9 time = 920
.meas tran vdout1_30ck183 FIND v(dout1_30) AT=920.025n

* CHECK dout1_31 Vdout1_31ck183 = 0 time = 920
.meas tran vdout1_31ck183 FIND v(dout1_31) AT=920.025n

* CHECK dout1_32 Vdout1_32ck183 = 0 time = 920
.meas tran vdout1_32ck183 FIND v(dout1_32) AT=920.025n

* CHECK dout1_33 Vdout1_33ck183 = 0 time = 920
.meas tran vdout1_33ck183 FIND v(dout1_33) AT=920.025n

* CHECK dout1_34 Vdout1_34ck183 = 0.9 time = 920
.meas tran vdout1_34ck183 FIND v(dout1_34) AT=920.025n

* CHECK dout1_35 Vdout1_35ck183 = 0 time = 920
.meas tran vdout1_35ck183 FIND v(dout1_35) AT=920.025n

* CHECK dout1_36 Vdout1_36ck183 = 0.9 time = 920
.meas tran vdout1_36ck183 FIND v(dout1_36) AT=920.025n

* CHECK dout1_37 Vdout1_37ck183 = 0 time = 920
.meas tran vdout1_37ck183 FIND v(dout1_37) AT=920.025n

* CHECK dout1_38 Vdout1_38ck183 = 0.9 time = 920
.meas tran vdout1_38ck183 FIND v(dout1_38) AT=920.025n

* CHECK dout1_39 Vdout1_39ck183 = 0.9 time = 920
.meas tran vdout1_39ck183 FIND v(dout1_39) AT=920.025n

* CHECK dout1_40 Vdout1_40ck183 = 0.9 time = 920
.meas tran vdout1_40ck183 FIND v(dout1_40) AT=920.025n

* CHECK dout1_41 Vdout1_41ck183 = 0 time = 920
.meas tran vdout1_41ck183 FIND v(dout1_41) AT=920.025n

* CHECK dout1_42 Vdout1_42ck183 = 0.9 time = 920
.meas tran vdout1_42ck183 FIND v(dout1_42) AT=920.025n

* CHECK dout1_43 Vdout1_43ck183 = 0.9 time = 920
.meas tran vdout1_43ck183 FIND v(dout1_43) AT=920.025n

* CHECK dout1_44 Vdout1_44ck183 = 0.9 time = 920
.meas tran vdout1_44ck183 FIND v(dout1_44) AT=920.025n

* CHECK dout1_45 Vdout1_45ck183 = 0.9 time = 920
.meas tran vdout1_45ck183 FIND v(dout1_45) AT=920.025n

* CHECK dout1_46 Vdout1_46ck183 = 0 time = 920
.meas tran vdout1_46ck183 FIND v(dout1_46) AT=920.025n

* CHECK dout1_47 Vdout1_47ck183 = 0.9 time = 920
.meas tran vdout1_47ck183 FIND v(dout1_47) AT=920.025n

* CHECK dout1_48 Vdout1_48ck183 = 0 time = 920
.meas tran vdout1_48ck183 FIND v(dout1_48) AT=920.025n

* CHECK dout1_49 Vdout1_49ck183 = 0.9 time = 920
.meas tran vdout1_49ck183 FIND v(dout1_49) AT=920.025n

* CHECK dout1_50 Vdout1_50ck183 = 0 time = 920
.meas tran vdout1_50ck183 FIND v(dout1_50) AT=920.025n

* CHECK dout1_51 Vdout1_51ck183 = 0 time = 920
.meas tran vdout1_51ck183 FIND v(dout1_51) AT=920.025n

* CHECK dout1_52 Vdout1_52ck183 = 0 time = 920
.meas tran vdout1_52ck183 FIND v(dout1_52) AT=920.025n

* CHECK dout1_53 Vdout1_53ck183 = 0.9 time = 920
.meas tran vdout1_53ck183 FIND v(dout1_53) AT=920.025n

* CHECK dout1_54 Vdout1_54ck183 = 0 time = 920
.meas tran vdout1_54ck183 FIND v(dout1_54) AT=920.025n

* CHECK dout1_55 Vdout1_55ck183 = 0 time = 920
.meas tran vdout1_55ck183 FIND v(dout1_55) AT=920.025n

* CHECK dout1_56 Vdout1_56ck183 = 0.9 time = 920
.meas tran vdout1_56ck183 FIND v(dout1_56) AT=920.025n

* CHECK dout1_57 Vdout1_57ck183 = 0.9 time = 920
.meas tran vdout1_57ck183 FIND v(dout1_57) AT=920.025n

* CHECK dout1_58 Vdout1_58ck183 = 0 time = 920
.meas tran vdout1_58ck183 FIND v(dout1_58) AT=920.025n

* CHECK dout1_59 Vdout1_59ck183 = 0 time = 920
.meas tran vdout1_59ck183 FIND v(dout1_59) AT=920.025n

* CHECK dout1_60 Vdout1_60ck183 = 0.9 time = 920
.meas tran vdout1_60ck183 FIND v(dout1_60) AT=920.025n

* CHECK dout1_61 Vdout1_61ck183 = 0.9 time = 920
.meas tran vdout1_61ck183 FIND v(dout1_61) AT=920.025n

* CHECK dout1_62 Vdout1_62ck183 = 0 time = 920
.meas tran vdout1_62ck183 FIND v(dout1_62) AT=920.025n

* CHECK dout1_63 Vdout1_63ck183 = 0.9 time = 920
.meas tran vdout1_63ck183 FIND v(dout1_63) AT=920.025n

* CHECK dout1_64 Vdout1_64ck183 = 0.9 time = 920
.meas tran vdout1_64ck183 FIND v(dout1_64) AT=920.025n

* CHECK dout1_65 Vdout1_65ck183 = 0 time = 920
.meas tran vdout1_65ck183 FIND v(dout1_65) AT=920.025n

* CHECK dout1_66 Vdout1_66ck183 = 0 time = 920
.meas tran vdout1_66ck183 FIND v(dout1_66) AT=920.025n

* CHECK dout1_67 Vdout1_67ck183 = 0.9 time = 920
.meas tran vdout1_67ck183 FIND v(dout1_67) AT=920.025n

* CHECK dout1_68 Vdout1_68ck183 = 0.9 time = 920
.meas tran vdout1_68ck183 FIND v(dout1_68) AT=920.025n

* CHECK dout1_69 Vdout1_69ck183 = 0.9 time = 920
.meas tran vdout1_69ck183 FIND v(dout1_69) AT=920.025n

* CHECK dout1_70 Vdout1_70ck183 = 0 time = 920
.meas tran vdout1_70ck183 FIND v(dout1_70) AT=920.025n

* CHECK dout1_71 Vdout1_71ck183 = 0.9 time = 920
.meas tran vdout1_71ck183 FIND v(dout1_71) AT=920.025n

* CHECK dout1_0 Vdout1_0ck190 = 0.9 time = 955
.meas tran vdout1_0ck190 FIND v(dout1_0) AT=955.025n

* CHECK dout1_1 Vdout1_1ck190 = 0.9 time = 955
.meas tran vdout1_1ck190 FIND v(dout1_1) AT=955.025n

* CHECK dout1_2 Vdout1_2ck190 = 0 time = 955
.meas tran vdout1_2ck190 FIND v(dout1_2) AT=955.025n

* CHECK dout1_3 Vdout1_3ck190 = 0.9 time = 955
.meas tran vdout1_3ck190 FIND v(dout1_3) AT=955.025n

* CHECK dout1_4 Vdout1_4ck190 = 0 time = 955
.meas tran vdout1_4ck190 FIND v(dout1_4) AT=955.025n

* CHECK dout1_5 Vdout1_5ck190 = 0.9 time = 955
.meas tran vdout1_5ck190 FIND v(dout1_5) AT=955.025n

* CHECK dout1_6 Vdout1_6ck190 = 0.9 time = 955
.meas tran vdout1_6ck190 FIND v(dout1_6) AT=955.025n

* CHECK dout1_7 Vdout1_7ck190 = 0.9 time = 955
.meas tran vdout1_7ck190 FIND v(dout1_7) AT=955.025n

* CHECK dout1_8 Vdout1_8ck190 = 0.9 time = 955
.meas tran vdout1_8ck190 FIND v(dout1_8) AT=955.025n

* CHECK dout1_9 Vdout1_9ck190 = 0 time = 955
.meas tran vdout1_9ck190 FIND v(dout1_9) AT=955.025n

* CHECK dout1_10 Vdout1_10ck190 = 0 time = 955
.meas tran vdout1_10ck190 FIND v(dout1_10) AT=955.025n

* CHECK dout1_11 Vdout1_11ck190 = 0.9 time = 955
.meas tran vdout1_11ck190 FIND v(dout1_11) AT=955.025n

* CHECK dout1_12 Vdout1_12ck190 = 0.9 time = 955
.meas tran vdout1_12ck190 FIND v(dout1_12) AT=955.025n

* CHECK dout1_13 Vdout1_13ck190 = 0.9 time = 955
.meas tran vdout1_13ck190 FIND v(dout1_13) AT=955.025n

* CHECK dout1_14 Vdout1_14ck190 = 0.9 time = 955
.meas tran vdout1_14ck190 FIND v(dout1_14) AT=955.025n

* CHECK dout1_15 Vdout1_15ck190 = 0.9 time = 955
.meas tran vdout1_15ck190 FIND v(dout1_15) AT=955.025n

* CHECK dout1_16 Vdout1_16ck190 = 0.9 time = 955
.meas tran vdout1_16ck190 FIND v(dout1_16) AT=955.025n

* CHECK dout1_17 Vdout1_17ck190 = 0.9 time = 955
.meas tran vdout1_17ck190 FIND v(dout1_17) AT=955.025n

* CHECK dout1_18 Vdout1_18ck190 = 0.9 time = 955
.meas tran vdout1_18ck190 FIND v(dout1_18) AT=955.025n

* CHECK dout1_19 Vdout1_19ck190 = 0.9 time = 955
.meas tran vdout1_19ck190 FIND v(dout1_19) AT=955.025n

* CHECK dout1_20 Vdout1_20ck190 = 0.9 time = 955
.meas tran vdout1_20ck190 FIND v(dout1_20) AT=955.025n

* CHECK dout1_21 Vdout1_21ck190 = 0 time = 955
.meas tran vdout1_21ck190 FIND v(dout1_21) AT=955.025n

* CHECK dout1_22 Vdout1_22ck190 = 0.9 time = 955
.meas tran vdout1_22ck190 FIND v(dout1_22) AT=955.025n

* CHECK dout1_23 Vdout1_23ck190 = 0 time = 955
.meas tran vdout1_23ck190 FIND v(dout1_23) AT=955.025n

* CHECK dout1_24 Vdout1_24ck190 = 0.9 time = 955
.meas tran vdout1_24ck190 FIND v(dout1_24) AT=955.025n

* CHECK dout1_25 Vdout1_25ck190 = 0.9 time = 955
.meas tran vdout1_25ck190 FIND v(dout1_25) AT=955.025n

* CHECK dout1_26 Vdout1_26ck190 = 0.9 time = 955
.meas tran vdout1_26ck190 FIND v(dout1_26) AT=955.025n

* CHECK dout1_27 Vdout1_27ck190 = 0.9 time = 955
.meas tran vdout1_27ck190 FIND v(dout1_27) AT=955.025n

* CHECK dout1_28 Vdout1_28ck190 = 0.9 time = 955
.meas tran vdout1_28ck190 FIND v(dout1_28) AT=955.025n

* CHECK dout1_29 Vdout1_29ck190 = 0.9 time = 955
.meas tran vdout1_29ck190 FIND v(dout1_29) AT=955.025n

* CHECK dout1_30 Vdout1_30ck190 = 0.9 time = 955
.meas tran vdout1_30ck190 FIND v(dout1_30) AT=955.025n

* CHECK dout1_31 Vdout1_31ck190 = 0.9 time = 955
.meas tran vdout1_31ck190 FIND v(dout1_31) AT=955.025n

* CHECK dout1_32 Vdout1_32ck190 = 0.9 time = 955
.meas tran vdout1_32ck190 FIND v(dout1_32) AT=955.025n

* CHECK dout1_33 Vdout1_33ck190 = 0.9 time = 955
.meas tran vdout1_33ck190 FIND v(dout1_33) AT=955.025n

* CHECK dout1_34 Vdout1_34ck190 = 0.9 time = 955
.meas tran vdout1_34ck190 FIND v(dout1_34) AT=955.025n

* CHECK dout1_35 Vdout1_35ck190 = 0.9 time = 955
.meas tran vdout1_35ck190 FIND v(dout1_35) AT=955.025n

* CHECK dout1_36 Vdout1_36ck190 = 0.9 time = 955
.meas tran vdout1_36ck190 FIND v(dout1_36) AT=955.025n

* CHECK dout1_37 Vdout1_37ck190 = 0.9 time = 955
.meas tran vdout1_37ck190 FIND v(dout1_37) AT=955.025n

* CHECK dout1_38 Vdout1_38ck190 = 0 time = 955
.meas tran vdout1_38ck190 FIND v(dout1_38) AT=955.025n

* CHECK dout1_39 Vdout1_39ck190 = 0 time = 955
.meas tran vdout1_39ck190 FIND v(dout1_39) AT=955.025n

* CHECK dout1_40 Vdout1_40ck190 = 0 time = 955
.meas tran vdout1_40ck190 FIND v(dout1_40) AT=955.025n

* CHECK dout1_41 Vdout1_41ck190 = 0 time = 955
.meas tran vdout1_41ck190 FIND v(dout1_41) AT=955.025n

* CHECK dout1_42 Vdout1_42ck190 = 0 time = 955
.meas tran vdout1_42ck190 FIND v(dout1_42) AT=955.025n

* CHECK dout1_43 Vdout1_43ck190 = 0 time = 955
.meas tran vdout1_43ck190 FIND v(dout1_43) AT=955.025n

* CHECK dout1_44 Vdout1_44ck190 = 0 time = 955
.meas tran vdout1_44ck190 FIND v(dout1_44) AT=955.025n

* CHECK dout1_45 Vdout1_45ck190 = 0 time = 955
.meas tran vdout1_45ck190 FIND v(dout1_45) AT=955.025n

* CHECK dout1_46 Vdout1_46ck190 = 0 time = 955
.meas tran vdout1_46ck190 FIND v(dout1_46) AT=955.025n

* CHECK dout1_47 Vdout1_47ck190 = 0 time = 955
.meas tran vdout1_47ck190 FIND v(dout1_47) AT=955.025n

* CHECK dout1_48 Vdout1_48ck190 = 0.9 time = 955
.meas tran vdout1_48ck190 FIND v(dout1_48) AT=955.025n

* CHECK dout1_49 Vdout1_49ck190 = 0 time = 955
.meas tran vdout1_49ck190 FIND v(dout1_49) AT=955.025n

* CHECK dout1_50 Vdout1_50ck190 = 0 time = 955
.meas tran vdout1_50ck190 FIND v(dout1_50) AT=955.025n

* CHECK dout1_51 Vdout1_51ck190 = 0 time = 955
.meas tran vdout1_51ck190 FIND v(dout1_51) AT=955.025n

* CHECK dout1_52 Vdout1_52ck190 = 0 time = 955
.meas tran vdout1_52ck190 FIND v(dout1_52) AT=955.025n

* CHECK dout1_53 Vdout1_53ck190 = 0.9 time = 955
.meas tran vdout1_53ck190 FIND v(dout1_53) AT=955.025n

* CHECK dout1_54 Vdout1_54ck190 = 0 time = 955
.meas tran vdout1_54ck190 FIND v(dout1_54) AT=955.025n

* CHECK dout1_55 Vdout1_55ck190 = 0 time = 955
.meas tran vdout1_55ck190 FIND v(dout1_55) AT=955.025n

* CHECK dout1_56 Vdout1_56ck190 = 0 time = 955
.meas tran vdout1_56ck190 FIND v(dout1_56) AT=955.025n

* CHECK dout1_57 Vdout1_57ck190 = 0.9 time = 955
.meas tran vdout1_57ck190 FIND v(dout1_57) AT=955.025n

* CHECK dout1_58 Vdout1_58ck190 = 0.9 time = 955
.meas tran vdout1_58ck190 FIND v(dout1_58) AT=955.025n

* CHECK dout1_59 Vdout1_59ck190 = 0 time = 955
.meas tran vdout1_59ck190 FIND v(dout1_59) AT=955.025n

* CHECK dout1_60 Vdout1_60ck190 = 0.9 time = 955
.meas tran vdout1_60ck190 FIND v(dout1_60) AT=955.025n

* CHECK dout1_61 Vdout1_61ck190 = 0 time = 955
.meas tran vdout1_61ck190 FIND v(dout1_61) AT=955.025n

* CHECK dout1_62 Vdout1_62ck190 = 0.9 time = 955
.meas tran vdout1_62ck190 FIND v(dout1_62) AT=955.025n

* CHECK dout1_63 Vdout1_63ck190 = 0.9 time = 955
.meas tran vdout1_63ck190 FIND v(dout1_63) AT=955.025n

* CHECK dout1_64 Vdout1_64ck190 = 0.9 time = 955
.meas tran vdout1_64ck190 FIND v(dout1_64) AT=955.025n

* CHECK dout1_65 Vdout1_65ck190 = 0 time = 955
.meas tran vdout1_65ck190 FIND v(dout1_65) AT=955.025n

* CHECK dout1_66 Vdout1_66ck190 = 0 time = 955
.meas tran vdout1_66ck190 FIND v(dout1_66) AT=955.025n

* CHECK dout1_67 Vdout1_67ck190 = 0 time = 955
.meas tran vdout1_67ck190 FIND v(dout1_67) AT=955.025n

* CHECK dout1_68 Vdout1_68ck190 = 0.9 time = 955
.meas tran vdout1_68ck190 FIND v(dout1_68) AT=955.025n

* CHECK dout1_69 Vdout1_69ck190 = 0 time = 955
.meas tran vdout1_69ck190 FIND v(dout1_69) AT=955.025n

* CHECK dout1_70 Vdout1_70ck190 = 0 time = 955
.meas tran vdout1_70ck190 FIND v(dout1_70) AT=955.025n

* CHECK dout1_71 Vdout1_71ck190 = 0 time = 955
.meas tran vdout1_71ck190 FIND v(dout1_71) AT=955.025n

* CHECK dout1_0 Vdout1_0ck191 = 0.9 time = 960
.meas tran vdout1_0ck191 FIND v(dout1_0) AT=960.025n

* CHECK dout1_1 Vdout1_1ck191 = 0.9 time = 960
.meas tran vdout1_1ck191 FIND v(dout1_1) AT=960.025n

* CHECK dout1_2 Vdout1_2ck191 = 0 time = 960
.meas tran vdout1_2ck191 FIND v(dout1_2) AT=960.025n

* CHECK dout1_3 Vdout1_3ck191 = 0.9 time = 960
.meas tran vdout1_3ck191 FIND v(dout1_3) AT=960.025n

* CHECK dout1_4 Vdout1_4ck191 = 0 time = 960
.meas tran vdout1_4ck191 FIND v(dout1_4) AT=960.025n

* CHECK dout1_5 Vdout1_5ck191 = 0.9 time = 960
.meas tran vdout1_5ck191 FIND v(dout1_5) AT=960.025n

* CHECK dout1_6 Vdout1_6ck191 = 0.9 time = 960
.meas tran vdout1_6ck191 FIND v(dout1_6) AT=960.025n

* CHECK dout1_7 Vdout1_7ck191 = 0.9 time = 960
.meas tran vdout1_7ck191 FIND v(dout1_7) AT=960.025n

* CHECK dout1_8 Vdout1_8ck191 = 0.9 time = 960
.meas tran vdout1_8ck191 FIND v(dout1_8) AT=960.025n

* CHECK dout1_9 Vdout1_9ck191 = 0 time = 960
.meas tran vdout1_9ck191 FIND v(dout1_9) AT=960.025n

* CHECK dout1_10 Vdout1_10ck191 = 0 time = 960
.meas tran vdout1_10ck191 FIND v(dout1_10) AT=960.025n

* CHECK dout1_11 Vdout1_11ck191 = 0.9 time = 960
.meas tran vdout1_11ck191 FIND v(dout1_11) AT=960.025n

* CHECK dout1_12 Vdout1_12ck191 = 0.9 time = 960
.meas tran vdout1_12ck191 FIND v(dout1_12) AT=960.025n

* CHECK dout1_13 Vdout1_13ck191 = 0.9 time = 960
.meas tran vdout1_13ck191 FIND v(dout1_13) AT=960.025n

* CHECK dout1_14 Vdout1_14ck191 = 0.9 time = 960
.meas tran vdout1_14ck191 FIND v(dout1_14) AT=960.025n

* CHECK dout1_15 Vdout1_15ck191 = 0.9 time = 960
.meas tran vdout1_15ck191 FIND v(dout1_15) AT=960.025n

* CHECK dout1_16 Vdout1_16ck191 = 0.9 time = 960
.meas tran vdout1_16ck191 FIND v(dout1_16) AT=960.025n

* CHECK dout1_17 Vdout1_17ck191 = 0.9 time = 960
.meas tran vdout1_17ck191 FIND v(dout1_17) AT=960.025n

* CHECK dout1_18 Vdout1_18ck191 = 0.9 time = 960
.meas tran vdout1_18ck191 FIND v(dout1_18) AT=960.025n

* CHECK dout1_19 Vdout1_19ck191 = 0.9 time = 960
.meas tran vdout1_19ck191 FIND v(dout1_19) AT=960.025n

* CHECK dout1_20 Vdout1_20ck191 = 0.9 time = 960
.meas tran vdout1_20ck191 FIND v(dout1_20) AT=960.025n

* CHECK dout1_21 Vdout1_21ck191 = 0 time = 960
.meas tran vdout1_21ck191 FIND v(dout1_21) AT=960.025n

* CHECK dout1_22 Vdout1_22ck191 = 0.9 time = 960
.meas tran vdout1_22ck191 FIND v(dout1_22) AT=960.025n

* CHECK dout1_23 Vdout1_23ck191 = 0 time = 960
.meas tran vdout1_23ck191 FIND v(dout1_23) AT=960.025n

* CHECK dout1_24 Vdout1_24ck191 = 0.9 time = 960
.meas tran vdout1_24ck191 FIND v(dout1_24) AT=960.025n

* CHECK dout1_25 Vdout1_25ck191 = 0.9 time = 960
.meas tran vdout1_25ck191 FIND v(dout1_25) AT=960.025n

* CHECK dout1_26 Vdout1_26ck191 = 0.9 time = 960
.meas tran vdout1_26ck191 FIND v(dout1_26) AT=960.025n

* CHECK dout1_27 Vdout1_27ck191 = 0.9 time = 960
.meas tran vdout1_27ck191 FIND v(dout1_27) AT=960.025n

* CHECK dout1_28 Vdout1_28ck191 = 0.9 time = 960
.meas tran vdout1_28ck191 FIND v(dout1_28) AT=960.025n

* CHECK dout1_29 Vdout1_29ck191 = 0.9 time = 960
.meas tran vdout1_29ck191 FIND v(dout1_29) AT=960.025n

* CHECK dout1_30 Vdout1_30ck191 = 0.9 time = 960
.meas tran vdout1_30ck191 FIND v(dout1_30) AT=960.025n

* CHECK dout1_31 Vdout1_31ck191 = 0.9 time = 960
.meas tran vdout1_31ck191 FIND v(dout1_31) AT=960.025n

* CHECK dout1_32 Vdout1_32ck191 = 0.9 time = 960
.meas tran vdout1_32ck191 FIND v(dout1_32) AT=960.025n

* CHECK dout1_33 Vdout1_33ck191 = 0.9 time = 960
.meas tran vdout1_33ck191 FIND v(dout1_33) AT=960.025n

* CHECK dout1_34 Vdout1_34ck191 = 0.9 time = 960
.meas tran vdout1_34ck191 FIND v(dout1_34) AT=960.025n

* CHECK dout1_35 Vdout1_35ck191 = 0.9 time = 960
.meas tran vdout1_35ck191 FIND v(dout1_35) AT=960.025n

* CHECK dout1_36 Vdout1_36ck191 = 0.9 time = 960
.meas tran vdout1_36ck191 FIND v(dout1_36) AT=960.025n

* CHECK dout1_37 Vdout1_37ck191 = 0.9 time = 960
.meas tran vdout1_37ck191 FIND v(dout1_37) AT=960.025n

* CHECK dout1_38 Vdout1_38ck191 = 0 time = 960
.meas tran vdout1_38ck191 FIND v(dout1_38) AT=960.025n

* CHECK dout1_39 Vdout1_39ck191 = 0 time = 960
.meas tran vdout1_39ck191 FIND v(dout1_39) AT=960.025n

* CHECK dout1_40 Vdout1_40ck191 = 0 time = 960
.meas tran vdout1_40ck191 FIND v(dout1_40) AT=960.025n

* CHECK dout1_41 Vdout1_41ck191 = 0 time = 960
.meas tran vdout1_41ck191 FIND v(dout1_41) AT=960.025n

* CHECK dout1_42 Vdout1_42ck191 = 0 time = 960
.meas tran vdout1_42ck191 FIND v(dout1_42) AT=960.025n

* CHECK dout1_43 Vdout1_43ck191 = 0 time = 960
.meas tran vdout1_43ck191 FIND v(dout1_43) AT=960.025n

* CHECK dout1_44 Vdout1_44ck191 = 0 time = 960
.meas tran vdout1_44ck191 FIND v(dout1_44) AT=960.025n

* CHECK dout1_45 Vdout1_45ck191 = 0 time = 960
.meas tran vdout1_45ck191 FIND v(dout1_45) AT=960.025n

* CHECK dout1_46 Vdout1_46ck191 = 0 time = 960
.meas tran vdout1_46ck191 FIND v(dout1_46) AT=960.025n

* CHECK dout1_47 Vdout1_47ck191 = 0 time = 960
.meas tran vdout1_47ck191 FIND v(dout1_47) AT=960.025n

* CHECK dout1_48 Vdout1_48ck191 = 0.9 time = 960
.meas tran vdout1_48ck191 FIND v(dout1_48) AT=960.025n

* CHECK dout1_49 Vdout1_49ck191 = 0 time = 960
.meas tran vdout1_49ck191 FIND v(dout1_49) AT=960.025n

* CHECK dout1_50 Vdout1_50ck191 = 0 time = 960
.meas tran vdout1_50ck191 FIND v(dout1_50) AT=960.025n

* CHECK dout1_51 Vdout1_51ck191 = 0 time = 960
.meas tran vdout1_51ck191 FIND v(dout1_51) AT=960.025n

* CHECK dout1_52 Vdout1_52ck191 = 0 time = 960
.meas tran vdout1_52ck191 FIND v(dout1_52) AT=960.025n

* CHECK dout1_53 Vdout1_53ck191 = 0.9 time = 960
.meas tran vdout1_53ck191 FIND v(dout1_53) AT=960.025n

* CHECK dout1_54 Vdout1_54ck191 = 0 time = 960
.meas tran vdout1_54ck191 FIND v(dout1_54) AT=960.025n

* CHECK dout1_55 Vdout1_55ck191 = 0 time = 960
.meas tran vdout1_55ck191 FIND v(dout1_55) AT=960.025n

* CHECK dout1_56 Vdout1_56ck191 = 0 time = 960
.meas tran vdout1_56ck191 FIND v(dout1_56) AT=960.025n

* CHECK dout1_57 Vdout1_57ck191 = 0.9 time = 960
.meas tran vdout1_57ck191 FIND v(dout1_57) AT=960.025n

* CHECK dout1_58 Vdout1_58ck191 = 0.9 time = 960
.meas tran vdout1_58ck191 FIND v(dout1_58) AT=960.025n

* CHECK dout1_59 Vdout1_59ck191 = 0 time = 960
.meas tran vdout1_59ck191 FIND v(dout1_59) AT=960.025n

* CHECK dout1_60 Vdout1_60ck191 = 0.9 time = 960
.meas tran vdout1_60ck191 FIND v(dout1_60) AT=960.025n

* CHECK dout1_61 Vdout1_61ck191 = 0 time = 960
.meas tran vdout1_61ck191 FIND v(dout1_61) AT=960.025n

* CHECK dout1_62 Vdout1_62ck191 = 0.9 time = 960
.meas tran vdout1_62ck191 FIND v(dout1_62) AT=960.025n

* CHECK dout1_63 Vdout1_63ck191 = 0.9 time = 960
.meas tran vdout1_63ck191 FIND v(dout1_63) AT=960.025n

* CHECK dout1_64 Vdout1_64ck191 = 0.9 time = 960
.meas tran vdout1_64ck191 FIND v(dout1_64) AT=960.025n

* CHECK dout1_65 Vdout1_65ck191 = 0 time = 960
.meas tran vdout1_65ck191 FIND v(dout1_65) AT=960.025n

* CHECK dout1_66 Vdout1_66ck191 = 0 time = 960
.meas tran vdout1_66ck191 FIND v(dout1_66) AT=960.025n

* CHECK dout1_67 Vdout1_67ck191 = 0 time = 960
.meas tran vdout1_67ck191 FIND v(dout1_67) AT=960.025n

* CHECK dout1_68 Vdout1_68ck191 = 0.9 time = 960
.meas tran vdout1_68ck191 FIND v(dout1_68) AT=960.025n

* CHECK dout1_69 Vdout1_69ck191 = 0 time = 960
.meas tran vdout1_69ck191 FIND v(dout1_69) AT=960.025n

* CHECK dout1_70 Vdout1_70ck191 = 0 time = 960
.meas tran vdout1_70ck191 FIND v(dout1_70) AT=960.025n

* CHECK dout1_71 Vdout1_71ck191 = 0 time = 960
.meas tran vdout1_71ck191 FIND v(dout1_71) AT=960.025n

* CHECK dout1_0 Vdout1_0ck192 = 0.9 time = 965
.meas tran vdout1_0ck192 FIND v(dout1_0) AT=965.025n

* CHECK dout1_1 Vdout1_1ck192 = 0 time = 965
.meas tran vdout1_1ck192 FIND v(dout1_1) AT=965.025n

* CHECK dout1_2 Vdout1_2ck192 = 0.9 time = 965
.meas tran vdout1_2ck192 FIND v(dout1_2) AT=965.025n

* CHECK dout1_3 Vdout1_3ck192 = 0 time = 965
.meas tran vdout1_3ck192 FIND v(dout1_3) AT=965.025n

* CHECK dout1_4 Vdout1_4ck192 = 0.9 time = 965
.meas tran vdout1_4ck192 FIND v(dout1_4) AT=965.025n

* CHECK dout1_5 Vdout1_5ck192 = 0.9 time = 965
.meas tran vdout1_5ck192 FIND v(dout1_5) AT=965.025n

* CHECK dout1_6 Vdout1_6ck192 = 0 time = 965
.meas tran vdout1_6ck192 FIND v(dout1_6) AT=965.025n

* CHECK dout1_7 Vdout1_7ck192 = 0.9 time = 965
.meas tran vdout1_7ck192 FIND v(dout1_7) AT=965.025n

* CHECK dout1_8 Vdout1_8ck192 = 0 time = 965
.meas tran vdout1_8ck192 FIND v(dout1_8) AT=965.025n

* CHECK dout1_9 Vdout1_9ck192 = 0.9 time = 965
.meas tran vdout1_9ck192 FIND v(dout1_9) AT=965.025n

* CHECK dout1_10 Vdout1_10ck192 = 0 time = 965
.meas tran vdout1_10ck192 FIND v(dout1_10) AT=965.025n

* CHECK dout1_11 Vdout1_11ck192 = 0.9 time = 965
.meas tran vdout1_11ck192 FIND v(dout1_11) AT=965.025n

* CHECK dout1_12 Vdout1_12ck192 = 0 time = 965
.meas tran vdout1_12ck192 FIND v(dout1_12) AT=965.025n

* CHECK dout1_13 Vdout1_13ck192 = 0.9 time = 965
.meas tran vdout1_13ck192 FIND v(dout1_13) AT=965.025n

* CHECK dout1_14 Vdout1_14ck192 = 0.9 time = 965
.meas tran vdout1_14ck192 FIND v(dout1_14) AT=965.025n

* CHECK dout1_15 Vdout1_15ck192 = 0.9 time = 965
.meas tran vdout1_15ck192 FIND v(dout1_15) AT=965.025n

* CHECK dout1_16 Vdout1_16ck192 = 0 time = 965
.meas tran vdout1_16ck192 FIND v(dout1_16) AT=965.025n

* CHECK dout1_17 Vdout1_17ck192 = 0.9 time = 965
.meas tran vdout1_17ck192 FIND v(dout1_17) AT=965.025n

* CHECK dout1_18 Vdout1_18ck192 = 0.9 time = 965
.meas tran vdout1_18ck192 FIND v(dout1_18) AT=965.025n

* CHECK dout1_19 Vdout1_19ck192 = 0.9 time = 965
.meas tran vdout1_19ck192 FIND v(dout1_19) AT=965.025n

* CHECK dout1_20 Vdout1_20ck192 = 0.9 time = 965
.meas tran vdout1_20ck192 FIND v(dout1_20) AT=965.025n

* CHECK dout1_21 Vdout1_21ck192 = 0 time = 965
.meas tran vdout1_21ck192 FIND v(dout1_21) AT=965.025n

* CHECK dout1_22 Vdout1_22ck192 = 0.9 time = 965
.meas tran vdout1_22ck192 FIND v(dout1_22) AT=965.025n

* CHECK dout1_23 Vdout1_23ck192 = 0 time = 965
.meas tran vdout1_23ck192 FIND v(dout1_23) AT=965.025n

* CHECK dout1_24 Vdout1_24ck192 = 0 time = 965
.meas tran vdout1_24ck192 FIND v(dout1_24) AT=965.025n

* CHECK dout1_25 Vdout1_25ck192 = 0 time = 965
.meas tran vdout1_25ck192 FIND v(dout1_25) AT=965.025n

* CHECK dout1_26 Vdout1_26ck192 = 0 time = 965
.meas tran vdout1_26ck192 FIND v(dout1_26) AT=965.025n

* CHECK dout1_27 Vdout1_27ck192 = 0 time = 965
.meas tran vdout1_27ck192 FIND v(dout1_27) AT=965.025n

* CHECK dout1_28 Vdout1_28ck192 = 0.9 time = 965
.meas tran vdout1_28ck192 FIND v(dout1_28) AT=965.025n

* CHECK dout1_29 Vdout1_29ck192 = 0 time = 965
.meas tran vdout1_29ck192 FIND v(dout1_29) AT=965.025n

* CHECK dout1_30 Vdout1_30ck192 = 0 time = 965
.meas tran vdout1_30ck192 FIND v(dout1_30) AT=965.025n

* CHECK dout1_31 Vdout1_31ck192 = 0 time = 965
.meas tran vdout1_31ck192 FIND v(dout1_31) AT=965.025n

* CHECK dout1_32 Vdout1_32ck192 = 0.9 time = 965
.meas tran vdout1_32ck192 FIND v(dout1_32) AT=965.025n

* CHECK dout1_33 Vdout1_33ck192 = 0 time = 965
.meas tran vdout1_33ck192 FIND v(dout1_33) AT=965.025n

* CHECK dout1_34 Vdout1_34ck192 = 0.9 time = 965
.meas tran vdout1_34ck192 FIND v(dout1_34) AT=965.025n

* CHECK dout1_35 Vdout1_35ck192 = 0 time = 965
.meas tran vdout1_35ck192 FIND v(dout1_35) AT=965.025n

* CHECK dout1_36 Vdout1_36ck192 = 0.9 time = 965
.meas tran vdout1_36ck192 FIND v(dout1_36) AT=965.025n

* CHECK dout1_37 Vdout1_37ck192 = 0 time = 965
.meas tran vdout1_37ck192 FIND v(dout1_37) AT=965.025n

* CHECK dout1_38 Vdout1_38ck192 = 0 time = 965
.meas tran vdout1_38ck192 FIND v(dout1_38) AT=965.025n

* CHECK dout1_39 Vdout1_39ck192 = 0.9 time = 965
.meas tran vdout1_39ck192 FIND v(dout1_39) AT=965.025n

* CHECK dout1_40 Vdout1_40ck192 = 0 time = 965
.meas tran vdout1_40ck192 FIND v(dout1_40) AT=965.025n

* CHECK dout1_41 Vdout1_41ck192 = 0.9 time = 965
.meas tran vdout1_41ck192 FIND v(dout1_41) AT=965.025n

* CHECK dout1_42 Vdout1_42ck192 = 0.9 time = 965
.meas tran vdout1_42ck192 FIND v(dout1_42) AT=965.025n

* CHECK dout1_43 Vdout1_43ck192 = 0 time = 965
.meas tran vdout1_43ck192 FIND v(dout1_43) AT=965.025n

* CHECK dout1_44 Vdout1_44ck192 = 0 time = 965
.meas tran vdout1_44ck192 FIND v(dout1_44) AT=965.025n

* CHECK dout1_45 Vdout1_45ck192 = 0 time = 965
.meas tran vdout1_45ck192 FIND v(dout1_45) AT=965.025n

* CHECK dout1_46 Vdout1_46ck192 = 0.9 time = 965
.meas tran vdout1_46ck192 FIND v(dout1_46) AT=965.025n

* CHECK dout1_47 Vdout1_47ck192 = 0 time = 965
.meas tran vdout1_47ck192 FIND v(dout1_47) AT=965.025n

* CHECK dout1_48 Vdout1_48ck192 = 0.9 time = 965
.meas tran vdout1_48ck192 FIND v(dout1_48) AT=965.025n

* CHECK dout1_49 Vdout1_49ck192 = 0.9 time = 965
.meas tran vdout1_49ck192 FIND v(dout1_49) AT=965.025n

* CHECK dout1_50 Vdout1_50ck192 = 0 time = 965
.meas tran vdout1_50ck192 FIND v(dout1_50) AT=965.025n

* CHECK dout1_51 Vdout1_51ck192 = 0 time = 965
.meas tran vdout1_51ck192 FIND v(dout1_51) AT=965.025n

* CHECK dout1_52 Vdout1_52ck192 = 0 time = 965
.meas tran vdout1_52ck192 FIND v(dout1_52) AT=965.025n

* CHECK dout1_53 Vdout1_53ck192 = 0.9 time = 965
.meas tran vdout1_53ck192 FIND v(dout1_53) AT=965.025n

* CHECK dout1_54 Vdout1_54ck192 = 0 time = 965
.meas tran vdout1_54ck192 FIND v(dout1_54) AT=965.025n

* CHECK dout1_55 Vdout1_55ck192 = 0 time = 965
.meas tran vdout1_55ck192 FIND v(dout1_55) AT=965.025n

* CHECK dout1_56 Vdout1_56ck192 = 0.9 time = 965
.meas tran vdout1_56ck192 FIND v(dout1_56) AT=965.025n

* CHECK dout1_57 Vdout1_57ck192 = 0.9 time = 965
.meas tran vdout1_57ck192 FIND v(dout1_57) AT=965.025n

* CHECK dout1_58 Vdout1_58ck192 = 0.9 time = 965
.meas tran vdout1_58ck192 FIND v(dout1_58) AT=965.025n

* CHECK dout1_59 Vdout1_59ck192 = 0.9 time = 965
.meas tran vdout1_59ck192 FIND v(dout1_59) AT=965.025n

* CHECK dout1_60 Vdout1_60ck192 = 0 time = 965
.meas tran vdout1_60ck192 FIND v(dout1_60) AT=965.025n

* CHECK dout1_61 Vdout1_61ck192 = 0 time = 965
.meas tran vdout1_61ck192 FIND v(dout1_61) AT=965.025n

* CHECK dout1_62 Vdout1_62ck192 = 0.9 time = 965
.meas tran vdout1_62ck192 FIND v(dout1_62) AT=965.025n

* CHECK dout1_63 Vdout1_63ck192 = 0 time = 965
.meas tran vdout1_63ck192 FIND v(dout1_63) AT=965.025n

* CHECK dout1_64 Vdout1_64ck192 = 0 time = 965
.meas tran vdout1_64ck192 FIND v(dout1_64) AT=965.025n

* CHECK dout1_65 Vdout1_65ck192 = 0 time = 965
.meas tran vdout1_65ck192 FIND v(dout1_65) AT=965.025n

* CHECK dout1_66 Vdout1_66ck192 = 0.9 time = 965
.meas tran vdout1_66ck192 FIND v(dout1_66) AT=965.025n

* CHECK dout1_67 Vdout1_67ck192 = 0.9 time = 965
.meas tran vdout1_67ck192 FIND v(dout1_67) AT=965.025n

* CHECK dout1_68 Vdout1_68ck192 = 0 time = 965
.meas tran vdout1_68ck192 FIND v(dout1_68) AT=965.025n

* CHECK dout1_69 Vdout1_69ck192 = 0.9 time = 965
.meas tran vdout1_69ck192 FIND v(dout1_69) AT=965.025n

* CHECK dout1_70 Vdout1_70ck192 = 0.9 time = 965
.meas tran vdout1_70ck192 FIND v(dout1_70) AT=965.025n

* CHECK dout1_71 Vdout1_71ck192 = 0.9 time = 965
.meas tran vdout1_71ck192 FIND v(dout1_71) AT=965.025n

* CHECK dout1_0 Vdout1_0ck194 = 0.9 time = 975
.meas tran vdout1_0ck194 FIND v(dout1_0) AT=975.025n

* CHECK dout1_1 Vdout1_1ck194 = 0 time = 975
.meas tran vdout1_1ck194 FIND v(dout1_1) AT=975.025n

* CHECK dout1_2 Vdout1_2ck194 = 0.9 time = 975
.meas tran vdout1_2ck194 FIND v(dout1_2) AT=975.025n

* CHECK dout1_3 Vdout1_3ck194 = 0.9 time = 975
.meas tran vdout1_3ck194 FIND v(dout1_3) AT=975.025n

* CHECK dout1_4 Vdout1_4ck194 = 0 time = 975
.meas tran vdout1_4ck194 FIND v(dout1_4) AT=975.025n

* CHECK dout1_5 Vdout1_5ck194 = 0 time = 975
.meas tran vdout1_5ck194 FIND v(dout1_5) AT=975.025n

* CHECK dout1_6 Vdout1_6ck194 = 0.9 time = 975
.meas tran vdout1_6ck194 FIND v(dout1_6) AT=975.025n

* CHECK dout1_7 Vdout1_7ck194 = 0 time = 975
.meas tran vdout1_7ck194 FIND v(dout1_7) AT=975.025n

* CHECK dout1_8 Vdout1_8ck194 = 0.9 time = 975
.meas tran vdout1_8ck194 FIND v(dout1_8) AT=975.025n

* CHECK dout1_9 Vdout1_9ck194 = 0.9 time = 975
.meas tran vdout1_9ck194 FIND v(dout1_9) AT=975.025n

* CHECK dout1_10 Vdout1_10ck194 = 0.9 time = 975
.meas tran vdout1_10ck194 FIND v(dout1_10) AT=975.025n

* CHECK dout1_11 Vdout1_11ck194 = 0.9 time = 975
.meas tran vdout1_11ck194 FIND v(dout1_11) AT=975.025n

* CHECK dout1_12 Vdout1_12ck194 = 0.9 time = 975
.meas tran vdout1_12ck194 FIND v(dout1_12) AT=975.025n

* CHECK dout1_13 Vdout1_13ck194 = 0 time = 975
.meas tran vdout1_13ck194 FIND v(dout1_13) AT=975.025n

* CHECK dout1_14 Vdout1_14ck194 = 0.9 time = 975
.meas tran vdout1_14ck194 FIND v(dout1_14) AT=975.025n

* CHECK dout1_15 Vdout1_15ck194 = 0.9 time = 975
.meas tran vdout1_15ck194 FIND v(dout1_15) AT=975.025n

* CHECK dout1_16 Vdout1_16ck194 = 0.9 time = 975
.meas tran vdout1_16ck194 FIND v(dout1_16) AT=975.025n

* CHECK dout1_17 Vdout1_17ck194 = 0 time = 975
.meas tran vdout1_17ck194 FIND v(dout1_17) AT=975.025n

* CHECK dout1_18 Vdout1_18ck194 = 0 time = 975
.meas tran vdout1_18ck194 FIND v(dout1_18) AT=975.025n

* CHECK dout1_19 Vdout1_19ck194 = 0.9 time = 975
.meas tran vdout1_19ck194 FIND v(dout1_19) AT=975.025n

* CHECK dout1_20 Vdout1_20ck194 = 0 time = 975
.meas tran vdout1_20ck194 FIND v(dout1_20) AT=975.025n

* CHECK dout1_21 Vdout1_21ck194 = 0 time = 975
.meas tran vdout1_21ck194 FIND v(dout1_21) AT=975.025n

* CHECK dout1_22 Vdout1_22ck194 = 0 time = 975
.meas tran vdout1_22ck194 FIND v(dout1_22) AT=975.025n

* CHECK dout1_23 Vdout1_23ck194 = 0.9 time = 975
.meas tran vdout1_23ck194 FIND v(dout1_23) AT=975.025n

* CHECK dout1_24 Vdout1_24ck194 = 0.9 time = 975
.meas tran vdout1_24ck194 FIND v(dout1_24) AT=975.025n

* CHECK dout1_25 Vdout1_25ck194 = 0 time = 975
.meas tran vdout1_25ck194 FIND v(dout1_25) AT=975.025n

* CHECK dout1_26 Vdout1_26ck194 = 0 time = 975
.meas tran vdout1_26ck194 FIND v(dout1_26) AT=975.025n

* CHECK dout1_27 Vdout1_27ck194 = 0.9 time = 975
.meas tran vdout1_27ck194 FIND v(dout1_27) AT=975.025n

* CHECK dout1_28 Vdout1_28ck194 = 0.9 time = 975
.meas tran vdout1_28ck194 FIND v(dout1_28) AT=975.025n

* CHECK dout1_29 Vdout1_29ck194 = 0.9 time = 975
.meas tran vdout1_29ck194 FIND v(dout1_29) AT=975.025n

* CHECK dout1_30 Vdout1_30ck194 = 0 time = 975
.meas tran vdout1_30ck194 FIND v(dout1_30) AT=975.025n

* CHECK dout1_31 Vdout1_31ck194 = 0.9 time = 975
.meas tran vdout1_31ck194 FIND v(dout1_31) AT=975.025n

* CHECK dout1_32 Vdout1_32ck194 = 0.9 time = 975
.meas tran vdout1_32ck194 FIND v(dout1_32) AT=975.025n

* CHECK dout1_33 Vdout1_33ck194 = 0.9 time = 975
.meas tran vdout1_33ck194 FIND v(dout1_33) AT=975.025n

* CHECK dout1_34 Vdout1_34ck194 = 0.9 time = 975
.meas tran vdout1_34ck194 FIND v(dout1_34) AT=975.025n

* CHECK dout1_35 Vdout1_35ck194 = 0.9 time = 975
.meas tran vdout1_35ck194 FIND v(dout1_35) AT=975.025n

* CHECK dout1_36 Vdout1_36ck194 = 0.9 time = 975
.meas tran vdout1_36ck194 FIND v(dout1_36) AT=975.025n

* CHECK dout1_37 Vdout1_37ck194 = 0 time = 975
.meas tran vdout1_37ck194 FIND v(dout1_37) AT=975.025n

* CHECK dout1_38 Vdout1_38ck194 = 0.9 time = 975
.meas tran vdout1_38ck194 FIND v(dout1_38) AT=975.025n

* CHECK dout1_39 Vdout1_39ck194 = 0.9 time = 975
.meas tran vdout1_39ck194 FIND v(dout1_39) AT=975.025n

* CHECK dout1_40 Vdout1_40ck194 = 0.9 time = 975
.meas tran vdout1_40ck194 FIND v(dout1_40) AT=975.025n

* CHECK dout1_41 Vdout1_41ck194 = 0 time = 975
.meas tran vdout1_41ck194 FIND v(dout1_41) AT=975.025n

* CHECK dout1_42 Vdout1_42ck194 = 0.9 time = 975
.meas tran vdout1_42ck194 FIND v(dout1_42) AT=975.025n

* CHECK dout1_43 Vdout1_43ck194 = 0.9 time = 975
.meas tran vdout1_43ck194 FIND v(dout1_43) AT=975.025n

* CHECK dout1_44 Vdout1_44ck194 = 0.9 time = 975
.meas tran vdout1_44ck194 FIND v(dout1_44) AT=975.025n

* CHECK dout1_45 Vdout1_45ck194 = 0 time = 975
.meas tran vdout1_45ck194 FIND v(dout1_45) AT=975.025n

* CHECK dout1_46 Vdout1_46ck194 = 0.9 time = 975
.meas tran vdout1_46ck194 FIND v(dout1_46) AT=975.025n

* CHECK dout1_47 Vdout1_47ck194 = 0 time = 975
.meas tran vdout1_47ck194 FIND v(dout1_47) AT=975.025n

* CHECK dout1_48 Vdout1_48ck194 = 0.9 time = 975
.meas tran vdout1_48ck194 FIND v(dout1_48) AT=975.025n

* CHECK dout1_49 Vdout1_49ck194 = 0.9 time = 975
.meas tran vdout1_49ck194 FIND v(dout1_49) AT=975.025n

* CHECK dout1_50 Vdout1_50ck194 = 0 time = 975
.meas tran vdout1_50ck194 FIND v(dout1_50) AT=975.025n

* CHECK dout1_51 Vdout1_51ck194 = 0.9 time = 975
.meas tran vdout1_51ck194 FIND v(dout1_51) AT=975.025n

* CHECK dout1_52 Vdout1_52ck194 = 0.9 time = 975
.meas tran vdout1_52ck194 FIND v(dout1_52) AT=975.025n

* CHECK dout1_53 Vdout1_53ck194 = 0.9 time = 975
.meas tran vdout1_53ck194 FIND v(dout1_53) AT=975.025n

* CHECK dout1_54 Vdout1_54ck194 = 0 time = 975
.meas tran vdout1_54ck194 FIND v(dout1_54) AT=975.025n

* CHECK dout1_55 Vdout1_55ck194 = 0.9 time = 975
.meas tran vdout1_55ck194 FIND v(dout1_55) AT=975.025n

* CHECK dout1_56 Vdout1_56ck194 = 0.9 time = 975
.meas tran vdout1_56ck194 FIND v(dout1_56) AT=975.025n

* CHECK dout1_57 Vdout1_57ck194 = 0 time = 975
.meas tran vdout1_57ck194 FIND v(dout1_57) AT=975.025n

* CHECK dout1_58 Vdout1_58ck194 = 0 time = 975
.meas tran vdout1_58ck194 FIND v(dout1_58) AT=975.025n

* CHECK dout1_59 Vdout1_59ck194 = 0.9 time = 975
.meas tran vdout1_59ck194 FIND v(dout1_59) AT=975.025n

* CHECK dout1_60 Vdout1_60ck194 = 0.9 time = 975
.meas tran vdout1_60ck194 FIND v(dout1_60) AT=975.025n

* CHECK dout1_61 Vdout1_61ck194 = 0 time = 975
.meas tran vdout1_61ck194 FIND v(dout1_61) AT=975.025n

* CHECK dout1_62 Vdout1_62ck194 = 0 time = 975
.meas tran vdout1_62ck194 FIND v(dout1_62) AT=975.025n

* CHECK dout1_63 Vdout1_63ck194 = 0.9 time = 975
.meas tran vdout1_63ck194 FIND v(dout1_63) AT=975.025n

* CHECK dout1_64 Vdout1_64ck194 = 0 time = 975
.meas tran vdout1_64ck194 FIND v(dout1_64) AT=975.025n

* CHECK dout1_65 Vdout1_65ck194 = 0 time = 975
.meas tran vdout1_65ck194 FIND v(dout1_65) AT=975.025n

* CHECK dout1_66 Vdout1_66ck194 = 0 time = 975
.meas tran vdout1_66ck194 FIND v(dout1_66) AT=975.025n

* CHECK dout1_67 Vdout1_67ck194 = 0 time = 975
.meas tran vdout1_67ck194 FIND v(dout1_67) AT=975.025n

* CHECK dout1_68 Vdout1_68ck194 = 0.9 time = 975
.meas tran vdout1_68ck194 FIND v(dout1_68) AT=975.025n

* CHECK dout1_69 Vdout1_69ck194 = 0 time = 975
.meas tran vdout1_69ck194 FIND v(dout1_69) AT=975.025n

* CHECK dout1_70 Vdout1_70ck194 = 0 time = 975
.meas tran vdout1_70ck194 FIND v(dout1_70) AT=975.025n

* CHECK dout1_71 Vdout1_71ck194 = 0.9 time = 975
.meas tran vdout1_71ck194 FIND v(dout1_71) AT=975.025n

* CHECK dout1_0 Vdout1_0ck195 = 0.9 time = 980
.meas tran vdout1_0ck195 FIND v(dout1_0) AT=980.025n

* CHECK dout1_1 Vdout1_1ck195 = 0 time = 980
.meas tran vdout1_1ck195 FIND v(dout1_1) AT=980.025n

* CHECK dout1_2 Vdout1_2ck195 = 0.9 time = 980
.meas tran vdout1_2ck195 FIND v(dout1_2) AT=980.025n

* CHECK dout1_3 Vdout1_3ck195 = 0.9 time = 980
.meas tran vdout1_3ck195 FIND v(dout1_3) AT=980.025n

* CHECK dout1_4 Vdout1_4ck195 = 0 time = 980
.meas tran vdout1_4ck195 FIND v(dout1_4) AT=980.025n

* CHECK dout1_5 Vdout1_5ck195 = 0 time = 980
.meas tran vdout1_5ck195 FIND v(dout1_5) AT=980.025n

* CHECK dout1_6 Vdout1_6ck195 = 0.9 time = 980
.meas tran vdout1_6ck195 FIND v(dout1_6) AT=980.025n

* CHECK dout1_7 Vdout1_7ck195 = 0 time = 980
.meas tran vdout1_7ck195 FIND v(dout1_7) AT=980.025n

* CHECK dout1_8 Vdout1_8ck195 = 0.9 time = 980
.meas tran vdout1_8ck195 FIND v(dout1_8) AT=980.025n

* CHECK dout1_9 Vdout1_9ck195 = 0.9 time = 980
.meas tran vdout1_9ck195 FIND v(dout1_9) AT=980.025n

* CHECK dout1_10 Vdout1_10ck195 = 0.9 time = 980
.meas tran vdout1_10ck195 FIND v(dout1_10) AT=980.025n

* CHECK dout1_11 Vdout1_11ck195 = 0.9 time = 980
.meas tran vdout1_11ck195 FIND v(dout1_11) AT=980.025n

* CHECK dout1_12 Vdout1_12ck195 = 0.9 time = 980
.meas tran vdout1_12ck195 FIND v(dout1_12) AT=980.025n

* CHECK dout1_13 Vdout1_13ck195 = 0 time = 980
.meas tran vdout1_13ck195 FIND v(dout1_13) AT=980.025n

* CHECK dout1_14 Vdout1_14ck195 = 0.9 time = 980
.meas tran vdout1_14ck195 FIND v(dout1_14) AT=980.025n

* CHECK dout1_15 Vdout1_15ck195 = 0.9 time = 980
.meas tran vdout1_15ck195 FIND v(dout1_15) AT=980.025n

* CHECK dout1_16 Vdout1_16ck195 = 0.9 time = 980
.meas tran vdout1_16ck195 FIND v(dout1_16) AT=980.025n

* CHECK dout1_17 Vdout1_17ck195 = 0 time = 980
.meas tran vdout1_17ck195 FIND v(dout1_17) AT=980.025n

* CHECK dout1_18 Vdout1_18ck195 = 0 time = 980
.meas tran vdout1_18ck195 FIND v(dout1_18) AT=980.025n

* CHECK dout1_19 Vdout1_19ck195 = 0.9 time = 980
.meas tran vdout1_19ck195 FIND v(dout1_19) AT=980.025n

* CHECK dout1_20 Vdout1_20ck195 = 0 time = 980
.meas tran vdout1_20ck195 FIND v(dout1_20) AT=980.025n

* CHECK dout1_21 Vdout1_21ck195 = 0 time = 980
.meas tran vdout1_21ck195 FIND v(dout1_21) AT=980.025n

* CHECK dout1_22 Vdout1_22ck195 = 0 time = 980
.meas tran vdout1_22ck195 FIND v(dout1_22) AT=980.025n

* CHECK dout1_23 Vdout1_23ck195 = 0.9 time = 980
.meas tran vdout1_23ck195 FIND v(dout1_23) AT=980.025n

* CHECK dout1_24 Vdout1_24ck195 = 0.9 time = 980
.meas tran vdout1_24ck195 FIND v(dout1_24) AT=980.025n

* CHECK dout1_25 Vdout1_25ck195 = 0 time = 980
.meas tran vdout1_25ck195 FIND v(dout1_25) AT=980.025n

* CHECK dout1_26 Vdout1_26ck195 = 0 time = 980
.meas tran vdout1_26ck195 FIND v(dout1_26) AT=980.025n

* CHECK dout1_27 Vdout1_27ck195 = 0.9 time = 980
.meas tran vdout1_27ck195 FIND v(dout1_27) AT=980.025n

* CHECK dout1_28 Vdout1_28ck195 = 0.9 time = 980
.meas tran vdout1_28ck195 FIND v(dout1_28) AT=980.025n

* CHECK dout1_29 Vdout1_29ck195 = 0.9 time = 980
.meas tran vdout1_29ck195 FIND v(dout1_29) AT=980.025n

* CHECK dout1_30 Vdout1_30ck195 = 0 time = 980
.meas tran vdout1_30ck195 FIND v(dout1_30) AT=980.025n

* CHECK dout1_31 Vdout1_31ck195 = 0.9 time = 980
.meas tran vdout1_31ck195 FIND v(dout1_31) AT=980.025n

* CHECK dout1_32 Vdout1_32ck195 = 0.9 time = 980
.meas tran vdout1_32ck195 FIND v(dout1_32) AT=980.025n

* CHECK dout1_33 Vdout1_33ck195 = 0.9 time = 980
.meas tran vdout1_33ck195 FIND v(dout1_33) AT=980.025n

* CHECK dout1_34 Vdout1_34ck195 = 0.9 time = 980
.meas tran vdout1_34ck195 FIND v(dout1_34) AT=980.025n

* CHECK dout1_35 Vdout1_35ck195 = 0.9 time = 980
.meas tran vdout1_35ck195 FIND v(dout1_35) AT=980.025n

* CHECK dout1_36 Vdout1_36ck195 = 0.9 time = 980
.meas tran vdout1_36ck195 FIND v(dout1_36) AT=980.025n

* CHECK dout1_37 Vdout1_37ck195 = 0 time = 980
.meas tran vdout1_37ck195 FIND v(dout1_37) AT=980.025n

* CHECK dout1_38 Vdout1_38ck195 = 0.9 time = 980
.meas tran vdout1_38ck195 FIND v(dout1_38) AT=980.025n

* CHECK dout1_39 Vdout1_39ck195 = 0.9 time = 980
.meas tran vdout1_39ck195 FIND v(dout1_39) AT=980.025n

* CHECK dout1_40 Vdout1_40ck195 = 0.9 time = 980
.meas tran vdout1_40ck195 FIND v(dout1_40) AT=980.025n

* CHECK dout1_41 Vdout1_41ck195 = 0 time = 980
.meas tran vdout1_41ck195 FIND v(dout1_41) AT=980.025n

* CHECK dout1_42 Vdout1_42ck195 = 0.9 time = 980
.meas tran vdout1_42ck195 FIND v(dout1_42) AT=980.025n

* CHECK dout1_43 Vdout1_43ck195 = 0.9 time = 980
.meas tran vdout1_43ck195 FIND v(dout1_43) AT=980.025n

* CHECK dout1_44 Vdout1_44ck195 = 0.9 time = 980
.meas tran vdout1_44ck195 FIND v(dout1_44) AT=980.025n

* CHECK dout1_45 Vdout1_45ck195 = 0 time = 980
.meas tran vdout1_45ck195 FIND v(dout1_45) AT=980.025n

* CHECK dout1_46 Vdout1_46ck195 = 0.9 time = 980
.meas tran vdout1_46ck195 FIND v(dout1_46) AT=980.025n

* CHECK dout1_47 Vdout1_47ck195 = 0 time = 980
.meas tran vdout1_47ck195 FIND v(dout1_47) AT=980.025n

* CHECK dout1_48 Vdout1_48ck195 = 0.9 time = 980
.meas tran vdout1_48ck195 FIND v(dout1_48) AT=980.025n

* CHECK dout1_49 Vdout1_49ck195 = 0.9 time = 980
.meas tran vdout1_49ck195 FIND v(dout1_49) AT=980.025n

* CHECK dout1_50 Vdout1_50ck195 = 0 time = 980
.meas tran vdout1_50ck195 FIND v(dout1_50) AT=980.025n

* CHECK dout1_51 Vdout1_51ck195 = 0.9 time = 980
.meas tran vdout1_51ck195 FIND v(dout1_51) AT=980.025n

* CHECK dout1_52 Vdout1_52ck195 = 0.9 time = 980
.meas tran vdout1_52ck195 FIND v(dout1_52) AT=980.025n

* CHECK dout1_53 Vdout1_53ck195 = 0.9 time = 980
.meas tran vdout1_53ck195 FIND v(dout1_53) AT=980.025n

* CHECK dout1_54 Vdout1_54ck195 = 0 time = 980
.meas tran vdout1_54ck195 FIND v(dout1_54) AT=980.025n

* CHECK dout1_55 Vdout1_55ck195 = 0.9 time = 980
.meas tran vdout1_55ck195 FIND v(dout1_55) AT=980.025n

* CHECK dout1_56 Vdout1_56ck195 = 0.9 time = 980
.meas tran vdout1_56ck195 FIND v(dout1_56) AT=980.025n

* CHECK dout1_57 Vdout1_57ck195 = 0 time = 980
.meas tran vdout1_57ck195 FIND v(dout1_57) AT=980.025n

* CHECK dout1_58 Vdout1_58ck195 = 0 time = 980
.meas tran vdout1_58ck195 FIND v(dout1_58) AT=980.025n

* CHECK dout1_59 Vdout1_59ck195 = 0.9 time = 980
.meas tran vdout1_59ck195 FIND v(dout1_59) AT=980.025n

* CHECK dout1_60 Vdout1_60ck195 = 0.9 time = 980
.meas tran vdout1_60ck195 FIND v(dout1_60) AT=980.025n

* CHECK dout1_61 Vdout1_61ck195 = 0 time = 980
.meas tran vdout1_61ck195 FIND v(dout1_61) AT=980.025n

* CHECK dout1_62 Vdout1_62ck195 = 0 time = 980
.meas tran vdout1_62ck195 FIND v(dout1_62) AT=980.025n

* CHECK dout1_63 Vdout1_63ck195 = 0.9 time = 980
.meas tran vdout1_63ck195 FIND v(dout1_63) AT=980.025n

* CHECK dout1_64 Vdout1_64ck195 = 0 time = 980
.meas tran vdout1_64ck195 FIND v(dout1_64) AT=980.025n

* CHECK dout1_65 Vdout1_65ck195 = 0 time = 980
.meas tran vdout1_65ck195 FIND v(dout1_65) AT=980.025n

* CHECK dout1_66 Vdout1_66ck195 = 0 time = 980
.meas tran vdout1_66ck195 FIND v(dout1_66) AT=980.025n

* CHECK dout1_67 Vdout1_67ck195 = 0 time = 980
.meas tran vdout1_67ck195 FIND v(dout1_67) AT=980.025n

* CHECK dout1_68 Vdout1_68ck195 = 0.9 time = 980
.meas tran vdout1_68ck195 FIND v(dout1_68) AT=980.025n

* CHECK dout1_69 Vdout1_69ck195 = 0 time = 980
.meas tran vdout1_69ck195 FIND v(dout1_69) AT=980.025n

* CHECK dout1_70 Vdout1_70ck195 = 0 time = 980
.meas tran vdout1_70ck195 FIND v(dout1_70) AT=980.025n

* CHECK dout1_71 Vdout1_71ck195 = 0.9 time = 980
.meas tran vdout1_71ck195 FIND v(dout1_71) AT=980.025n

* CHECK dout1_0 Vdout1_0ck198 = 0.9 time = 995
.meas tran vdout1_0ck198 FIND v(dout1_0) AT=995.025n

* CHECK dout1_1 Vdout1_1ck198 = 0 time = 995
.meas tran vdout1_1ck198 FIND v(dout1_1) AT=995.025n

* CHECK dout1_2 Vdout1_2ck198 = 0.9 time = 995
.meas tran vdout1_2ck198 FIND v(dout1_2) AT=995.025n

* CHECK dout1_3 Vdout1_3ck198 = 0.9 time = 995
.meas tran vdout1_3ck198 FIND v(dout1_3) AT=995.025n

* CHECK dout1_4 Vdout1_4ck198 = 0 time = 995
.meas tran vdout1_4ck198 FIND v(dout1_4) AT=995.025n

* CHECK dout1_5 Vdout1_5ck198 = 0 time = 995
.meas tran vdout1_5ck198 FIND v(dout1_5) AT=995.025n

* CHECK dout1_6 Vdout1_6ck198 = 0.9 time = 995
.meas tran vdout1_6ck198 FIND v(dout1_6) AT=995.025n

* CHECK dout1_7 Vdout1_7ck198 = 0 time = 995
.meas tran vdout1_7ck198 FIND v(dout1_7) AT=995.025n

* CHECK dout1_8 Vdout1_8ck198 = 0.9 time = 995
.meas tran vdout1_8ck198 FIND v(dout1_8) AT=995.025n

* CHECK dout1_9 Vdout1_9ck198 = 0.9 time = 995
.meas tran vdout1_9ck198 FIND v(dout1_9) AT=995.025n

* CHECK dout1_10 Vdout1_10ck198 = 0.9 time = 995
.meas tran vdout1_10ck198 FIND v(dout1_10) AT=995.025n

* CHECK dout1_11 Vdout1_11ck198 = 0.9 time = 995
.meas tran vdout1_11ck198 FIND v(dout1_11) AT=995.025n

* CHECK dout1_12 Vdout1_12ck198 = 0.9 time = 995
.meas tran vdout1_12ck198 FIND v(dout1_12) AT=995.025n

* CHECK dout1_13 Vdout1_13ck198 = 0 time = 995
.meas tran vdout1_13ck198 FIND v(dout1_13) AT=995.025n

* CHECK dout1_14 Vdout1_14ck198 = 0.9 time = 995
.meas tran vdout1_14ck198 FIND v(dout1_14) AT=995.025n

* CHECK dout1_15 Vdout1_15ck198 = 0.9 time = 995
.meas tran vdout1_15ck198 FIND v(dout1_15) AT=995.025n

* CHECK dout1_16 Vdout1_16ck198 = 0.9 time = 995
.meas tran vdout1_16ck198 FIND v(dout1_16) AT=995.025n

* CHECK dout1_17 Vdout1_17ck198 = 0 time = 995
.meas tran vdout1_17ck198 FIND v(dout1_17) AT=995.025n

* CHECK dout1_18 Vdout1_18ck198 = 0 time = 995
.meas tran vdout1_18ck198 FIND v(dout1_18) AT=995.025n

* CHECK dout1_19 Vdout1_19ck198 = 0.9 time = 995
.meas tran vdout1_19ck198 FIND v(dout1_19) AT=995.025n

* CHECK dout1_20 Vdout1_20ck198 = 0 time = 995
.meas tran vdout1_20ck198 FIND v(dout1_20) AT=995.025n

* CHECK dout1_21 Vdout1_21ck198 = 0 time = 995
.meas tran vdout1_21ck198 FIND v(dout1_21) AT=995.025n

* CHECK dout1_22 Vdout1_22ck198 = 0 time = 995
.meas tran vdout1_22ck198 FIND v(dout1_22) AT=995.025n

* CHECK dout1_23 Vdout1_23ck198 = 0.9 time = 995
.meas tran vdout1_23ck198 FIND v(dout1_23) AT=995.025n

* CHECK dout1_24 Vdout1_24ck198 = 0.9 time = 995
.meas tran vdout1_24ck198 FIND v(dout1_24) AT=995.025n

* CHECK dout1_25 Vdout1_25ck198 = 0 time = 995
.meas tran vdout1_25ck198 FIND v(dout1_25) AT=995.025n

* CHECK dout1_26 Vdout1_26ck198 = 0 time = 995
.meas tran vdout1_26ck198 FIND v(dout1_26) AT=995.025n

* CHECK dout1_27 Vdout1_27ck198 = 0.9 time = 995
.meas tran vdout1_27ck198 FIND v(dout1_27) AT=995.025n

* CHECK dout1_28 Vdout1_28ck198 = 0.9 time = 995
.meas tran vdout1_28ck198 FIND v(dout1_28) AT=995.025n

* CHECK dout1_29 Vdout1_29ck198 = 0.9 time = 995
.meas tran vdout1_29ck198 FIND v(dout1_29) AT=995.025n

* CHECK dout1_30 Vdout1_30ck198 = 0 time = 995
.meas tran vdout1_30ck198 FIND v(dout1_30) AT=995.025n

* CHECK dout1_31 Vdout1_31ck198 = 0.9 time = 995
.meas tran vdout1_31ck198 FIND v(dout1_31) AT=995.025n

* CHECK dout1_32 Vdout1_32ck198 = 0.9 time = 995
.meas tran vdout1_32ck198 FIND v(dout1_32) AT=995.025n

* CHECK dout1_33 Vdout1_33ck198 = 0.9 time = 995
.meas tran vdout1_33ck198 FIND v(dout1_33) AT=995.025n

* CHECK dout1_34 Vdout1_34ck198 = 0.9 time = 995
.meas tran vdout1_34ck198 FIND v(dout1_34) AT=995.025n

* CHECK dout1_35 Vdout1_35ck198 = 0.9 time = 995
.meas tran vdout1_35ck198 FIND v(dout1_35) AT=995.025n

* CHECK dout1_36 Vdout1_36ck198 = 0.9 time = 995
.meas tran vdout1_36ck198 FIND v(dout1_36) AT=995.025n

* CHECK dout1_37 Vdout1_37ck198 = 0 time = 995
.meas tran vdout1_37ck198 FIND v(dout1_37) AT=995.025n

* CHECK dout1_38 Vdout1_38ck198 = 0.9 time = 995
.meas tran vdout1_38ck198 FIND v(dout1_38) AT=995.025n

* CHECK dout1_39 Vdout1_39ck198 = 0.9 time = 995
.meas tran vdout1_39ck198 FIND v(dout1_39) AT=995.025n

* CHECK dout1_40 Vdout1_40ck198 = 0.9 time = 995
.meas tran vdout1_40ck198 FIND v(dout1_40) AT=995.025n

* CHECK dout1_41 Vdout1_41ck198 = 0 time = 995
.meas tran vdout1_41ck198 FIND v(dout1_41) AT=995.025n

* CHECK dout1_42 Vdout1_42ck198 = 0.9 time = 995
.meas tran vdout1_42ck198 FIND v(dout1_42) AT=995.025n

* CHECK dout1_43 Vdout1_43ck198 = 0.9 time = 995
.meas tran vdout1_43ck198 FIND v(dout1_43) AT=995.025n

* CHECK dout1_44 Vdout1_44ck198 = 0.9 time = 995
.meas tran vdout1_44ck198 FIND v(dout1_44) AT=995.025n

* CHECK dout1_45 Vdout1_45ck198 = 0 time = 995
.meas tran vdout1_45ck198 FIND v(dout1_45) AT=995.025n

* CHECK dout1_46 Vdout1_46ck198 = 0.9 time = 995
.meas tran vdout1_46ck198 FIND v(dout1_46) AT=995.025n

* CHECK dout1_47 Vdout1_47ck198 = 0 time = 995
.meas tran vdout1_47ck198 FIND v(dout1_47) AT=995.025n

* CHECK dout1_48 Vdout1_48ck198 = 0.9 time = 995
.meas tran vdout1_48ck198 FIND v(dout1_48) AT=995.025n

* CHECK dout1_49 Vdout1_49ck198 = 0.9 time = 995
.meas tran vdout1_49ck198 FIND v(dout1_49) AT=995.025n

* CHECK dout1_50 Vdout1_50ck198 = 0 time = 995
.meas tran vdout1_50ck198 FIND v(dout1_50) AT=995.025n

* CHECK dout1_51 Vdout1_51ck198 = 0.9 time = 995
.meas tran vdout1_51ck198 FIND v(dout1_51) AT=995.025n

* CHECK dout1_52 Vdout1_52ck198 = 0.9 time = 995
.meas tran vdout1_52ck198 FIND v(dout1_52) AT=995.025n

* CHECK dout1_53 Vdout1_53ck198 = 0.9 time = 995
.meas tran vdout1_53ck198 FIND v(dout1_53) AT=995.025n

* CHECK dout1_54 Vdout1_54ck198 = 0 time = 995
.meas tran vdout1_54ck198 FIND v(dout1_54) AT=995.025n

* CHECK dout1_55 Vdout1_55ck198 = 0.9 time = 995
.meas tran vdout1_55ck198 FIND v(dout1_55) AT=995.025n

* CHECK dout1_56 Vdout1_56ck198 = 0.9 time = 995
.meas tran vdout1_56ck198 FIND v(dout1_56) AT=995.025n

* CHECK dout1_57 Vdout1_57ck198 = 0 time = 995
.meas tran vdout1_57ck198 FIND v(dout1_57) AT=995.025n

* CHECK dout1_58 Vdout1_58ck198 = 0 time = 995
.meas tran vdout1_58ck198 FIND v(dout1_58) AT=995.025n

* CHECK dout1_59 Vdout1_59ck198 = 0.9 time = 995
.meas tran vdout1_59ck198 FIND v(dout1_59) AT=995.025n

* CHECK dout1_60 Vdout1_60ck198 = 0.9 time = 995
.meas tran vdout1_60ck198 FIND v(dout1_60) AT=995.025n

* CHECK dout1_61 Vdout1_61ck198 = 0 time = 995
.meas tran vdout1_61ck198 FIND v(dout1_61) AT=995.025n

* CHECK dout1_62 Vdout1_62ck198 = 0 time = 995
.meas tran vdout1_62ck198 FIND v(dout1_62) AT=995.025n

* CHECK dout1_63 Vdout1_63ck198 = 0.9 time = 995
.meas tran vdout1_63ck198 FIND v(dout1_63) AT=995.025n

* CHECK dout1_64 Vdout1_64ck198 = 0 time = 995
.meas tran vdout1_64ck198 FIND v(dout1_64) AT=995.025n

* CHECK dout1_65 Vdout1_65ck198 = 0 time = 995
.meas tran vdout1_65ck198 FIND v(dout1_65) AT=995.025n

* CHECK dout1_66 Vdout1_66ck198 = 0 time = 995
.meas tran vdout1_66ck198 FIND v(dout1_66) AT=995.025n

* CHECK dout1_67 Vdout1_67ck198 = 0 time = 995
.meas tran vdout1_67ck198 FIND v(dout1_67) AT=995.025n

* CHECK dout1_68 Vdout1_68ck198 = 0.9 time = 995
.meas tran vdout1_68ck198 FIND v(dout1_68) AT=995.025n

* CHECK dout1_69 Vdout1_69ck198 = 0 time = 995
.meas tran vdout1_69ck198 FIND v(dout1_69) AT=995.025n

* CHECK dout1_70 Vdout1_70ck198 = 0 time = 995
.meas tran vdout1_70ck198 FIND v(dout1_70) AT=995.025n

* CHECK dout1_71 Vdout1_71ck198 = 0.9 time = 995
.meas tran vdout1_71ck198 FIND v(dout1_71) AT=995.025n

* CHECK dout1_0 Vdout1_0ck200 = 0 time = 1005
.meas tran vdout1_0ck200 FIND v(dout1_0) AT=1005.025n

* CHECK dout1_1 Vdout1_1ck200 = 0.9 time = 1005
.meas tran vdout1_1ck200 FIND v(dout1_1) AT=1005.025n

* CHECK dout1_2 Vdout1_2ck200 = 0 time = 1005
.meas tran vdout1_2ck200 FIND v(dout1_2) AT=1005.025n

* CHECK dout1_3 Vdout1_3ck200 = 0.9 time = 1005
.meas tran vdout1_3ck200 FIND v(dout1_3) AT=1005.025n

* CHECK dout1_4 Vdout1_4ck200 = 0 time = 1005
.meas tran vdout1_4ck200 FIND v(dout1_4) AT=1005.025n

* CHECK dout1_5 Vdout1_5ck200 = 0.9 time = 1005
.meas tran vdout1_5ck200 FIND v(dout1_5) AT=1005.025n

* CHECK dout1_6 Vdout1_6ck200 = 0.9 time = 1005
.meas tran vdout1_6ck200 FIND v(dout1_6) AT=1005.025n

* CHECK dout1_7 Vdout1_7ck200 = 0.9 time = 1005
.meas tran vdout1_7ck200 FIND v(dout1_7) AT=1005.025n

* CHECK dout1_8 Vdout1_8ck200 = 0.9 time = 1005
.meas tran vdout1_8ck200 FIND v(dout1_8) AT=1005.025n

* CHECK dout1_9 Vdout1_9ck200 = 0.9 time = 1005
.meas tran vdout1_9ck200 FIND v(dout1_9) AT=1005.025n

* CHECK dout1_10 Vdout1_10ck200 = 0 time = 1005
.meas tran vdout1_10ck200 FIND v(dout1_10) AT=1005.025n

* CHECK dout1_11 Vdout1_11ck200 = 0.9 time = 1005
.meas tran vdout1_11ck200 FIND v(dout1_11) AT=1005.025n

* CHECK dout1_12 Vdout1_12ck200 = 0.9 time = 1005
.meas tran vdout1_12ck200 FIND v(dout1_12) AT=1005.025n

* CHECK dout1_13 Vdout1_13ck200 = 0.9 time = 1005
.meas tran vdout1_13ck200 FIND v(dout1_13) AT=1005.025n

* CHECK dout1_14 Vdout1_14ck200 = 0 time = 1005
.meas tran vdout1_14ck200 FIND v(dout1_14) AT=1005.025n

* CHECK dout1_15 Vdout1_15ck200 = 0 time = 1005
.meas tran vdout1_15ck200 FIND v(dout1_15) AT=1005.025n

* CHECK dout1_16 Vdout1_16ck200 = 0.9 time = 1005
.meas tran vdout1_16ck200 FIND v(dout1_16) AT=1005.025n

* CHECK dout1_17 Vdout1_17ck200 = 0.9 time = 1005
.meas tran vdout1_17ck200 FIND v(dout1_17) AT=1005.025n

* CHECK dout1_18 Vdout1_18ck200 = 0.9 time = 1005
.meas tran vdout1_18ck200 FIND v(dout1_18) AT=1005.025n

* CHECK dout1_19 Vdout1_19ck200 = 0.9 time = 1005
.meas tran vdout1_19ck200 FIND v(dout1_19) AT=1005.025n

* CHECK dout1_20 Vdout1_20ck200 = 0.9 time = 1005
.meas tran vdout1_20ck200 FIND v(dout1_20) AT=1005.025n

* CHECK dout1_21 Vdout1_21ck200 = 0 time = 1005
.meas tran vdout1_21ck200 FIND v(dout1_21) AT=1005.025n

* CHECK dout1_22 Vdout1_22ck200 = 0.9 time = 1005
.meas tran vdout1_22ck200 FIND v(dout1_22) AT=1005.025n

* CHECK dout1_23 Vdout1_23ck200 = 0.9 time = 1005
.meas tran vdout1_23ck200 FIND v(dout1_23) AT=1005.025n

* CHECK dout1_24 Vdout1_24ck200 = 0 time = 1005
.meas tran vdout1_24ck200 FIND v(dout1_24) AT=1005.025n

* CHECK dout1_25 Vdout1_25ck200 = 0.9 time = 1005
.meas tran vdout1_25ck200 FIND v(dout1_25) AT=1005.025n

* CHECK dout1_26 Vdout1_26ck200 = 0 time = 1005
.meas tran vdout1_26ck200 FIND v(dout1_26) AT=1005.025n

* CHECK dout1_27 Vdout1_27ck200 = 0.9 time = 1005
.meas tran vdout1_27ck200 FIND v(dout1_27) AT=1005.025n

* CHECK dout1_28 Vdout1_28ck200 = 0 time = 1005
.meas tran vdout1_28ck200 FIND v(dout1_28) AT=1005.025n

* CHECK dout1_29 Vdout1_29ck200 = 0.9 time = 1005
.meas tran vdout1_29ck200 FIND v(dout1_29) AT=1005.025n

* CHECK dout1_30 Vdout1_30ck200 = 0 time = 1005
.meas tran vdout1_30ck200 FIND v(dout1_30) AT=1005.025n

* CHECK dout1_31 Vdout1_31ck200 = 0 time = 1005
.meas tran vdout1_31ck200 FIND v(dout1_31) AT=1005.025n

* CHECK dout1_32 Vdout1_32ck200 = 0.9 time = 1005
.meas tran vdout1_32ck200 FIND v(dout1_32) AT=1005.025n

* CHECK dout1_33 Vdout1_33ck200 = 0.9 time = 1005
.meas tran vdout1_33ck200 FIND v(dout1_33) AT=1005.025n

* CHECK dout1_34 Vdout1_34ck200 = 0.9 time = 1005
.meas tran vdout1_34ck200 FIND v(dout1_34) AT=1005.025n

* CHECK dout1_35 Vdout1_35ck200 = 0 time = 1005
.meas tran vdout1_35ck200 FIND v(dout1_35) AT=1005.025n

* CHECK dout1_36 Vdout1_36ck200 = 0.9 time = 1005
.meas tran vdout1_36ck200 FIND v(dout1_36) AT=1005.025n

* CHECK dout1_37 Vdout1_37ck200 = 0.9 time = 1005
.meas tran vdout1_37ck200 FIND v(dout1_37) AT=1005.025n

* CHECK dout1_38 Vdout1_38ck200 = 0.9 time = 1005
.meas tran vdout1_38ck200 FIND v(dout1_38) AT=1005.025n

* CHECK dout1_39 Vdout1_39ck200 = 0 time = 1005
.meas tran vdout1_39ck200 FIND v(dout1_39) AT=1005.025n

* CHECK dout1_40 Vdout1_40ck200 = 0.9 time = 1005
.meas tran vdout1_40ck200 FIND v(dout1_40) AT=1005.025n

* CHECK dout1_41 Vdout1_41ck200 = 0 time = 1005
.meas tran vdout1_41ck200 FIND v(dout1_41) AT=1005.025n

* CHECK dout1_42 Vdout1_42ck200 = 0 time = 1005
.meas tran vdout1_42ck200 FIND v(dout1_42) AT=1005.025n

* CHECK dout1_43 Vdout1_43ck200 = 0.9 time = 1005
.meas tran vdout1_43ck200 FIND v(dout1_43) AT=1005.025n

* CHECK dout1_44 Vdout1_44ck200 = 0 time = 1005
.meas tran vdout1_44ck200 FIND v(dout1_44) AT=1005.025n

* CHECK dout1_45 Vdout1_45ck200 = 0 time = 1005
.meas tran vdout1_45ck200 FIND v(dout1_45) AT=1005.025n

* CHECK dout1_46 Vdout1_46ck200 = 0.9 time = 1005
.meas tran vdout1_46ck200 FIND v(dout1_46) AT=1005.025n

* CHECK dout1_47 Vdout1_47ck200 = 0.9 time = 1005
.meas tran vdout1_47ck200 FIND v(dout1_47) AT=1005.025n

* CHECK dout1_48 Vdout1_48ck200 = 0.9 time = 1005
.meas tran vdout1_48ck200 FIND v(dout1_48) AT=1005.025n

* CHECK dout1_49 Vdout1_49ck200 = 0.9 time = 1005
.meas tran vdout1_49ck200 FIND v(dout1_49) AT=1005.025n

* CHECK dout1_50 Vdout1_50ck200 = 0.9 time = 1005
.meas tran vdout1_50ck200 FIND v(dout1_50) AT=1005.025n

* CHECK dout1_51 Vdout1_51ck200 = 0.9 time = 1005
.meas tran vdout1_51ck200 FIND v(dout1_51) AT=1005.025n

* CHECK dout1_52 Vdout1_52ck200 = 0 time = 1005
.meas tran vdout1_52ck200 FIND v(dout1_52) AT=1005.025n

* CHECK dout1_53 Vdout1_53ck200 = 0 time = 1005
.meas tran vdout1_53ck200 FIND v(dout1_53) AT=1005.025n

* CHECK dout1_54 Vdout1_54ck200 = 0 time = 1005
.meas tran vdout1_54ck200 FIND v(dout1_54) AT=1005.025n

* CHECK dout1_55 Vdout1_55ck200 = 0.9 time = 1005
.meas tran vdout1_55ck200 FIND v(dout1_55) AT=1005.025n

* CHECK dout1_56 Vdout1_56ck200 = 0 time = 1005
.meas tran vdout1_56ck200 FIND v(dout1_56) AT=1005.025n

* CHECK dout1_57 Vdout1_57ck200 = 0.9 time = 1005
.meas tran vdout1_57ck200 FIND v(dout1_57) AT=1005.025n

* CHECK dout1_58 Vdout1_58ck200 = 0 time = 1005
.meas tran vdout1_58ck200 FIND v(dout1_58) AT=1005.025n

* CHECK dout1_59 Vdout1_59ck200 = 0 time = 1005
.meas tran vdout1_59ck200 FIND v(dout1_59) AT=1005.025n

* CHECK dout1_60 Vdout1_60ck200 = 0 time = 1005
.meas tran vdout1_60ck200 FIND v(dout1_60) AT=1005.025n

* CHECK dout1_61 Vdout1_61ck200 = 0 time = 1005
.meas tran vdout1_61ck200 FIND v(dout1_61) AT=1005.025n

* CHECK dout1_62 Vdout1_62ck200 = 0 time = 1005
.meas tran vdout1_62ck200 FIND v(dout1_62) AT=1005.025n

* CHECK dout1_63 Vdout1_63ck200 = 0.9 time = 1005
.meas tran vdout1_63ck200 FIND v(dout1_63) AT=1005.025n

* CHECK dout1_64 Vdout1_64ck200 = 0 time = 1005
.meas tran vdout1_64ck200 FIND v(dout1_64) AT=1005.025n

* CHECK dout1_65 Vdout1_65ck200 = 0 time = 1005
.meas tran vdout1_65ck200 FIND v(dout1_65) AT=1005.025n

* CHECK dout1_66 Vdout1_66ck200 = 0.9 time = 1005
.meas tran vdout1_66ck200 FIND v(dout1_66) AT=1005.025n

* CHECK dout1_67 Vdout1_67ck200 = 0 time = 1005
.meas tran vdout1_67ck200 FIND v(dout1_67) AT=1005.025n

* CHECK dout1_68 Vdout1_68ck200 = 0 time = 1005
.meas tran vdout1_68ck200 FIND v(dout1_68) AT=1005.025n

* CHECK dout1_69 Vdout1_69ck200 = 0.9 time = 1005
.meas tran vdout1_69ck200 FIND v(dout1_69) AT=1005.025n

* CHECK dout1_70 Vdout1_70ck200 = 0.9 time = 1005
.meas tran vdout1_70ck200 FIND v(dout1_70) AT=1005.025n

* CHECK dout1_71 Vdout1_71ck200 = 0 time = 1005
.meas tran vdout1_71ck200 FIND v(dout1_71) AT=1005.025n

* CHECK dout1_0 Vdout1_0ck201 = 0.9 time = 1010
.meas tran vdout1_0ck201 FIND v(dout1_0) AT=1010.025n

* CHECK dout1_1 Vdout1_1ck201 = 0 time = 1010
.meas tran vdout1_1ck201 FIND v(dout1_1) AT=1010.025n

* CHECK dout1_2 Vdout1_2ck201 = 0.9 time = 1010
.meas tran vdout1_2ck201 FIND v(dout1_2) AT=1010.025n

* CHECK dout1_3 Vdout1_3ck201 = 0.9 time = 1010
.meas tran vdout1_3ck201 FIND v(dout1_3) AT=1010.025n

* CHECK dout1_4 Vdout1_4ck201 = 0 time = 1010
.meas tran vdout1_4ck201 FIND v(dout1_4) AT=1010.025n

* CHECK dout1_5 Vdout1_5ck201 = 0 time = 1010
.meas tran vdout1_5ck201 FIND v(dout1_5) AT=1010.025n

* CHECK dout1_6 Vdout1_6ck201 = 0.9 time = 1010
.meas tran vdout1_6ck201 FIND v(dout1_6) AT=1010.025n

* CHECK dout1_7 Vdout1_7ck201 = 0 time = 1010
.meas tran vdout1_7ck201 FIND v(dout1_7) AT=1010.025n

* CHECK dout1_8 Vdout1_8ck201 = 0.9 time = 1010
.meas tran vdout1_8ck201 FIND v(dout1_8) AT=1010.025n

* CHECK dout1_9 Vdout1_9ck201 = 0.9 time = 1010
.meas tran vdout1_9ck201 FIND v(dout1_9) AT=1010.025n

* CHECK dout1_10 Vdout1_10ck201 = 0.9 time = 1010
.meas tran vdout1_10ck201 FIND v(dout1_10) AT=1010.025n

* CHECK dout1_11 Vdout1_11ck201 = 0.9 time = 1010
.meas tran vdout1_11ck201 FIND v(dout1_11) AT=1010.025n

* CHECK dout1_12 Vdout1_12ck201 = 0.9 time = 1010
.meas tran vdout1_12ck201 FIND v(dout1_12) AT=1010.025n

* CHECK dout1_13 Vdout1_13ck201 = 0 time = 1010
.meas tran vdout1_13ck201 FIND v(dout1_13) AT=1010.025n

* CHECK dout1_14 Vdout1_14ck201 = 0.9 time = 1010
.meas tran vdout1_14ck201 FIND v(dout1_14) AT=1010.025n

* CHECK dout1_15 Vdout1_15ck201 = 0.9 time = 1010
.meas tran vdout1_15ck201 FIND v(dout1_15) AT=1010.025n

* CHECK dout1_16 Vdout1_16ck201 = 0.9 time = 1010
.meas tran vdout1_16ck201 FIND v(dout1_16) AT=1010.025n

* CHECK dout1_17 Vdout1_17ck201 = 0 time = 1010
.meas tran vdout1_17ck201 FIND v(dout1_17) AT=1010.025n

* CHECK dout1_18 Vdout1_18ck201 = 0 time = 1010
.meas tran vdout1_18ck201 FIND v(dout1_18) AT=1010.025n

* CHECK dout1_19 Vdout1_19ck201 = 0.9 time = 1010
.meas tran vdout1_19ck201 FIND v(dout1_19) AT=1010.025n

* CHECK dout1_20 Vdout1_20ck201 = 0 time = 1010
.meas tran vdout1_20ck201 FIND v(dout1_20) AT=1010.025n

* CHECK dout1_21 Vdout1_21ck201 = 0 time = 1010
.meas tran vdout1_21ck201 FIND v(dout1_21) AT=1010.025n

* CHECK dout1_22 Vdout1_22ck201 = 0 time = 1010
.meas tran vdout1_22ck201 FIND v(dout1_22) AT=1010.025n

* CHECK dout1_23 Vdout1_23ck201 = 0.9 time = 1010
.meas tran vdout1_23ck201 FIND v(dout1_23) AT=1010.025n

* CHECK dout1_24 Vdout1_24ck201 = 0.9 time = 1010
.meas tran vdout1_24ck201 FIND v(dout1_24) AT=1010.025n

* CHECK dout1_25 Vdout1_25ck201 = 0 time = 1010
.meas tran vdout1_25ck201 FIND v(dout1_25) AT=1010.025n

* CHECK dout1_26 Vdout1_26ck201 = 0 time = 1010
.meas tran vdout1_26ck201 FIND v(dout1_26) AT=1010.025n

* CHECK dout1_27 Vdout1_27ck201 = 0.9 time = 1010
.meas tran vdout1_27ck201 FIND v(dout1_27) AT=1010.025n

* CHECK dout1_28 Vdout1_28ck201 = 0.9 time = 1010
.meas tran vdout1_28ck201 FIND v(dout1_28) AT=1010.025n

* CHECK dout1_29 Vdout1_29ck201 = 0.9 time = 1010
.meas tran vdout1_29ck201 FIND v(dout1_29) AT=1010.025n

* CHECK dout1_30 Vdout1_30ck201 = 0 time = 1010
.meas tran vdout1_30ck201 FIND v(dout1_30) AT=1010.025n

* CHECK dout1_31 Vdout1_31ck201 = 0.9 time = 1010
.meas tran vdout1_31ck201 FIND v(dout1_31) AT=1010.025n

* CHECK dout1_32 Vdout1_32ck201 = 0.9 time = 1010
.meas tran vdout1_32ck201 FIND v(dout1_32) AT=1010.025n

* CHECK dout1_33 Vdout1_33ck201 = 0.9 time = 1010
.meas tran vdout1_33ck201 FIND v(dout1_33) AT=1010.025n

* CHECK dout1_34 Vdout1_34ck201 = 0.9 time = 1010
.meas tran vdout1_34ck201 FIND v(dout1_34) AT=1010.025n

* CHECK dout1_35 Vdout1_35ck201 = 0.9 time = 1010
.meas tran vdout1_35ck201 FIND v(dout1_35) AT=1010.025n

* CHECK dout1_36 Vdout1_36ck201 = 0.9 time = 1010
.meas tran vdout1_36ck201 FIND v(dout1_36) AT=1010.025n

* CHECK dout1_37 Vdout1_37ck201 = 0 time = 1010
.meas tran vdout1_37ck201 FIND v(dout1_37) AT=1010.025n

* CHECK dout1_38 Vdout1_38ck201 = 0.9 time = 1010
.meas tran vdout1_38ck201 FIND v(dout1_38) AT=1010.025n

* CHECK dout1_39 Vdout1_39ck201 = 0.9 time = 1010
.meas tran vdout1_39ck201 FIND v(dout1_39) AT=1010.025n

* CHECK dout1_40 Vdout1_40ck201 = 0.9 time = 1010
.meas tran vdout1_40ck201 FIND v(dout1_40) AT=1010.025n

* CHECK dout1_41 Vdout1_41ck201 = 0 time = 1010
.meas tran vdout1_41ck201 FIND v(dout1_41) AT=1010.025n

* CHECK dout1_42 Vdout1_42ck201 = 0.9 time = 1010
.meas tran vdout1_42ck201 FIND v(dout1_42) AT=1010.025n

* CHECK dout1_43 Vdout1_43ck201 = 0.9 time = 1010
.meas tran vdout1_43ck201 FIND v(dout1_43) AT=1010.025n

* CHECK dout1_44 Vdout1_44ck201 = 0.9 time = 1010
.meas tran vdout1_44ck201 FIND v(dout1_44) AT=1010.025n

* CHECK dout1_45 Vdout1_45ck201 = 0 time = 1010
.meas tran vdout1_45ck201 FIND v(dout1_45) AT=1010.025n

* CHECK dout1_46 Vdout1_46ck201 = 0.9 time = 1010
.meas tran vdout1_46ck201 FIND v(dout1_46) AT=1010.025n

* CHECK dout1_47 Vdout1_47ck201 = 0 time = 1010
.meas tran vdout1_47ck201 FIND v(dout1_47) AT=1010.025n

* CHECK dout1_48 Vdout1_48ck201 = 0.9 time = 1010
.meas tran vdout1_48ck201 FIND v(dout1_48) AT=1010.025n

* CHECK dout1_49 Vdout1_49ck201 = 0.9 time = 1010
.meas tran vdout1_49ck201 FIND v(dout1_49) AT=1010.025n

* CHECK dout1_50 Vdout1_50ck201 = 0 time = 1010
.meas tran vdout1_50ck201 FIND v(dout1_50) AT=1010.025n

* CHECK dout1_51 Vdout1_51ck201 = 0.9 time = 1010
.meas tran vdout1_51ck201 FIND v(dout1_51) AT=1010.025n

* CHECK dout1_52 Vdout1_52ck201 = 0.9 time = 1010
.meas tran vdout1_52ck201 FIND v(dout1_52) AT=1010.025n

* CHECK dout1_53 Vdout1_53ck201 = 0.9 time = 1010
.meas tran vdout1_53ck201 FIND v(dout1_53) AT=1010.025n

* CHECK dout1_54 Vdout1_54ck201 = 0 time = 1010
.meas tran vdout1_54ck201 FIND v(dout1_54) AT=1010.025n

* CHECK dout1_55 Vdout1_55ck201 = 0.9 time = 1010
.meas tran vdout1_55ck201 FIND v(dout1_55) AT=1010.025n

* CHECK dout1_56 Vdout1_56ck201 = 0.9 time = 1010
.meas tran vdout1_56ck201 FIND v(dout1_56) AT=1010.025n

* CHECK dout1_57 Vdout1_57ck201 = 0 time = 1010
.meas tran vdout1_57ck201 FIND v(dout1_57) AT=1010.025n

* CHECK dout1_58 Vdout1_58ck201 = 0 time = 1010
.meas tran vdout1_58ck201 FIND v(dout1_58) AT=1010.025n

* CHECK dout1_59 Vdout1_59ck201 = 0.9 time = 1010
.meas tran vdout1_59ck201 FIND v(dout1_59) AT=1010.025n

* CHECK dout1_60 Vdout1_60ck201 = 0.9 time = 1010
.meas tran vdout1_60ck201 FIND v(dout1_60) AT=1010.025n

* CHECK dout1_61 Vdout1_61ck201 = 0 time = 1010
.meas tran vdout1_61ck201 FIND v(dout1_61) AT=1010.025n

* CHECK dout1_62 Vdout1_62ck201 = 0 time = 1010
.meas tran vdout1_62ck201 FIND v(dout1_62) AT=1010.025n

* CHECK dout1_63 Vdout1_63ck201 = 0.9 time = 1010
.meas tran vdout1_63ck201 FIND v(dout1_63) AT=1010.025n

* CHECK dout1_64 Vdout1_64ck201 = 0 time = 1010
.meas tran vdout1_64ck201 FIND v(dout1_64) AT=1010.025n

* CHECK dout1_65 Vdout1_65ck201 = 0 time = 1010
.meas tran vdout1_65ck201 FIND v(dout1_65) AT=1010.025n

* CHECK dout1_66 Vdout1_66ck201 = 0 time = 1010
.meas tran vdout1_66ck201 FIND v(dout1_66) AT=1010.025n

* CHECK dout1_67 Vdout1_67ck201 = 0 time = 1010
.meas tran vdout1_67ck201 FIND v(dout1_67) AT=1010.025n

* CHECK dout1_68 Vdout1_68ck201 = 0.9 time = 1010
.meas tran vdout1_68ck201 FIND v(dout1_68) AT=1010.025n

* CHECK dout1_69 Vdout1_69ck201 = 0 time = 1010
.meas tran vdout1_69ck201 FIND v(dout1_69) AT=1010.025n

* CHECK dout1_70 Vdout1_70ck201 = 0 time = 1010
.meas tran vdout1_70ck201 FIND v(dout1_70) AT=1010.025n

* CHECK dout1_71 Vdout1_71ck201 = 0.9 time = 1010
.meas tran vdout1_71ck201 FIND v(dout1_71) AT=1010.025n

* CHECK dout1_0 Vdout1_0ck203 = 0.9 time = 1020
.meas tran vdout1_0ck203 FIND v(dout1_0) AT=1020.025n

* CHECK dout1_1 Vdout1_1ck203 = 0 time = 1020
.meas tran vdout1_1ck203 FIND v(dout1_1) AT=1020.025n

* CHECK dout1_2 Vdout1_2ck203 = 0.9 time = 1020
.meas tran vdout1_2ck203 FIND v(dout1_2) AT=1020.025n

* CHECK dout1_3 Vdout1_3ck203 = 0.9 time = 1020
.meas tran vdout1_3ck203 FIND v(dout1_3) AT=1020.025n

* CHECK dout1_4 Vdout1_4ck203 = 0 time = 1020
.meas tran vdout1_4ck203 FIND v(dout1_4) AT=1020.025n

* CHECK dout1_5 Vdout1_5ck203 = 0 time = 1020
.meas tran vdout1_5ck203 FIND v(dout1_5) AT=1020.025n

* CHECK dout1_6 Vdout1_6ck203 = 0.9 time = 1020
.meas tran vdout1_6ck203 FIND v(dout1_6) AT=1020.025n

* CHECK dout1_7 Vdout1_7ck203 = 0 time = 1020
.meas tran vdout1_7ck203 FIND v(dout1_7) AT=1020.025n

* CHECK dout1_8 Vdout1_8ck203 = 0.9 time = 1020
.meas tran vdout1_8ck203 FIND v(dout1_8) AT=1020.025n

* CHECK dout1_9 Vdout1_9ck203 = 0.9 time = 1020
.meas tran vdout1_9ck203 FIND v(dout1_9) AT=1020.025n

* CHECK dout1_10 Vdout1_10ck203 = 0.9 time = 1020
.meas tran vdout1_10ck203 FIND v(dout1_10) AT=1020.025n

* CHECK dout1_11 Vdout1_11ck203 = 0.9 time = 1020
.meas tran vdout1_11ck203 FIND v(dout1_11) AT=1020.025n

* CHECK dout1_12 Vdout1_12ck203 = 0.9 time = 1020
.meas tran vdout1_12ck203 FIND v(dout1_12) AT=1020.025n

* CHECK dout1_13 Vdout1_13ck203 = 0 time = 1020
.meas tran vdout1_13ck203 FIND v(dout1_13) AT=1020.025n

* CHECK dout1_14 Vdout1_14ck203 = 0.9 time = 1020
.meas tran vdout1_14ck203 FIND v(dout1_14) AT=1020.025n

* CHECK dout1_15 Vdout1_15ck203 = 0.9 time = 1020
.meas tran vdout1_15ck203 FIND v(dout1_15) AT=1020.025n

* CHECK dout1_16 Vdout1_16ck203 = 0.9 time = 1020
.meas tran vdout1_16ck203 FIND v(dout1_16) AT=1020.025n

* CHECK dout1_17 Vdout1_17ck203 = 0 time = 1020
.meas tran vdout1_17ck203 FIND v(dout1_17) AT=1020.025n

* CHECK dout1_18 Vdout1_18ck203 = 0 time = 1020
.meas tran vdout1_18ck203 FIND v(dout1_18) AT=1020.025n

* CHECK dout1_19 Vdout1_19ck203 = 0.9 time = 1020
.meas tran vdout1_19ck203 FIND v(dout1_19) AT=1020.025n

* CHECK dout1_20 Vdout1_20ck203 = 0 time = 1020
.meas tran vdout1_20ck203 FIND v(dout1_20) AT=1020.025n

* CHECK dout1_21 Vdout1_21ck203 = 0 time = 1020
.meas tran vdout1_21ck203 FIND v(dout1_21) AT=1020.025n

* CHECK dout1_22 Vdout1_22ck203 = 0 time = 1020
.meas tran vdout1_22ck203 FIND v(dout1_22) AT=1020.025n

* CHECK dout1_23 Vdout1_23ck203 = 0.9 time = 1020
.meas tran vdout1_23ck203 FIND v(dout1_23) AT=1020.025n

* CHECK dout1_24 Vdout1_24ck203 = 0.9 time = 1020
.meas tran vdout1_24ck203 FIND v(dout1_24) AT=1020.025n

* CHECK dout1_25 Vdout1_25ck203 = 0 time = 1020
.meas tran vdout1_25ck203 FIND v(dout1_25) AT=1020.025n

* CHECK dout1_26 Vdout1_26ck203 = 0 time = 1020
.meas tran vdout1_26ck203 FIND v(dout1_26) AT=1020.025n

* CHECK dout1_27 Vdout1_27ck203 = 0.9 time = 1020
.meas tran vdout1_27ck203 FIND v(dout1_27) AT=1020.025n

* CHECK dout1_28 Vdout1_28ck203 = 0.9 time = 1020
.meas tran vdout1_28ck203 FIND v(dout1_28) AT=1020.025n

* CHECK dout1_29 Vdout1_29ck203 = 0.9 time = 1020
.meas tran vdout1_29ck203 FIND v(dout1_29) AT=1020.025n

* CHECK dout1_30 Vdout1_30ck203 = 0 time = 1020
.meas tran vdout1_30ck203 FIND v(dout1_30) AT=1020.025n

* CHECK dout1_31 Vdout1_31ck203 = 0.9 time = 1020
.meas tran vdout1_31ck203 FIND v(dout1_31) AT=1020.025n

* CHECK dout1_32 Vdout1_32ck203 = 0.9 time = 1020
.meas tran vdout1_32ck203 FIND v(dout1_32) AT=1020.025n

* CHECK dout1_33 Vdout1_33ck203 = 0.9 time = 1020
.meas tran vdout1_33ck203 FIND v(dout1_33) AT=1020.025n

* CHECK dout1_34 Vdout1_34ck203 = 0.9 time = 1020
.meas tran vdout1_34ck203 FIND v(dout1_34) AT=1020.025n

* CHECK dout1_35 Vdout1_35ck203 = 0.9 time = 1020
.meas tran vdout1_35ck203 FIND v(dout1_35) AT=1020.025n

* CHECK dout1_36 Vdout1_36ck203 = 0.9 time = 1020
.meas tran vdout1_36ck203 FIND v(dout1_36) AT=1020.025n

* CHECK dout1_37 Vdout1_37ck203 = 0 time = 1020
.meas tran vdout1_37ck203 FIND v(dout1_37) AT=1020.025n

* CHECK dout1_38 Vdout1_38ck203 = 0.9 time = 1020
.meas tran vdout1_38ck203 FIND v(dout1_38) AT=1020.025n

* CHECK dout1_39 Vdout1_39ck203 = 0.9 time = 1020
.meas tran vdout1_39ck203 FIND v(dout1_39) AT=1020.025n

* CHECK dout1_40 Vdout1_40ck203 = 0.9 time = 1020
.meas tran vdout1_40ck203 FIND v(dout1_40) AT=1020.025n

* CHECK dout1_41 Vdout1_41ck203 = 0 time = 1020
.meas tran vdout1_41ck203 FIND v(dout1_41) AT=1020.025n

* CHECK dout1_42 Vdout1_42ck203 = 0.9 time = 1020
.meas tran vdout1_42ck203 FIND v(dout1_42) AT=1020.025n

* CHECK dout1_43 Vdout1_43ck203 = 0.9 time = 1020
.meas tran vdout1_43ck203 FIND v(dout1_43) AT=1020.025n

* CHECK dout1_44 Vdout1_44ck203 = 0.9 time = 1020
.meas tran vdout1_44ck203 FIND v(dout1_44) AT=1020.025n

* CHECK dout1_45 Vdout1_45ck203 = 0 time = 1020
.meas tran vdout1_45ck203 FIND v(dout1_45) AT=1020.025n

* CHECK dout1_46 Vdout1_46ck203 = 0.9 time = 1020
.meas tran vdout1_46ck203 FIND v(dout1_46) AT=1020.025n

* CHECK dout1_47 Vdout1_47ck203 = 0 time = 1020
.meas tran vdout1_47ck203 FIND v(dout1_47) AT=1020.025n

* CHECK dout1_48 Vdout1_48ck203 = 0.9 time = 1020
.meas tran vdout1_48ck203 FIND v(dout1_48) AT=1020.025n

* CHECK dout1_49 Vdout1_49ck203 = 0.9 time = 1020
.meas tran vdout1_49ck203 FIND v(dout1_49) AT=1020.025n

* CHECK dout1_50 Vdout1_50ck203 = 0 time = 1020
.meas tran vdout1_50ck203 FIND v(dout1_50) AT=1020.025n

* CHECK dout1_51 Vdout1_51ck203 = 0.9 time = 1020
.meas tran vdout1_51ck203 FIND v(dout1_51) AT=1020.025n

* CHECK dout1_52 Vdout1_52ck203 = 0.9 time = 1020
.meas tran vdout1_52ck203 FIND v(dout1_52) AT=1020.025n

* CHECK dout1_53 Vdout1_53ck203 = 0.9 time = 1020
.meas tran vdout1_53ck203 FIND v(dout1_53) AT=1020.025n

* CHECK dout1_54 Vdout1_54ck203 = 0 time = 1020
.meas tran vdout1_54ck203 FIND v(dout1_54) AT=1020.025n

* CHECK dout1_55 Vdout1_55ck203 = 0.9 time = 1020
.meas tran vdout1_55ck203 FIND v(dout1_55) AT=1020.025n

* CHECK dout1_56 Vdout1_56ck203 = 0.9 time = 1020
.meas tran vdout1_56ck203 FIND v(dout1_56) AT=1020.025n

* CHECK dout1_57 Vdout1_57ck203 = 0 time = 1020
.meas tran vdout1_57ck203 FIND v(dout1_57) AT=1020.025n

* CHECK dout1_58 Vdout1_58ck203 = 0 time = 1020
.meas tran vdout1_58ck203 FIND v(dout1_58) AT=1020.025n

* CHECK dout1_59 Vdout1_59ck203 = 0.9 time = 1020
.meas tran vdout1_59ck203 FIND v(dout1_59) AT=1020.025n

* CHECK dout1_60 Vdout1_60ck203 = 0.9 time = 1020
.meas tran vdout1_60ck203 FIND v(dout1_60) AT=1020.025n

* CHECK dout1_61 Vdout1_61ck203 = 0 time = 1020
.meas tran vdout1_61ck203 FIND v(dout1_61) AT=1020.025n

* CHECK dout1_62 Vdout1_62ck203 = 0 time = 1020
.meas tran vdout1_62ck203 FIND v(dout1_62) AT=1020.025n

* CHECK dout1_63 Vdout1_63ck203 = 0.9 time = 1020
.meas tran vdout1_63ck203 FIND v(dout1_63) AT=1020.025n

* CHECK dout1_64 Vdout1_64ck203 = 0 time = 1020
.meas tran vdout1_64ck203 FIND v(dout1_64) AT=1020.025n

* CHECK dout1_65 Vdout1_65ck203 = 0 time = 1020
.meas tran vdout1_65ck203 FIND v(dout1_65) AT=1020.025n

* CHECK dout1_66 Vdout1_66ck203 = 0 time = 1020
.meas tran vdout1_66ck203 FIND v(dout1_66) AT=1020.025n

* CHECK dout1_67 Vdout1_67ck203 = 0 time = 1020
.meas tran vdout1_67ck203 FIND v(dout1_67) AT=1020.025n

* CHECK dout1_68 Vdout1_68ck203 = 0.9 time = 1020
.meas tran vdout1_68ck203 FIND v(dout1_68) AT=1020.025n

* CHECK dout1_69 Vdout1_69ck203 = 0 time = 1020
.meas tran vdout1_69ck203 FIND v(dout1_69) AT=1020.025n

* CHECK dout1_70 Vdout1_70ck203 = 0 time = 1020
.meas tran vdout1_70ck203 FIND v(dout1_70) AT=1020.025n

* CHECK dout1_71 Vdout1_71ck203 = 0.9 time = 1020
.meas tran vdout1_71ck203 FIND v(dout1_71) AT=1020.025n

* CHECK dout1_0 Vdout1_0ck204 = 0 time = 1025
.meas tran vdout1_0ck204 FIND v(dout1_0) AT=1025.025n

* CHECK dout1_1 Vdout1_1ck204 = 0.9 time = 1025
.meas tran vdout1_1ck204 FIND v(dout1_1) AT=1025.025n

* CHECK dout1_2 Vdout1_2ck204 = 0 time = 1025
.meas tran vdout1_2ck204 FIND v(dout1_2) AT=1025.025n

* CHECK dout1_3 Vdout1_3ck204 = 0.9 time = 1025
.meas tran vdout1_3ck204 FIND v(dout1_3) AT=1025.025n

* CHECK dout1_4 Vdout1_4ck204 = 0 time = 1025
.meas tran vdout1_4ck204 FIND v(dout1_4) AT=1025.025n

* CHECK dout1_5 Vdout1_5ck204 = 0.9 time = 1025
.meas tran vdout1_5ck204 FIND v(dout1_5) AT=1025.025n

* CHECK dout1_6 Vdout1_6ck204 = 0.9 time = 1025
.meas tran vdout1_6ck204 FIND v(dout1_6) AT=1025.025n

* CHECK dout1_7 Vdout1_7ck204 = 0.9 time = 1025
.meas tran vdout1_7ck204 FIND v(dout1_7) AT=1025.025n

* CHECK dout1_8 Vdout1_8ck204 = 0.9 time = 1025
.meas tran vdout1_8ck204 FIND v(dout1_8) AT=1025.025n

* CHECK dout1_9 Vdout1_9ck204 = 0.9 time = 1025
.meas tran vdout1_9ck204 FIND v(dout1_9) AT=1025.025n

* CHECK dout1_10 Vdout1_10ck204 = 0 time = 1025
.meas tran vdout1_10ck204 FIND v(dout1_10) AT=1025.025n

* CHECK dout1_11 Vdout1_11ck204 = 0.9 time = 1025
.meas tran vdout1_11ck204 FIND v(dout1_11) AT=1025.025n

* CHECK dout1_12 Vdout1_12ck204 = 0.9 time = 1025
.meas tran vdout1_12ck204 FIND v(dout1_12) AT=1025.025n

* CHECK dout1_13 Vdout1_13ck204 = 0.9 time = 1025
.meas tran vdout1_13ck204 FIND v(dout1_13) AT=1025.025n

* CHECK dout1_14 Vdout1_14ck204 = 0 time = 1025
.meas tran vdout1_14ck204 FIND v(dout1_14) AT=1025.025n

* CHECK dout1_15 Vdout1_15ck204 = 0 time = 1025
.meas tran vdout1_15ck204 FIND v(dout1_15) AT=1025.025n

* CHECK dout1_16 Vdout1_16ck204 = 0.9 time = 1025
.meas tran vdout1_16ck204 FIND v(dout1_16) AT=1025.025n

* CHECK dout1_17 Vdout1_17ck204 = 0.9 time = 1025
.meas tran vdout1_17ck204 FIND v(dout1_17) AT=1025.025n

* CHECK dout1_18 Vdout1_18ck204 = 0.9 time = 1025
.meas tran vdout1_18ck204 FIND v(dout1_18) AT=1025.025n

* CHECK dout1_19 Vdout1_19ck204 = 0.9 time = 1025
.meas tran vdout1_19ck204 FIND v(dout1_19) AT=1025.025n

* CHECK dout1_20 Vdout1_20ck204 = 0.9 time = 1025
.meas tran vdout1_20ck204 FIND v(dout1_20) AT=1025.025n

* CHECK dout1_21 Vdout1_21ck204 = 0 time = 1025
.meas tran vdout1_21ck204 FIND v(dout1_21) AT=1025.025n

* CHECK dout1_22 Vdout1_22ck204 = 0.9 time = 1025
.meas tran vdout1_22ck204 FIND v(dout1_22) AT=1025.025n

* CHECK dout1_23 Vdout1_23ck204 = 0.9 time = 1025
.meas tran vdout1_23ck204 FIND v(dout1_23) AT=1025.025n

* CHECK dout1_24 Vdout1_24ck204 = 0 time = 1025
.meas tran vdout1_24ck204 FIND v(dout1_24) AT=1025.025n

* CHECK dout1_25 Vdout1_25ck204 = 0.9 time = 1025
.meas tran vdout1_25ck204 FIND v(dout1_25) AT=1025.025n

* CHECK dout1_26 Vdout1_26ck204 = 0 time = 1025
.meas tran vdout1_26ck204 FIND v(dout1_26) AT=1025.025n

* CHECK dout1_27 Vdout1_27ck204 = 0.9 time = 1025
.meas tran vdout1_27ck204 FIND v(dout1_27) AT=1025.025n

* CHECK dout1_28 Vdout1_28ck204 = 0 time = 1025
.meas tran vdout1_28ck204 FIND v(dout1_28) AT=1025.025n

* CHECK dout1_29 Vdout1_29ck204 = 0.9 time = 1025
.meas tran vdout1_29ck204 FIND v(dout1_29) AT=1025.025n

* CHECK dout1_30 Vdout1_30ck204 = 0 time = 1025
.meas tran vdout1_30ck204 FIND v(dout1_30) AT=1025.025n

* CHECK dout1_31 Vdout1_31ck204 = 0 time = 1025
.meas tran vdout1_31ck204 FIND v(dout1_31) AT=1025.025n

* CHECK dout1_32 Vdout1_32ck204 = 0.9 time = 1025
.meas tran vdout1_32ck204 FIND v(dout1_32) AT=1025.025n

* CHECK dout1_33 Vdout1_33ck204 = 0.9 time = 1025
.meas tran vdout1_33ck204 FIND v(dout1_33) AT=1025.025n

* CHECK dout1_34 Vdout1_34ck204 = 0.9 time = 1025
.meas tran vdout1_34ck204 FIND v(dout1_34) AT=1025.025n

* CHECK dout1_35 Vdout1_35ck204 = 0 time = 1025
.meas tran vdout1_35ck204 FIND v(dout1_35) AT=1025.025n

* CHECK dout1_36 Vdout1_36ck204 = 0.9 time = 1025
.meas tran vdout1_36ck204 FIND v(dout1_36) AT=1025.025n

* CHECK dout1_37 Vdout1_37ck204 = 0.9 time = 1025
.meas tran vdout1_37ck204 FIND v(dout1_37) AT=1025.025n

* CHECK dout1_38 Vdout1_38ck204 = 0.9 time = 1025
.meas tran vdout1_38ck204 FIND v(dout1_38) AT=1025.025n

* CHECK dout1_39 Vdout1_39ck204 = 0 time = 1025
.meas tran vdout1_39ck204 FIND v(dout1_39) AT=1025.025n

* CHECK dout1_40 Vdout1_40ck204 = 0.9 time = 1025
.meas tran vdout1_40ck204 FIND v(dout1_40) AT=1025.025n

* CHECK dout1_41 Vdout1_41ck204 = 0 time = 1025
.meas tran vdout1_41ck204 FIND v(dout1_41) AT=1025.025n

* CHECK dout1_42 Vdout1_42ck204 = 0 time = 1025
.meas tran vdout1_42ck204 FIND v(dout1_42) AT=1025.025n

* CHECK dout1_43 Vdout1_43ck204 = 0.9 time = 1025
.meas tran vdout1_43ck204 FIND v(dout1_43) AT=1025.025n

* CHECK dout1_44 Vdout1_44ck204 = 0 time = 1025
.meas tran vdout1_44ck204 FIND v(dout1_44) AT=1025.025n

* CHECK dout1_45 Vdout1_45ck204 = 0 time = 1025
.meas tran vdout1_45ck204 FIND v(dout1_45) AT=1025.025n

* CHECK dout1_46 Vdout1_46ck204 = 0.9 time = 1025
.meas tran vdout1_46ck204 FIND v(dout1_46) AT=1025.025n

* CHECK dout1_47 Vdout1_47ck204 = 0.9 time = 1025
.meas tran vdout1_47ck204 FIND v(dout1_47) AT=1025.025n

* CHECK dout1_48 Vdout1_48ck204 = 0.9 time = 1025
.meas tran vdout1_48ck204 FIND v(dout1_48) AT=1025.025n

* CHECK dout1_49 Vdout1_49ck204 = 0.9 time = 1025
.meas tran vdout1_49ck204 FIND v(dout1_49) AT=1025.025n

* CHECK dout1_50 Vdout1_50ck204 = 0.9 time = 1025
.meas tran vdout1_50ck204 FIND v(dout1_50) AT=1025.025n

* CHECK dout1_51 Vdout1_51ck204 = 0.9 time = 1025
.meas tran vdout1_51ck204 FIND v(dout1_51) AT=1025.025n

* CHECK dout1_52 Vdout1_52ck204 = 0 time = 1025
.meas tran vdout1_52ck204 FIND v(dout1_52) AT=1025.025n

* CHECK dout1_53 Vdout1_53ck204 = 0 time = 1025
.meas tran vdout1_53ck204 FIND v(dout1_53) AT=1025.025n

* CHECK dout1_54 Vdout1_54ck204 = 0 time = 1025
.meas tran vdout1_54ck204 FIND v(dout1_54) AT=1025.025n

* CHECK dout1_55 Vdout1_55ck204 = 0.9 time = 1025
.meas tran vdout1_55ck204 FIND v(dout1_55) AT=1025.025n

* CHECK dout1_56 Vdout1_56ck204 = 0 time = 1025
.meas tran vdout1_56ck204 FIND v(dout1_56) AT=1025.025n

* CHECK dout1_57 Vdout1_57ck204 = 0.9 time = 1025
.meas tran vdout1_57ck204 FIND v(dout1_57) AT=1025.025n

* CHECK dout1_58 Vdout1_58ck204 = 0 time = 1025
.meas tran vdout1_58ck204 FIND v(dout1_58) AT=1025.025n

* CHECK dout1_59 Vdout1_59ck204 = 0 time = 1025
.meas tran vdout1_59ck204 FIND v(dout1_59) AT=1025.025n

* CHECK dout1_60 Vdout1_60ck204 = 0 time = 1025
.meas tran vdout1_60ck204 FIND v(dout1_60) AT=1025.025n

* CHECK dout1_61 Vdout1_61ck204 = 0 time = 1025
.meas tran vdout1_61ck204 FIND v(dout1_61) AT=1025.025n

* CHECK dout1_62 Vdout1_62ck204 = 0 time = 1025
.meas tran vdout1_62ck204 FIND v(dout1_62) AT=1025.025n

* CHECK dout1_63 Vdout1_63ck204 = 0.9 time = 1025
.meas tran vdout1_63ck204 FIND v(dout1_63) AT=1025.025n

* CHECK dout1_64 Vdout1_64ck204 = 0 time = 1025
.meas tran vdout1_64ck204 FIND v(dout1_64) AT=1025.025n

* CHECK dout1_65 Vdout1_65ck204 = 0 time = 1025
.meas tran vdout1_65ck204 FIND v(dout1_65) AT=1025.025n

* CHECK dout1_66 Vdout1_66ck204 = 0.9 time = 1025
.meas tran vdout1_66ck204 FIND v(dout1_66) AT=1025.025n

* CHECK dout1_67 Vdout1_67ck204 = 0 time = 1025
.meas tran vdout1_67ck204 FIND v(dout1_67) AT=1025.025n

* CHECK dout1_68 Vdout1_68ck204 = 0 time = 1025
.meas tran vdout1_68ck204 FIND v(dout1_68) AT=1025.025n

* CHECK dout1_69 Vdout1_69ck204 = 0.9 time = 1025
.meas tran vdout1_69ck204 FIND v(dout1_69) AT=1025.025n

* CHECK dout1_70 Vdout1_70ck204 = 0.9 time = 1025
.meas tran vdout1_70ck204 FIND v(dout1_70) AT=1025.025n

* CHECK dout1_71 Vdout1_71ck204 = 0 time = 1025
.meas tran vdout1_71ck204 FIND v(dout1_71) AT=1025.025n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
