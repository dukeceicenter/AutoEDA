* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "freepdk45_sram_1rw0r_256x64.sp"

* Global Power Supplies
Vvdd vdd 0 0.9

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xfreepdk45_sram_1rw0r_256x64 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 din0_40 din0_41 din0_42 din0_43 din0_44 din0_45 din0_46 din0_47 din0_48 din0_49 din0_50 din0_51 din0_52 din0_53 din0_54 din0_55 din0_56 din0_57 din0_58 din0_59 din0_60 din0_61 din0_62 din0_63 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout0_32 dout0_33 dout0_34 dout0_35 dout0_36 dout0_37 dout0_38 dout0_39 dout0_40 dout0_41 dout0_42 dout0_43 dout0_44 dout0_45 dout0_46 dout0_47 dout0_48 dout0_49 dout0_50 dout0_51 dout0_52 dout0_53 dout0_54 dout0_55 dout0_56 dout0_57 dout0_58 dout0_59 dout0_60 dout0_61 dout0_62 dout0_63 vdd gnd freepdk45_sram_1rw0r_256x64

* SRAM output loads
CD00 dout0_0  0 0.8364f
CD01 dout0_1  0 0.8364f
CD02 dout0_2  0 0.8364f
CD03 dout0_3  0 0.8364f
CD04 dout0_4  0 0.8364f
CD05 dout0_5  0 0.8364f
CD06 dout0_6  0 0.8364f
CD07 dout0_7  0 0.8364f
CD08 dout0_8  0 0.8364f
CD09 dout0_9  0 0.8364f
CD010 dout0_10  0 0.8364f
CD011 dout0_11  0 0.8364f
CD012 dout0_12  0 0.8364f
CD013 dout0_13  0 0.8364f
CD014 dout0_14  0 0.8364f
CD015 dout0_15  0 0.8364f
CD016 dout0_16  0 0.8364f
CD017 dout0_17  0 0.8364f
CD018 dout0_18  0 0.8364f
CD019 dout0_19  0 0.8364f
CD020 dout0_20  0 0.8364f
CD021 dout0_21  0 0.8364f
CD022 dout0_22  0 0.8364f
CD023 dout0_23  0 0.8364f
CD024 dout0_24  0 0.8364f
CD025 dout0_25  0 0.8364f
CD026 dout0_26  0 0.8364f
CD027 dout0_27  0 0.8364f
CD028 dout0_28  0 0.8364f
CD029 dout0_29  0 0.8364f
CD030 dout0_30  0 0.8364f
CD031 dout0_31  0 0.8364f
CD032 dout0_32  0 0.8364f
CD033 dout0_33  0 0.8364f
CD034 dout0_34  0 0.8364f
CD035 dout0_35  0 0.8364f
CD036 dout0_36  0 0.8364f
CD037 dout0_37  0 0.8364f
CD038 dout0_38  0 0.8364f
CD039 dout0_39  0 0.8364f
CD040 dout0_40  0 0.8364f
CD041 dout0_41  0 0.8364f
CD042 dout0_42  0 0.8364f
CD043 dout0_43  0 0.8364f
CD044 dout0_44  0 0.8364f
CD045 dout0_45  0 0.8364f
CD046 dout0_46  0 0.8364f
CD047 dout0_47  0 0.8364f
CD048 dout0_48  0 0.8364f
CD049 dout0_49  0 0.8364f
CD050 dout0_50  0 0.8364f
CD051 dout0_51  0 0.8364f
CD052 dout0_52  0 0.8364f
CD053 dout0_53  0 0.8364f
CD054 dout0_54  0 0.8364f
CD055 dout0_55  0 0.8364f
CD056 dout0_56  0 0.8364f
CD057 dout0_57  0 0.8364f
CD058 dout0_58  0 0.8364f
CD059 dout0_59  0 0.8364f
CD060 dout0_60  0 0.8364f
CD061 dout0_61  0 0.8364f
CD062 dout0_62  0 0.8364f
CD063 dout0_63  0 0.8364f

* Important signals for debug
* bl:	xfreepdk45_sram_1rw0r_256x64.xbank0.bl_0_0
* br:	xfreepdk45_sram_1rw0r_256x64.xbank0.br_0_0
* s_en:	xfreepdk45_sram_1rw0r_256x64.s_en
* q:	xfreepdk45_sram_1rw0r_256x64.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xfreepdk45_sram_1rw0r_256x64.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 1010100001111110011001100011000101000010110100010011111011011110  to  address 11111101 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 0100011101111011101101001100011010011001100011101001001011110001  to  address 00000000 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 1100010111010100000001111111011101001110001110001110111010001110  to  address 11111101 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 0100011101111011101101001100011010011001100011101001001011110001 from address 00000000 (from port 0) during cycle 4 (20ns - 25ns)
*	Writing 0011101001100101110000001101110010010101100100000000101001011001  to  address 00000000 (from port 0) during cycle 5 (25ns - 30ns)
*	Reading 0011101001100101110000001101110010010101100100000000101001011001 from address 00000000 (from port 0) during cycle 6 (30ns - 35ns)
*	Writing 1010110101001110011001011000000110101101011010010001101001100101  to  address 11111110 (from port 0) during cycle 9 (45ns - 50ns)
*	Reading 1100010111010100000001111111011101001110001110001110111010001110 from address 11111101 (from port 0) during cycle 10 (50ns - 55ns)
*	Writing 0111010011001101110101110100111111100101111011111100100010010110  to  address 11111110 (from port 0) during cycle 11 (55ns - 60ns)
*	Reading 0111010011001101110101110100111111100101111011111100100010010110 from address 11111110 (from port 0) during cycle 14 (70ns - 75ns)
*	Reading 0011101001100101110000001101110010010101100100000000101001011001 from address 00000000 (from port 0) during cycle 15 (75ns - 80ns)
*	Writing 0011111000001000100110101100100100000101001100111000001000010011  to  address 00000001 (from port 0) during cycle 16 (80ns - 85ns)
*	Reading 0011101001100101110000001101110010010101100100000000101001011001 from address 00000000 (from port 0) during cycle 17 (85ns - 90ns)
*	Reading 0111010011001101110101110100111111100101111011111100100010010110 from address 11111110 (from port 0) during cycle 18 (90ns - 95ns)
*	Writing 1001010010101111101010110110110010110100101101010011001110010001  to  address 00000001 (from port 0) during cycle 19 (95ns - 100ns)
*	Reading 1100010111010100000001111111011101001110001110001110111010001110 from address 11111101 (from port 0) during cycle 20 (100ns - 105ns)
*	Reading 1100010111010100000001111111011101001110001110001110111010001110 from address 11111101 (from port 0) during cycle 21 (105ns - 110ns)
*	Reading 0111010011001101110101110100111111100101111011111100100010010110 from address 11111110 (from port 0) during cycle 23 (115ns - 120ns)
*	Writing 0000110110111111110101011010000101010001001100011110100111000110  to  address 11111110 (from port 0) during cycle 24 (120ns - 125ns)
*	Reading 1001010010101111101010110110110010110100101101010011001110010001 from address 00000001 (from port 0) during cycle 26 (130ns - 135ns)
*	Writing 0001110110110101100100000110100110001001111100111011111000100001  to  address 00000001 (from port 0) during cycle 28 (140ns - 145ns)
*	Reading 1100010111010100000001111111011101001110001110001110111010001110 from address 11111101 (from port 0) during cycle 29 (145ns - 150ns)
*	Reading 1100010111010100000001111111011101001110001110001110111010001110 from address 11111101 (from port 0) during cycle 33 (165ns - 170ns)
*	Reading 1100010111010100000001111111011101001110001110001110111010001110 from address 11111101 (from port 0) during cycle 34 (170ns - 175ns)
*	Reading 0001110110110101100100000110100110001001111100111011111000100001 from address 00000001 (from port 0) during cycle 36 (180ns - 185ns)
*	Writing 0110011010110010110100010001010111110100110110010111000010101001  to  address 00000001 (from port 0) during cycle 38 (190ns - 195ns)
*	Reading 0000110110111111110101011010000101010001001100011110100111000110 from address 11111110 (from port 0) during cycle 39 (195ns - 200ns)
*	Reading 0011101001100101110000001101110010010101100100000000101001011001 from address 00000000 (from port 0) during cycle 40 (200ns - 205ns)
*	Reading 0110011010110010110100010001010111110100110110010111000010101001 from address 00000001 (from port 0) during cycle 41 (205ns - 210ns)
*	Reading 0110011010110010110100010001010111110100110110010111000010101001 from address 00000001 (from port 0) during cycle 42 (210ns - 215ns)
*	Writing 1011100000100011110000100000100010000000010100101110001110101111  to  address 00000000 (from port 0) during cycle 43 (215ns - 220ns)
*	Writing 0011001111001110101110000100100100011001010010011101110101110111  to  address 00000001 (from port 0) during cycle 44 (220ns - 225ns)
*	Reading 0011001111001110101110000100100100011001010010011101110101110111 from address 00000001 (from port 0) during cycle 45 (225ns - 230ns)
*	Reading 0011001111001110101110000100100100011001010010011101110101110111 from address 00000001 (from port 0) during cycle 46 (230ns - 235ns)
*	Reading 1011100000100011110000100000100010000000010100101110001110101111 from address 00000000 (from port 0) during cycle 47 (235ns - 240ns)
*	Reading 1011100000100011110000100000100010000000010100101110001110101111 from address 00000000 (from port 0) during cycle 48 (240ns - 245ns)
*	Reading 1100010111010100000001111111011101001110001110001110111010001110 from address 11111101 (from port 0) during cycle 51 (255ns - 260ns)
*	Writing 1111000001001101100011000101101010011110010100000111111000000110  to  address 00000001 (from port 0) during cycle 52 (260ns - 265ns)
*	Reading 1100010111010100000001111111011101001110001110001110111010001110 from address 11111101 (from port 0) during cycle 53 (265ns - 270ns)
*	Writing 0010010000101110110001111101100101011000101110010111100101101110  to  address 11111110 (from port 0) during cycle 54 (270ns - 275ns)
*	Reading 1111000001001101100011000101101010011110010100000111111000000110 from address 00000001 (from port 0) during cycle 55 (275ns - 280ns)
*	Writing 0111010011011010000101011011001010001111101010110010100011011011  to  address 00000000 (from port 0) during cycle 57 (285ns - 290ns)
*	Reading 0111010011011010000101011011001010001111101010110010100011011011 from address 00000000 (from port 0) during cycle 58 (290ns - 295ns)
*	Writing 0000101101111100111100101100001111101110011111000001011011101010  to  address 11111101 (from port 0) during cycle 59 (295ns - 300ns)
*	Writing 0011101110111000110011100001010001101111101100001011101101110110  to  address 00000001 (from port 0) during cycle 60 (300ns - 305ns)
*	Reading 0010010000101110110001111101100101011000101110010111100101101110 from address 11111110 (from port 0) during cycle 61 (305ns - 310ns)
*	Reading 0010010000101110110001111101100101011000101110010111100101101110 from address 11111110 (from port 0) during cycle 62 (310ns - 315ns)
*	Reading 0111010011011010000101011011001010001111101010110010100011011011 from address 00000000 (from port 0) during cycle 63 (315ns - 320ns)
*	Writing 1000101111001111101000110011110010011010101101001100110110101011  to  address 11111110 (from port 0) during cycle 64 (320ns - 325ns)
*	Reading 0000101101111100111100101100001111101110011111000001011011101010 from address 11111101 (from port 0) during cycle 65 (325ns - 330ns)
*	Reading 0000101101111100111100101100001111101110011111000001011011101010 from address 11111101 (from port 0) during cycle 70 (350ns - 355ns)
*	Reading 0011101110111000110011100001010001101111101100001011101101110110 from address 00000001 (from port 0) during cycle 71 (355ns - 360ns)
*	Reading 0111010011011010000101011011001010001111101010110010100011011011 from address 00000000 (from port 0) during cycle 73 (365ns - 370ns)
*	Reading 0111010011011010000101011011001010001111101010110010100011011011 from address 00000000 (from port 0) during cycle 74 (370ns - 375ns)
*	Writing 0100011001101100101001101000111010110110100001001101111001011010  to  address 11111110 (from port 0) during cycle 78 (390ns - 395ns)
*	Writing 1011000000101010001111110101101111100111111011101000100000111111  to  address 00000000 (from port 0) during cycle 79 (395ns - 400ns)
*	Reading 0011101110111000110011100001010001101111101100001011101101110110 from address 00000001 (from port 0) during cycle 80 (400ns - 405ns)
*	Reading 0000101101111100111100101100001111101110011111000001011011101010 from address 11111101 (from port 0) during cycle 81 (405ns - 410ns)
*	Writing 1001010100110110000000000100110101111111100111001101000011110011  to  address 00000000 (from port 0) during cycle 82 (410ns - 415ns)
*	Reading 0100011001101100101001101000111010110110100001001101111001011010 from address 11111110 (from port 0) during cycle 83 (415ns - 420ns)
*	Reading 1001010100110110000000000100110101111111100111001101000011110011 from address 00000000 (from port 0) during cycle 85 (425ns - 430ns)
*	Reading 1001010100110110000000000100110101111111100111001101000011110011 from address 00000000 (from port 0) during cycle 86 (430ns - 435ns)
*	Reading 0100011001101100101001101000111010110110100001001101111001011010 from address 11111110 (from port 0) during cycle 87 (435ns - 440ns)
*	Reading 0000101101111100111100101100001111101110011111000001011011101010 from address 11111101 (from port 0) during cycle 89 (445ns - 450ns)
*	Reading 0011101110111000110011100001010001101111101100001011101101110110 from address 00000001 (from port 0) during cycle 90 (450ns - 455ns)
*	Writing 0110100110010100001001011000000011110000110010100001101001011111  to  address 11111101 (from port 0) during cycle 91 (455ns - 460ns)
*	Reading 0011101110111000110011100001010001101111101100001011101101110110 from address 00000001 (from port 0) during cycle 92 (460ns - 465ns)
*	Writing 0000110111010010111101000001011100100000010010000000001100001110  to  address 00000000 (from port 0) during cycle 93 (465ns - 470ns)
*	Writing 1101000000011000011100011001111011010100100001111110000001000010  to  address 11111101 (from port 0) during cycle 94 (470ns - 475ns)
*	Reading 0100011001101100101001101000111010110110100001001101111001011010 from address 11111110 (from port 0) during cycle 95 (475ns - 480ns)
*	Writing 1111011110010110001100001000101011100111010010100111100101111010  to  address 00000001 (from port 0) during cycle 96 (480ns - 485ns)
*	Reading 1101000000011000011100011001111011010100100001111110000001000010 from address 11111101 (from port 0) during cycle 97 (485ns - 490ns)
*	Reading 0100011001101100101001101000111010110110100001001101111001011010 from address 11111110 (from port 0) during cycle 98 (490ns - 495ns)
*	Reading 0000110111010010111101000001011100100000010010000000001100001110 from address 00000000 (from port 0) during cycle 99 (495ns - 500ns)
*	Reading 1101000000011000011100011001111011010100100001111110000001000010 from address 11111101 (from port 0) during cycle 101 (505ns - 510ns)
*	Reading 1101000000011000011100011001111011010100100001111110000001000010 from address 11111101 (from port 0) during cycle 103 (515ns - 520ns)
*	Reading 0000110111010010111101000001011100100000010010000000001100001110 from address 00000000 (from port 0) during cycle 106 (530ns - 535ns)
*	Reading 0100011001101100101001101000111010110110100001001101111001011010 from address 11111110 (from port 0) during cycle 107 (535ns - 540ns)
*	Writing 0011101110110100110011111001111110100000110110011010010110001011  to  address 11111110 (from port 0) during cycle 108 (540ns - 545ns)
*	Reading 1111011110010110001100001000101011100111010010100111100101111010 from address 00000001 (from port 0) during cycle 109 (545ns - 550ns)
*	Writing 0100001001100111110000010101101110001101111110011111011100001011  to  address 00000000 (from port 0) during cycle 110 (550ns - 555ns)
*	Reading 1101000000011000011100011001111011010100100001111110000001000010 from address 11111101 (from port 0) during cycle 111 (555ns - 560ns)
*	Reading 0011101110110100110011111001111110100000110110011010010110001011 from address 11111110 (from port 0) during cycle 113 (565ns - 570ns)
*	Writing 0011010010110010101110111111000011011011011110100100101011110110  to  address 11111110 (from port 0) during cycle 114 (570ns - 575ns)
*	Reading 0100001001100111110000010101101110001101111110011111011100001011 from address 00000000 (from port 0) during cycle 115 (575ns - 580ns)
*	Writing 0100010010011011010100001100011111100010010011000010011100010111  to  address 11111110 (from port 0) during cycle 116 (580ns - 585ns)
*	Writing 0000100110001010001001100111110001110100101110110110101001100010  to  address 00000000 (from port 0) during cycle 117 (585ns - 590ns)
*	Writing 0000011011111100000100100101101110000111101000101101010011000000  to  address 11111101 (from port 0) during cycle 118 (590ns - 595ns)
*	Reading 0100010010011011010100001100011111100010010011000010011100010111 from address 11111110 (from port 0) during cycle 120 (600ns - 605ns)
*	Reading 0000011011111100000100100101101110000111101000101101010011000000 from address 11111101 (from port 0) during cycle 121 (605ns - 610ns)
*	Writing 0101000110000100101110011001010011110001110100010011101110011000  to  address 11111101 (from port 0) during cycle 123 (615ns - 620ns)
*	Reading 0000100110001010001001100111110001110100101110110110101001100010 from address 00000000 (from port 0) during cycle 124 (620ns - 625ns)
*	Reading 1111011110010110001100001000101011100111010010100111100101111010 from address 00000001 (from port 0) during cycle 126 (630ns - 635ns)
*	Writing 0010010010001111001001100100000010010011000101010101001001100011  to  address 11111101 (from port 0) during cycle 127 (635ns - 640ns)
*	Reading 0010010010001111001001100100000010010011000101010101001001100011 from address 11111101 (from port 0) during cycle 128 (640ns - 645ns)
*	Writing 1100001011110000001101100100101001101000100100011011101001101010  to  address 11111101 (from port 0) during cycle 130 (650ns - 655ns)
*	Writing 1001010001001111011111111011100000011001001110010101100100001101  to  address 00000000 (from port 0) during cycle 131 (655ns - 660ns)
*	Reading 0100010010011011010100001100011111100010010011000010011100010111 from address 11111110 (from port 0) during cycle 133 (665ns - 670ns)
*	Writing 1010011000100000110101100011011111100111011110001011000111000110  to  address 11111110 (from port 0) during cycle 136 (680ns - 685ns)
*	Writing 1001110101001111000001110011000101101101001010100011111001000111  to  address 11111110 (from port 0) during cycle 137 (685ns - 690ns)
*	Reading 1001110101001111000001110011000101101101001010100011111001000111 from address 11111110 (from port 0) during cycle 138 (690ns - 695ns)
*	Reading 1001110101001111000001110011000101101101001010100011111001000111 from address 11111110 (from port 0) during cycle 139 (695ns - 700ns)
*	Reading 1100001011110000001101100100101001101000100100011011101001101010 from address 11111101 (from port 0) during cycle 140 (700ns - 705ns)
*	Reading 1111011110010110001100001000101011100111010010100111100101111010 from address 00000001 (from port 0) during cycle 143 (715ns - 720ns)
*	Writing 0000100001001011001000000011111111101101001001111011010101001001  to  address 00000000 (from port 0) during cycle 144 (720ns - 725ns)
*	Reading 1111011110010110001100001000101011100111010010100111100101111010 from address 00000001 (from port 0) during cycle 145 (725ns - 730ns)
*	Writing 0000111000011110111100010010101111101110011110001011010101110000  to  address 00000000 (from port 0) during cycle 147 (735ns - 740ns)
*	Reading 0000111000011110111100010010101111101110011110001011010101110000 from address 00000000 (from port 0) during cycle 148 (740ns - 745ns)
*	Writing 0110011101101010001011100111111011111101111001110011001001111111  to  address 00000000 (from port 0) during cycle 149 (745ns - 750ns)
*	Writing 1110100100100110000100110101110100100100110010101110010100001000  to  address 11111101 (from port 0) during cycle 150 (750ns - 755ns)
*	Reading 1110100100100110000100110101110100100100110010101110010100001000 from address 11111101 (from port 0) during cycle 152 (760ns - 765ns)
*	Reading 1110100100100110000100110101110100100100110010101110010100001000 from address 11111101 (from port 0) during cycle 153 (765ns - 770ns)
*	Reading 0110011101101010001011100111111011111101111001110011001001111111 from address 00000000 (from port 0) during cycle 154 (770ns - 775ns)
*	Writing 0001111101100010110101011001111111001001111110110111010101000111  to  address 11111110 (from port 0) during cycle 155 (775ns - 780ns)
*	Reading 1110100100100110000100110101110100100100110010101110010100001000 from address 11111101 (from port 0) during cycle 156 (780ns - 785ns)
*	Writing 0010100010001110100001111011001000100100111110110000100001000101  to  address 11111110 (from port 0) during cycle 157 (785ns - 790ns)
*	Reading 1110100100100110000100110101110100100100110010101110010100001000 from address 11111101 (from port 0) during cycle 158 (790ns - 795ns)
*	Writing 1000111110001010111000011111001011000101111001000101001000010010  to  address 00000000 (from port 0) during cycle 161 (805ns - 810ns)
*	Writing 0111101110011110001011101111010101000101010101000100001011111000  to  address 00000000 (from port 0) during cycle 162 (810ns - 815ns)
*	Reading 0010100010001110100001111011001000100100111110110000100001000101 from address 11111110 (from port 0) during cycle 163 (815ns - 820ns)
*	Reading 0010100010001110100001111011001000100100111110110000100001000101 from address 11111110 (from port 0) during cycle 164 (820ns - 825ns)
*	Reading 1111011110010110001100001000101011100111010010100111100101111010 from address 00000001 (from port 0) during cycle 165 (825ns - 830ns)
*	Reading 1111011110010110001100001000101011100111010010100111100101111010 from address 00000001 (from port 0) during cycle 166 (830ns - 835ns)
*	Reading 0111101110011110001011101111010101000101010101000100001011111000 from address 00000000 (from port 0) during cycle 168 (840ns - 845ns)
*	Reading 1110100100100110000100110101110100100100110010101110010100001000 from address 11111101 (from port 0) during cycle 169 (845ns - 850ns)
*	Reading 0010100010001110100001111011001000100100111110110000100001000101 from address 11111110 (from port 0) during cycle 170 (850ns - 855ns)
*	Reading 0111101110011110001011101111010101000101010101000100001011111000 from address 00000000 (from port 0) during cycle 171 (855ns - 860ns)
*	Writing 0101111010100111100001100100001000010100100110010100011101110001  to  address 00000000 (from port 0) during cycle 172 (860ns - 865ns)
*	Reading 1110100100100110000100110101110100100100110010101110010100001000 from address 11111101 (from port 0) during cycle 173 (865ns - 870ns)
*	Reading 1110100100100110000100110101110100100100110010101110010100001000 from address 11111101 (from port 0) during cycle 174 (870ns - 875ns)
*	Reading 1111011110010110001100001000101011100111010010100111100101111010 from address 00000001 (from port 0) during cycle 176 (880ns - 885ns)
*	Reading 1110100100100110000100110101110100100100110010101110010100001000 from address 11111101 (from port 0) during cycle 177 (885ns - 890ns)
*	Writing 0000110110000010100101011000100001011011010010100001001010001000  to  address 11111101 (from port 0) during cycle 178 (890ns - 895ns)
*	Reading 0101111010100111100001100100001000010100100110010100011101110001 from address 00000000 (from port 0) during cycle 179 (895ns - 900ns)
*	Reading 0101111010100111100001100100001000010100100110010100011101110001 from address 00000000 (from port 0) during cycle 180 (900ns - 905ns)
*	Reading 0000110110000010100101011000100001011011010010100001001010001000 from address 11111101 (from port 0) during cycle 182 (910ns - 915ns)
*	Writing 0011101011101001011101101001001111100100001010101110101001101010  to  address 11111110 (from port 0) during cycle 183 (915ns - 920ns)
*	Writing 1001101011111000010111110011011101111010001011001010110000011111  to  address 11111101 (from port 0) during cycle 184 (920ns - 925ns)
*	Reading 0101111010100111100001100100001000010100100110010100011101110001 from address 00000000 (from port 0) during cycle 186 (930ns - 935ns)
*	Reading 0011101011101001011101101001001111100100001010101110101001101010 from address 11111110 (from port 0) during cycle 187 (935ns - 940ns)
*	Writing 1101010010001000100100111110110000001100100100101000110000101100  to  address 11111101 (from port 0) during cycle 189 (945ns - 950ns)
*	Reading 1111011110010110001100001000101011100111010010100111100101111010 from address 00000001 (from port 0) during cycle 190 (950ns - 955ns)
*	Writing 0001111101011111011000100001010011101110110100110110010100011100  to  address 11111110 (from port 0) during cycle 191 (955ns - 960ns)
*	Writing 0110100101101011110100011010100011011101111111010001000011010001  to  address 00000000 (from port 0) during cycle 192 (960ns - 965ns)
*	Reading 1101010010001000100100111110110000001100100100101000110000101100 from address 11111101 (from port 0) during cycle 193 (965ns - 970ns)
*	Writing 1011100011110101010001101101100000010001100011011101110110001011  to  address 11111110 (from port 0) during cycle 194 (970ns - 975ns)
*	Reading 1011100011110101010001101101100000010001100011011101110110001011 from address 11111110 (from port 0) during cycle 195 (975ns - 980ns)
*	Reading 1111011110010110001100001000101011100111010010100111100101111010 from address 00000001 (from port 0) during cycle 196 (980ns - 985ns)
*	Reading 1011100011110101010001101101100000010001100011011101110110001011 from address 11111110 (from port 0) during cycle 197 (985ns - 990ns)
*	Reading 1011100011110101010001101101100000010001100011011101110110001011 from address 11111110 (from port 0) during cycle 198 (990ns - 995ns)
*	Reading 1011100011110101010001101101100000010001100011011101110110001011 from address 11111110 (from port 0) during cycle 199 (995ns - 1000ns)
*	Reading 1101010010001000100100111110110000001100100100101000110000101100 from address 11111101 (from port 0) during cycle 200 (1000ns - 1005ns)
*	Writing 1011010001111101011110101001100000111001011110111101110100010111  to  address 00000001 (from port 0) during cycle 201 (1005ns - 1010ns)
*	Reading 1011010001111101011110101001100000111001011110111101110100010111 from address 00000001 (from port 0) during cycle 202 (1010ns - 1015ns)
*	Reading 1101010010001000100100111110110000001100100100101000110000101100 from address 11111101 (from port 0) during cycle 203 (1015ns - 1020ns)
*	Writing 1000011000010101110100000001000000101101100101101110110001001101  to  address 00000001 (from port 0) during cycle 204 (1020ns - 1025ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_40  din0_40  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_41  din0_41  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_42  din0_42  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_43  din0_43  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_44  din0_44  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_45  din0_45  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_46  din0_46  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_47  din0_47  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_48  din0_48  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_49  din0_49  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_50  din0_50  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_51  din0_51  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_52  din0_52  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_53  din0_53  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_54  din0_54  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_55  din0_55  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_56  din0_56  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_57  din0_57  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_58  din0_58  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_59  din0_59  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_60  din0_60  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_61  din0_61  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_62  din0_62  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_63  din0_63  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 0), (960, 0), (965, 1), (970, 0), (975, 0), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Va0_6  a0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Va0_7  a0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 1), (130, 0), (135, 1), (140, 0), (145, 0), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 1), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 1), (650, 0), (655, 0), (660, 1), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 0), (935, 0), (940, 1), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 1), (130, 1), (135, 1), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 0), (470, 0), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 0), (950, 1), (955, 0), (960, 0), (965, 1), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 1)]
VWEB0 WEB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 0.9 time = 25
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=25.025n

* CHECK dout0_1 Vdout0_1ck4 = 0 time = 25
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=25.025n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 25
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=25.025n

* CHECK dout0_3 Vdout0_3ck4 = 0 time = 25
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=25.025n

* CHECK dout0_4 Vdout0_4ck4 = 0.9 time = 25
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=25.025n

* CHECK dout0_5 Vdout0_5ck4 = 0.9 time = 25
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=25.025n

* CHECK dout0_6 Vdout0_6ck4 = 0.9 time = 25
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=25.025n

* CHECK dout0_7 Vdout0_7ck4 = 0.9 time = 25
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=25.025n

* CHECK dout0_8 Vdout0_8ck4 = 0 time = 25
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=25.025n

* CHECK dout0_9 Vdout0_9ck4 = 0.9 time = 25
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=25.025n

* CHECK dout0_10 Vdout0_10ck4 = 0 time = 25
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=25.025n

* CHECK dout0_11 Vdout0_11ck4 = 0 time = 25
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=25.025n

* CHECK dout0_12 Vdout0_12ck4 = 0.9 time = 25
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=25.025n

* CHECK dout0_13 Vdout0_13ck4 = 0 time = 25
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=25.025n

* CHECK dout0_14 Vdout0_14ck4 = 0 time = 25
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=25.025n

* CHECK dout0_15 Vdout0_15ck4 = 0.9 time = 25
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=25.025n

* CHECK dout0_16 Vdout0_16ck4 = 0 time = 25
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=25.025n

* CHECK dout0_17 Vdout0_17ck4 = 0.9 time = 25
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=25.025n

* CHECK dout0_18 Vdout0_18ck4 = 0.9 time = 25
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=25.025n

* CHECK dout0_19 Vdout0_19ck4 = 0.9 time = 25
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=25.025n

* CHECK dout0_20 Vdout0_20ck4 = 0 time = 25
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=25.025n

* CHECK dout0_21 Vdout0_21ck4 = 0 time = 25
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=25.025n

* CHECK dout0_22 Vdout0_22ck4 = 0 time = 25
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=25.025n

* CHECK dout0_23 Vdout0_23ck4 = 0.9 time = 25
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=25.025n

* CHECK dout0_24 Vdout0_24ck4 = 0.9 time = 25
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=25.025n

* CHECK dout0_25 Vdout0_25ck4 = 0 time = 25
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=25.025n

* CHECK dout0_26 Vdout0_26ck4 = 0 time = 25
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=25.025n

* CHECK dout0_27 Vdout0_27ck4 = 0.9 time = 25
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=25.025n

* CHECK dout0_28 Vdout0_28ck4 = 0.9 time = 25
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=25.025n

* CHECK dout0_29 Vdout0_29ck4 = 0 time = 25
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=25.025n

* CHECK dout0_30 Vdout0_30ck4 = 0 time = 25
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=25.025n

* CHECK dout0_31 Vdout0_31ck4 = 0.9 time = 25
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=25.025n

* CHECK dout0_32 Vdout0_32ck4 = 0 time = 25
.meas tran vdout0_32ck4 FIND v(dout0_32) AT=25.025n

* CHECK dout0_33 Vdout0_33ck4 = 0.9 time = 25
.meas tran vdout0_33ck4 FIND v(dout0_33) AT=25.025n

* CHECK dout0_34 Vdout0_34ck4 = 0.9 time = 25
.meas tran vdout0_34ck4 FIND v(dout0_34) AT=25.025n

* CHECK dout0_35 Vdout0_35ck4 = 0 time = 25
.meas tran vdout0_35ck4 FIND v(dout0_35) AT=25.025n

* CHECK dout0_36 Vdout0_36ck4 = 0 time = 25
.meas tran vdout0_36ck4 FIND v(dout0_36) AT=25.025n

* CHECK dout0_37 Vdout0_37ck4 = 0 time = 25
.meas tran vdout0_37ck4 FIND v(dout0_37) AT=25.025n

* CHECK dout0_38 Vdout0_38ck4 = 0.9 time = 25
.meas tran vdout0_38ck4 FIND v(dout0_38) AT=25.025n

* CHECK dout0_39 Vdout0_39ck4 = 0.9 time = 25
.meas tran vdout0_39ck4 FIND v(dout0_39) AT=25.025n

* CHECK dout0_40 Vdout0_40ck4 = 0 time = 25
.meas tran vdout0_40ck4 FIND v(dout0_40) AT=25.025n

* CHECK dout0_41 Vdout0_41ck4 = 0 time = 25
.meas tran vdout0_41ck4 FIND v(dout0_41) AT=25.025n

* CHECK dout0_42 Vdout0_42ck4 = 0.9 time = 25
.meas tran vdout0_42ck4 FIND v(dout0_42) AT=25.025n

* CHECK dout0_43 Vdout0_43ck4 = 0 time = 25
.meas tran vdout0_43ck4 FIND v(dout0_43) AT=25.025n

* CHECK dout0_44 Vdout0_44ck4 = 0.9 time = 25
.meas tran vdout0_44ck4 FIND v(dout0_44) AT=25.025n

* CHECK dout0_45 Vdout0_45ck4 = 0.9 time = 25
.meas tran vdout0_45ck4 FIND v(dout0_45) AT=25.025n

* CHECK dout0_46 Vdout0_46ck4 = 0 time = 25
.meas tran vdout0_46ck4 FIND v(dout0_46) AT=25.025n

* CHECK dout0_47 Vdout0_47ck4 = 0.9 time = 25
.meas tran vdout0_47ck4 FIND v(dout0_47) AT=25.025n

* CHECK dout0_48 Vdout0_48ck4 = 0.9 time = 25
.meas tran vdout0_48ck4 FIND v(dout0_48) AT=25.025n

* CHECK dout0_49 Vdout0_49ck4 = 0.9 time = 25
.meas tran vdout0_49ck4 FIND v(dout0_49) AT=25.025n

* CHECK dout0_50 Vdout0_50ck4 = 0 time = 25
.meas tran vdout0_50ck4 FIND v(dout0_50) AT=25.025n

* CHECK dout0_51 Vdout0_51ck4 = 0.9 time = 25
.meas tran vdout0_51ck4 FIND v(dout0_51) AT=25.025n

* CHECK dout0_52 Vdout0_52ck4 = 0.9 time = 25
.meas tran vdout0_52ck4 FIND v(dout0_52) AT=25.025n

* CHECK dout0_53 Vdout0_53ck4 = 0.9 time = 25
.meas tran vdout0_53ck4 FIND v(dout0_53) AT=25.025n

* CHECK dout0_54 Vdout0_54ck4 = 0.9 time = 25
.meas tran vdout0_54ck4 FIND v(dout0_54) AT=25.025n

* CHECK dout0_55 Vdout0_55ck4 = 0 time = 25
.meas tran vdout0_55ck4 FIND v(dout0_55) AT=25.025n

* CHECK dout0_56 Vdout0_56ck4 = 0.9 time = 25
.meas tran vdout0_56ck4 FIND v(dout0_56) AT=25.025n

* CHECK dout0_57 Vdout0_57ck4 = 0.9 time = 25
.meas tran vdout0_57ck4 FIND v(dout0_57) AT=25.025n

* CHECK dout0_58 Vdout0_58ck4 = 0.9 time = 25
.meas tran vdout0_58ck4 FIND v(dout0_58) AT=25.025n

* CHECK dout0_59 Vdout0_59ck4 = 0 time = 25
.meas tran vdout0_59ck4 FIND v(dout0_59) AT=25.025n

* CHECK dout0_60 Vdout0_60ck4 = 0 time = 25
.meas tran vdout0_60ck4 FIND v(dout0_60) AT=25.025n

* CHECK dout0_61 Vdout0_61ck4 = 0 time = 25
.meas tran vdout0_61ck4 FIND v(dout0_61) AT=25.025n

* CHECK dout0_62 Vdout0_62ck4 = 0.9 time = 25
.meas tran vdout0_62ck4 FIND v(dout0_62) AT=25.025n

* CHECK dout0_63 Vdout0_63ck4 = 0 time = 25
.meas tran vdout0_63ck4 FIND v(dout0_63) AT=25.025n

* CHECK dout0_0 Vdout0_0ck6 = 0.9 time = 35
.meas tran vdout0_0ck6 FIND v(dout0_0) AT=35.025n

* CHECK dout0_1 Vdout0_1ck6 = 0 time = 35
.meas tran vdout0_1ck6 FIND v(dout0_1) AT=35.025n

* CHECK dout0_2 Vdout0_2ck6 = 0 time = 35
.meas tran vdout0_2ck6 FIND v(dout0_2) AT=35.025n

* CHECK dout0_3 Vdout0_3ck6 = 0.9 time = 35
.meas tran vdout0_3ck6 FIND v(dout0_3) AT=35.025n

* CHECK dout0_4 Vdout0_4ck6 = 0.9 time = 35
.meas tran vdout0_4ck6 FIND v(dout0_4) AT=35.025n

* CHECK dout0_5 Vdout0_5ck6 = 0 time = 35
.meas tran vdout0_5ck6 FIND v(dout0_5) AT=35.025n

* CHECK dout0_6 Vdout0_6ck6 = 0.9 time = 35
.meas tran vdout0_6ck6 FIND v(dout0_6) AT=35.025n

* CHECK dout0_7 Vdout0_7ck6 = 0 time = 35
.meas tran vdout0_7ck6 FIND v(dout0_7) AT=35.025n

* CHECK dout0_8 Vdout0_8ck6 = 0 time = 35
.meas tran vdout0_8ck6 FIND v(dout0_8) AT=35.025n

* CHECK dout0_9 Vdout0_9ck6 = 0.9 time = 35
.meas tran vdout0_9ck6 FIND v(dout0_9) AT=35.025n

* CHECK dout0_10 Vdout0_10ck6 = 0 time = 35
.meas tran vdout0_10ck6 FIND v(dout0_10) AT=35.025n

* CHECK dout0_11 Vdout0_11ck6 = 0.9 time = 35
.meas tran vdout0_11ck6 FIND v(dout0_11) AT=35.025n

* CHECK dout0_12 Vdout0_12ck6 = 0 time = 35
.meas tran vdout0_12ck6 FIND v(dout0_12) AT=35.025n

* CHECK dout0_13 Vdout0_13ck6 = 0 time = 35
.meas tran vdout0_13ck6 FIND v(dout0_13) AT=35.025n

* CHECK dout0_14 Vdout0_14ck6 = 0 time = 35
.meas tran vdout0_14ck6 FIND v(dout0_14) AT=35.025n

* CHECK dout0_15 Vdout0_15ck6 = 0 time = 35
.meas tran vdout0_15ck6 FIND v(dout0_15) AT=35.025n

* CHECK dout0_16 Vdout0_16ck6 = 0 time = 35
.meas tran vdout0_16ck6 FIND v(dout0_16) AT=35.025n

* CHECK dout0_17 Vdout0_17ck6 = 0 time = 35
.meas tran vdout0_17ck6 FIND v(dout0_17) AT=35.025n

* CHECK dout0_18 Vdout0_18ck6 = 0 time = 35
.meas tran vdout0_18ck6 FIND v(dout0_18) AT=35.025n

* CHECK dout0_19 Vdout0_19ck6 = 0 time = 35
.meas tran vdout0_19ck6 FIND v(dout0_19) AT=35.025n

* CHECK dout0_20 Vdout0_20ck6 = 0.9 time = 35
.meas tran vdout0_20ck6 FIND v(dout0_20) AT=35.025n

* CHECK dout0_21 Vdout0_21ck6 = 0 time = 35
.meas tran vdout0_21ck6 FIND v(dout0_21) AT=35.025n

* CHECK dout0_22 Vdout0_22ck6 = 0 time = 35
.meas tran vdout0_22ck6 FIND v(dout0_22) AT=35.025n

* CHECK dout0_23 Vdout0_23ck6 = 0.9 time = 35
.meas tran vdout0_23ck6 FIND v(dout0_23) AT=35.025n

* CHECK dout0_24 Vdout0_24ck6 = 0.9 time = 35
.meas tran vdout0_24ck6 FIND v(dout0_24) AT=35.025n

* CHECK dout0_25 Vdout0_25ck6 = 0 time = 35
.meas tran vdout0_25ck6 FIND v(dout0_25) AT=35.025n

* CHECK dout0_26 Vdout0_26ck6 = 0.9 time = 35
.meas tran vdout0_26ck6 FIND v(dout0_26) AT=35.025n

* CHECK dout0_27 Vdout0_27ck6 = 0 time = 35
.meas tran vdout0_27ck6 FIND v(dout0_27) AT=35.025n

* CHECK dout0_28 Vdout0_28ck6 = 0.9 time = 35
.meas tran vdout0_28ck6 FIND v(dout0_28) AT=35.025n

* CHECK dout0_29 Vdout0_29ck6 = 0 time = 35
.meas tran vdout0_29ck6 FIND v(dout0_29) AT=35.025n

* CHECK dout0_30 Vdout0_30ck6 = 0 time = 35
.meas tran vdout0_30ck6 FIND v(dout0_30) AT=35.025n

* CHECK dout0_31 Vdout0_31ck6 = 0.9 time = 35
.meas tran vdout0_31ck6 FIND v(dout0_31) AT=35.025n

* CHECK dout0_32 Vdout0_32ck6 = 0 time = 35
.meas tran vdout0_32ck6 FIND v(dout0_32) AT=35.025n

* CHECK dout0_33 Vdout0_33ck6 = 0 time = 35
.meas tran vdout0_33ck6 FIND v(dout0_33) AT=35.025n

* CHECK dout0_34 Vdout0_34ck6 = 0.9 time = 35
.meas tran vdout0_34ck6 FIND v(dout0_34) AT=35.025n

* CHECK dout0_35 Vdout0_35ck6 = 0.9 time = 35
.meas tran vdout0_35ck6 FIND v(dout0_35) AT=35.025n

* CHECK dout0_36 Vdout0_36ck6 = 0.9 time = 35
.meas tran vdout0_36ck6 FIND v(dout0_36) AT=35.025n

* CHECK dout0_37 Vdout0_37ck6 = 0 time = 35
.meas tran vdout0_37ck6 FIND v(dout0_37) AT=35.025n

* CHECK dout0_38 Vdout0_38ck6 = 0.9 time = 35
.meas tran vdout0_38ck6 FIND v(dout0_38) AT=35.025n

* CHECK dout0_39 Vdout0_39ck6 = 0.9 time = 35
.meas tran vdout0_39ck6 FIND v(dout0_39) AT=35.025n

* CHECK dout0_40 Vdout0_40ck6 = 0 time = 35
.meas tran vdout0_40ck6 FIND v(dout0_40) AT=35.025n

* CHECK dout0_41 Vdout0_41ck6 = 0 time = 35
.meas tran vdout0_41ck6 FIND v(dout0_41) AT=35.025n

* CHECK dout0_42 Vdout0_42ck6 = 0 time = 35
.meas tran vdout0_42ck6 FIND v(dout0_42) AT=35.025n

* CHECK dout0_43 Vdout0_43ck6 = 0 time = 35
.meas tran vdout0_43ck6 FIND v(dout0_43) AT=35.025n

* CHECK dout0_44 Vdout0_44ck6 = 0 time = 35
.meas tran vdout0_44ck6 FIND v(dout0_44) AT=35.025n

* CHECK dout0_45 Vdout0_45ck6 = 0 time = 35
.meas tran vdout0_45ck6 FIND v(dout0_45) AT=35.025n

* CHECK dout0_46 Vdout0_46ck6 = 0.9 time = 35
.meas tran vdout0_46ck6 FIND v(dout0_46) AT=35.025n

* CHECK dout0_47 Vdout0_47ck6 = 0.9 time = 35
.meas tran vdout0_47ck6 FIND v(dout0_47) AT=35.025n

* CHECK dout0_48 Vdout0_48ck6 = 0.9 time = 35
.meas tran vdout0_48ck6 FIND v(dout0_48) AT=35.025n

* CHECK dout0_49 Vdout0_49ck6 = 0 time = 35
.meas tran vdout0_49ck6 FIND v(dout0_49) AT=35.025n

* CHECK dout0_50 Vdout0_50ck6 = 0.9 time = 35
.meas tran vdout0_50ck6 FIND v(dout0_50) AT=35.025n

* CHECK dout0_51 Vdout0_51ck6 = 0 time = 35
.meas tran vdout0_51ck6 FIND v(dout0_51) AT=35.025n

* CHECK dout0_52 Vdout0_52ck6 = 0 time = 35
.meas tran vdout0_52ck6 FIND v(dout0_52) AT=35.025n

* CHECK dout0_53 Vdout0_53ck6 = 0.9 time = 35
.meas tran vdout0_53ck6 FIND v(dout0_53) AT=35.025n

* CHECK dout0_54 Vdout0_54ck6 = 0.9 time = 35
.meas tran vdout0_54ck6 FIND v(dout0_54) AT=35.025n

* CHECK dout0_55 Vdout0_55ck6 = 0 time = 35
.meas tran vdout0_55ck6 FIND v(dout0_55) AT=35.025n

* CHECK dout0_56 Vdout0_56ck6 = 0 time = 35
.meas tran vdout0_56ck6 FIND v(dout0_56) AT=35.025n

* CHECK dout0_57 Vdout0_57ck6 = 0.9 time = 35
.meas tran vdout0_57ck6 FIND v(dout0_57) AT=35.025n

* CHECK dout0_58 Vdout0_58ck6 = 0 time = 35
.meas tran vdout0_58ck6 FIND v(dout0_58) AT=35.025n

* CHECK dout0_59 Vdout0_59ck6 = 0.9 time = 35
.meas tran vdout0_59ck6 FIND v(dout0_59) AT=35.025n

* CHECK dout0_60 Vdout0_60ck6 = 0.9 time = 35
.meas tran vdout0_60ck6 FIND v(dout0_60) AT=35.025n

* CHECK dout0_61 Vdout0_61ck6 = 0.9 time = 35
.meas tran vdout0_61ck6 FIND v(dout0_61) AT=35.025n

* CHECK dout0_62 Vdout0_62ck6 = 0 time = 35
.meas tran vdout0_62ck6 FIND v(dout0_62) AT=35.025n

* CHECK dout0_63 Vdout0_63ck6 = 0 time = 35
.meas tran vdout0_63ck6 FIND v(dout0_63) AT=35.025n

* CHECK dout0_0 Vdout0_0ck10 = 0 time = 55
.meas tran vdout0_0ck10 FIND v(dout0_0) AT=55.025n

* CHECK dout0_1 Vdout0_1ck10 = 0.9 time = 55
.meas tran vdout0_1ck10 FIND v(dout0_1) AT=55.025n

* CHECK dout0_2 Vdout0_2ck10 = 0.9 time = 55
.meas tran vdout0_2ck10 FIND v(dout0_2) AT=55.025n

* CHECK dout0_3 Vdout0_3ck10 = 0.9 time = 55
.meas tran vdout0_3ck10 FIND v(dout0_3) AT=55.025n

* CHECK dout0_4 Vdout0_4ck10 = 0 time = 55
.meas tran vdout0_4ck10 FIND v(dout0_4) AT=55.025n

* CHECK dout0_5 Vdout0_5ck10 = 0 time = 55
.meas tran vdout0_5ck10 FIND v(dout0_5) AT=55.025n

* CHECK dout0_6 Vdout0_6ck10 = 0 time = 55
.meas tran vdout0_6ck10 FIND v(dout0_6) AT=55.025n

* CHECK dout0_7 Vdout0_7ck10 = 0.9 time = 55
.meas tran vdout0_7ck10 FIND v(dout0_7) AT=55.025n

* CHECK dout0_8 Vdout0_8ck10 = 0 time = 55
.meas tran vdout0_8ck10 FIND v(dout0_8) AT=55.025n

* CHECK dout0_9 Vdout0_9ck10 = 0.9 time = 55
.meas tran vdout0_9ck10 FIND v(dout0_9) AT=55.025n

* CHECK dout0_10 Vdout0_10ck10 = 0.9 time = 55
.meas tran vdout0_10ck10 FIND v(dout0_10) AT=55.025n

* CHECK dout0_11 Vdout0_11ck10 = 0.9 time = 55
.meas tran vdout0_11ck10 FIND v(dout0_11) AT=55.025n

* CHECK dout0_12 Vdout0_12ck10 = 0 time = 55
.meas tran vdout0_12ck10 FIND v(dout0_12) AT=55.025n

* CHECK dout0_13 Vdout0_13ck10 = 0.9 time = 55
.meas tran vdout0_13ck10 FIND v(dout0_13) AT=55.025n

* CHECK dout0_14 Vdout0_14ck10 = 0.9 time = 55
.meas tran vdout0_14ck10 FIND v(dout0_14) AT=55.025n

* CHECK dout0_15 Vdout0_15ck10 = 0.9 time = 55
.meas tran vdout0_15ck10 FIND v(dout0_15) AT=55.025n

* CHECK dout0_16 Vdout0_16ck10 = 0 time = 55
.meas tran vdout0_16ck10 FIND v(dout0_16) AT=55.025n

* CHECK dout0_17 Vdout0_17ck10 = 0 time = 55
.meas tran vdout0_17ck10 FIND v(dout0_17) AT=55.025n

* CHECK dout0_18 Vdout0_18ck10 = 0 time = 55
.meas tran vdout0_18ck10 FIND v(dout0_18) AT=55.025n

* CHECK dout0_19 Vdout0_19ck10 = 0.9 time = 55
.meas tran vdout0_19ck10 FIND v(dout0_19) AT=55.025n

* CHECK dout0_20 Vdout0_20ck10 = 0.9 time = 55
.meas tran vdout0_20ck10 FIND v(dout0_20) AT=55.025n

* CHECK dout0_21 Vdout0_21ck10 = 0.9 time = 55
.meas tran vdout0_21ck10 FIND v(dout0_21) AT=55.025n

* CHECK dout0_22 Vdout0_22ck10 = 0 time = 55
.meas tran vdout0_22ck10 FIND v(dout0_22) AT=55.025n

* CHECK dout0_23 Vdout0_23ck10 = 0 time = 55
.meas tran vdout0_23ck10 FIND v(dout0_23) AT=55.025n

* CHECK dout0_24 Vdout0_24ck10 = 0 time = 55
.meas tran vdout0_24ck10 FIND v(dout0_24) AT=55.025n

* CHECK dout0_25 Vdout0_25ck10 = 0.9 time = 55
.meas tran vdout0_25ck10 FIND v(dout0_25) AT=55.025n

* CHECK dout0_26 Vdout0_26ck10 = 0.9 time = 55
.meas tran vdout0_26ck10 FIND v(dout0_26) AT=55.025n

* CHECK dout0_27 Vdout0_27ck10 = 0.9 time = 55
.meas tran vdout0_27ck10 FIND v(dout0_27) AT=55.025n

* CHECK dout0_28 Vdout0_28ck10 = 0 time = 55
.meas tran vdout0_28ck10 FIND v(dout0_28) AT=55.025n

* CHECK dout0_29 Vdout0_29ck10 = 0 time = 55
.meas tran vdout0_29ck10 FIND v(dout0_29) AT=55.025n

* CHECK dout0_30 Vdout0_30ck10 = 0.9 time = 55
.meas tran vdout0_30ck10 FIND v(dout0_30) AT=55.025n

* CHECK dout0_31 Vdout0_31ck10 = 0 time = 55
.meas tran vdout0_31ck10 FIND v(dout0_31) AT=55.025n

* CHECK dout0_32 Vdout0_32ck10 = 0.9 time = 55
.meas tran vdout0_32ck10 FIND v(dout0_32) AT=55.025n

* CHECK dout0_33 Vdout0_33ck10 = 0.9 time = 55
.meas tran vdout0_33ck10 FIND v(dout0_33) AT=55.025n

* CHECK dout0_34 Vdout0_34ck10 = 0.9 time = 55
.meas tran vdout0_34ck10 FIND v(dout0_34) AT=55.025n

* CHECK dout0_35 Vdout0_35ck10 = 0 time = 55
.meas tran vdout0_35ck10 FIND v(dout0_35) AT=55.025n

* CHECK dout0_36 Vdout0_36ck10 = 0.9 time = 55
.meas tran vdout0_36ck10 FIND v(dout0_36) AT=55.025n

* CHECK dout0_37 Vdout0_37ck10 = 0.9 time = 55
.meas tran vdout0_37ck10 FIND v(dout0_37) AT=55.025n

* CHECK dout0_38 Vdout0_38ck10 = 0.9 time = 55
.meas tran vdout0_38ck10 FIND v(dout0_38) AT=55.025n

* CHECK dout0_39 Vdout0_39ck10 = 0.9 time = 55
.meas tran vdout0_39ck10 FIND v(dout0_39) AT=55.025n

* CHECK dout0_40 Vdout0_40ck10 = 0.9 time = 55
.meas tran vdout0_40ck10 FIND v(dout0_40) AT=55.025n

* CHECK dout0_41 Vdout0_41ck10 = 0.9 time = 55
.meas tran vdout0_41ck10 FIND v(dout0_41) AT=55.025n

* CHECK dout0_42 Vdout0_42ck10 = 0.9 time = 55
.meas tran vdout0_42ck10 FIND v(dout0_42) AT=55.025n

* CHECK dout0_43 Vdout0_43ck10 = 0 time = 55
.meas tran vdout0_43ck10 FIND v(dout0_43) AT=55.025n

* CHECK dout0_44 Vdout0_44ck10 = 0 time = 55
.meas tran vdout0_44ck10 FIND v(dout0_44) AT=55.025n

* CHECK dout0_45 Vdout0_45ck10 = 0 time = 55
.meas tran vdout0_45ck10 FIND v(dout0_45) AT=55.025n

* CHECK dout0_46 Vdout0_46ck10 = 0 time = 55
.meas tran vdout0_46ck10 FIND v(dout0_46) AT=55.025n

* CHECK dout0_47 Vdout0_47ck10 = 0 time = 55
.meas tran vdout0_47ck10 FIND v(dout0_47) AT=55.025n

* CHECK dout0_48 Vdout0_48ck10 = 0 time = 55
.meas tran vdout0_48ck10 FIND v(dout0_48) AT=55.025n

* CHECK dout0_49 Vdout0_49ck10 = 0 time = 55
.meas tran vdout0_49ck10 FIND v(dout0_49) AT=55.025n

* CHECK dout0_50 Vdout0_50ck10 = 0.9 time = 55
.meas tran vdout0_50ck10 FIND v(dout0_50) AT=55.025n

* CHECK dout0_51 Vdout0_51ck10 = 0 time = 55
.meas tran vdout0_51ck10 FIND v(dout0_51) AT=55.025n

* CHECK dout0_52 Vdout0_52ck10 = 0.9 time = 55
.meas tran vdout0_52ck10 FIND v(dout0_52) AT=55.025n

* CHECK dout0_53 Vdout0_53ck10 = 0 time = 55
.meas tran vdout0_53ck10 FIND v(dout0_53) AT=55.025n

* CHECK dout0_54 Vdout0_54ck10 = 0.9 time = 55
.meas tran vdout0_54ck10 FIND v(dout0_54) AT=55.025n

* CHECK dout0_55 Vdout0_55ck10 = 0.9 time = 55
.meas tran vdout0_55ck10 FIND v(dout0_55) AT=55.025n

* CHECK dout0_56 Vdout0_56ck10 = 0.9 time = 55
.meas tran vdout0_56ck10 FIND v(dout0_56) AT=55.025n

* CHECK dout0_57 Vdout0_57ck10 = 0 time = 55
.meas tran vdout0_57ck10 FIND v(dout0_57) AT=55.025n

* CHECK dout0_58 Vdout0_58ck10 = 0.9 time = 55
.meas tran vdout0_58ck10 FIND v(dout0_58) AT=55.025n

* CHECK dout0_59 Vdout0_59ck10 = 0 time = 55
.meas tran vdout0_59ck10 FIND v(dout0_59) AT=55.025n

* CHECK dout0_60 Vdout0_60ck10 = 0 time = 55
.meas tran vdout0_60ck10 FIND v(dout0_60) AT=55.025n

* CHECK dout0_61 Vdout0_61ck10 = 0 time = 55
.meas tran vdout0_61ck10 FIND v(dout0_61) AT=55.025n

* CHECK dout0_62 Vdout0_62ck10 = 0.9 time = 55
.meas tran vdout0_62ck10 FIND v(dout0_62) AT=55.025n

* CHECK dout0_63 Vdout0_63ck10 = 0.9 time = 55
.meas tran vdout0_63ck10 FIND v(dout0_63) AT=55.025n

* CHECK dout0_0 Vdout0_0ck14 = 0 time = 75
.meas tran vdout0_0ck14 FIND v(dout0_0) AT=75.025n

* CHECK dout0_1 Vdout0_1ck14 = 0.9 time = 75
.meas tran vdout0_1ck14 FIND v(dout0_1) AT=75.025n

* CHECK dout0_2 Vdout0_2ck14 = 0.9 time = 75
.meas tran vdout0_2ck14 FIND v(dout0_2) AT=75.025n

* CHECK dout0_3 Vdout0_3ck14 = 0 time = 75
.meas tran vdout0_3ck14 FIND v(dout0_3) AT=75.025n

* CHECK dout0_4 Vdout0_4ck14 = 0.9 time = 75
.meas tran vdout0_4ck14 FIND v(dout0_4) AT=75.025n

* CHECK dout0_5 Vdout0_5ck14 = 0 time = 75
.meas tran vdout0_5ck14 FIND v(dout0_5) AT=75.025n

* CHECK dout0_6 Vdout0_6ck14 = 0 time = 75
.meas tran vdout0_6ck14 FIND v(dout0_6) AT=75.025n

* CHECK dout0_7 Vdout0_7ck14 = 0.9 time = 75
.meas tran vdout0_7ck14 FIND v(dout0_7) AT=75.025n

* CHECK dout0_8 Vdout0_8ck14 = 0 time = 75
.meas tran vdout0_8ck14 FIND v(dout0_8) AT=75.025n

* CHECK dout0_9 Vdout0_9ck14 = 0 time = 75
.meas tran vdout0_9ck14 FIND v(dout0_9) AT=75.025n

* CHECK dout0_10 Vdout0_10ck14 = 0 time = 75
.meas tran vdout0_10ck14 FIND v(dout0_10) AT=75.025n

* CHECK dout0_11 Vdout0_11ck14 = 0.9 time = 75
.meas tran vdout0_11ck14 FIND v(dout0_11) AT=75.025n

* CHECK dout0_12 Vdout0_12ck14 = 0 time = 75
.meas tran vdout0_12ck14 FIND v(dout0_12) AT=75.025n

* CHECK dout0_13 Vdout0_13ck14 = 0 time = 75
.meas tran vdout0_13ck14 FIND v(dout0_13) AT=75.025n

* CHECK dout0_14 Vdout0_14ck14 = 0.9 time = 75
.meas tran vdout0_14ck14 FIND v(dout0_14) AT=75.025n

* CHECK dout0_15 Vdout0_15ck14 = 0.9 time = 75
.meas tran vdout0_15ck14 FIND v(dout0_15) AT=75.025n

* CHECK dout0_16 Vdout0_16ck14 = 0.9 time = 75
.meas tran vdout0_16ck14 FIND v(dout0_16) AT=75.025n

* CHECK dout0_17 Vdout0_17ck14 = 0.9 time = 75
.meas tran vdout0_17ck14 FIND v(dout0_17) AT=75.025n

* CHECK dout0_18 Vdout0_18ck14 = 0.9 time = 75
.meas tran vdout0_18ck14 FIND v(dout0_18) AT=75.025n

* CHECK dout0_19 Vdout0_19ck14 = 0.9 time = 75
.meas tran vdout0_19ck14 FIND v(dout0_19) AT=75.025n

* CHECK dout0_20 Vdout0_20ck14 = 0 time = 75
.meas tran vdout0_20ck14 FIND v(dout0_20) AT=75.025n

* CHECK dout0_21 Vdout0_21ck14 = 0.9 time = 75
.meas tran vdout0_21ck14 FIND v(dout0_21) AT=75.025n

* CHECK dout0_22 Vdout0_22ck14 = 0.9 time = 75
.meas tran vdout0_22ck14 FIND v(dout0_22) AT=75.025n

* CHECK dout0_23 Vdout0_23ck14 = 0.9 time = 75
.meas tran vdout0_23ck14 FIND v(dout0_23) AT=75.025n

* CHECK dout0_24 Vdout0_24ck14 = 0.9 time = 75
.meas tran vdout0_24ck14 FIND v(dout0_24) AT=75.025n

* CHECK dout0_25 Vdout0_25ck14 = 0 time = 75
.meas tran vdout0_25ck14 FIND v(dout0_25) AT=75.025n

* CHECK dout0_26 Vdout0_26ck14 = 0.9 time = 75
.meas tran vdout0_26ck14 FIND v(dout0_26) AT=75.025n

* CHECK dout0_27 Vdout0_27ck14 = 0 time = 75
.meas tran vdout0_27ck14 FIND v(dout0_27) AT=75.025n

* CHECK dout0_28 Vdout0_28ck14 = 0 time = 75
.meas tran vdout0_28ck14 FIND v(dout0_28) AT=75.025n

* CHECK dout0_29 Vdout0_29ck14 = 0.9 time = 75
.meas tran vdout0_29ck14 FIND v(dout0_29) AT=75.025n

* CHECK dout0_30 Vdout0_30ck14 = 0.9 time = 75
.meas tran vdout0_30ck14 FIND v(dout0_30) AT=75.025n

* CHECK dout0_31 Vdout0_31ck14 = 0.9 time = 75
.meas tran vdout0_31ck14 FIND v(dout0_31) AT=75.025n

* CHECK dout0_32 Vdout0_32ck14 = 0.9 time = 75
.meas tran vdout0_32ck14 FIND v(dout0_32) AT=75.025n

* CHECK dout0_33 Vdout0_33ck14 = 0.9 time = 75
.meas tran vdout0_33ck14 FIND v(dout0_33) AT=75.025n

* CHECK dout0_34 Vdout0_34ck14 = 0.9 time = 75
.meas tran vdout0_34ck14 FIND v(dout0_34) AT=75.025n

* CHECK dout0_35 Vdout0_35ck14 = 0.9 time = 75
.meas tran vdout0_35ck14 FIND v(dout0_35) AT=75.025n

* CHECK dout0_36 Vdout0_36ck14 = 0 time = 75
.meas tran vdout0_36ck14 FIND v(dout0_36) AT=75.025n

* CHECK dout0_37 Vdout0_37ck14 = 0 time = 75
.meas tran vdout0_37ck14 FIND v(dout0_37) AT=75.025n

* CHECK dout0_38 Vdout0_38ck14 = 0.9 time = 75
.meas tran vdout0_38ck14 FIND v(dout0_38) AT=75.025n

* CHECK dout0_39 Vdout0_39ck14 = 0 time = 75
.meas tran vdout0_39ck14 FIND v(dout0_39) AT=75.025n

* CHECK dout0_40 Vdout0_40ck14 = 0.9 time = 75
.meas tran vdout0_40ck14 FIND v(dout0_40) AT=75.025n

* CHECK dout0_41 Vdout0_41ck14 = 0.9 time = 75
.meas tran vdout0_41ck14 FIND v(dout0_41) AT=75.025n

* CHECK dout0_42 Vdout0_42ck14 = 0.9 time = 75
.meas tran vdout0_42ck14 FIND v(dout0_42) AT=75.025n

* CHECK dout0_43 Vdout0_43ck14 = 0 time = 75
.meas tran vdout0_43ck14 FIND v(dout0_43) AT=75.025n

* CHECK dout0_44 Vdout0_44ck14 = 0.9 time = 75
.meas tran vdout0_44ck14 FIND v(dout0_44) AT=75.025n

* CHECK dout0_45 Vdout0_45ck14 = 0 time = 75
.meas tran vdout0_45ck14 FIND v(dout0_45) AT=75.025n

* CHECK dout0_46 Vdout0_46ck14 = 0.9 time = 75
.meas tran vdout0_46ck14 FIND v(dout0_46) AT=75.025n

* CHECK dout0_47 Vdout0_47ck14 = 0.9 time = 75
.meas tran vdout0_47ck14 FIND v(dout0_47) AT=75.025n

* CHECK dout0_48 Vdout0_48ck14 = 0.9 time = 75
.meas tran vdout0_48ck14 FIND v(dout0_48) AT=75.025n

* CHECK dout0_49 Vdout0_49ck14 = 0 time = 75
.meas tran vdout0_49ck14 FIND v(dout0_49) AT=75.025n

* CHECK dout0_50 Vdout0_50ck14 = 0.9 time = 75
.meas tran vdout0_50ck14 FIND v(dout0_50) AT=75.025n

* CHECK dout0_51 Vdout0_51ck14 = 0.9 time = 75
.meas tran vdout0_51ck14 FIND v(dout0_51) AT=75.025n

* CHECK dout0_52 Vdout0_52ck14 = 0 time = 75
.meas tran vdout0_52ck14 FIND v(dout0_52) AT=75.025n

* CHECK dout0_53 Vdout0_53ck14 = 0 time = 75
.meas tran vdout0_53ck14 FIND v(dout0_53) AT=75.025n

* CHECK dout0_54 Vdout0_54ck14 = 0.9 time = 75
.meas tran vdout0_54ck14 FIND v(dout0_54) AT=75.025n

* CHECK dout0_55 Vdout0_55ck14 = 0.9 time = 75
.meas tran vdout0_55ck14 FIND v(dout0_55) AT=75.025n

* CHECK dout0_56 Vdout0_56ck14 = 0 time = 75
.meas tran vdout0_56ck14 FIND v(dout0_56) AT=75.025n

* CHECK dout0_57 Vdout0_57ck14 = 0 time = 75
.meas tran vdout0_57ck14 FIND v(dout0_57) AT=75.025n

* CHECK dout0_58 Vdout0_58ck14 = 0.9 time = 75
.meas tran vdout0_58ck14 FIND v(dout0_58) AT=75.025n

* CHECK dout0_59 Vdout0_59ck14 = 0 time = 75
.meas tran vdout0_59ck14 FIND v(dout0_59) AT=75.025n

* CHECK dout0_60 Vdout0_60ck14 = 0.9 time = 75
.meas tran vdout0_60ck14 FIND v(dout0_60) AT=75.025n

* CHECK dout0_61 Vdout0_61ck14 = 0.9 time = 75
.meas tran vdout0_61ck14 FIND v(dout0_61) AT=75.025n

* CHECK dout0_62 Vdout0_62ck14 = 0.9 time = 75
.meas tran vdout0_62ck14 FIND v(dout0_62) AT=75.025n

* CHECK dout0_63 Vdout0_63ck14 = 0 time = 75
.meas tran vdout0_63ck14 FIND v(dout0_63) AT=75.025n

* CHECK dout0_0 Vdout0_0ck15 = 0.9 time = 80
.meas tran vdout0_0ck15 FIND v(dout0_0) AT=80.025n

* CHECK dout0_1 Vdout0_1ck15 = 0 time = 80
.meas tran vdout0_1ck15 FIND v(dout0_1) AT=80.025n

* CHECK dout0_2 Vdout0_2ck15 = 0 time = 80
.meas tran vdout0_2ck15 FIND v(dout0_2) AT=80.025n

* CHECK dout0_3 Vdout0_3ck15 = 0.9 time = 80
.meas tran vdout0_3ck15 FIND v(dout0_3) AT=80.025n

* CHECK dout0_4 Vdout0_4ck15 = 0.9 time = 80
.meas tran vdout0_4ck15 FIND v(dout0_4) AT=80.025n

* CHECK dout0_5 Vdout0_5ck15 = 0 time = 80
.meas tran vdout0_5ck15 FIND v(dout0_5) AT=80.025n

* CHECK dout0_6 Vdout0_6ck15 = 0.9 time = 80
.meas tran vdout0_6ck15 FIND v(dout0_6) AT=80.025n

* CHECK dout0_7 Vdout0_7ck15 = 0 time = 80
.meas tran vdout0_7ck15 FIND v(dout0_7) AT=80.025n

* CHECK dout0_8 Vdout0_8ck15 = 0 time = 80
.meas tran vdout0_8ck15 FIND v(dout0_8) AT=80.025n

* CHECK dout0_9 Vdout0_9ck15 = 0.9 time = 80
.meas tran vdout0_9ck15 FIND v(dout0_9) AT=80.025n

* CHECK dout0_10 Vdout0_10ck15 = 0 time = 80
.meas tran vdout0_10ck15 FIND v(dout0_10) AT=80.025n

* CHECK dout0_11 Vdout0_11ck15 = 0.9 time = 80
.meas tran vdout0_11ck15 FIND v(dout0_11) AT=80.025n

* CHECK dout0_12 Vdout0_12ck15 = 0 time = 80
.meas tran vdout0_12ck15 FIND v(dout0_12) AT=80.025n

* CHECK dout0_13 Vdout0_13ck15 = 0 time = 80
.meas tran vdout0_13ck15 FIND v(dout0_13) AT=80.025n

* CHECK dout0_14 Vdout0_14ck15 = 0 time = 80
.meas tran vdout0_14ck15 FIND v(dout0_14) AT=80.025n

* CHECK dout0_15 Vdout0_15ck15 = 0 time = 80
.meas tran vdout0_15ck15 FIND v(dout0_15) AT=80.025n

* CHECK dout0_16 Vdout0_16ck15 = 0 time = 80
.meas tran vdout0_16ck15 FIND v(dout0_16) AT=80.025n

* CHECK dout0_17 Vdout0_17ck15 = 0 time = 80
.meas tran vdout0_17ck15 FIND v(dout0_17) AT=80.025n

* CHECK dout0_18 Vdout0_18ck15 = 0 time = 80
.meas tran vdout0_18ck15 FIND v(dout0_18) AT=80.025n

* CHECK dout0_19 Vdout0_19ck15 = 0 time = 80
.meas tran vdout0_19ck15 FIND v(dout0_19) AT=80.025n

* CHECK dout0_20 Vdout0_20ck15 = 0.9 time = 80
.meas tran vdout0_20ck15 FIND v(dout0_20) AT=80.025n

* CHECK dout0_21 Vdout0_21ck15 = 0 time = 80
.meas tran vdout0_21ck15 FIND v(dout0_21) AT=80.025n

* CHECK dout0_22 Vdout0_22ck15 = 0 time = 80
.meas tran vdout0_22ck15 FIND v(dout0_22) AT=80.025n

* CHECK dout0_23 Vdout0_23ck15 = 0.9 time = 80
.meas tran vdout0_23ck15 FIND v(dout0_23) AT=80.025n

* CHECK dout0_24 Vdout0_24ck15 = 0.9 time = 80
.meas tran vdout0_24ck15 FIND v(dout0_24) AT=80.025n

* CHECK dout0_25 Vdout0_25ck15 = 0 time = 80
.meas tran vdout0_25ck15 FIND v(dout0_25) AT=80.025n

* CHECK dout0_26 Vdout0_26ck15 = 0.9 time = 80
.meas tran vdout0_26ck15 FIND v(dout0_26) AT=80.025n

* CHECK dout0_27 Vdout0_27ck15 = 0 time = 80
.meas tran vdout0_27ck15 FIND v(dout0_27) AT=80.025n

* CHECK dout0_28 Vdout0_28ck15 = 0.9 time = 80
.meas tran vdout0_28ck15 FIND v(dout0_28) AT=80.025n

* CHECK dout0_29 Vdout0_29ck15 = 0 time = 80
.meas tran vdout0_29ck15 FIND v(dout0_29) AT=80.025n

* CHECK dout0_30 Vdout0_30ck15 = 0 time = 80
.meas tran vdout0_30ck15 FIND v(dout0_30) AT=80.025n

* CHECK dout0_31 Vdout0_31ck15 = 0.9 time = 80
.meas tran vdout0_31ck15 FIND v(dout0_31) AT=80.025n

* CHECK dout0_32 Vdout0_32ck15 = 0 time = 80
.meas tran vdout0_32ck15 FIND v(dout0_32) AT=80.025n

* CHECK dout0_33 Vdout0_33ck15 = 0 time = 80
.meas tran vdout0_33ck15 FIND v(dout0_33) AT=80.025n

* CHECK dout0_34 Vdout0_34ck15 = 0.9 time = 80
.meas tran vdout0_34ck15 FIND v(dout0_34) AT=80.025n

* CHECK dout0_35 Vdout0_35ck15 = 0.9 time = 80
.meas tran vdout0_35ck15 FIND v(dout0_35) AT=80.025n

* CHECK dout0_36 Vdout0_36ck15 = 0.9 time = 80
.meas tran vdout0_36ck15 FIND v(dout0_36) AT=80.025n

* CHECK dout0_37 Vdout0_37ck15 = 0 time = 80
.meas tran vdout0_37ck15 FIND v(dout0_37) AT=80.025n

* CHECK dout0_38 Vdout0_38ck15 = 0.9 time = 80
.meas tran vdout0_38ck15 FIND v(dout0_38) AT=80.025n

* CHECK dout0_39 Vdout0_39ck15 = 0.9 time = 80
.meas tran vdout0_39ck15 FIND v(dout0_39) AT=80.025n

* CHECK dout0_40 Vdout0_40ck15 = 0 time = 80
.meas tran vdout0_40ck15 FIND v(dout0_40) AT=80.025n

* CHECK dout0_41 Vdout0_41ck15 = 0 time = 80
.meas tran vdout0_41ck15 FIND v(dout0_41) AT=80.025n

* CHECK dout0_42 Vdout0_42ck15 = 0 time = 80
.meas tran vdout0_42ck15 FIND v(dout0_42) AT=80.025n

* CHECK dout0_43 Vdout0_43ck15 = 0 time = 80
.meas tran vdout0_43ck15 FIND v(dout0_43) AT=80.025n

* CHECK dout0_44 Vdout0_44ck15 = 0 time = 80
.meas tran vdout0_44ck15 FIND v(dout0_44) AT=80.025n

* CHECK dout0_45 Vdout0_45ck15 = 0 time = 80
.meas tran vdout0_45ck15 FIND v(dout0_45) AT=80.025n

* CHECK dout0_46 Vdout0_46ck15 = 0.9 time = 80
.meas tran vdout0_46ck15 FIND v(dout0_46) AT=80.025n

* CHECK dout0_47 Vdout0_47ck15 = 0.9 time = 80
.meas tran vdout0_47ck15 FIND v(dout0_47) AT=80.025n

* CHECK dout0_48 Vdout0_48ck15 = 0.9 time = 80
.meas tran vdout0_48ck15 FIND v(dout0_48) AT=80.025n

* CHECK dout0_49 Vdout0_49ck15 = 0 time = 80
.meas tran vdout0_49ck15 FIND v(dout0_49) AT=80.025n

* CHECK dout0_50 Vdout0_50ck15 = 0.9 time = 80
.meas tran vdout0_50ck15 FIND v(dout0_50) AT=80.025n

* CHECK dout0_51 Vdout0_51ck15 = 0 time = 80
.meas tran vdout0_51ck15 FIND v(dout0_51) AT=80.025n

* CHECK dout0_52 Vdout0_52ck15 = 0 time = 80
.meas tran vdout0_52ck15 FIND v(dout0_52) AT=80.025n

* CHECK dout0_53 Vdout0_53ck15 = 0.9 time = 80
.meas tran vdout0_53ck15 FIND v(dout0_53) AT=80.025n

* CHECK dout0_54 Vdout0_54ck15 = 0.9 time = 80
.meas tran vdout0_54ck15 FIND v(dout0_54) AT=80.025n

* CHECK dout0_55 Vdout0_55ck15 = 0 time = 80
.meas tran vdout0_55ck15 FIND v(dout0_55) AT=80.025n

* CHECK dout0_56 Vdout0_56ck15 = 0 time = 80
.meas tran vdout0_56ck15 FIND v(dout0_56) AT=80.025n

* CHECK dout0_57 Vdout0_57ck15 = 0.9 time = 80
.meas tran vdout0_57ck15 FIND v(dout0_57) AT=80.025n

* CHECK dout0_58 Vdout0_58ck15 = 0 time = 80
.meas tran vdout0_58ck15 FIND v(dout0_58) AT=80.025n

* CHECK dout0_59 Vdout0_59ck15 = 0.9 time = 80
.meas tran vdout0_59ck15 FIND v(dout0_59) AT=80.025n

* CHECK dout0_60 Vdout0_60ck15 = 0.9 time = 80
.meas tran vdout0_60ck15 FIND v(dout0_60) AT=80.025n

* CHECK dout0_61 Vdout0_61ck15 = 0.9 time = 80
.meas tran vdout0_61ck15 FIND v(dout0_61) AT=80.025n

* CHECK dout0_62 Vdout0_62ck15 = 0 time = 80
.meas tran vdout0_62ck15 FIND v(dout0_62) AT=80.025n

* CHECK dout0_63 Vdout0_63ck15 = 0 time = 80
.meas tran vdout0_63ck15 FIND v(dout0_63) AT=80.025n

* CHECK dout0_0 Vdout0_0ck17 = 0.9 time = 90
.meas tran vdout0_0ck17 FIND v(dout0_0) AT=90.025n

* CHECK dout0_1 Vdout0_1ck17 = 0 time = 90
.meas tran vdout0_1ck17 FIND v(dout0_1) AT=90.025n

* CHECK dout0_2 Vdout0_2ck17 = 0 time = 90
.meas tran vdout0_2ck17 FIND v(dout0_2) AT=90.025n

* CHECK dout0_3 Vdout0_3ck17 = 0.9 time = 90
.meas tran vdout0_3ck17 FIND v(dout0_3) AT=90.025n

* CHECK dout0_4 Vdout0_4ck17 = 0.9 time = 90
.meas tran vdout0_4ck17 FIND v(dout0_4) AT=90.025n

* CHECK dout0_5 Vdout0_5ck17 = 0 time = 90
.meas tran vdout0_5ck17 FIND v(dout0_5) AT=90.025n

* CHECK dout0_6 Vdout0_6ck17 = 0.9 time = 90
.meas tran vdout0_6ck17 FIND v(dout0_6) AT=90.025n

* CHECK dout0_7 Vdout0_7ck17 = 0 time = 90
.meas tran vdout0_7ck17 FIND v(dout0_7) AT=90.025n

* CHECK dout0_8 Vdout0_8ck17 = 0 time = 90
.meas tran vdout0_8ck17 FIND v(dout0_8) AT=90.025n

* CHECK dout0_9 Vdout0_9ck17 = 0.9 time = 90
.meas tran vdout0_9ck17 FIND v(dout0_9) AT=90.025n

* CHECK dout0_10 Vdout0_10ck17 = 0 time = 90
.meas tran vdout0_10ck17 FIND v(dout0_10) AT=90.025n

* CHECK dout0_11 Vdout0_11ck17 = 0.9 time = 90
.meas tran vdout0_11ck17 FIND v(dout0_11) AT=90.025n

* CHECK dout0_12 Vdout0_12ck17 = 0 time = 90
.meas tran vdout0_12ck17 FIND v(dout0_12) AT=90.025n

* CHECK dout0_13 Vdout0_13ck17 = 0 time = 90
.meas tran vdout0_13ck17 FIND v(dout0_13) AT=90.025n

* CHECK dout0_14 Vdout0_14ck17 = 0 time = 90
.meas tran vdout0_14ck17 FIND v(dout0_14) AT=90.025n

* CHECK dout0_15 Vdout0_15ck17 = 0 time = 90
.meas tran vdout0_15ck17 FIND v(dout0_15) AT=90.025n

* CHECK dout0_16 Vdout0_16ck17 = 0 time = 90
.meas tran vdout0_16ck17 FIND v(dout0_16) AT=90.025n

* CHECK dout0_17 Vdout0_17ck17 = 0 time = 90
.meas tran vdout0_17ck17 FIND v(dout0_17) AT=90.025n

* CHECK dout0_18 Vdout0_18ck17 = 0 time = 90
.meas tran vdout0_18ck17 FIND v(dout0_18) AT=90.025n

* CHECK dout0_19 Vdout0_19ck17 = 0 time = 90
.meas tran vdout0_19ck17 FIND v(dout0_19) AT=90.025n

* CHECK dout0_20 Vdout0_20ck17 = 0.9 time = 90
.meas tran vdout0_20ck17 FIND v(dout0_20) AT=90.025n

* CHECK dout0_21 Vdout0_21ck17 = 0 time = 90
.meas tran vdout0_21ck17 FIND v(dout0_21) AT=90.025n

* CHECK dout0_22 Vdout0_22ck17 = 0 time = 90
.meas tran vdout0_22ck17 FIND v(dout0_22) AT=90.025n

* CHECK dout0_23 Vdout0_23ck17 = 0.9 time = 90
.meas tran vdout0_23ck17 FIND v(dout0_23) AT=90.025n

* CHECK dout0_24 Vdout0_24ck17 = 0.9 time = 90
.meas tran vdout0_24ck17 FIND v(dout0_24) AT=90.025n

* CHECK dout0_25 Vdout0_25ck17 = 0 time = 90
.meas tran vdout0_25ck17 FIND v(dout0_25) AT=90.025n

* CHECK dout0_26 Vdout0_26ck17 = 0.9 time = 90
.meas tran vdout0_26ck17 FIND v(dout0_26) AT=90.025n

* CHECK dout0_27 Vdout0_27ck17 = 0 time = 90
.meas tran vdout0_27ck17 FIND v(dout0_27) AT=90.025n

* CHECK dout0_28 Vdout0_28ck17 = 0.9 time = 90
.meas tran vdout0_28ck17 FIND v(dout0_28) AT=90.025n

* CHECK dout0_29 Vdout0_29ck17 = 0 time = 90
.meas tran vdout0_29ck17 FIND v(dout0_29) AT=90.025n

* CHECK dout0_30 Vdout0_30ck17 = 0 time = 90
.meas tran vdout0_30ck17 FIND v(dout0_30) AT=90.025n

* CHECK dout0_31 Vdout0_31ck17 = 0.9 time = 90
.meas tran vdout0_31ck17 FIND v(dout0_31) AT=90.025n

* CHECK dout0_32 Vdout0_32ck17 = 0 time = 90
.meas tran vdout0_32ck17 FIND v(dout0_32) AT=90.025n

* CHECK dout0_33 Vdout0_33ck17 = 0 time = 90
.meas tran vdout0_33ck17 FIND v(dout0_33) AT=90.025n

* CHECK dout0_34 Vdout0_34ck17 = 0.9 time = 90
.meas tran vdout0_34ck17 FIND v(dout0_34) AT=90.025n

* CHECK dout0_35 Vdout0_35ck17 = 0.9 time = 90
.meas tran vdout0_35ck17 FIND v(dout0_35) AT=90.025n

* CHECK dout0_36 Vdout0_36ck17 = 0.9 time = 90
.meas tran vdout0_36ck17 FIND v(dout0_36) AT=90.025n

* CHECK dout0_37 Vdout0_37ck17 = 0 time = 90
.meas tran vdout0_37ck17 FIND v(dout0_37) AT=90.025n

* CHECK dout0_38 Vdout0_38ck17 = 0.9 time = 90
.meas tran vdout0_38ck17 FIND v(dout0_38) AT=90.025n

* CHECK dout0_39 Vdout0_39ck17 = 0.9 time = 90
.meas tran vdout0_39ck17 FIND v(dout0_39) AT=90.025n

* CHECK dout0_40 Vdout0_40ck17 = 0 time = 90
.meas tran vdout0_40ck17 FIND v(dout0_40) AT=90.025n

* CHECK dout0_41 Vdout0_41ck17 = 0 time = 90
.meas tran vdout0_41ck17 FIND v(dout0_41) AT=90.025n

* CHECK dout0_42 Vdout0_42ck17 = 0 time = 90
.meas tran vdout0_42ck17 FIND v(dout0_42) AT=90.025n

* CHECK dout0_43 Vdout0_43ck17 = 0 time = 90
.meas tran vdout0_43ck17 FIND v(dout0_43) AT=90.025n

* CHECK dout0_44 Vdout0_44ck17 = 0 time = 90
.meas tran vdout0_44ck17 FIND v(dout0_44) AT=90.025n

* CHECK dout0_45 Vdout0_45ck17 = 0 time = 90
.meas tran vdout0_45ck17 FIND v(dout0_45) AT=90.025n

* CHECK dout0_46 Vdout0_46ck17 = 0.9 time = 90
.meas tran vdout0_46ck17 FIND v(dout0_46) AT=90.025n

* CHECK dout0_47 Vdout0_47ck17 = 0.9 time = 90
.meas tran vdout0_47ck17 FIND v(dout0_47) AT=90.025n

* CHECK dout0_48 Vdout0_48ck17 = 0.9 time = 90
.meas tran vdout0_48ck17 FIND v(dout0_48) AT=90.025n

* CHECK dout0_49 Vdout0_49ck17 = 0 time = 90
.meas tran vdout0_49ck17 FIND v(dout0_49) AT=90.025n

* CHECK dout0_50 Vdout0_50ck17 = 0.9 time = 90
.meas tran vdout0_50ck17 FIND v(dout0_50) AT=90.025n

* CHECK dout0_51 Vdout0_51ck17 = 0 time = 90
.meas tran vdout0_51ck17 FIND v(dout0_51) AT=90.025n

* CHECK dout0_52 Vdout0_52ck17 = 0 time = 90
.meas tran vdout0_52ck17 FIND v(dout0_52) AT=90.025n

* CHECK dout0_53 Vdout0_53ck17 = 0.9 time = 90
.meas tran vdout0_53ck17 FIND v(dout0_53) AT=90.025n

* CHECK dout0_54 Vdout0_54ck17 = 0.9 time = 90
.meas tran vdout0_54ck17 FIND v(dout0_54) AT=90.025n

* CHECK dout0_55 Vdout0_55ck17 = 0 time = 90
.meas tran vdout0_55ck17 FIND v(dout0_55) AT=90.025n

* CHECK dout0_56 Vdout0_56ck17 = 0 time = 90
.meas tran vdout0_56ck17 FIND v(dout0_56) AT=90.025n

* CHECK dout0_57 Vdout0_57ck17 = 0.9 time = 90
.meas tran vdout0_57ck17 FIND v(dout0_57) AT=90.025n

* CHECK dout0_58 Vdout0_58ck17 = 0 time = 90
.meas tran vdout0_58ck17 FIND v(dout0_58) AT=90.025n

* CHECK dout0_59 Vdout0_59ck17 = 0.9 time = 90
.meas tran vdout0_59ck17 FIND v(dout0_59) AT=90.025n

* CHECK dout0_60 Vdout0_60ck17 = 0.9 time = 90
.meas tran vdout0_60ck17 FIND v(dout0_60) AT=90.025n

* CHECK dout0_61 Vdout0_61ck17 = 0.9 time = 90
.meas tran vdout0_61ck17 FIND v(dout0_61) AT=90.025n

* CHECK dout0_62 Vdout0_62ck17 = 0 time = 90
.meas tran vdout0_62ck17 FIND v(dout0_62) AT=90.025n

* CHECK dout0_63 Vdout0_63ck17 = 0 time = 90
.meas tran vdout0_63ck17 FIND v(dout0_63) AT=90.025n

* CHECK dout0_0 Vdout0_0ck18 = 0 time = 95
.meas tran vdout0_0ck18 FIND v(dout0_0) AT=95.025n

* CHECK dout0_1 Vdout0_1ck18 = 0.9 time = 95
.meas tran vdout0_1ck18 FIND v(dout0_1) AT=95.025n

* CHECK dout0_2 Vdout0_2ck18 = 0.9 time = 95
.meas tran vdout0_2ck18 FIND v(dout0_2) AT=95.025n

* CHECK dout0_3 Vdout0_3ck18 = 0 time = 95
.meas tran vdout0_3ck18 FIND v(dout0_3) AT=95.025n

* CHECK dout0_4 Vdout0_4ck18 = 0.9 time = 95
.meas tran vdout0_4ck18 FIND v(dout0_4) AT=95.025n

* CHECK dout0_5 Vdout0_5ck18 = 0 time = 95
.meas tran vdout0_5ck18 FIND v(dout0_5) AT=95.025n

* CHECK dout0_6 Vdout0_6ck18 = 0 time = 95
.meas tran vdout0_6ck18 FIND v(dout0_6) AT=95.025n

* CHECK dout0_7 Vdout0_7ck18 = 0.9 time = 95
.meas tran vdout0_7ck18 FIND v(dout0_7) AT=95.025n

* CHECK dout0_8 Vdout0_8ck18 = 0 time = 95
.meas tran vdout0_8ck18 FIND v(dout0_8) AT=95.025n

* CHECK dout0_9 Vdout0_9ck18 = 0 time = 95
.meas tran vdout0_9ck18 FIND v(dout0_9) AT=95.025n

* CHECK dout0_10 Vdout0_10ck18 = 0 time = 95
.meas tran vdout0_10ck18 FIND v(dout0_10) AT=95.025n

* CHECK dout0_11 Vdout0_11ck18 = 0.9 time = 95
.meas tran vdout0_11ck18 FIND v(dout0_11) AT=95.025n

* CHECK dout0_12 Vdout0_12ck18 = 0 time = 95
.meas tran vdout0_12ck18 FIND v(dout0_12) AT=95.025n

* CHECK dout0_13 Vdout0_13ck18 = 0 time = 95
.meas tran vdout0_13ck18 FIND v(dout0_13) AT=95.025n

* CHECK dout0_14 Vdout0_14ck18 = 0.9 time = 95
.meas tran vdout0_14ck18 FIND v(dout0_14) AT=95.025n

* CHECK dout0_15 Vdout0_15ck18 = 0.9 time = 95
.meas tran vdout0_15ck18 FIND v(dout0_15) AT=95.025n

* CHECK dout0_16 Vdout0_16ck18 = 0.9 time = 95
.meas tran vdout0_16ck18 FIND v(dout0_16) AT=95.025n

* CHECK dout0_17 Vdout0_17ck18 = 0.9 time = 95
.meas tran vdout0_17ck18 FIND v(dout0_17) AT=95.025n

* CHECK dout0_18 Vdout0_18ck18 = 0.9 time = 95
.meas tran vdout0_18ck18 FIND v(dout0_18) AT=95.025n

* CHECK dout0_19 Vdout0_19ck18 = 0.9 time = 95
.meas tran vdout0_19ck18 FIND v(dout0_19) AT=95.025n

* CHECK dout0_20 Vdout0_20ck18 = 0 time = 95
.meas tran vdout0_20ck18 FIND v(dout0_20) AT=95.025n

* CHECK dout0_21 Vdout0_21ck18 = 0.9 time = 95
.meas tran vdout0_21ck18 FIND v(dout0_21) AT=95.025n

* CHECK dout0_22 Vdout0_22ck18 = 0.9 time = 95
.meas tran vdout0_22ck18 FIND v(dout0_22) AT=95.025n

* CHECK dout0_23 Vdout0_23ck18 = 0.9 time = 95
.meas tran vdout0_23ck18 FIND v(dout0_23) AT=95.025n

* CHECK dout0_24 Vdout0_24ck18 = 0.9 time = 95
.meas tran vdout0_24ck18 FIND v(dout0_24) AT=95.025n

* CHECK dout0_25 Vdout0_25ck18 = 0 time = 95
.meas tran vdout0_25ck18 FIND v(dout0_25) AT=95.025n

* CHECK dout0_26 Vdout0_26ck18 = 0.9 time = 95
.meas tran vdout0_26ck18 FIND v(dout0_26) AT=95.025n

* CHECK dout0_27 Vdout0_27ck18 = 0 time = 95
.meas tran vdout0_27ck18 FIND v(dout0_27) AT=95.025n

* CHECK dout0_28 Vdout0_28ck18 = 0 time = 95
.meas tran vdout0_28ck18 FIND v(dout0_28) AT=95.025n

* CHECK dout0_29 Vdout0_29ck18 = 0.9 time = 95
.meas tran vdout0_29ck18 FIND v(dout0_29) AT=95.025n

* CHECK dout0_30 Vdout0_30ck18 = 0.9 time = 95
.meas tran vdout0_30ck18 FIND v(dout0_30) AT=95.025n

* CHECK dout0_31 Vdout0_31ck18 = 0.9 time = 95
.meas tran vdout0_31ck18 FIND v(dout0_31) AT=95.025n

* CHECK dout0_32 Vdout0_32ck18 = 0.9 time = 95
.meas tran vdout0_32ck18 FIND v(dout0_32) AT=95.025n

* CHECK dout0_33 Vdout0_33ck18 = 0.9 time = 95
.meas tran vdout0_33ck18 FIND v(dout0_33) AT=95.025n

* CHECK dout0_34 Vdout0_34ck18 = 0.9 time = 95
.meas tran vdout0_34ck18 FIND v(dout0_34) AT=95.025n

* CHECK dout0_35 Vdout0_35ck18 = 0.9 time = 95
.meas tran vdout0_35ck18 FIND v(dout0_35) AT=95.025n

* CHECK dout0_36 Vdout0_36ck18 = 0 time = 95
.meas tran vdout0_36ck18 FIND v(dout0_36) AT=95.025n

* CHECK dout0_37 Vdout0_37ck18 = 0 time = 95
.meas tran vdout0_37ck18 FIND v(dout0_37) AT=95.025n

* CHECK dout0_38 Vdout0_38ck18 = 0.9 time = 95
.meas tran vdout0_38ck18 FIND v(dout0_38) AT=95.025n

* CHECK dout0_39 Vdout0_39ck18 = 0 time = 95
.meas tran vdout0_39ck18 FIND v(dout0_39) AT=95.025n

* CHECK dout0_40 Vdout0_40ck18 = 0.9 time = 95
.meas tran vdout0_40ck18 FIND v(dout0_40) AT=95.025n

* CHECK dout0_41 Vdout0_41ck18 = 0.9 time = 95
.meas tran vdout0_41ck18 FIND v(dout0_41) AT=95.025n

* CHECK dout0_42 Vdout0_42ck18 = 0.9 time = 95
.meas tran vdout0_42ck18 FIND v(dout0_42) AT=95.025n

* CHECK dout0_43 Vdout0_43ck18 = 0 time = 95
.meas tran vdout0_43ck18 FIND v(dout0_43) AT=95.025n

* CHECK dout0_44 Vdout0_44ck18 = 0.9 time = 95
.meas tran vdout0_44ck18 FIND v(dout0_44) AT=95.025n

* CHECK dout0_45 Vdout0_45ck18 = 0 time = 95
.meas tran vdout0_45ck18 FIND v(dout0_45) AT=95.025n

* CHECK dout0_46 Vdout0_46ck18 = 0.9 time = 95
.meas tran vdout0_46ck18 FIND v(dout0_46) AT=95.025n

* CHECK dout0_47 Vdout0_47ck18 = 0.9 time = 95
.meas tran vdout0_47ck18 FIND v(dout0_47) AT=95.025n

* CHECK dout0_48 Vdout0_48ck18 = 0.9 time = 95
.meas tran vdout0_48ck18 FIND v(dout0_48) AT=95.025n

* CHECK dout0_49 Vdout0_49ck18 = 0 time = 95
.meas tran vdout0_49ck18 FIND v(dout0_49) AT=95.025n

* CHECK dout0_50 Vdout0_50ck18 = 0.9 time = 95
.meas tran vdout0_50ck18 FIND v(dout0_50) AT=95.025n

* CHECK dout0_51 Vdout0_51ck18 = 0.9 time = 95
.meas tran vdout0_51ck18 FIND v(dout0_51) AT=95.025n

* CHECK dout0_52 Vdout0_52ck18 = 0 time = 95
.meas tran vdout0_52ck18 FIND v(dout0_52) AT=95.025n

* CHECK dout0_53 Vdout0_53ck18 = 0 time = 95
.meas tran vdout0_53ck18 FIND v(dout0_53) AT=95.025n

* CHECK dout0_54 Vdout0_54ck18 = 0.9 time = 95
.meas tran vdout0_54ck18 FIND v(dout0_54) AT=95.025n

* CHECK dout0_55 Vdout0_55ck18 = 0.9 time = 95
.meas tran vdout0_55ck18 FIND v(dout0_55) AT=95.025n

* CHECK dout0_56 Vdout0_56ck18 = 0 time = 95
.meas tran vdout0_56ck18 FIND v(dout0_56) AT=95.025n

* CHECK dout0_57 Vdout0_57ck18 = 0 time = 95
.meas tran vdout0_57ck18 FIND v(dout0_57) AT=95.025n

* CHECK dout0_58 Vdout0_58ck18 = 0.9 time = 95
.meas tran vdout0_58ck18 FIND v(dout0_58) AT=95.025n

* CHECK dout0_59 Vdout0_59ck18 = 0 time = 95
.meas tran vdout0_59ck18 FIND v(dout0_59) AT=95.025n

* CHECK dout0_60 Vdout0_60ck18 = 0.9 time = 95
.meas tran vdout0_60ck18 FIND v(dout0_60) AT=95.025n

* CHECK dout0_61 Vdout0_61ck18 = 0.9 time = 95
.meas tran vdout0_61ck18 FIND v(dout0_61) AT=95.025n

* CHECK dout0_62 Vdout0_62ck18 = 0.9 time = 95
.meas tran vdout0_62ck18 FIND v(dout0_62) AT=95.025n

* CHECK dout0_63 Vdout0_63ck18 = 0 time = 95
.meas tran vdout0_63ck18 FIND v(dout0_63) AT=95.025n

* CHECK dout0_0 Vdout0_0ck20 = 0 time = 105
.meas tran vdout0_0ck20 FIND v(dout0_0) AT=105.025n

* CHECK dout0_1 Vdout0_1ck20 = 0.9 time = 105
.meas tran vdout0_1ck20 FIND v(dout0_1) AT=105.025n

* CHECK dout0_2 Vdout0_2ck20 = 0.9 time = 105
.meas tran vdout0_2ck20 FIND v(dout0_2) AT=105.025n

* CHECK dout0_3 Vdout0_3ck20 = 0.9 time = 105
.meas tran vdout0_3ck20 FIND v(dout0_3) AT=105.025n

* CHECK dout0_4 Vdout0_4ck20 = 0 time = 105
.meas tran vdout0_4ck20 FIND v(dout0_4) AT=105.025n

* CHECK dout0_5 Vdout0_5ck20 = 0 time = 105
.meas tran vdout0_5ck20 FIND v(dout0_5) AT=105.025n

* CHECK dout0_6 Vdout0_6ck20 = 0 time = 105
.meas tran vdout0_6ck20 FIND v(dout0_6) AT=105.025n

* CHECK dout0_7 Vdout0_7ck20 = 0.9 time = 105
.meas tran vdout0_7ck20 FIND v(dout0_7) AT=105.025n

* CHECK dout0_8 Vdout0_8ck20 = 0 time = 105
.meas tran vdout0_8ck20 FIND v(dout0_8) AT=105.025n

* CHECK dout0_9 Vdout0_9ck20 = 0.9 time = 105
.meas tran vdout0_9ck20 FIND v(dout0_9) AT=105.025n

* CHECK dout0_10 Vdout0_10ck20 = 0.9 time = 105
.meas tran vdout0_10ck20 FIND v(dout0_10) AT=105.025n

* CHECK dout0_11 Vdout0_11ck20 = 0.9 time = 105
.meas tran vdout0_11ck20 FIND v(dout0_11) AT=105.025n

* CHECK dout0_12 Vdout0_12ck20 = 0 time = 105
.meas tran vdout0_12ck20 FIND v(dout0_12) AT=105.025n

* CHECK dout0_13 Vdout0_13ck20 = 0.9 time = 105
.meas tran vdout0_13ck20 FIND v(dout0_13) AT=105.025n

* CHECK dout0_14 Vdout0_14ck20 = 0.9 time = 105
.meas tran vdout0_14ck20 FIND v(dout0_14) AT=105.025n

* CHECK dout0_15 Vdout0_15ck20 = 0.9 time = 105
.meas tran vdout0_15ck20 FIND v(dout0_15) AT=105.025n

* CHECK dout0_16 Vdout0_16ck20 = 0 time = 105
.meas tran vdout0_16ck20 FIND v(dout0_16) AT=105.025n

* CHECK dout0_17 Vdout0_17ck20 = 0 time = 105
.meas tran vdout0_17ck20 FIND v(dout0_17) AT=105.025n

* CHECK dout0_18 Vdout0_18ck20 = 0 time = 105
.meas tran vdout0_18ck20 FIND v(dout0_18) AT=105.025n

* CHECK dout0_19 Vdout0_19ck20 = 0.9 time = 105
.meas tran vdout0_19ck20 FIND v(dout0_19) AT=105.025n

* CHECK dout0_20 Vdout0_20ck20 = 0.9 time = 105
.meas tran vdout0_20ck20 FIND v(dout0_20) AT=105.025n

* CHECK dout0_21 Vdout0_21ck20 = 0.9 time = 105
.meas tran vdout0_21ck20 FIND v(dout0_21) AT=105.025n

* CHECK dout0_22 Vdout0_22ck20 = 0 time = 105
.meas tran vdout0_22ck20 FIND v(dout0_22) AT=105.025n

* CHECK dout0_23 Vdout0_23ck20 = 0 time = 105
.meas tran vdout0_23ck20 FIND v(dout0_23) AT=105.025n

* CHECK dout0_24 Vdout0_24ck20 = 0 time = 105
.meas tran vdout0_24ck20 FIND v(dout0_24) AT=105.025n

* CHECK dout0_25 Vdout0_25ck20 = 0.9 time = 105
.meas tran vdout0_25ck20 FIND v(dout0_25) AT=105.025n

* CHECK dout0_26 Vdout0_26ck20 = 0.9 time = 105
.meas tran vdout0_26ck20 FIND v(dout0_26) AT=105.025n

* CHECK dout0_27 Vdout0_27ck20 = 0.9 time = 105
.meas tran vdout0_27ck20 FIND v(dout0_27) AT=105.025n

* CHECK dout0_28 Vdout0_28ck20 = 0 time = 105
.meas tran vdout0_28ck20 FIND v(dout0_28) AT=105.025n

* CHECK dout0_29 Vdout0_29ck20 = 0 time = 105
.meas tran vdout0_29ck20 FIND v(dout0_29) AT=105.025n

* CHECK dout0_30 Vdout0_30ck20 = 0.9 time = 105
.meas tran vdout0_30ck20 FIND v(dout0_30) AT=105.025n

* CHECK dout0_31 Vdout0_31ck20 = 0 time = 105
.meas tran vdout0_31ck20 FIND v(dout0_31) AT=105.025n

* CHECK dout0_32 Vdout0_32ck20 = 0.9 time = 105
.meas tran vdout0_32ck20 FIND v(dout0_32) AT=105.025n

* CHECK dout0_33 Vdout0_33ck20 = 0.9 time = 105
.meas tran vdout0_33ck20 FIND v(dout0_33) AT=105.025n

* CHECK dout0_34 Vdout0_34ck20 = 0.9 time = 105
.meas tran vdout0_34ck20 FIND v(dout0_34) AT=105.025n

* CHECK dout0_35 Vdout0_35ck20 = 0 time = 105
.meas tran vdout0_35ck20 FIND v(dout0_35) AT=105.025n

* CHECK dout0_36 Vdout0_36ck20 = 0.9 time = 105
.meas tran vdout0_36ck20 FIND v(dout0_36) AT=105.025n

* CHECK dout0_37 Vdout0_37ck20 = 0.9 time = 105
.meas tran vdout0_37ck20 FIND v(dout0_37) AT=105.025n

* CHECK dout0_38 Vdout0_38ck20 = 0.9 time = 105
.meas tran vdout0_38ck20 FIND v(dout0_38) AT=105.025n

* CHECK dout0_39 Vdout0_39ck20 = 0.9 time = 105
.meas tran vdout0_39ck20 FIND v(dout0_39) AT=105.025n

* CHECK dout0_40 Vdout0_40ck20 = 0.9 time = 105
.meas tran vdout0_40ck20 FIND v(dout0_40) AT=105.025n

* CHECK dout0_41 Vdout0_41ck20 = 0.9 time = 105
.meas tran vdout0_41ck20 FIND v(dout0_41) AT=105.025n

* CHECK dout0_42 Vdout0_42ck20 = 0.9 time = 105
.meas tran vdout0_42ck20 FIND v(dout0_42) AT=105.025n

* CHECK dout0_43 Vdout0_43ck20 = 0 time = 105
.meas tran vdout0_43ck20 FIND v(dout0_43) AT=105.025n

* CHECK dout0_44 Vdout0_44ck20 = 0 time = 105
.meas tran vdout0_44ck20 FIND v(dout0_44) AT=105.025n

* CHECK dout0_45 Vdout0_45ck20 = 0 time = 105
.meas tran vdout0_45ck20 FIND v(dout0_45) AT=105.025n

* CHECK dout0_46 Vdout0_46ck20 = 0 time = 105
.meas tran vdout0_46ck20 FIND v(dout0_46) AT=105.025n

* CHECK dout0_47 Vdout0_47ck20 = 0 time = 105
.meas tran vdout0_47ck20 FIND v(dout0_47) AT=105.025n

* CHECK dout0_48 Vdout0_48ck20 = 0 time = 105
.meas tran vdout0_48ck20 FIND v(dout0_48) AT=105.025n

* CHECK dout0_49 Vdout0_49ck20 = 0 time = 105
.meas tran vdout0_49ck20 FIND v(dout0_49) AT=105.025n

* CHECK dout0_50 Vdout0_50ck20 = 0.9 time = 105
.meas tran vdout0_50ck20 FIND v(dout0_50) AT=105.025n

* CHECK dout0_51 Vdout0_51ck20 = 0 time = 105
.meas tran vdout0_51ck20 FIND v(dout0_51) AT=105.025n

* CHECK dout0_52 Vdout0_52ck20 = 0.9 time = 105
.meas tran vdout0_52ck20 FIND v(dout0_52) AT=105.025n

* CHECK dout0_53 Vdout0_53ck20 = 0 time = 105
.meas tran vdout0_53ck20 FIND v(dout0_53) AT=105.025n

* CHECK dout0_54 Vdout0_54ck20 = 0.9 time = 105
.meas tran vdout0_54ck20 FIND v(dout0_54) AT=105.025n

* CHECK dout0_55 Vdout0_55ck20 = 0.9 time = 105
.meas tran vdout0_55ck20 FIND v(dout0_55) AT=105.025n

* CHECK dout0_56 Vdout0_56ck20 = 0.9 time = 105
.meas tran vdout0_56ck20 FIND v(dout0_56) AT=105.025n

* CHECK dout0_57 Vdout0_57ck20 = 0 time = 105
.meas tran vdout0_57ck20 FIND v(dout0_57) AT=105.025n

* CHECK dout0_58 Vdout0_58ck20 = 0.9 time = 105
.meas tran vdout0_58ck20 FIND v(dout0_58) AT=105.025n

* CHECK dout0_59 Vdout0_59ck20 = 0 time = 105
.meas tran vdout0_59ck20 FIND v(dout0_59) AT=105.025n

* CHECK dout0_60 Vdout0_60ck20 = 0 time = 105
.meas tran vdout0_60ck20 FIND v(dout0_60) AT=105.025n

* CHECK dout0_61 Vdout0_61ck20 = 0 time = 105
.meas tran vdout0_61ck20 FIND v(dout0_61) AT=105.025n

* CHECK dout0_62 Vdout0_62ck20 = 0.9 time = 105
.meas tran vdout0_62ck20 FIND v(dout0_62) AT=105.025n

* CHECK dout0_63 Vdout0_63ck20 = 0.9 time = 105
.meas tran vdout0_63ck20 FIND v(dout0_63) AT=105.025n

* CHECK dout0_0 Vdout0_0ck21 = 0 time = 110
.meas tran vdout0_0ck21 FIND v(dout0_0) AT=110.025n

* CHECK dout0_1 Vdout0_1ck21 = 0.9 time = 110
.meas tran vdout0_1ck21 FIND v(dout0_1) AT=110.025n

* CHECK dout0_2 Vdout0_2ck21 = 0.9 time = 110
.meas tran vdout0_2ck21 FIND v(dout0_2) AT=110.025n

* CHECK dout0_3 Vdout0_3ck21 = 0.9 time = 110
.meas tran vdout0_3ck21 FIND v(dout0_3) AT=110.025n

* CHECK dout0_4 Vdout0_4ck21 = 0 time = 110
.meas tran vdout0_4ck21 FIND v(dout0_4) AT=110.025n

* CHECK dout0_5 Vdout0_5ck21 = 0 time = 110
.meas tran vdout0_5ck21 FIND v(dout0_5) AT=110.025n

* CHECK dout0_6 Vdout0_6ck21 = 0 time = 110
.meas tran vdout0_6ck21 FIND v(dout0_6) AT=110.025n

* CHECK dout0_7 Vdout0_7ck21 = 0.9 time = 110
.meas tran vdout0_7ck21 FIND v(dout0_7) AT=110.025n

* CHECK dout0_8 Vdout0_8ck21 = 0 time = 110
.meas tran vdout0_8ck21 FIND v(dout0_8) AT=110.025n

* CHECK dout0_9 Vdout0_9ck21 = 0.9 time = 110
.meas tran vdout0_9ck21 FIND v(dout0_9) AT=110.025n

* CHECK dout0_10 Vdout0_10ck21 = 0.9 time = 110
.meas tran vdout0_10ck21 FIND v(dout0_10) AT=110.025n

* CHECK dout0_11 Vdout0_11ck21 = 0.9 time = 110
.meas tran vdout0_11ck21 FIND v(dout0_11) AT=110.025n

* CHECK dout0_12 Vdout0_12ck21 = 0 time = 110
.meas tran vdout0_12ck21 FIND v(dout0_12) AT=110.025n

* CHECK dout0_13 Vdout0_13ck21 = 0.9 time = 110
.meas tran vdout0_13ck21 FIND v(dout0_13) AT=110.025n

* CHECK dout0_14 Vdout0_14ck21 = 0.9 time = 110
.meas tran vdout0_14ck21 FIND v(dout0_14) AT=110.025n

* CHECK dout0_15 Vdout0_15ck21 = 0.9 time = 110
.meas tran vdout0_15ck21 FIND v(dout0_15) AT=110.025n

* CHECK dout0_16 Vdout0_16ck21 = 0 time = 110
.meas tran vdout0_16ck21 FIND v(dout0_16) AT=110.025n

* CHECK dout0_17 Vdout0_17ck21 = 0 time = 110
.meas tran vdout0_17ck21 FIND v(dout0_17) AT=110.025n

* CHECK dout0_18 Vdout0_18ck21 = 0 time = 110
.meas tran vdout0_18ck21 FIND v(dout0_18) AT=110.025n

* CHECK dout0_19 Vdout0_19ck21 = 0.9 time = 110
.meas tran vdout0_19ck21 FIND v(dout0_19) AT=110.025n

* CHECK dout0_20 Vdout0_20ck21 = 0.9 time = 110
.meas tran vdout0_20ck21 FIND v(dout0_20) AT=110.025n

* CHECK dout0_21 Vdout0_21ck21 = 0.9 time = 110
.meas tran vdout0_21ck21 FIND v(dout0_21) AT=110.025n

* CHECK dout0_22 Vdout0_22ck21 = 0 time = 110
.meas tran vdout0_22ck21 FIND v(dout0_22) AT=110.025n

* CHECK dout0_23 Vdout0_23ck21 = 0 time = 110
.meas tran vdout0_23ck21 FIND v(dout0_23) AT=110.025n

* CHECK dout0_24 Vdout0_24ck21 = 0 time = 110
.meas tran vdout0_24ck21 FIND v(dout0_24) AT=110.025n

* CHECK dout0_25 Vdout0_25ck21 = 0.9 time = 110
.meas tran vdout0_25ck21 FIND v(dout0_25) AT=110.025n

* CHECK dout0_26 Vdout0_26ck21 = 0.9 time = 110
.meas tran vdout0_26ck21 FIND v(dout0_26) AT=110.025n

* CHECK dout0_27 Vdout0_27ck21 = 0.9 time = 110
.meas tran vdout0_27ck21 FIND v(dout0_27) AT=110.025n

* CHECK dout0_28 Vdout0_28ck21 = 0 time = 110
.meas tran vdout0_28ck21 FIND v(dout0_28) AT=110.025n

* CHECK dout0_29 Vdout0_29ck21 = 0 time = 110
.meas tran vdout0_29ck21 FIND v(dout0_29) AT=110.025n

* CHECK dout0_30 Vdout0_30ck21 = 0.9 time = 110
.meas tran vdout0_30ck21 FIND v(dout0_30) AT=110.025n

* CHECK dout0_31 Vdout0_31ck21 = 0 time = 110
.meas tran vdout0_31ck21 FIND v(dout0_31) AT=110.025n

* CHECK dout0_32 Vdout0_32ck21 = 0.9 time = 110
.meas tran vdout0_32ck21 FIND v(dout0_32) AT=110.025n

* CHECK dout0_33 Vdout0_33ck21 = 0.9 time = 110
.meas tran vdout0_33ck21 FIND v(dout0_33) AT=110.025n

* CHECK dout0_34 Vdout0_34ck21 = 0.9 time = 110
.meas tran vdout0_34ck21 FIND v(dout0_34) AT=110.025n

* CHECK dout0_35 Vdout0_35ck21 = 0 time = 110
.meas tran vdout0_35ck21 FIND v(dout0_35) AT=110.025n

* CHECK dout0_36 Vdout0_36ck21 = 0.9 time = 110
.meas tran vdout0_36ck21 FIND v(dout0_36) AT=110.025n

* CHECK dout0_37 Vdout0_37ck21 = 0.9 time = 110
.meas tran vdout0_37ck21 FIND v(dout0_37) AT=110.025n

* CHECK dout0_38 Vdout0_38ck21 = 0.9 time = 110
.meas tran vdout0_38ck21 FIND v(dout0_38) AT=110.025n

* CHECK dout0_39 Vdout0_39ck21 = 0.9 time = 110
.meas tran vdout0_39ck21 FIND v(dout0_39) AT=110.025n

* CHECK dout0_40 Vdout0_40ck21 = 0.9 time = 110
.meas tran vdout0_40ck21 FIND v(dout0_40) AT=110.025n

* CHECK dout0_41 Vdout0_41ck21 = 0.9 time = 110
.meas tran vdout0_41ck21 FIND v(dout0_41) AT=110.025n

* CHECK dout0_42 Vdout0_42ck21 = 0.9 time = 110
.meas tran vdout0_42ck21 FIND v(dout0_42) AT=110.025n

* CHECK dout0_43 Vdout0_43ck21 = 0 time = 110
.meas tran vdout0_43ck21 FIND v(dout0_43) AT=110.025n

* CHECK dout0_44 Vdout0_44ck21 = 0 time = 110
.meas tran vdout0_44ck21 FIND v(dout0_44) AT=110.025n

* CHECK dout0_45 Vdout0_45ck21 = 0 time = 110
.meas tran vdout0_45ck21 FIND v(dout0_45) AT=110.025n

* CHECK dout0_46 Vdout0_46ck21 = 0 time = 110
.meas tran vdout0_46ck21 FIND v(dout0_46) AT=110.025n

* CHECK dout0_47 Vdout0_47ck21 = 0 time = 110
.meas tran vdout0_47ck21 FIND v(dout0_47) AT=110.025n

* CHECK dout0_48 Vdout0_48ck21 = 0 time = 110
.meas tran vdout0_48ck21 FIND v(dout0_48) AT=110.025n

* CHECK dout0_49 Vdout0_49ck21 = 0 time = 110
.meas tran vdout0_49ck21 FIND v(dout0_49) AT=110.025n

* CHECK dout0_50 Vdout0_50ck21 = 0.9 time = 110
.meas tran vdout0_50ck21 FIND v(dout0_50) AT=110.025n

* CHECK dout0_51 Vdout0_51ck21 = 0 time = 110
.meas tran vdout0_51ck21 FIND v(dout0_51) AT=110.025n

* CHECK dout0_52 Vdout0_52ck21 = 0.9 time = 110
.meas tran vdout0_52ck21 FIND v(dout0_52) AT=110.025n

* CHECK dout0_53 Vdout0_53ck21 = 0 time = 110
.meas tran vdout0_53ck21 FIND v(dout0_53) AT=110.025n

* CHECK dout0_54 Vdout0_54ck21 = 0.9 time = 110
.meas tran vdout0_54ck21 FIND v(dout0_54) AT=110.025n

* CHECK dout0_55 Vdout0_55ck21 = 0.9 time = 110
.meas tran vdout0_55ck21 FIND v(dout0_55) AT=110.025n

* CHECK dout0_56 Vdout0_56ck21 = 0.9 time = 110
.meas tran vdout0_56ck21 FIND v(dout0_56) AT=110.025n

* CHECK dout0_57 Vdout0_57ck21 = 0 time = 110
.meas tran vdout0_57ck21 FIND v(dout0_57) AT=110.025n

* CHECK dout0_58 Vdout0_58ck21 = 0.9 time = 110
.meas tran vdout0_58ck21 FIND v(dout0_58) AT=110.025n

* CHECK dout0_59 Vdout0_59ck21 = 0 time = 110
.meas tran vdout0_59ck21 FIND v(dout0_59) AT=110.025n

* CHECK dout0_60 Vdout0_60ck21 = 0 time = 110
.meas tran vdout0_60ck21 FIND v(dout0_60) AT=110.025n

* CHECK dout0_61 Vdout0_61ck21 = 0 time = 110
.meas tran vdout0_61ck21 FIND v(dout0_61) AT=110.025n

* CHECK dout0_62 Vdout0_62ck21 = 0.9 time = 110
.meas tran vdout0_62ck21 FIND v(dout0_62) AT=110.025n

* CHECK dout0_63 Vdout0_63ck21 = 0.9 time = 110
.meas tran vdout0_63ck21 FIND v(dout0_63) AT=110.025n

* CHECK dout0_0 Vdout0_0ck23 = 0 time = 120
.meas tran vdout0_0ck23 FIND v(dout0_0) AT=120.025n

* CHECK dout0_1 Vdout0_1ck23 = 0.9 time = 120
.meas tran vdout0_1ck23 FIND v(dout0_1) AT=120.025n

* CHECK dout0_2 Vdout0_2ck23 = 0.9 time = 120
.meas tran vdout0_2ck23 FIND v(dout0_2) AT=120.025n

* CHECK dout0_3 Vdout0_3ck23 = 0 time = 120
.meas tran vdout0_3ck23 FIND v(dout0_3) AT=120.025n

* CHECK dout0_4 Vdout0_4ck23 = 0.9 time = 120
.meas tran vdout0_4ck23 FIND v(dout0_4) AT=120.025n

* CHECK dout0_5 Vdout0_5ck23 = 0 time = 120
.meas tran vdout0_5ck23 FIND v(dout0_5) AT=120.025n

* CHECK dout0_6 Vdout0_6ck23 = 0 time = 120
.meas tran vdout0_6ck23 FIND v(dout0_6) AT=120.025n

* CHECK dout0_7 Vdout0_7ck23 = 0.9 time = 120
.meas tran vdout0_7ck23 FIND v(dout0_7) AT=120.025n

* CHECK dout0_8 Vdout0_8ck23 = 0 time = 120
.meas tran vdout0_8ck23 FIND v(dout0_8) AT=120.025n

* CHECK dout0_9 Vdout0_9ck23 = 0 time = 120
.meas tran vdout0_9ck23 FIND v(dout0_9) AT=120.025n

* CHECK dout0_10 Vdout0_10ck23 = 0 time = 120
.meas tran vdout0_10ck23 FIND v(dout0_10) AT=120.025n

* CHECK dout0_11 Vdout0_11ck23 = 0.9 time = 120
.meas tran vdout0_11ck23 FIND v(dout0_11) AT=120.025n

* CHECK dout0_12 Vdout0_12ck23 = 0 time = 120
.meas tran vdout0_12ck23 FIND v(dout0_12) AT=120.025n

* CHECK dout0_13 Vdout0_13ck23 = 0 time = 120
.meas tran vdout0_13ck23 FIND v(dout0_13) AT=120.025n

* CHECK dout0_14 Vdout0_14ck23 = 0.9 time = 120
.meas tran vdout0_14ck23 FIND v(dout0_14) AT=120.025n

* CHECK dout0_15 Vdout0_15ck23 = 0.9 time = 120
.meas tran vdout0_15ck23 FIND v(dout0_15) AT=120.025n

* CHECK dout0_16 Vdout0_16ck23 = 0.9 time = 120
.meas tran vdout0_16ck23 FIND v(dout0_16) AT=120.025n

* CHECK dout0_17 Vdout0_17ck23 = 0.9 time = 120
.meas tran vdout0_17ck23 FIND v(dout0_17) AT=120.025n

* CHECK dout0_18 Vdout0_18ck23 = 0.9 time = 120
.meas tran vdout0_18ck23 FIND v(dout0_18) AT=120.025n

* CHECK dout0_19 Vdout0_19ck23 = 0.9 time = 120
.meas tran vdout0_19ck23 FIND v(dout0_19) AT=120.025n

* CHECK dout0_20 Vdout0_20ck23 = 0 time = 120
.meas tran vdout0_20ck23 FIND v(dout0_20) AT=120.025n

* CHECK dout0_21 Vdout0_21ck23 = 0.9 time = 120
.meas tran vdout0_21ck23 FIND v(dout0_21) AT=120.025n

* CHECK dout0_22 Vdout0_22ck23 = 0.9 time = 120
.meas tran vdout0_22ck23 FIND v(dout0_22) AT=120.025n

* CHECK dout0_23 Vdout0_23ck23 = 0.9 time = 120
.meas tran vdout0_23ck23 FIND v(dout0_23) AT=120.025n

* CHECK dout0_24 Vdout0_24ck23 = 0.9 time = 120
.meas tran vdout0_24ck23 FIND v(dout0_24) AT=120.025n

* CHECK dout0_25 Vdout0_25ck23 = 0 time = 120
.meas tran vdout0_25ck23 FIND v(dout0_25) AT=120.025n

* CHECK dout0_26 Vdout0_26ck23 = 0.9 time = 120
.meas tran vdout0_26ck23 FIND v(dout0_26) AT=120.025n

* CHECK dout0_27 Vdout0_27ck23 = 0 time = 120
.meas tran vdout0_27ck23 FIND v(dout0_27) AT=120.025n

* CHECK dout0_28 Vdout0_28ck23 = 0 time = 120
.meas tran vdout0_28ck23 FIND v(dout0_28) AT=120.025n

* CHECK dout0_29 Vdout0_29ck23 = 0.9 time = 120
.meas tran vdout0_29ck23 FIND v(dout0_29) AT=120.025n

* CHECK dout0_30 Vdout0_30ck23 = 0.9 time = 120
.meas tran vdout0_30ck23 FIND v(dout0_30) AT=120.025n

* CHECK dout0_31 Vdout0_31ck23 = 0.9 time = 120
.meas tran vdout0_31ck23 FIND v(dout0_31) AT=120.025n

* CHECK dout0_32 Vdout0_32ck23 = 0.9 time = 120
.meas tran vdout0_32ck23 FIND v(dout0_32) AT=120.025n

* CHECK dout0_33 Vdout0_33ck23 = 0.9 time = 120
.meas tran vdout0_33ck23 FIND v(dout0_33) AT=120.025n

* CHECK dout0_34 Vdout0_34ck23 = 0.9 time = 120
.meas tran vdout0_34ck23 FIND v(dout0_34) AT=120.025n

* CHECK dout0_35 Vdout0_35ck23 = 0.9 time = 120
.meas tran vdout0_35ck23 FIND v(dout0_35) AT=120.025n

* CHECK dout0_36 Vdout0_36ck23 = 0 time = 120
.meas tran vdout0_36ck23 FIND v(dout0_36) AT=120.025n

* CHECK dout0_37 Vdout0_37ck23 = 0 time = 120
.meas tran vdout0_37ck23 FIND v(dout0_37) AT=120.025n

* CHECK dout0_38 Vdout0_38ck23 = 0.9 time = 120
.meas tran vdout0_38ck23 FIND v(dout0_38) AT=120.025n

* CHECK dout0_39 Vdout0_39ck23 = 0 time = 120
.meas tran vdout0_39ck23 FIND v(dout0_39) AT=120.025n

* CHECK dout0_40 Vdout0_40ck23 = 0.9 time = 120
.meas tran vdout0_40ck23 FIND v(dout0_40) AT=120.025n

* CHECK dout0_41 Vdout0_41ck23 = 0.9 time = 120
.meas tran vdout0_41ck23 FIND v(dout0_41) AT=120.025n

* CHECK dout0_42 Vdout0_42ck23 = 0.9 time = 120
.meas tran vdout0_42ck23 FIND v(dout0_42) AT=120.025n

* CHECK dout0_43 Vdout0_43ck23 = 0 time = 120
.meas tran vdout0_43ck23 FIND v(dout0_43) AT=120.025n

* CHECK dout0_44 Vdout0_44ck23 = 0.9 time = 120
.meas tran vdout0_44ck23 FIND v(dout0_44) AT=120.025n

* CHECK dout0_45 Vdout0_45ck23 = 0 time = 120
.meas tran vdout0_45ck23 FIND v(dout0_45) AT=120.025n

* CHECK dout0_46 Vdout0_46ck23 = 0.9 time = 120
.meas tran vdout0_46ck23 FIND v(dout0_46) AT=120.025n

* CHECK dout0_47 Vdout0_47ck23 = 0.9 time = 120
.meas tran vdout0_47ck23 FIND v(dout0_47) AT=120.025n

* CHECK dout0_48 Vdout0_48ck23 = 0.9 time = 120
.meas tran vdout0_48ck23 FIND v(dout0_48) AT=120.025n

* CHECK dout0_49 Vdout0_49ck23 = 0 time = 120
.meas tran vdout0_49ck23 FIND v(dout0_49) AT=120.025n

* CHECK dout0_50 Vdout0_50ck23 = 0.9 time = 120
.meas tran vdout0_50ck23 FIND v(dout0_50) AT=120.025n

* CHECK dout0_51 Vdout0_51ck23 = 0.9 time = 120
.meas tran vdout0_51ck23 FIND v(dout0_51) AT=120.025n

* CHECK dout0_52 Vdout0_52ck23 = 0 time = 120
.meas tran vdout0_52ck23 FIND v(dout0_52) AT=120.025n

* CHECK dout0_53 Vdout0_53ck23 = 0 time = 120
.meas tran vdout0_53ck23 FIND v(dout0_53) AT=120.025n

* CHECK dout0_54 Vdout0_54ck23 = 0.9 time = 120
.meas tran vdout0_54ck23 FIND v(dout0_54) AT=120.025n

* CHECK dout0_55 Vdout0_55ck23 = 0.9 time = 120
.meas tran vdout0_55ck23 FIND v(dout0_55) AT=120.025n

* CHECK dout0_56 Vdout0_56ck23 = 0 time = 120
.meas tran vdout0_56ck23 FIND v(dout0_56) AT=120.025n

* CHECK dout0_57 Vdout0_57ck23 = 0 time = 120
.meas tran vdout0_57ck23 FIND v(dout0_57) AT=120.025n

* CHECK dout0_58 Vdout0_58ck23 = 0.9 time = 120
.meas tran vdout0_58ck23 FIND v(dout0_58) AT=120.025n

* CHECK dout0_59 Vdout0_59ck23 = 0 time = 120
.meas tran vdout0_59ck23 FIND v(dout0_59) AT=120.025n

* CHECK dout0_60 Vdout0_60ck23 = 0.9 time = 120
.meas tran vdout0_60ck23 FIND v(dout0_60) AT=120.025n

* CHECK dout0_61 Vdout0_61ck23 = 0.9 time = 120
.meas tran vdout0_61ck23 FIND v(dout0_61) AT=120.025n

* CHECK dout0_62 Vdout0_62ck23 = 0.9 time = 120
.meas tran vdout0_62ck23 FIND v(dout0_62) AT=120.025n

* CHECK dout0_63 Vdout0_63ck23 = 0 time = 120
.meas tran vdout0_63ck23 FIND v(dout0_63) AT=120.025n

* CHECK dout0_0 Vdout0_0ck26 = 0.9 time = 135
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=135.025n

* CHECK dout0_1 Vdout0_1ck26 = 0 time = 135
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=135.025n

* CHECK dout0_2 Vdout0_2ck26 = 0 time = 135
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=135.025n

* CHECK dout0_3 Vdout0_3ck26 = 0 time = 135
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=135.025n

* CHECK dout0_4 Vdout0_4ck26 = 0.9 time = 135
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=135.025n

* CHECK dout0_5 Vdout0_5ck26 = 0 time = 135
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=135.025n

* CHECK dout0_6 Vdout0_6ck26 = 0 time = 135
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=135.025n

* CHECK dout0_7 Vdout0_7ck26 = 0.9 time = 135
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=135.025n

* CHECK dout0_8 Vdout0_8ck26 = 0.9 time = 135
.meas tran vdout0_8ck26 FIND v(dout0_8) AT=135.025n

* CHECK dout0_9 Vdout0_9ck26 = 0.9 time = 135
.meas tran vdout0_9ck26 FIND v(dout0_9) AT=135.025n

* CHECK dout0_10 Vdout0_10ck26 = 0 time = 135
.meas tran vdout0_10ck26 FIND v(dout0_10) AT=135.025n

* CHECK dout0_11 Vdout0_11ck26 = 0 time = 135
.meas tran vdout0_11ck26 FIND v(dout0_11) AT=135.025n

* CHECK dout0_12 Vdout0_12ck26 = 0.9 time = 135
.meas tran vdout0_12ck26 FIND v(dout0_12) AT=135.025n

* CHECK dout0_13 Vdout0_13ck26 = 0.9 time = 135
.meas tran vdout0_13ck26 FIND v(dout0_13) AT=135.025n

* CHECK dout0_14 Vdout0_14ck26 = 0 time = 135
.meas tran vdout0_14ck26 FIND v(dout0_14) AT=135.025n

* CHECK dout0_15 Vdout0_15ck26 = 0 time = 135
.meas tran vdout0_15ck26 FIND v(dout0_15) AT=135.025n

* CHECK dout0_16 Vdout0_16ck26 = 0.9 time = 135
.meas tran vdout0_16ck26 FIND v(dout0_16) AT=135.025n

* CHECK dout0_17 Vdout0_17ck26 = 0 time = 135
.meas tran vdout0_17ck26 FIND v(dout0_17) AT=135.025n

* CHECK dout0_18 Vdout0_18ck26 = 0.9 time = 135
.meas tran vdout0_18ck26 FIND v(dout0_18) AT=135.025n

* CHECK dout0_19 Vdout0_19ck26 = 0 time = 135
.meas tran vdout0_19ck26 FIND v(dout0_19) AT=135.025n

* CHECK dout0_20 Vdout0_20ck26 = 0.9 time = 135
.meas tran vdout0_20ck26 FIND v(dout0_20) AT=135.025n

* CHECK dout0_21 Vdout0_21ck26 = 0.9 time = 135
.meas tran vdout0_21ck26 FIND v(dout0_21) AT=135.025n

* CHECK dout0_22 Vdout0_22ck26 = 0 time = 135
.meas tran vdout0_22ck26 FIND v(dout0_22) AT=135.025n

* CHECK dout0_23 Vdout0_23ck26 = 0.9 time = 135
.meas tran vdout0_23ck26 FIND v(dout0_23) AT=135.025n

* CHECK dout0_24 Vdout0_24ck26 = 0 time = 135
.meas tran vdout0_24ck26 FIND v(dout0_24) AT=135.025n

* CHECK dout0_25 Vdout0_25ck26 = 0 time = 135
.meas tran vdout0_25ck26 FIND v(dout0_25) AT=135.025n

* CHECK dout0_26 Vdout0_26ck26 = 0.9 time = 135
.meas tran vdout0_26ck26 FIND v(dout0_26) AT=135.025n

* CHECK dout0_27 Vdout0_27ck26 = 0 time = 135
.meas tran vdout0_27ck26 FIND v(dout0_27) AT=135.025n

* CHECK dout0_28 Vdout0_28ck26 = 0.9 time = 135
.meas tran vdout0_28ck26 FIND v(dout0_28) AT=135.025n

* CHECK dout0_29 Vdout0_29ck26 = 0.9 time = 135
.meas tran vdout0_29ck26 FIND v(dout0_29) AT=135.025n

* CHECK dout0_30 Vdout0_30ck26 = 0 time = 135
.meas tran vdout0_30ck26 FIND v(dout0_30) AT=135.025n

* CHECK dout0_31 Vdout0_31ck26 = 0.9 time = 135
.meas tran vdout0_31ck26 FIND v(dout0_31) AT=135.025n

* CHECK dout0_32 Vdout0_32ck26 = 0 time = 135
.meas tran vdout0_32ck26 FIND v(dout0_32) AT=135.025n

* CHECK dout0_33 Vdout0_33ck26 = 0 time = 135
.meas tran vdout0_33ck26 FIND v(dout0_33) AT=135.025n

* CHECK dout0_34 Vdout0_34ck26 = 0.9 time = 135
.meas tran vdout0_34ck26 FIND v(dout0_34) AT=135.025n

* CHECK dout0_35 Vdout0_35ck26 = 0.9 time = 135
.meas tran vdout0_35ck26 FIND v(dout0_35) AT=135.025n

* CHECK dout0_36 Vdout0_36ck26 = 0 time = 135
.meas tran vdout0_36ck26 FIND v(dout0_36) AT=135.025n

* CHECK dout0_37 Vdout0_37ck26 = 0.9 time = 135
.meas tran vdout0_37ck26 FIND v(dout0_37) AT=135.025n

* CHECK dout0_38 Vdout0_38ck26 = 0.9 time = 135
.meas tran vdout0_38ck26 FIND v(dout0_38) AT=135.025n

* CHECK dout0_39 Vdout0_39ck26 = 0 time = 135
.meas tran vdout0_39ck26 FIND v(dout0_39) AT=135.025n

* CHECK dout0_40 Vdout0_40ck26 = 0.9 time = 135
.meas tran vdout0_40ck26 FIND v(dout0_40) AT=135.025n

* CHECK dout0_41 Vdout0_41ck26 = 0.9 time = 135
.meas tran vdout0_41ck26 FIND v(dout0_41) AT=135.025n

* CHECK dout0_42 Vdout0_42ck26 = 0 time = 135
.meas tran vdout0_42ck26 FIND v(dout0_42) AT=135.025n

* CHECK dout0_43 Vdout0_43ck26 = 0.9 time = 135
.meas tran vdout0_43ck26 FIND v(dout0_43) AT=135.025n

* CHECK dout0_44 Vdout0_44ck26 = 0 time = 135
.meas tran vdout0_44ck26 FIND v(dout0_44) AT=135.025n

* CHECK dout0_45 Vdout0_45ck26 = 0.9 time = 135
.meas tran vdout0_45ck26 FIND v(dout0_45) AT=135.025n

* CHECK dout0_46 Vdout0_46ck26 = 0 time = 135
.meas tran vdout0_46ck26 FIND v(dout0_46) AT=135.025n

* CHECK dout0_47 Vdout0_47ck26 = 0.9 time = 135
.meas tran vdout0_47ck26 FIND v(dout0_47) AT=135.025n

* CHECK dout0_48 Vdout0_48ck26 = 0.9 time = 135
.meas tran vdout0_48ck26 FIND v(dout0_48) AT=135.025n

* CHECK dout0_49 Vdout0_49ck26 = 0.9 time = 135
.meas tran vdout0_49ck26 FIND v(dout0_49) AT=135.025n

* CHECK dout0_50 Vdout0_50ck26 = 0.9 time = 135
.meas tran vdout0_50ck26 FIND v(dout0_50) AT=135.025n

* CHECK dout0_51 Vdout0_51ck26 = 0.9 time = 135
.meas tran vdout0_51ck26 FIND v(dout0_51) AT=135.025n

* CHECK dout0_52 Vdout0_52ck26 = 0 time = 135
.meas tran vdout0_52ck26 FIND v(dout0_52) AT=135.025n

* CHECK dout0_53 Vdout0_53ck26 = 0.9 time = 135
.meas tran vdout0_53ck26 FIND v(dout0_53) AT=135.025n

* CHECK dout0_54 Vdout0_54ck26 = 0 time = 135
.meas tran vdout0_54ck26 FIND v(dout0_54) AT=135.025n

* CHECK dout0_55 Vdout0_55ck26 = 0.9 time = 135
.meas tran vdout0_55ck26 FIND v(dout0_55) AT=135.025n

* CHECK dout0_56 Vdout0_56ck26 = 0 time = 135
.meas tran vdout0_56ck26 FIND v(dout0_56) AT=135.025n

* CHECK dout0_57 Vdout0_57ck26 = 0 time = 135
.meas tran vdout0_57ck26 FIND v(dout0_57) AT=135.025n

* CHECK dout0_58 Vdout0_58ck26 = 0.9 time = 135
.meas tran vdout0_58ck26 FIND v(dout0_58) AT=135.025n

* CHECK dout0_59 Vdout0_59ck26 = 0 time = 135
.meas tran vdout0_59ck26 FIND v(dout0_59) AT=135.025n

* CHECK dout0_60 Vdout0_60ck26 = 0.9 time = 135
.meas tran vdout0_60ck26 FIND v(dout0_60) AT=135.025n

* CHECK dout0_61 Vdout0_61ck26 = 0 time = 135
.meas tran vdout0_61ck26 FIND v(dout0_61) AT=135.025n

* CHECK dout0_62 Vdout0_62ck26 = 0 time = 135
.meas tran vdout0_62ck26 FIND v(dout0_62) AT=135.025n

* CHECK dout0_63 Vdout0_63ck26 = 0.9 time = 135
.meas tran vdout0_63ck26 FIND v(dout0_63) AT=135.025n

* CHECK dout0_0 Vdout0_0ck29 = 0 time = 150
.meas tran vdout0_0ck29 FIND v(dout0_0) AT=150.025n

* CHECK dout0_1 Vdout0_1ck29 = 0.9 time = 150
.meas tran vdout0_1ck29 FIND v(dout0_1) AT=150.025n

* CHECK dout0_2 Vdout0_2ck29 = 0.9 time = 150
.meas tran vdout0_2ck29 FIND v(dout0_2) AT=150.025n

* CHECK dout0_3 Vdout0_3ck29 = 0.9 time = 150
.meas tran vdout0_3ck29 FIND v(dout0_3) AT=150.025n

* CHECK dout0_4 Vdout0_4ck29 = 0 time = 150
.meas tran vdout0_4ck29 FIND v(dout0_4) AT=150.025n

* CHECK dout0_5 Vdout0_5ck29 = 0 time = 150
.meas tran vdout0_5ck29 FIND v(dout0_5) AT=150.025n

* CHECK dout0_6 Vdout0_6ck29 = 0 time = 150
.meas tran vdout0_6ck29 FIND v(dout0_6) AT=150.025n

* CHECK dout0_7 Vdout0_7ck29 = 0.9 time = 150
.meas tran vdout0_7ck29 FIND v(dout0_7) AT=150.025n

* CHECK dout0_8 Vdout0_8ck29 = 0 time = 150
.meas tran vdout0_8ck29 FIND v(dout0_8) AT=150.025n

* CHECK dout0_9 Vdout0_9ck29 = 0.9 time = 150
.meas tran vdout0_9ck29 FIND v(dout0_9) AT=150.025n

* CHECK dout0_10 Vdout0_10ck29 = 0.9 time = 150
.meas tran vdout0_10ck29 FIND v(dout0_10) AT=150.025n

* CHECK dout0_11 Vdout0_11ck29 = 0.9 time = 150
.meas tran vdout0_11ck29 FIND v(dout0_11) AT=150.025n

* CHECK dout0_12 Vdout0_12ck29 = 0 time = 150
.meas tran vdout0_12ck29 FIND v(dout0_12) AT=150.025n

* CHECK dout0_13 Vdout0_13ck29 = 0.9 time = 150
.meas tran vdout0_13ck29 FIND v(dout0_13) AT=150.025n

* CHECK dout0_14 Vdout0_14ck29 = 0.9 time = 150
.meas tran vdout0_14ck29 FIND v(dout0_14) AT=150.025n

* CHECK dout0_15 Vdout0_15ck29 = 0.9 time = 150
.meas tran vdout0_15ck29 FIND v(dout0_15) AT=150.025n

* CHECK dout0_16 Vdout0_16ck29 = 0 time = 150
.meas tran vdout0_16ck29 FIND v(dout0_16) AT=150.025n

* CHECK dout0_17 Vdout0_17ck29 = 0 time = 150
.meas tran vdout0_17ck29 FIND v(dout0_17) AT=150.025n

* CHECK dout0_18 Vdout0_18ck29 = 0 time = 150
.meas tran vdout0_18ck29 FIND v(dout0_18) AT=150.025n

* CHECK dout0_19 Vdout0_19ck29 = 0.9 time = 150
.meas tran vdout0_19ck29 FIND v(dout0_19) AT=150.025n

* CHECK dout0_20 Vdout0_20ck29 = 0.9 time = 150
.meas tran vdout0_20ck29 FIND v(dout0_20) AT=150.025n

* CHECK dout0_21 Vdout0_21ck29 = 0.9 time = 150
.meas tran vdout0_21ck29 FIND v(dout0_21) AT=150.025n

* CHECK dout0_22 Vdout0_22ck29 = 0 time = 150
.meas tran vdout0_22ck29 FIND v(dout0_22) AT=150.025n

* CHECK dout0_23 Vdout0_23ck29 = 0 time = 150
.meas tran vdout0_23ck29 FIND v(dout0_23) AT=150.025n

* CHECK dout0_24 Vdout0_24ck29 = 0 time = 150
.meas tran vdout0_24ck29 FIND v(dout0_24) AT=150.025n

* CHECK dout0_25 Vdout0_25ck29 = 0.9 time = 150
.meas tran vdout0_25ck29 FIND v(dout0_25) AT=150.025n

* CHECK dout0_26 Vdout0_26ck29 = 0.9 time = 150
.meas tran vdout0_26ck29 FIND v(dout0_26) AT=150.025n

* CHECK dout0_27 Vdout0_27ck29 = 0.9 time = 150
.meas tran vdout0_27ck29 FIND v(dout0_27) AT=150.025n

* CHECK dout0_28 Vdout0_28ck29 = 0 time = 150
.meas tran vdout0_28ck29 FIND v(dout0_28) AT=150.025n

* CHECK dout0_29 Vdout0_29ck29 = 0 time = 150
.meas tran vdout0_29ck29 FIND v(dout0_29) AT=150.025n

* CHECK dout0_30 Vdout0_30ck29 = 0.9 time = 150
.meas tran vdout0_30ck29 FIND v(dout0_30) AT=150.025n

* CHECK dout0_31 Vdout0_31ck29 = 0 time = 150
.meas tran vdout0_31ck29 FIND v(dout0_31) AT=150.025n

* CHECK dout0_32 Vdout0_32ck29 = 0.9 time = 150
.meas tran vdout0_32ck29 FIND v(dout0_32) AT=150.025n

* CHECK dout0_33 Vdout0_33ck29 = 0.9 time = 150
.meas tran vdout0_33ck29 FIND v(dout0_33) AT=150.025n

* CHECK dout0_34 Vdout0_34ck29 = 0.9 time = 150
.meas tran vdout0_34ck29 FIND v(dout0_34) AT=150.025n

* CHECK dout0_35 Vdout0_35ck29 = 0 time = 150
.meas tran vdout0_35ck29 FIND v(dout0_35) AT=150.025n

* CHECK dout0_36 Vdout0_36ck29 = 0.9 time = 150
.meas tran vdout0_36ck29 FIND v(dout0_36) AT=150.025n

* CHECK dout0_37 Vdout0_37ck29 = 0.9 time = 150
.meas tran vdout0_37ck29 FIND v(dout0_37) AT=150.025n

* CHECK dout0_38 Vdout0_38ck29 = 0.9 time = 150
.meas tran vdout0_38ck29 FIND v(dout0_38) AT=150.025n

* CHECK dout0_39 Vdout0_39ck29 = 0.9 time = 150
.meas tran vdout0_39ck29 FIND v(dout0_39) AT=150.025n

* CHECK dout0_40 Vdout0_40ck29 = 0.9 time = 150
.meas tran vdout0_40ck29 FIND v(dout0_40) AT=150.025n

* CHECK dout0_41 Vdout0_41ck29 = 0.9 time = 150
.meas tran vdout0_41ck29 FIND v(dout0_41) AT=150.025n

* CHECK dout0_42 Vdout0_42ck29 = 0.9 time = 150
.meas tran vdout0_42ck29 FIND v(dout0_42) AT=150.025n

* CHECK dout0_43 Vdout0_43ck29 = 0 time = 150
.meas tran vdout0_43ck29 FIND v(dout0_43) AT=150.025n

* CHECK dout0_44 Vdout0_44ck29 = 0 time = 150
.meas tran vdout0_44ck29 FIND v(dout0_44) AT=150.025n

* CHECK dout0_45 Vdout0_45ck29 = 0 time = 150
.meas tran vdout0_45ck29 FIND v(dout0_45) AT=150.025n

* CHECK dout0_46 Vdout0_46ck29 = 0 time = 150
.meas tran vdout0_46ck29 FIND v(dout0_46) AT=150.025n

* CHECK dout0_47 Vdout0_47ck29 = 0 time = 150
.meas tran vdout0_47ck29 FIND v(dout0_47) AT=150.025n

* CHECK dout0_48 Vdout0_48ck29 = 0 time = 150
.meas tran vdout0_48ck29 FIND v(dout0_48) AT=150.025n

* CHECK dout0_49 Vdout0_49ck29 = 0 time = 150
.meas tran vdout0_49ck29 FIND v(dout0_49) AT=150.025n

* CHECK dout0_50 Vdout0_50ck29 = 0.9 time = 150
.meas tran vdout0_50ck29 FIND v(dout0_50) AT=150.025n

* CHECK dout0_51 Vdout0_51ck29 = 0 time = 150
.meas tran vdout0_51ck29 FIND v(dout0_51) AT=150.025n

* CHECK dout0_52 Vdout0_52ck29 = 0.9 time = 150
.meas tran vdout0_52ck29 FIND v(dout0_52) AT=150.025n

* CHECK dout0_53 Vdout0_53ck29 = 0 time = 150
.meas tran vdout0_53ck29 FIND v(dout0_53) AT=150.025n

* CHECK dout0_54 Vdout0_54ck29 = 0.9 time = 150
.meas tran vdout0_54ck29 FIND v(dout0_54) AT=150.025n

* CHECK dout0_55 Vdout0_55ck29 = 0.9 time = 150
.meas tran vdout0_55ck29 FIND v(dout0_55) AT=150.025n

* CHECK dout0_56 Vdout0_56ck29 = 0.9 time = 150
.meas tran vdout0_56ck29 FIND v(dout0_56) AT=150.025n

* CHECK dout0_57 Vdout0_57ck29 = 0 time = 150
.meas tran vdout0_57ck29 FIND v(dout0_57) AT=150.025n

* CHECK dout0_58 Vdout0_58ck29 = 0.9 time = 150
.meas tran vdout0_58ck29 FIND v(dout0_58) AT=150.025n

* CHECK dout0_59 Vdout0_59ck29 = 0 time = 150
.meas tran vdout0_59ck29 FIND v(dout0_59) AT=150.025n

* CHECK dout0_60 Vdout0_60ck29 = 0 time = 150
.meas tran vdout0_60ck29 FIND v(dout0_60) AT=150.025n

* CHECK dout0_61 Vdout0_61ck29 = 0 time = 150
.meas tran vdout0_61ck29 FIND v(dout0_61) AT=150.025n

* CHECK dout0_62 Vdout0_62ck29 = 0.9 time = 150
.meas tran vdout0_62ck29 FIND v(dout0_62) AT=150.025n

* CHECK dout0_63 Vdout0_63ck29 = 0.9 time = 150
.meas tran vdout0_63ck29 FIND v(dout0_63) AT=150.025n

* CHECK dout0_0 Vdout0_0ck33 = 0 time = 170
.meas tran vdout0_0ck33 FIND v(dout0_0) AT=170.025n

* CHECK dout0_1 Vdout0_1ck33 = 0.9 time = 170
.meas tran vdout0_1ck33 FIND v(dout0_1) AT=170.025n

* CHECK dout0_2 Vdout0_2ck33 = 0.9 time = 170
.meas tran vdout0_2ck33 FIND v(dout0_2) AT=170.025n

* CHECK dout0_3 Vdout0_3ck33 = 0.9 time = 170
.meas tran vdout0_3ck33 FIND v(dout0_3) AT=170.025n

* CHECK dout0_4 Vdout0_4ck33 = 0 time = 170
.meas tran vdout0_4ck33 FIND v(dout0_4) AT=170.025n

* CHECK dout0_5 Vdout0_5ck33 = 0 time = 170
.meas tran vdout0_5ck33 FIND v(dout0_5) AT=170.025n

* CHECK dout0_6 Vdout0_6ck33 = 0 time = 170
.meas tran vdout0_6ck33 FIND v(dout0_6) AT=170.025n

* CHECK dout0_7 Vdout0_7ck33 = 0.9 time = 170
.meas tran vdout0_7ck33 FIND v(dout0_7) AT=170.025n

* CHECK dout0_8 Vdout0_8ck33 = 0 time = 170
.meas tran vdout0_8ck33 FIND v(dout0_8) AT=170.025n

* CHECK dout0_9 Vdout0_9ck33 = 0.9 time = 170
.meas tran vdout0_9ck33 FIND v(dout0_9) AT=170.025n

* CHECK dout0_10 Vdout0_10ck33 = 0.9 time = 170
.meas tran vdout0_10ck33 FIND v(dout0_10) AT=170.025n

* CHECK dout0_11 Vdout0_11ck33 = 0.9 time = 170
.meas tran vdout0_11ck33 FIND v(dout0_11) AT=170.025n

* CHECK dout0_12 Vdout0_12ck33 = 0 time = 170
.meas tran vdout0_12ck33 FIND v(dout0_12) AT=170.025n

* CHECK dout0_13 Vdout0_13ck33 = 0.9 time = 170
.meas tran vdout0_13ck33 FIND v(dout0_13) AT=170.025n

* CHECK dout0_14 Vdout0_14ck33 = 0.9 time = 170
.meas tran vdout0_14ck33 FIND v(dout0_14) AT=170.025n

* CHECK dout0_15 Vdout0_15ck33 = 0.9 time = 170
.meas tran vdout0_15ck33 FIND v(dout0_15) AT=170.025n

* CHECK dout0_16 Vdout0_16ck33 = 0 time = 170
.meas tran vdout0_16ck33 FIND v(dout0_16) AT=170.025n

* CHECK dout0_17 Vdout0_17ck33 = 0 time = 170
.meas tran vdout0_17ck33 FIND v(dout0_17) AT=170.025n

* CHECK dout0_18 Vdout0_18ck33 = 0 time = 170
.meas tran vdout0_18ck33 FIND v(dout0_18) AT=170.025n

* CHECK dout0_19 Vdout0_19ck33 = 0.9 time = 170
.meas tran vdout0_19ck33 FIND v(dout0_19) AT=170.025n

* CHECK dout0_20 Vdout0_20ck33 = 0.9 time = 170
.meas tran vdout0_20ck33 FIND v(dout0_20) AT=170.025n

* CHECK dout0_21 Vdout0_21ck33 = 0.9 time = 170
.meas tran vdout0_21ck33 FIND v(dout0_21) AT=170.025n

* CHECK dout0_22 Vdout0_22ck33 = 0 time = 170
.meas tran vdout0_22ck33 FIND v(dout0_22) AT=170.025n

* CHECK dout0_23 Vdout0_23ck33 = 0 time = 170
.meas tran vdout0_23ck33 FIND v(dout0_23) AT=170.025n

* CHECK dout0_24 Vdout0_24ck33 = 0 time = 170
.meas tran vdout0_24ck33 FIND v(dout0_24) AT=170.025n

* CHECK dout0_25 Vdout0_25ck33 = 0.9 time = 170
.meas tran vdout0_25ck33 FIND v(dout0_25) AT=170.025n

* CHECK dout0_26 Vdout0_26ck33 = 0.9 time = 170
.meas tran vdout0_26ck33 FIND v(dout0_26) AT=170.025n

* CHECK dout0_27 Vdout0_27ck33 = 0.9 time = 170
.meas tran vdout0_27ck33 FIND v(dout0_27) AT=170.025n

* CHECK dout0_28 Vdout0_28ck33 = 0 time = 170
.meas tran vdout0_28ck33 FIND v(dout0_28) AT=170.025n

* CHECK dout0_29 Vdout0_29ck33 = 0 time = 170
.meas tran vdout0_29ck33 FIND v(dout0_29) AT=170.025n

* CHECK dout0_30 Vdout0_30ck33 = 0.9 time = 170
.meas tran vdout0_30ck33 FIND v(dout0_30) AT=170.025n

* CHECK dout0_31 Vdout0_31ck33 = 0 time = 170
.meas tran vdout0_31ck33 FIND v(dout0_31) AT=170.025n

* CHECK dout0_32 Vdout0_32ck33 = 0.9 time = 170
.meas tran vdout0_32ck33 FIND v(dout0_32) AT=170.025n

* CHECK dout0_33 Vdout0_33ck33 = 0.9 time = 170
.meas tran vdout0_33ck33 FIND v(dout0_33) AT=170.025n

* CHECK dout0_34 Vdout0_34ck33 = 0.9 time = 170
.meas tran vdout0_34ck33 FIND v(dout0_34) AT=170.025n

* CHECK dout0_35 Vdout0_35ck33 = 0 time = 170
.meas tran vdout0_35ck33 FIND v(dout0_35) AT=170.025n

* CHECK dout0_36 Vdout0_36ck33 = 0.9 time = 170
.meas tran vdout0_36ck33 FIND v(dout0_36) AT=170.025n

* CHECK dout0_37 Vdout0_37ck33 = 0.9 time = 170
.meas tran vdout0_37ck33 FIND v(dout0_37) AT=170.025n

* CHECK dout0_38 Vdout0_38ck33 = 0.9 time = 170
.meas tran vdout0_38ck33 FIND v(dout0_38) AT=170.025n

* CHECK dout0_39 Vdout0_39ck33 = 0.9 time = 170
.meas tran vdout0_39ck33 FIND v(dout0_39) AT=170.025n

* CHECK dout0_40 Vdout0_40ck33 = 0.9 time = 170
.meas tran vdout0_40ck33 FIND v(dout0_40) AT=170.025n

* CHECK dout0_41 Vdout0_41ck33 = 0.9 time = 170
.meas tran vdout0_41ck33 FIND v(dout0_41) AT=170.025n

* CHECK dout0_42 Vdout0_42ck33 = 0.9 time = 170
.meas tran vdout0_42ck33 FIND v(dout0_42) AT=170.025n

* CHECK dout0_43 Vdout0_43ck33 = 0 time = 170
.meas tran vdout0_43ck33 FIND v(dout0_43) AT=170.025n

* CHECK dout0_44 Vdout0_44ck33 = 0 time = 170
.meas tran vdout0_44ck33 FIND v(dout0_44) AT=170.025n

* CHECK dout0_45 Vdout0_45ck33 = 0 time = 170
.meas tran vdout0_45ck33 FIND v(dout0_45) AT=170.025n

* CHECK dout0_46 Vdout0_46ck33 = 0 time = 170
.meas tran vdout0_46ck33 FIND v(dout0_46) AT=170.025n

* CHECK dout0_47 Vdout0_47ck33 = 0 time = 170
.meas tran vdout0_47ck33 FIND v(dout0_47) AT=170.025n

* CHECK dout0_48 Vdout0_48ck33 = 0 time = 170
.meas tran vdout0_48ck33 FIND v(dout0_48) AT=170.025n

* CHECK dout0_49 Vdout0_49ck33 = 0 time = 170
.meas tran vdout0_49ck33 FIND v(dout0_49) AT=170.025n

* CHECK dout0_50 Vdout0_50ck33 = 0.9 time = 170
.meas tran vdout0_50ck33 FIND v(dout0_50) AT=170.025n

* CHECK dout0_51 Vdout0_51ck33 = 0 time = 170
.meas tran vdout0_51ck33 FIND v(dout0_51) AT=170.025n

* CHECK dout0_52 Vdout0_52ck33 = 0.9 time = 170
.meas tran vdout0_52ck33 FIND v(dout0_52) AT=170.025n

* CHECK dout0_53 Vdout0_53ck33 = 0 time = 170
.meas tran vdout0_53ck33 FIND v(dout0_53) AT=170.025n

* CHECK dout0_54 Vdout0_54ck33 = 0.9 time = 170
.meas tran vdout0_54ck33 FIND v(dout0_54) AT=170.025n

* CHECK dout0_55 Vdout0_55ck33 = 0.9 time = 170
.meas tran vdout0_55ck33 FIND v(dout0_55) AT=170.025n

* CHECK dout0_56 Vdout0_56ck33 = 0.9 time = 170
.meas tran vdout0_56ck33 FIND v(dout0_56) AT=170.025n

* CHECK dout0_57 Vdout0_57ck33 = 0 time = 170
.meas tran vdout0_57ck33 FIND v(dout0_57) AT=170.025n

* CHECK dout0_58 Vdout0_58ck33 = 0.9 time = 170
.meas tran vdout0_58ck33 FIND v(dout0_58) AT=170.025n

* CHECK dout0_59 Vdout0_59ck33 = 0 time = 170
.meas tran vdout0_59ck33 FIND v(dout0_59) AT=170.025n

* CHECK dout0_60 Vdout0_60ck33 = 0 time = 170
.meas tran vdout0_60ck33 FIND v(dout0_60) AT=170.025n

* CHECK dout0_61 Vdout0_61ck33 = 0 time = 170
.meas tran vdout0_61ck33 FIND v(dout0_61) AT=170.025n

* CHECK dout0_62 Vdout0_62ck33 = 0.9 time = 170
.meas tran vdout0_62ck33 FIND v(dout0_62) AT=170.025n

* CHECK dout0_63 Vdout0_63ck33 = 0.9 time = 170
.meas tran vdout0_63ck33 FIND v(dout0_63) AT=170.025n

* CHECK dout0_0 Vdout0_0ck34 = 0 time = 175
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=175.025n

* CHECK dout0_1 Vdout0_1ck34 = 0.9 time = 175
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=175.025n

* CHECK dout0_2 Vdout0_2ck34 = 0.9 time = 175
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=175.025n

* CHECK dout0_3 Vdout0_3ck34 = 0.9 time = 175
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=175.025n

* CHECK dout0_4 Vdout0_4ck34 = 0 time = 175
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=175.025n

* CHECK dout0_5 Vdout0_5ck34 = 0 time = 175
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=175.025n

* CHECK dout0_6 Vdout0_6ck34 = 0 time = 175
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=175.025n

* CHECK dout0_7 Vdout0_7ck34 = 0.9 time = 175
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=175.025n

* CHECK dout0_8 Vdout0_8ck34 = 0 time = 175
.meas tran vdout0_8ck34 FIND v(dout0_8) AT=175.025n

* CHECK dout0_9 Vdout0_9ck34 = 0.9 time = 175
.meas tran vdout0_9ck34 FIND v(dout0_9) AT=175.025n

* CHECK dout0_10 Vdout0_10ck34 = 0.9 time = 175
.meas tran vdout0_10ck34 FIND v(dout0_10) AT=175.025n

* CHECK dout0_11 Vdout0_11ck34 = 0.9 time = 175
.meas tran vdout0_11ck34 FIND v(dout0_11) AT=175.025n

* CHECK dout0_12 Vdout0_12ck34 = 0 time = 175
.meas tran vdout0_12ck34 FIND v(dout0_12) AT=175.025n

* CHECK dout0_13 Vdout0_13ck34 = 0.9 time = 175
.meas tran vdout0_13ck34 FIND v(dout0_13) AT=175.025n

* CHECK dout0_14 Vdout0_14ck34 = 0.9 time = 175
.meas tran vdout0_14ck34 FIND v(dout0_14) AT=175.025n

* CHECK dout0_15 Vdout0_15ck34 = 0.9 time = 175
.meas tran vdout0_15ck34 FIND v(dout0_15) AT=175.025n

* CHECK dout0_16 Vdout0_16ck34 = 0 time = 175
.meas tran vdout0_16ck34 FIND v(dout0_16) AT=175.025n

* CHECK dout0_17 Vdout0_17ck34 = 0 time = 175
.meas tran vdout0_17ck34 FIND v(dout0_17) AT=175.025n

* CHECK dout0_18 Vdout0_18ck34 = 0 time = 175
.meas tran vdout0_18ck34 FIND v(dout0_18) AT=175.025n

* CHECK dout0_19 Vdout0_19ck34 = 0.9 time = 175
.meas tran vdout0_19ck34 FIND v(dout0_19) AT=175.025n

* CHECK dout0_20 Vdout0_20ck34 = 0.9 time = 175
.meas tran vdout0_20ck34 FIND v(dout0_20) AT=175.025n

* CHECK dout0_21 Vdout0_21ck34 = 0.9 time = 175
.meas tran vdout0_21ck34 FIND v(dout0_21) AT=175.025n

* CHECK dout0_22 Vdout0_22ck34 = 0 time = 175
.meas tran vdout0_22ck34 FIND v(dout0_22) AT=175.025n

* CHECK dout0_23 Vdout0_23ck34 = 0 time = 175
.meas tran vdout0_23ck34 FIND v(dout0_23) AT=175.025n

* CHECK dout0_24 Vdout0_24ck34 = 0 time = 175
.meas tran vdout0_24ck34 FIND v(dout0_24) AT=175.025n

* CHECK dout0_25 Vdout0_25ck34 = 0.9 time = 175
.meas tran vdout0_25ck34 FIND v(dout0_25) AT=175.025n

* CHECK dout0_26 Vdout0_26ck34 = 0.9 time = 175
.meas tran vdout0_26ck34 FIND v(dout0_26) AT=175.025n

* CHECK dout0_27 Vdout0_27ck34 = 0.9 time = 175
.meas tran vdout0_27ck34 FIND v(dout0_27) AT=175.025n

* CHECK dout0_28 Vdout0_28ck34 = 0 time = 175
.meas tran vdout0_28ck34 FIND v(dout0_28) AT=175.025n

* CHECK dout0_29 Vdout0_29ck34 = 0 time = 175
.meas tran vdout0_29ck34 FIND v(dout0_29) AT=175.025n

* CHECK dout0_30 Vdout0_30ck34 = 0.9 time = 175
.meas tran vdout0_30ck34 FIND v(dout0_30) AT=175.025n

* CHECK dout0_31 Vdout0_31ck34 = 0 time = 175
.meas tran vdout0_31ck34 FIND v(dout0_31) AT=175.025n

* CHECK dout0_32 Vdout0_32ck34 = 0.9 time = 175
.meas tran vdout0_32ck34 FIND v(dout0_32) AT=175.025n

* CHECK dout0_33 Vdout0_33ck34 = 0.9 time = 175
.meas tran vdout0_33ck34 FIND v(dout0_33) AT=175.025n

* CHECK dout0_34 Vdout0_34ck34 = 0.9 time = 175
.meas tran vdout0_34ck34 FIND v(dout0_34) AT=175.025n

* CHECK dout0_35 Vdout0_35ck34 = 0 time = 175
.meas tran vdout0_35ck34 FIND v(dout0_35) AT=175.025n

* CHECK dout0_36 Vdout0_36ck34 = 0.9 time = 175
.meas tran vdout0_36ck34 FIND v(dout0_36) AT=175.025n

* CHECK dout0_37 Vdout0_37ck34 = 0.9 time = 175
.meas tran vdout0_37ck34 FIND v(dout0_37) AT=175.025n

* CHECK dout0_38 Vdout0_38ck34 = 0.9 time = 175
.meas tran vdout0_38ck34 FIND v(dout0_38) AT=175.025n

* CHECK dout0_39 Vdout0_39ck34 = 0.9 time = 175
.meas tran vdout0_39ck34 FIND v(dout0_39) AT=175.025n

* CHECK dout0_40 Vdout0_40ck34 = 0.9 time = 175
.meas tran vdout0_40ck34 FIND v(dout0_40) AT=175.025n

* CHECK dout0_41 Vdout0_41ck34 = 0.9 time = 175
.meas tran vdout0_41ck34 FIND v(dout0_41) AT=175.025n

* CHECK dout0_42 Vdout0_42ck34 = 0.9 time = 175
.meas tran vdout0_42ck34 FIND v(dout0_42) AT=175.025n

* CHECK dout0_43 Vdout0_43ck34 = 0 time = 175
.meas tran vdout0_43ck34 FIND v(dout0_43) AT=175.025n

* CHECK dout0_44 Vdout0_44ck34 = 0 time = 175
.meas tran vdout0_44ck34 FIND v(dout0_44) AT=175.025n

* CHECK dout0_45 Vdout0_45ck34 = 0 time = 175
.meas tran vdout0_45ck34 FIND v(dout0_45) AT=175.025n

* CHECK dout0_46 Vdout0_46ck34 = 0 time = 175
.meas tran vdout0_46ck34 FIND v(dout0_46) AT=175.025n

* CHECK dout0_47 Vdout0_47ck34 = 0 time = 175
.meas tran vdout0_47ck34 FIND v(dout0_47) AT=175.025n

* CHECK dout0_48 Vdout0_48ck34 = 0 time = 175
.meas tran vdout0_48ck34 FIND v(dout0_48) AT=175.025n

* CHECK dout0_49 Vdout0_49ck34 = 0 time = 175
.meas tran vdout0_49ck34 FIND v(dout0_49) AT=175.025n

* CHECK dout0_50 Vdout0_50ck34 = 0.9 time = 175
.meas tran vdout0_50ck34 FIND v(dout0_50) AT=175.025n

* CHECK dout0_51 Vdout0_51ck34 = 0 time = 175
.meas tran vdout0_51ck34 FIND v(dout0_51) AT=175.025n

* CHECK dout0_52 Vdout0_52ck34 = 0.9 time = 175
.meas tran vdout0_52ck34 FIND v(dout0_52) AT=175.025n

* CHECK dout0_53 Vdout0_53ck34 = 0 time = 175
.meas tran vdout0_53ck34 FIND v(dout0_53) AT=175.025n

* CHECK dout0_54 Vdout0_54ck34 = 0.9 time = 175
.meas tran vdout0_54ck34 FIND v(dout0_54) AT=175.025n

* CHECK dout0_55 Vdout0_55ck34 = 0.9 time = 175
.meas tran vdout0_55ck34 FIND v(dout0_55) AT=175.025n

* CHECK dout0_56 Vdout0_56ck34 = 0.9 time = 175
.meas tran vdout0_56ck34 FIND v(dout0_56) AT=175.025n

* CHECK dout0_57 Vdout0_57ck34 = 0 time = 175
.meas tran vdout0_57ck34 FIND v(dout0_57) AT=175.025n

* CHECK dout0_58 Vdout0_58ck34 = 0.9 time = 175
.meas tran vdout0_58ck34 FIND v(dout0_58) AT=175.025n

* CHECK dout0_59 Vdout0_59ck34 = 0 time = 175
.meas tran vdout0_59ck34 FIND v(dout0_59) AT=175.025n

* CHECK dout0_60 Vdout0_60ck34 = 0 time = 175
.meas tran vdout0_60ck34 FIND v(dout0_60) AT=175.025n

* CHECK dout0_61 Vdout0_61ck34 = 0 time = 175
.meas tran vdout0_61ck34 FIND v(dout0_61) AT=175.025n

* CHECK dout0_62 Vdout0_62ck34 = 0.9 time = 175
.meas tran vdout0_62ck34 FIND v(dout0_62) AT=175.025n

* CHECK dout0_63 Vdout0_63ck34 = 0.9 time = 175
.meas tran vdout0_63ck34 FIND v(dout0_63) AT=175.025n

* CHECK dout0_0 Vdout0_0ck36 = 0.9 time = 185
.meas tran vdout0_0ck36 FIND v(dout0_0) AT=185.025n

* CHECK dout0_1 Vdout0_1ck36 = 0 time = 185
.meas tran vdout0_1ck36 FIND v(dout0_1) AT=185.025n

* CHECK dout0_2 Vdout0_2ck36 = 0 time = 185
.meas tran vdout0_2ck36 FIND v(dout0_2) AT=185.025n

* CHECK dout0_3 Vdout0_3ck36 = 0 time = 185
.meas tran vdout0_3ck36 FIND v(dout0_3) AT=185.025n

* CHECK dout0_4 Vdout0_4ck36 = 0 time = 185
.meas tran vdout0_4ck36 FIND v(dout0_4) AT=185.025n

* CHECK dout0_5 Vdout0_5ck36 = 0.9 time = 185
.meas tran vdout0_5ck36 FIND v(dout0_5) AT=185.025n

* CHECK dout0_6 Vdout0_6ck36 = 0 time = 185
.meas tran vdout0_6ck36 FIND v(dout0_6) AT=185.025n

* CHECK dout0_7 Vdout0_7ck36 = 0 time = 185
.meas tran vdout0_7ck36 FIND v(dout0_7) AT=185.025n

* CHECK dout0_8 Vdout0_8ck36 = 0 time = 185
.meas tran vdout0_8ck36 FIND v(dout0_8) AT=185.025n

* CHECK dout0_9 Vdout0_9ck36 = 0.9 time = 185
.meas tran vdout0_9ck36 FIND v(dout0_9) AT=185.025n

* CHECK dout0_10 Vdout0_10ck36 = 0.9 time = 185
.meas tran vdout0_10ck36 FIND v(dout0_10) AT=185.025n

* CHECK dout0_11 Vdout0_11ck36 = 0.9 time = 185
.meas tran vdout0_11ck36 FIND v(dout0_11) AT=185.025n

* CHECK dout0_12 Vdout0_12ck36 = 0.9 time = 185
.meas tran vdout0_12ck36 FIND v(dout0_12) AT=185.025n

* CHECK dout0_13 Vdout0_13ck36 = 0.9 time = 185
.meas tran vdout0_13ck36 FIND v(dout0_13) AT=185.025n

* CHECK dout0_14 Vdout0_14ck36 = 0 time = 185
.meas tran vdout0_14ck36 FIND v(dout0_14) AT=185.025n

* CHECK dout0_15 Vdout0_15ck36 = 0.9 time = 185
.meas tran vdout0_15ck36 FIND v(dout0_15) AT=185.025n

* CHECK dout0_16 Vdout0_16ck36 = 0.9 time = 185
.meas tran vdout0_16ck36 FIND v(dout0_16) AT=185.025n

* CHECK dout0_17 Vdout0_17ck36 = 0.9 time = 185
.meas tran vdout0_17ck36 FIND v(dout0_17) AT=185.025n

* CHECK dout0_18 Vdout0_18ck36 = 0 time = 185
.meas tran vdout0_18ck36 FIND v(dout0_18) AT=185.025n

* CHECK dout0_19 Vdout0_19ck36 = 0 time = 185
.meas tran vdout0_19ck36 FIND v(dout0_19) AT=185.025n

* CHECK dout0_20 Vdout0_20ck36 = 0.9 time = 185
.meas tran vdout0_20ck36 FIND v(dout0_20) AT=185.025n

* CHECK dout0_21 Vdout0_21ck36 = 0.9 time = 185
.meas tran vdout0_21ck36 FIND v(dout0_21) AT=185.025n

* CHECK dout0_22 Vdout0_22ck36 = 0.9 time = 185
.meas tran vdout0_22ck36 FIND v(dout0_22) AT=185.025n

* CHECK dout0_23 Vdout0_23ck36 = 0.9 time = 185
.meas tran vdout0_23ck36 FIND v(dout0_23) AT=185.025n

* CHECK dout0_24 Vdout0_24ck36 = 0.9 time = 185
.meas tran vdout0_24ck36 FIND v(dout0_24) AT=185.025n

* CHECK dout0_25 Vdout0_25ck36 = 0 time = 185
.meas tran vdout0_25ck36 FIND v(dout0_25) AT=185.025n

* CHECK dout0_26 Vdout0_26ck36 = 0 time = 185
.meas tran vdout0_26ck36 FIND v(dout0_26) AT=185.025n

* CHECK dout0_27 Vdout0_27ck36 = 0.9 time = 185
.meas tran vdout0_27ck36 FIND v(dout0_27) AT=185.025n

* CHECK dout0_28 Vdout0_28ck36 = 0 time = 185
.meas tran vdout0_28ck36 FIND v(dout0_28) AT=185.025n

* CHECK dout0_29 Vdout0_29ck36 = 0 time = 185
.meas tran vdout0_29ck36 FIND v(dout0_29) AT=185.025n

* CHECK dout0_30 Vdout0_30ck36 = 0 time = 185
.meas tran vdout0_30ck36 FIND v(dout0_30) AT=185.025n

* CHECK dout0_31 Vdout0_31ck36 = 0.9 time = 185
.meas tran vdout0_31ck36 FIND v(dout0_31) AT=185.025n

* CHECK dout0_32 Vdout0_32ck36 = 0.9 time = 185
.meas tran vdout0_32ck36 FIND v(dout0_32) AT=185.025n

* CHECK dout0_33 Vdout0_33ck36 = 0 time = 185
.meas tran vdout0_33ck36 FIND v(dout0_33) AT=185.025n

* CHECK dout0_34 Vdout0_34ck36 = 0 time = 185
.meas tran vdout0_34ck36 FIND v(dout0_34) AT=185.025n

* CHECK dout0_35 Vdout0_35ck36 = 0.9 time = 185
.meas tran vdout0_35ck36 FIND v(dout0_35) AT=185.025n

* CHECK dout0_36 Vdout0_36ck36 = 0 time = 185
.meas tran vdout0_36ck36 FIND v(dout0_36) AT=185.025n

* CHECK dout0_37 Vdout0_37ck36 = 0.9 time = 185
.meas tran vdout0_37ck36 FIND v(dout0_37) AT=185.025n

* CHECK dout0_38 Vdout0_38ck36 = 0.9 time = 185
.meas tran vdout0_38ck36 FIND v(dout0_38) AT=185.025n

* CHECK dout0_39 Vdout0_39ck36 = 0 time = 185
.meas tran vdout0_39ck36 FIND v(dout0_39) AT=185.025n

* CHECK dout0_40 Vdout0_40ck36 = 0 time = 185
.meas tran vdout0_40ck36 FIND v(dout0_40) AT=185.025n

* CHECK dout0_41 Vdout0_41ck36 = 0 time = 185
.meas tran vdout0_41ck36 FIND v(dout0_41) AT=185.025n

* CHECK dout0_42 Vdout0_42ck36 = 0 time = 185
.meas tran vdout0_42ck36 FIND v(dout0_42) AT=185.025n

* CHECK dout0_43 Vdout0_43ck36 = 0 time = 185
.meas tran vdout0_43ck36 FIND v(dout0_43) AT=185.025n

* CHECK dout0_44 Vdout0_44ck36 = 0.9 time = 185
.meas tran vdout0_44ck36 FIND v(dout0_44) AT=185.025n

* CHECK dout0_45 Vdout0_45ck36 = 0 time = 185
.meas tran vdout0_45ck36 FIND v(dout0_45) AT=185.025n

* CHECK dout0_46 Vdout0_46ck36 = 0 time = 185
.meas tran vdout0_46ck36 FIND v(dout0_46) AT=185.025n

* CHECK dout0_47 Vdout0_47ck36 = 0.9 time = 185
.meas tran vdout0_47ck36 FIND v(dout0_47) AT=185.025n

* CHECK dout0_48 Vdout0_48ck36 = 0.9 time = 185
.meas tran vdout0_48ck36 FIND v(dout0_48) AT=185.025n

* CHECK dout0_49 Vdout0_49ck36 = 0 time = 185
.meas tran vdout0_49ck36 FIND v(dout0_49) AT=185.025n

* CHECK dout0_50 Vdout0_50ck36 = 0.9 time = 185
.meas tran vdout0_50ck36 FIND v(dout0_50) AT=185.025n

* CHECK dout0_51 Vdout0_51ck36 = 0 time = 185
.meas tran vdout0_51ck36 FIND v(dout0_51) AT=185.025n

* CHECK dout0_52 Vdout0_52ck36 = 0.9 time = 185
.meas tran vdout0_52ck36 FIND v(dout0_52) AT=185.025n

* CHECK dout0_53 Vdout0_53ck36 = 0.9 time = 185
.meas tran vdout0_53ck36 FIND v(dout0_53) AT=185.025n

* CHECK dout0_54 Vdout0_54ck36 = 0 time = 185
.meas tran vdout0_54ck36 FIND v(dout0_54) AT=185.025n

* CHECK dout0_55 Vdout0_55ck36 = 0.9 time = 185
.meas tran vdout0_55ck36 FIND v(dout0_55) AT=185.025n

* CHECK dout0_56 Vdout0_56ck36 = 0.9 time = 185
.meas tran vdout0_56ck36 FIND v(dout0_56) AT=185.025n

* CHECK dout0_57 Vdout0_57ck36 = 0 time = 185
.meas tran vdout0_57ck36 FIND v(dout0_57) AT=185.025n

* CHECK dout0_58 Vdout0_58ck36 = 0.9 time = 185
.meas tran vdout0_58ck36 FIND v(dout0_58) AT=185.025n

* CHECK dout0_59 Vdout0_59ck36 = 0.9 time = 185
.meas tran vdout0_59ck36 FIND v(dout0_59) AT=185.025n

* CHECK dout0_60 Vdout0_60ck36 = 0.9 time = 185
.meas tran vdout0_60ck36 FIND v(dout0_60) AT=185.025n

* CHECK dout0_61 Vdout0_61ck36 = 0 time = 185
.meas tran vdout0_61ck36 FIND v(dout0_61) AT=185.025n

* CHECK dout0_62 Vdout0_62ck36 = 0 time = 185
.meas tran vdout0_62ck36 FIND v(dout0_62) AT=185.025n

* CHECK dout0_63 Vdout0_63ck36 = 0 time = 185
.meas tran vdout0_63ck36 FIND v(dout0_63) AT=185.025n

* CHECK dout0_0 Vdout0_0ck39 = 0 time = 200
.meas tran vdout0_0ck39 FIND v(dout0_0) AT=200.025n

* CHECK dout0_1 Vdout0_1ck39 = 0.9 time = 200
.meas tran vdout0_1ck39 FIND v(dout0_1) AT=200.025n

* CHECK dout0_2 Vdout0_2ck39 = 0.9 time = 200
.meas tran vdout0_2ck39 FIND v(dout0_2) AT=200.025n

* CHECK dout0_3 Vdout0_3ck39 = 0 time = 200
.meas tran vdout0_3ck39 FIND v(dout0_3) AT=200.025n

* CHECK dout0_4 Vdout0_4ck39 = 0 time = 200
.meas tran vdout0_4ck39 FIND v(dout0_4) AT=200.025n

* CHECK dout0_5 Vdout0_5ck39 = 0 time = 200
.meas tran vdout0_5ck39 FIND v(dout0_5) AT=200.025n

* CHECK dout0_6 Vdout0_6ck39 = 0.9 time = 200
.meas tran vdout0_6ck39 FIND v(dout0_6) AT=200.025n

* CHECK dout0_7 Vdout0_7ck39 = 0.9 time = 200
.meas tran vdout0_7ck39 FIND v(dout0_7) AT=200.025n

* CHECK dout0_8 Vdout0_8ck39 = 0.9 time = 200
.meas tran vdout0_8ck39 FIND v(dout0_8) AT=200.025n

* CHECK dout0_9 Vdout0_9ck39 = 0 time = 200
.meas tran vdout0_9ck39 FIND v(dout0_9) AT=200.025n

* CHECK dout0_10 Vdout0_10ck39 = 0 time = 200
.meas tran vdout0_10ck39 FIND v(dout0_10) AT=200.025n

* CHECK dout0_11 Vdout0_11ck39 = 0.9 time = 200
.meas tran vdout0_11ck39 FIND v(dout0_11) AT=200.025n

* CHECK dout0_12 Vdout0_12ck39 = 0 time = 200
.meas tran vdout0_12ck39 FIND v(dout0_12) AT=200.025n

* CHECK dout0_13 Vdout0_13ck39 = 0.9 time = 200
.meas tran vdout0_13ck39 FIND v(dout0_13) AT=200.025n

* CHECK dout0_14 Vdout0_14ck39 = 0.9 time = 200
.meas tran vdout0_14ck39 FIND v(dout0_14) AT=200.025n

* CHECK dout0_15 Vdout0_15ck39 = 0.9 time = 200
.meas tran vdout0_15ck39 FIND v(dout0_15) AT=200.025n

* CHECK dout0_16 Vdout0_16ck39 = 0.9 time = 200
.meas tran vdout0_16ck39 FIND v(dout0_16) AT=200.025n

* CHECK dout0_17 Vdout0_17ck39 = 0 time = 200
.meas tran vdout0_17ck39 FIND v(dout0_17) AT=200.025n

* CHECK dout0_18 Vdout0_18ck39 = 0 time = 200
.meas tran vdout0_18ck39 FIND v(dout0_18) AT=200.025n

* CHECK dout0_19 Vdout0_19ck39 = 0 time = 200
.meas tran vdout0_19ck39 FIND v(dout0_19) AT=200.025n

* CHECK dout0_20 Vdout0_20ck39 = 0.9 time = 200
.meas tran vdout0_20ck39 FIND v(dout0_20) AT=200.025n

* CHECK dout0_21 Vdout0_21ck39 = 0.9 time = 200
.meas tran vdout0_21ck39 FIND v(dout0_21) AT=200.025n

* CHECK dout0_22 Vdout0_22ck39 = 0 time = 200
.meas tran vdout0_22ck39 FIND v(dout0_22) AT=200.025n

* CHECK dout0_23 Vdout0_23ck39 = 0 time = 200
.meas tran vdout0_23ck39 FIND v(dout0_23) AT=200.025n

* CHECK dout0_24 Vdout0_24ck39 = 0.9 time = 200
.meas tran vdout0_24ck39 FIND v(dout0_24) AT=200.025n

* CHECK dout0_25 Vdout0_25ck39 = 0 time = 200
.meas tran vdout0_25ck39 FIND v(dout0_25) AT=200.025n

* CHECK dout0_26 Vdout0_26ck39 = 0 time = 200
.meas tran vdout0_26ck39 FIND v(dout0_26) AT=200.025n

* CHECK dout0_27 Vdout0_27ck39 = 0 time = 200
.meas tran vdout0_27ck39 FIND v(dout0_27) AT=200.025n

* CHECK dout0_28 Vdout0_28ck39 = 0.9 time = 200
.meas tran vdout0_28ck39 FIND v(dout0_28) AT=200.025n

* CHECK dout0_29 Vdout0_29ck39 = 0 time = 200
.meas tran vdout0_29ck39 FIND v(dout0_29) AT=200.025n

* CHECK dout0_30 Vdout0_30ck39 = 0.9 time = 200
.meas tran vdout0_30ck39 FIND v(dout0_30) AT=200.025n

* CHECK dout0_31 Vdout0_31ck39 = 0 time = 200
.meas tran vdout0_31ck39 FIND v(dout0_31) AT=200.025n

* CHECK dout0_32 Vdout0_32ck39 = 0.9 time = 200
.meas tran vdout0_32ck39 FIND v(dout0_32) AT=200.025n

* CHECK dout0_33 Vdout0_33ck39 = 0 time = 200
.meas tran vdout0_33ck39 FIND v(dout0_33) AT=200.025n

* CHECK dout0_34 Vdout0_34ck39 = 0 time = 200
.meas tran vdout0_34ck39 FIND v(dout0_34) AT=200.025n

* CHECK dout0_35 Vdout0_35ck39 = 0 time = 200
.meas tran vdout0_35ck39 FIND v(dout0_35) AT=200.025n

* CHECK dout0_36 Vdout0_36ck39 = 0 time = 200
.meas tran vdout0_36ck39 FIND v(dout0_36) AT=200.025n

* CHECK dout0_37 Vdout0_37ck39 = 0.9 time = 200
.meas tran vdout0_37ck39 FIND v(dout0_37) AT=200.025n

* CHECK dout0_38 Vdout0_38ck39 = 0 time = 200
.meas tran vdout0_38ck39 FIND v(dout0_38) AT=200.025n

* CHECK dout0_39 Vdout0_39ck39 = 0.9 time = 200
.meas tran vdout0_39ck39 FIND v(dout0_39) AT=200.025n

* CHECK dout0_40 Vdout0_40ck39 = 0.9 time = 200
.meas tran vdout0_40ck39 FIND v(dout0_40) AT=200.025n

* CHECK dout0_41 Vdout0_41ck39 = 0 time = 200
.meas tran vdout0_41ck39 FIND v(dout0_41) AT=200.025n

* CHECK dout0_42 Vdout0_42ck39 = 0.9 time = 200
.meas tran vdout0_42ck39 FIND v(dout0_42) AT=200.025n

* CHECK dout0_43 Vdout0_43ck39 = 0 time = 200
.meas tran vdout0_43ck39 FIND v(dout0_43) AT=200.025n

* CHECK dout0_44 Vdout0_44ck39 = 0.9 time = 200
.meas tran vdout0_44ck39 FIND v(dout0_44) AT=200.025n

* CHECK dout0_45 Vdout0_45ck39 = 0 time = 200
.meas tran vdout0_45ck39 FIND v(dout0_45) AT=200.025n

* CHECK dout0_46 Vdout0_46ck39 = 0.9 time = 200
.meas tran vdout0_46ck39 FIND v(dout0_46) AT=200.025n

* CHECK dout0_47 Vdout0_47ck39 = 0.9 time = 200
.meas tran vdout0_47ck39 FIND v(dout0_47) AT=200.025n

* CHECK dout0_48 Vdout0_48ck39 = 0.9 time = 200
.meas tran vdout0_48ck39 FIND v(dout0_48) AT=200.025n

* CHECK dout0_49 Vdout0_49ck39 = 0.9 time = 200
.meas tran vdout0_49ck39 FIND v(dout0_49) AT=200.025n

* CHECK dout0_50 Vdout0_50ck39 = 0.9 time = 200
.meas tran vdout0_50ck39 FIND v(dout0_50) AT=200.025n

* CHECK dout0_51 Vdout0_51ck39 = 0.9 time = 200
.meas tran vdout0_51ck39 FIND v(dout0_51) AT=200.025n

* CHECK dout0_52 Vdout0_52ck39 = 0.9 time = 200
.meas tran vdout0_52ck39 FIND v(dout0_52) AT=200.025n

* CHECK dout0_53 Vdout0_53ck39 = 0.9 time = 200
.meas tran vdout0_53ck39 FIND v(dout0_53) AT=200.025n

* CHECK dout0_54 Vdout0_54ck39 = 0 time = 200
.meas tran vdout0_54ck39 FIND v(dout0_54) AT=200.025n

* CHECK dout0_55 Vdout0_55ck39 = 0.9 time = 200
.meas tran vdout0_55ck39 FIND v(dout0_55) AT=200.025n

* CHECK dout0_56 Vdout0_56ck39 = 0.9 time = 200
.meas tran vdout0_56ck39 FIND v(dout0_56) AT=200.025n

* CHECK dout0_57 Vdout0_57ck39 = 0 time = 200
.meas tran vdout0_57ck39 FIND v(dout0_57) AT=200.025n

* CHECK dout0_58 Vdout0_58ck39 = 0.9 time = 200
.meas tran vdout0_58ck39 FIND v(dout0_58) AT=200.025n

* CHECK dout0_59 Vdout0_59ck39 = 0.9 time = 200
.meas tran vdout0_59ck39 FIND v(dout0_59) AT=200.025n

* CHECK dout0_60 Vdout0_60ck39 = 0 time = 200
.meas tran vdout0_60ck39 FIND v(dout0_60) AT=200.025n

* CHECK dout0_61 Vdout0_61ck39 = 0 time = 200
.meas tran vdout0_61ck39 FIND v(dout0_61) AT=200.025n

* CHECK dout0_62 Vdout0_62ck39 = 0 time = 200
.meas tran vdout0_62ck39 FIND v(dout0_62) AT=200.025n

* CHECK dout0_63 Vdout0_63ck39 = 0 time = 200
.meas tran vdout0_63ck39 FIND v(dout0_63) AT=200.025n

* CHECK dout0_0 Vdout0_0ck40 = 0.9 time = 205
.meas tran vdout0_0ck40 FIND v(dout0_0) AT=205.025n

* CHECK dout0_1 Vdout0_1ck40 = 0 time = 205
.meas tran vdout0_1ck40 FIND v(dout0_1) AT=205.025n

* CHECK dout0_2 Vdout0_2ck40 = 0 time = 205
.meas tran vdout0_2ck40 FIND v(dout0_2) AT=205.025n

* CHECK dout0_3 Vdout0_3ck40 = 0.9 time = 205
.meas tran vdout0_3ck40 FIND v(dout0_3) AT=205.025n

* CHECK dout0_4 Vdout0_4ck40 = 0.9 time = 205
.meas tran vdout0_4ck40 FIND v(dout0_4) AT=205.025n

* CHECK dout0_5 Vdout0_5ck40 = 0 time = 205
.meas tran vdout0_5ck40 FIND v(dout0_5) AT=205.025n

* CHECK dout0_6 Vdout0_6ck40 = 0.9 time = 205
.meas tran vdout0_6ck40 FIND v(dout0_6) AT=205.025n

* CHECK dout0_7 Vdout0_7ck40 = 0 time = 205
.meas tran vdout0_7ck40 FIND v(dout0_7) AT=205.025n

* CHECK dout0_8 Vdout0_8ck40 = 0 time = 205
.meas tran vdout0_8ck40 FIND v(dout0_8) AT=205.025n

* CHECK dout0_9 Vdout0_9ck40 = 0.9 time = 205
.meas tran vdout0_9ck40 FIND v(dout0_9) AT=205.025n

* CHECK dout0_10 Vdout0_10ck40 = 0 time = 205
.meas tran vdout0_10ck40 FIND v(dout0_10) AT=205.025n

* CHECK dout0_11 Vdout0_11ck40 = 0.9 time = 205
.meas tran vdout0_11ck40 FIND v(dout0_11) AT=205.025n

* CHECK dout0_12 Vdout0_12ck40 = 0 time = 205
.meas tran vdout0_12ck40 FIND v(dout0_12) AT=205.025n

* CHECK dout0_13 Vdout0_13ck40 = 0 time = 205
.meas tran vdout0_13ck40 FIND v(dout0_13) AT=205.025n

* CHECK dout0_14 Vdout0_14ck40 = 0 time = 205
.meas tran vdout0_14ck40 FIND v(dout0_14) AT=205.025n

* CHECK dout0_15 Vdout0_15ck40 = 0 time = 205
.meas tran vdout0_15ck40 FIND v(dout0_15) AT=205.025n

* CHECK dout0_16 Vdout0_16ck40 = 0 time = 205
.meas tran vdout0_16ck40 FIND v(dout0_16) AT=205.025n

* CHECK dout0_17 Vdout0_17ck40 = 0 time = 205
.meas tran vdout0_17ck40 FIND v(dout0_17) AT=205.025n

* CHECK dout0_18 Vdout0_18ck40 = 0 time = 205
.meas tran vdout0_18ck40 FIND v(dout0_18) AT=205.025n

* CHECK dout0_19 Vdout0_19ck40 = 0 time = 205
.meas tran vdout0_19ck40 FIND v(dout0_19) AT=205.025n

* CHECK dout0_20 Vdout0_20ck40 = 0.9 time = 205
.meas tran vdout0_20ck40 FIND v(dout0_20) AT=205.025n

* CHECK dout0_21 Vdout0_21ck40 = 0 time = 205
.meas tran vdout0_21ck40 FIND v(dout0_21) AT=205.025n

* CHECK dout0_22 Vdout0_22ck40 = 0 time = 205
.meas tran vdout0_22ck40 FIND v(dout0_22) AT=205.025n

* CHECK dout0_23 Vdout0_23ck40 = 0.9 time = 205
.meas tran vdout0_23ck40 FIND v(dout0_23) AT=205.025n

* CHECK dout0_24 Vdout0_24ck40 = 0.9 time = 205
.meas tran vdout0_24ck40 FIND v(dout0_24) AT=205.025n

* CHECK dout0_25 Vdout0_25ck40 = 0 time = 205
.meas tran vdout0_25ck40 FIND v(dout0_25) AT=205.025n

* CHECK dout0_26 Vdout0_26ck40 = 0.9 time = 205
.meas tran vdout0_26ck40 FIND v(dout0_26) AT=205.025n

* CHECK dout0_27 Vdout0_27ck40 = 0 time = 205
.meas tran vdout0_27ck40 FIND v(dout0_27) AT=205.025n

* CHECK dout0_28 Vdout0_28ck40 = 0.9 time = 205
.meas tran vdout0_28ck40 FIND v(dout0_28) AT=205.025n

* CHECK dout0_29 Vdout0_29ck40 = 0 time = 205
.meas tran vdout0_29ck40 FIND v(dout0_29) AT=205.025n

* CHECK dout0_30 Vdout0_30ck40 = 0 time = 205
.meas tran vdout0_30ck40 FIND v(dout0_30) AT=205.025n

* CHECK dout0_31 Vdout0_31ck40 = 0.9 time = 205
.meas tran vdout0_31ck40 FIND v(dout0_31) AT=205.025n

* CHECK dout0_32 Vdout0_32ck40 = 0 time = 205
.meas tran vdout0_32ck40 FIND v(dout0_32) AT=205.025n

* CHECK dout0_33 Vdout0_33ck40 = 0 time = 205
.meas tran vdout0_33ck40 FIND v(dout0_33) AT=205.025n

* CHECK dout0_34 Vdout0_34ck40 = 0.9 time = 205
.meas tran vdout0_34ck40 FIND v(dout0_34) AT=205.025n

* CHECK dout0_35 Vdout0_35ck40 = 0.9 time = 205
.meas tran vdout0_35ck40 FIND v(dout0_35) AT=205.025n

* CHECK dout0_36 Vdout0_36ck40 = 0.9 time = 205
.meas tran vdout0_36ck40 FIND v(dout0_36) AT=205.025n

* CHECK dout0_37 Vdout0_37ck40 = 0 time = 205
.meas tran vdout0_37ck40 FIND v(dout0_37) AT=205.025n

* CHECK dout0_38 Vdout0_38ck40 = 0.9 time = 205
.meas tran vdout0_38ck40 FIND v(dout0_38) AT=205.025n

* CHECK dout0_39 Vdout0_39ck40 = 0.9 time = 205
.meas tran vdout0_39ck40 FIND v(dout0_39) AT=205.025n

* CHECK dout0_40 Vdout0_40ck40 = 0 time = 205
.meas tran vdout0_40ck40 FIND v(dout0_40) AT=205.025n

* CHECK dout0_41 Vdout0_41ck40 = 0 time = 205
.meas tran vdout0_41ck40 FIND v(dout0_41) AT=205.025n

* CHECK dout0_42 Vdout0_42ck40 = 0 time = 205
.meas tran vdout0_42ck40 FIND v(dout0_42) AT=205.025n

* CHECK dout0_43 Vdout0_43ck40 = 0 time = 205
.meas tran vdout0_43ck40 FIND v(dout0_43) AT=205.025n

* CHECK dout0_44 Vdout0_44ck40 = 0 time = 205
.meas tran vdout0_44ck40 FIND v(dout0_44) AT=205.025n

* CHECK dout0_45 Vdout0_45ck40 = 0 time = 205
.meas tran vdout0_45ck40 FIND v(dout0_45) AT=205.025n

* CHECK dout0_46 Vdout0_46ck40 = 0.9 time = 205
.meas tran vdout0_46ck40 FIND v(dout0_46) AT=205.025n

* CHECK dout0_47 Vdout0_47ck40 = 0.9 time = 205
.meas tran vdout0_47ck40 FIND v(dout0_47) AT=205.025n

* CHECK dout0_48 Vdout0_48ck40 = 0.9 time = 205
.meas tran vdout0_48ck40 FIND v(dout0_48) AT=205.025n

* CHECK dout0_49 Vdout0_49ck40 = 0 time = 205
.meas tran vdout0_49ck40 FIND v(dout0_49) AT=205.025n

* CHECK dout0_50 Vdout0_50ck40 = 0.9 time = 205
.meas tran vdout0_50ck40 FIND v(dout0_50) AT=205.025n

* CHECK dout0_51 Vdout0_51ck40 = 0 time = 205
.meas tran vdout0_51ck40 FIND v(dout0_51) AT=205.025n

* CHECK dout0_52 Vdout0_52ck40 = 0 time = 205
.meas tran vdout0_52ck40 FIND v(dout0_52) AT=205.025n

* CHECK dout0_53 Vdout0_53ck40 = 0.9 time = 205
.meas tran vdout0_53ck40 FIND v(dout0_53) AT=205.025n

* CHECK dout0_54 Vdout0_54ck40 = 0.9 time = 205
.meas tran vdout0_54ck40 FIND v(dout0_54) AT=205.025n

* CHECK dout0_55 Vdout0_55ck40 = 0 time = 205
.meas tran vdout0_55ck40 FIND v(dout0_55) AT=205.025n

* CHECK dout0_56 Vdout0_56ck40 = 0 time = 205
.meas tran vdout0_56ck40 FIND v(dout0_56) AT=205.025n

* CHECK dout0_57 Vdout0_57ck40 = 0.9 time = 205
.meas tran vdout0_57ck40 FIND v(dout0_57) AT=205.025n

* CHECK dout0_58 Vdout0_58ck40 = 0 time = 205
.meas tran vdout0_58ck40 FIND v(dout0_58) AT=205.025n

* CHECK dout0_59 Vdout0_59ck40 = 0.9 time = 205
.meas tran vdout0_59ck40 FIND v(dout0_59) AT=205.025n

* CHECK dout0_60 Vdout0_60ck40 = 0.9 time = 205
.meas tran vdout0_60ck40 FIND v(dout0_60) AT=205.025n

* CHECK dout0_61 Vdout0_61ck40 = 0.9 time = 205
.meas tran vdout0_61ck40 FIND v(dout0_61) AT=205.025n

* CHECK dout0_62 Vdout0_62ck40 = 0 time = 205
.meas tran vdout0_62ck40 FIND v(dout0_62) AT=205.025n

* CHECK dout0_63 Vdout0_63ck40 = 0 time = 205
.meas tran vdout0_63ck40 FIND v(dout0_63) AT=205.025n

* CHECK dout0_0 Vdout0_0ck41 = 0.9 time = 210
.meas tran vdout0_0ck41 FIND v(dout0_0) AT=210.025n

* CHECK dout0_1 Vdout0_1ck41 = 0 time = 210
.meas tran vdout0_1ck41 FIND v(dout0_1) AT=210.025n

* CHECK dout0_2 Vdout0_2ck41 = 0 time = 210
.meas tran vdout0_2ck41 FIND v(dout0_2) AT=210.025n

* CHECK dout0_3 Vdout0_3ck41 = 0.9 time = 210
.meas tran vdout0_3ck41 FIND v(dout0_3) AT=210.025n

* CHECK dout0_4 Vdout0_4ck41 = 0 time = 210
.meas tran vdout0_4ck41 FIND v(dout0_4) AT=210.025n

* CHECK dout0_5 Vdout0_5ck41 = 0.9 time = 210
.meas tran vdout0_5ck41 FIND v(dout0_5) AT=210.025n

* CHECK dout0_6 Vdout0_6ck41 = 0 time = 210
.meas tran vdout0_6ck41 FIND v(dout0_6) AT=210.025n

* CHECK dout0_7 Vdout0_7ck41 = 0.9 time = 210
.meas tran vdout0_7ck41 FIND v(dout0_7) AT=210.025n

* CHECK dout0_8 Vdout0_8ck41 = 0 time = 210
.meas tran vdout0_8ck41 FIND v(dout0_8) AT=210.025n

* CHECK dout0_9 Vdout0_9ck41 = 0 time = 210
.meas tran vdout0_9ck41 FIND v(dout0_9) AT=210.025n

* CHECK dout0_10 Vdout0_10ck41 = 0 time = 210
.meas tran vdout0_10ck41 FIND v(dout0_10) AT=210.025n

* CHECK dout0_11 Vdout0_11ck41 = 0 time = 210
.meas tran vdout0_11ck41 FIND v(dout0_11) AT=210.025n

* CHECK dout0_12 Vdout0_12ck41 = 0.9 time = 210
.meas tran vdout0_12ck41 FIND v(dout0_12) AT=210.025n

* CHECK dout0_13 Vdout0_13ck41 = 0.9 time = 210
.meas tran vdout0_13ck41 FIND v(dout0_13) AT=210.025n

* CHECK dout0_14 Vdout0_14ck41 = 0.9 time = 210
.meas tran vdout0_14ck41 FIND v(dout0_14) AT=210.025n

* CHECK dout0_15 Vdout0_15ck41 = 0 time = 210
.meas tran vdout0_15ck41 FIND v(dout0_15) AT=210.025n

* CHECK dout0_16 Vdout0_16ck41 = 0.9 time = 210
.meas tran vdout0_16ck41 FIND v(dout0_16) AT=210.025n

* CHECK dout0_17 Vdout0_17ck41 = 0 time = 210
.meas tran vdout0_17ck41 FIND v(dout0_17) AT=210.025n

* CHECK dout0_18 Vdout0_18ck41 = 0 time = 210
.meas tran vdout0_18ck41 FIND v(dout0_18) AT=210.025n

* CHECK dout0_19 Vdout0_19ck41 = 0.9 time = 210
.meas tran vdout0_19ck41 FIND v(dout0_19) AT=210.025n

* CHECK dout0_20 Vdout0_20ck41 = 0.9 time = 210
.meas tran vdout0_20ck41 FIND v(dout0_20) AT=210.025n

* CHECK dout0_21 Vdout0_21ck41 = 0 time = 210
.meas tran vdout0_21ck41 FIND v(dout0_21) AT=210.025n

* CHECK dout0_22 Vdout0_22ck41 = 0.9 time = 210
.meas tran vdout0_22ck41 FIND v(dout0_22) AT=210.025n

* CHECK dout0_23 Vdout0_23ck41 = 0.9 time = 210
.meas tran vdout0_23ck41 FIND v(dout0_23) AT=210.025n

* CHECK dout0_24 Vdout0_24ck41 = 0 time = 210
.meas tran vdout0_24ck41 FIND v(dout0_24) AT=210.025n

* CHECK dout0_25 Vdout0_25ck41 = 0 time = 210
.meas tran vdout0_25ck41 FIND v(dout0_25) AT=210.025n

* CHECK dout0_26 Vdout0_26ck41 = 0.9 time = 210
.meas tran vdout0_26ck41 FIND v(dout0_26) AT=210.025n

* CHECK dout0_27 Vdout0_27ck41 = 0 time = 210
.meas tran vdout0_27ck41 FIND v(dout0_27) AT=210.025n

* CHECK dout0_28 Vdout0_28ck41 = 0.9 time = 210
.meas tran vdout0_28ck41 FIND v(dout0_28) AT=210.025n

* CHECK dout0_29 Vdout0_29ck41 = 0.9 time = 210
.meas tran vdout0_29ck41 FIND v(dout0_29) AT=210.025n

* CHECK dout0_30 Vdout0_30ck41 = 0.9 time = 210
.meas tran vdout0_30ck41 FIND v(dout0_30) AT=210.025n

* CHECK dout0_31 Vdout0_31ck41 = 0.9 time = 210
.meas tran vdout0_31ck41 FIND v(dout0_31) AT=210.025n

* CHECK dout0_32 Vdout0_32ck41 = 0.9 time = 210
.meas tran vdout0_32ck41 FIND v(dout0_32) AT=210.025n

* CHECK dout0_33 Vdout0_33ck41 = 0 time = 210
.meas tran vdout0_33ck41 FIND v(dout0_33) AT=210.025n

* CHECK dout0_34 Vdout0_34ck41 = 0.9 time = 210
.meas tran vdout0_34ck41 FIND v(dout0_34) AT=210.025n

* CHECK dout0_35 Vdout0_35ck41 = 0 time = 210
.meas tran vdout0_35ck41 FIND v(dout0_35) AT=210.025n

* CHECK dout0_36 Vdout0_36ck41 = 0.9 time = 210
.meas tran vdout0_36ck41 FIND v(dout0_36) AT=210.025n

* CHECK dout0_37 Vdout0_37ck41 = 0 time = 210
.meas tran vdout0_37ck41 FIND v(dout0_37) AT=210.025n

* CHECK dout0_38 Vdout0_38ck41 = 0 time = 210
.meas tran vdout0_38ck41 FIND v(dout0_38) AT=210.025n

* CHECK dout0_39 Vdout0_39ck41 = 0 time = 210
.meas tran vdout0_39ck41 FIND v(dout0_39) AT=210.025n

* CHECK dout0_40 Vdout0_40ck41 = 0.9 time = 210
.meas tran vdout0_40ck41 FIND v(dout0_40) AT=210.025n

* CHECK dout0_41 Vdout0_41ck41 = 0 time = 210
.meas tran vdout0_41ck41 FIND v(dout0_41) AT=210.025n

* CHECK dout0_42 Vdout0_42ck41 = 0 time = 210
.meas tran vdout0_42ck41 FIND v(dout0_42) AT=210.025n

* CHECK dout0_43 Vdout0_43ck41 = 0 time = 210
.meas tran vdout0_43ck41 FIND v(dout0_43) AT=210.025n

* CHECK dout0_44 Vdout0_44ck41 = 0.9 time = 210
.meas tran vdout0_44ck41 FIND v(dout0_44) AT=210.025n

* CHECK dout0_45 Vdout0_45ck41 = 0 time = 210
.meas tran vdout0_45ck41 FIND v(dout0_45) AT=210.025n

* CHECK dout0_46 Vdout0_46ck41 = 0.9 time = 210
.meas tran vdout0_46ck41 FIND v(dout0_46) AT=210.025n

* CHECK dout0_47 Vdout0_47ck41 = 0.9 time = 210
.meas tran vdout0_47ck41 FIND v(dout0_47) AT=210.025n

* CHECK dout0_48 Vdout0_48ck41 = 0 time = 210
.meas tran vdout0_48ck41 FIND v(dout0_48) AT=210.025n

* CHECK dout0_49 Vdout0_49ck41 = 0.9 time = 210
.meas tran vdout0_49ck41 FIND v(dout0_49) AT=210.025n

* CHECK dout0_50 Vdout0_50ck41 = 0 time = 210
.meas tran vdout0_50ck41 FIND v(dout0_50) AT=210.025n

* CHECK dout0_51 Vdout0_51ck41 = 0 time = 210
.meas tran vdout0_51ck41 FIND v(dout0_51) AT=210.025n

* CHECK dout0_52 Vdout0_52ck41 = 0.9 time = 210
.meas tran vdout0_52ck41 FIND v(dout0_52) AT=210.025n

* CHECK dout0_53 Vdout0_53ck41 = 0.9 time = 210
.meas tran vdout0_53ck41 FIND v(dout0_53) AT=210.025n

* CHECK dout0_54 Vdout0_54ck41 = 0 time = 210
.meas tran vdout0_54ck41 FIND v(dout0_54) AT=210.025n

* CHECK dout0_55 Vdout0_55ck41 = 0.9 time = 210
.meas tran vdout0_55ck41 FIND v(dout0_55) AT=210.025n

* CHECK dout0_56 Vdout0_56ck41 = 0 time = 210
.meas tran vdout0_56ck41 FIND v(dout0_56) AT=210.025n

* CHECK dout0_57 Vdout0_57ck41 = 0.9 time = 210
.meas tran vdout0_57ck41 FIND v(dout0_57) AT=210.025n

* CHECK dout0_58 Vdout0_58ck41 = 0.9 time = 210
.meas tran vdout0_58ck41 FIND v(dout0_58) AT=210.025n

* CHECK dout0_59 Vdout0_59ck41 = 0 time = 210
.meas tran vdout0_59ck41 FIND v(dout0_59) AT=210.025n

* CHECK dout0_60 Vdout0_60ck41 = 0 time = 210
.meas tran vdout0_60ck41 FIND v(dout0_60) AT=210.025n

* CHECK dout0_61 Vdout0_61ck41 = 0.9 time = 210
.meas tran vdout0_61ck41 FIND v(dout0_61) AT=210.025n

* CHECK dout0_62 Vdout0_62ck41 = 0.9 time = 210
.meas tran vdout0_62ck41 FIND v(dout0_62) AT=210.025n

* CHECK dout0_63 Vdout0_63ck41 = 0 time = 210
.meas tran vdout0_63ck41 FIND v(dout0_63) AT=210.025n

* CHECK dout0_0 Vdout0_0ck42 = 0.9 time = 215
.meas tran vdout0_0ck42 FIND v(dout0_0) AT=215.025n

* CHECK dout0_1 Vdout0_1ck42 = 0 time = 215
.meas tran vdout0_1ck42 FIND v(dout0_1) AT=215.025n

* CHECK dout0_2 Vdout0_2ck42 = 0 time = 215
.meas tran vdout0_2ck42 FIND v(dout0_2) AT=215.025n

* CHECK dout0_3 Vdout0_3ck42 = 0.9 time = 215
.meas tran vdout0_3ck42 FIND v(dout0_3) AT=215.025n

* CHECK dout0_4 Vdout0_4ck42 = 0 time = 215
.meas tran vdout0_4ck42 FIND v(dout0_4) AT=215.025n

* CHECK dout0_5 Vdout0_5ck42 = 0.9 time = 215
.meas tran vdout0_5ck42 FIND v(dout0_5) AT=215.025n

* CHECK dout0_6 Vdout0_6ck42 = 0 time = 215
.meas tran vdout0_6ck42 FIND v(dout0_6) AT=215.025n

* CHECK dout0_7 Vdout0_7ck42 = 0.9 time = 215
.meas tran vdout0_7ck42 FIND v(dout0_7) AT=215.025n

* CHECK dout0_8 Vdout0_8ck42 = 0 time = 215
.meas tran vdout0_8ck42 FIND v(dout0_8) AT=215.025n

* CHECK dout0_9 Vdout0_9ck42 = 0 time = 215
.meas tran vdout0_9ck42 FIND v(dout0_9) AT=215.025n

* CHECK dout0_10 Vdout0_10ck42 = 0 time = 215
.meas tran vdout0_10ck42 FIND v(dout0_10) AT=215.025n

* CHECK dout0_11 Vdout0_11ck42 = 0 time = 215
.meas tran vdout0_11ck42 FIND v(dout0_11) AT=215.025n

* CHECK dout0_12 Vdout0_12ck42 = 0.9 time = 215
.meas tran vdout0_12ck42 FIND v(dout0_12) AT=215.025n

* CHECK dout0_13 Vdout0_13ck42 = 0.9 time = 215
.meas tran vdout0_13ck42 FIND v(dout0_13) AT=215.025n

* CHECK dout0_14 Vdout0_14ck42 = 0.9 time = 215
.meas tran vdout0_14ck42 FIND v(dout0_14) AT=215.025n

* CHECK dout0_15 Vdout0_15ck42 = 0 time = 215
.meas tran vdout0_15ck42 FIND v(dout0_15) AT=215.025n

* CHECK dout0_16 Vdout0_16ck42 = 0.9 time = 215
.meas tran vdout0_16ck42 FIND v(dout0_16) AT=215.025n

* CHECK dout0_17 Vdout0_17ck42 = 0 time = 215
.meas tran vdout0_17ck42 FIND v(dout0_17) AT=215.025n

* CHECK dout0_18 Vdout0_18ck42 = 0 time = 215
.meas tran vdout0_18ck42 FIND v(dout0_18) AT=215.025n

* CHECK dout0_19 Vdout0_19ck42 = 0.9 time = 215
.meas tran vdout0_19ck42 FIND v(dout0_19) AT=215.025n

* CHECK dout0_20 Vdout0_20ck42 = 0.9 time = 215
.meas tran vdout0_20ck42 FIND v(dout0_20) AT=215.025n

* CHECK dout0_21 Vdout0_21ck42 = 0 time = 215
.meas tran vdout0_21ck42 FIND v(dout0_21) AT=215.025n

* CHECK dout0_22 Vdout0_22ck42 = 0.9 time = 215
.meas tran vdout0_22ck42 FIND v(dout0_22) AT=215.025n

* CHECK dout0_23 Vdout0_23ck42 = 0.9 time = 215
.meas tran vdout0_23ck42 FIND v(dout0_23) AT=215.025n

* CHECK dout0_24 Vdout0_24ck42 = 0 time = 215
.meas tran vdout0_24ck42 FIND v(dout0_24) AT=215.025n

* CHECK dout0_25 Vdout0_25ck42 = 0 time = 215
.meas tran vdout0_25ck42 FIND v(dout0_25) AT=215.025n

* CHECK dout0_26 Vdout0_26ck42 = 0.9 time = 215
.meas tran vdout0_26ck42 FIND v(dout0_26) AT=215.025n

* CHECK dout0_27 Vdout0_27ck42 = 0 time = 215
.meas tran vdout0_27ck42 FIND v(dout0_27) AT=215.025n

* CHECK dout0_28 Vdout0_28ck42 = 0.9 time = 215
.meas tran vdout0_28ck42 FIND v(dout0_28) AT=215.025n

* CHECK dout0_29 Vdout0_29ck42 = 0.9 time = 215
.meas tran vdout0_29ck42 FIND v(dout0_29) AT=215.025n

* CHECK dout0_30 Vdout0_30ck42 = 0.9 time = 215
.meas tran vdout0_30ck42 FIND v(dout0_30) AT=215.025n

* CHECK dout0_31 Vdout0_31ck42 = 0.9 time = 215
.meas tran vdout0_31ck42 FIND v(dout0_31) AT=215.025n

* CHECK dout0_32 Vdout0_32ck42 = 0.9 time = 215
.meas tran vdout0_32ck42 FIND v(dout0_32) AT=215.025n

* CHECK dout0_33 Vdout0_33ck42 = 0 time = 215
.meas tran vdout0_33ck42 FIND v(dout0_33) AT=215.025n

* CHECK dout0_34 Vdout0_34ck42 = 0.9 time = 215
.meas tran vdout0_34ck42 FIND v(dout0_34) AT=215.025n

* CHECK dout0_35 Vdout0_35ck42 = 0 time = 215
.meas tran vdout0_35ck42 FIND v(dout0_35) AT=215.025n

* CHECK dout0_36 Vdout0_36ck42 = 0.9 time = 215
.meas tran vdout0_36ck42 FIND v(dout0_36) AT=215.025n

* CHECK dout0_37 Vdout0_37ck42 = 0 time = 215
.meas tran vdout0_37ck42 FIND v(dout0_37) AT=215.025n

* CHECK dout0_38 Vdout0_38ck42 = 0 time = 215
.meas tran vdout0_38ck42 FIND v(dout0_38) AT=215.025n

* CHECK dout0_39 Vdout0_39ck42 = 0 time = 215
.meas tran vdout0_39ck42 FIND v(dout0_39) AT=215.025n

* CHECK dout0_40 Vdout0_40ck42 = 0.9 time = 215
.meas tran vdout0_40ck42 FIND v(dout0_40) AT=215.025n

* CHECK dout0_41 Vdout0_41ck42 = 0 time = 215
.meas tran vdout0_41ck42 FIND v(dout0_41) AT=215.025n

* CHECK dout0_42 Vdout0_42ck42 = 0 time = 215
.meas tran vdout0_42ck42 FIND v(dout0_42) AT=215.025n

* CHECK dout0_43 Vdout0_43ck42 = 0 time = 215
.meas tran vdout0_43ck42 FIND v(dout0_43) AT=215.025n

* CHECK dout0_44 Vdout0_44ck42 = 0.9 time = 215
.meas tran vdout0_44ck42 FIND v(dout0_44) AT=215.025n

* CHECK dout0_45 Vdout0_45ck42 = 0 time = 215
.meas tran vdout0_45ck42 FIND v(dout0_45) AT=215.025n

* CHECK dout0_46 Vdout0_46ck42 = 0.9 time = 215
.meas tran vdout0_46ck42 FIND v(dout0_46) AT=215.025n

* CHECK dout0_47 Vdout0_47ck42 = 0.9 time = 215
.meas tran vdout0_47ck42 FIND v(dout0_47) AT=215.025n

* CHECK dout0_48 Vdout0_48ck42 = 0 time = 215
.meas tran vdout0_48ck42 FIND v(dout0_48) AT=215.025n

* CHECK dout0_49 Vdout0_49ck42 = 0.9 time = 215
.meas tran vdout0_49ck42 FIND v(dout0_49) AT=215.025n

* CHECK dout0_50 Vdout0_50ck42 = 0 time = 215
.meas tran vdout0_50ck42 FIND v(dout0_50) AT=215.025n

* CHECK dout0_51 Vdout0_51ck42 = 0 time = 215
.meas tran vdout0_51ck42 FIND v(dout0_51) AT=215.025n

* CHECK dout0_52 Vdout0_52ck42 = 0.9 time = 215
.meas tran vdout0_52ck42 FIND v(dout0_52) AT=215.025n

* CHECK dout0_53 Vdout0_53ck42 = 0.9 time = 215
.meas tran vdout0_53ck42 FIND v(dout0_53) AT=215.025n

* CHECK dout0_54 Vdout0_54ck42 = 0 time = 215
.meas tran vdout0_54ck42 FIND v(dout0_54) AT=215.025n

* CHECK dout0_55 Vdout0_55ck42 = 0.9 time = 215
.meas tran vdout0_55ck42 FIND v(dout0_55) AT=215.025n

* CHECK dout0_56 Vdout0_56ck42 = 0 time = 215
.meas tran vdout0_56ck42 FIND v(dout0_56) AT=215.025n

* CHECK dout0_57 Vdout0_57ck42 = 0.9 time = 215
.meas tran vdout0_57ck42 FIND v(dout0_57) AT=215.025n

* CHECK dout0_58 Vdout0_58ck42 = 0.9 time = 215
.meas tran vdout0_58ck42 FIND v(dout0_58) AT=215.025n

* CHECK dout0_59 Vdout0_59ck42 = 0 time = 215
.meas tran vdout0_59ck42 FIND v(dout0_59) AT=215.025n

* CHECK dout0_60 Vdout0_60ck42 = 0 time = 215
.meas tran vdout0_60ck42 FIND v(dout0_60) AT=215.025n

* CHECK dout0_61 Vdout0_61ck42 = 0.9 time = 215
.meas tran vdout0_61ck42 FIND v(dout0_61) AT=215.025n

* CHECK dout0_62 Vdout0_62ck42 = 0.9 time = 215
.meas tran vdout0_62ck42 FIND v(dout0_62) AT=215.025n

* CHECK dout0_63 Vdout0_63ck42 = 0 time = 215
.meas tran vdout0_63ck42 FIND v(dout0_63) AT=215.025n

* CHECK dout0_0 Vdout0_0ck45 = 0.9 time = 230
.meas tran vdout0_0ck45 FIND v(dout0_0) AT=230.025n

* CHECK dout0_1 Vdout0_1ck45 = 0.9 time = 230
.meas tran vdout0_1ck45 FIND v(dout0_1) AT=230.025n

* CHECK dout0_2 Vdout0_2ck45 = 0.9 time = 230
.meas tran vdout0_2ck45 FIND v(dout0_2) AT=230.025n

* CHECK dout0_3 Vdout0_3ck45 = 0 time = 230
.meas tran vdout0_3ck45 FIND v(dout0_3) AT=230.025n

* CHECK dout0_4 Vdout0_4ck45 = 0.9 time = 230
.meas tran vdout0_4ck45 FIND v(dout0_4) AT=230.025n

* CHECK dout0_5 Vdout0_5ck45 = 0.9 time = 230
.meas tran vdout0_5ck45 FIND v(dout0_5) AT=230.025n

* CHECK dout0_6 Vdout0_6ck45 = 0.9 time = 230
.meas tran vdout0_6ck45 FIND v(dout0_6) AT=230.025n

* CHECK dout0_7 Vdout0_7ck45 = 0 time = 230
.meas tran vdout0_7ck45 FIND v(dout0_7) AT=230.025n

* CHECK dout0_8 Vdout0_8ck45 = 0.9 time = 230
.meas tran vdout0_8ck45 FIND v(dout0_8) AT=230.025n

* CHECK dout0_9 Vdout0_9ck45 = 0 time = 230
.meas tran vdout0_9ck45 FIND v(dout0_9) AT=230.025n

* CHECK dout0_10 Vdout0_10ck45 = 0.9 time = 230
.meas tran vdout0_10ck45 FIND v(dout0_10) AT=230.025n

* CHECK dout0_11 Vdout0_11ck45 = 0.9 time = 230
.meas tran vdout0_11ck45 FIND v(dout0_11) AT=230.025n

* CHECK dout0_12 Vdout0_12ck45 = 0.9 time = 230
.meas tran vdout0_12ck45 FIND v(dout0_12) AT=230.025n

* CHECK dout0_13 Vdout0_13ck45 = 0 time = 230
.meas tran vdout0_13ck45 FIND v(dout0_13) AT=230.025n

* CHECK dout0_14 Vdout0_14ck45 = 0.9 time = 230
.meas tran vdout0_14ck45 FIND v(dout0_14) AT=230.025n

* CHECK dout0_15 Vdout0_15ck45 = 0.9 time = 230
.meas tran vdout0_15ck45 FIND v(dout0_15) AT=230.025n

* CHECK dout0_16 Vdout0_16ck45 = 0.9 time = 230
.meas tran vdout0_16ck45 FIND v(dout0_16) AT=230.025n

* CHECK dout0_17 Vdout0_17ck45 = 0 time = 230
.meas tran vdout0_17ck45 FIND v(dout0_17) AT=230.025n

* CHECK dout0_18 Vdout0_18ck45 = 0 time = 230
.meas tran vdout0_18ck45 FIND v(dout0_18) AT=230.025n

* CHECK dout0_19 Vdout0_19ck45 = 0.9 time = 230
.meas tran vdout0_19ck45 FIND v(dout0_19) AT=230.025n

* CHECK dout0_20 Vdout0_20ck45 = 0 time = 230
.meas tran vdout0_20ck45 FIND v(dout0_20) AT=230.025n

* CHECK dout0_21 Vdout0_21ck45 = 0 time = 230
.meas tran vdout0_21ck45 FIND v(dout0_21) AT=230.025n

* CHECK dout0_22 Vdout0_22ck45 = 0.9 time = 230
.meas tran vdout0_22ck45 FIND v(dout0_22) AT=230.025n

* CHECK dout0_23 Vdout0_23ck45 = 0 time = 230
.meas tran vdout0_23ck45 FIND v(dout0_23) AT=230.025n

* CHECK dout0_24 Vdout0_24ck45 = 0.9 time = 230
.meas tran vdout0_24ck45 FIND v(dout0_24) AT=230.025n

* CHECK dout0_25 Vdout0_25ck45 = 0 time = 230
.meas tran vdout0_25ck45 FIND v(dout0_25) AT=230.025n

* CHECK dout0_26 Vdout0_26ck45 = 0 time = 230
.meas tran vdout0_26ck45 FIND v(dout0_26) AT=230.025n

* CHECK dout0_27 Vdout0_27ck45 = 0.9 time = 230
.meas tran vdout0_27ck45 FIND v(dout0_27) AT=230.025n

* CHECK dout0_28 Vdout0_28ck45 = 0.9 time = 230
.meas tran vdout0_28ck45 FIND v(dout0_28) AT=230.025n

* CHECK dout0_29 Vdout0_29ck45 = 0 time = 230
.meas tran vdout0_29ck45 FIND v(dout0_29) AT=230.025n

* CHECK dout0_30 Vdout0_30ck45 = 0 time = 230
.meas tran vdout0_30ck45 FIND v(dout0_30) AT=230.025n

* CHECK dout0_31 Vdout0_31ck45 = 0 time = 230
.meas tran vdout0_31ck45 FIND v(dout0_31) AT=230.025n

* CHECK dout0_32 Vdout0_32ck45 = 0.9 time = 230
.meas tran vdout0_32ck45 FIND v(dout0_32) AT=230.025n

* CHECK dout0_33 Vdout0_33ck45 = 0 time = 230
.meas tran vdout0_33ck45 FIND v(dout0_33) AT=230.025n

* CHECK dout0_34 Vdout0_34ck45 = 0 time = 230
.meas tran vdout0_34ck45 FIND v(dout0_34) AT=230.025n

* CHECK dout0_35 Vdout0_35ck45 = 0.9 time = 230
.meas tran vdout0_35ck45 FIND v(dout0_35) AT=230.025n

* CHECK dout0_36 Vdout0_36ck45 = 0 time = 230
.meas tran vdout0_36ck45 FIND v(dout0_36) AT=230.025n

* CHECK dout0_37 Vdout0_37ck45 = 0 time = 230
.meas tran vdout0_37ck45 FIND v(dout0_37) AT=230.025n

* CHECK dout0_38 Vdout0_38ck45 = 0.9 time = 230
.meas tran vdout0_38ck45 FIND v(dout0_38) AT=230.025n

* CHECK dout0_39 Vdout0_39ck45 = 0 time = 230
.meas tran vdout0_39ck45 FIND v(dout0_39) AT=230.025n

* CHECK dout0_40 Vdout0_40ck45 = 0 time = 230
.meas tran vdout0_40ck45 FIND v(dout0_40) AT=230.025n

* CHECK dout0_41 Vdout0_41ck45 = 0 time = 230
.meas tran vdout0_41ck45 FIND v(dout0_41) AT=230.025n

* CHECK dout0_42 Vdout0_42ck45 = 0 time = 230
.meas tran vdout0_42ck45 FIND v(dout0_42) AT=230.025n

* CHECK dout0_43 Vdout0_43ck45 = 0.9 time = 230
.meas tran vdout0_43ck45 FIND v(dout0_43) AT=230.025n

* CHECK dout0_44 Vdout0_44ck45 = 0.9 time = 230
.meas tran vdout0_44ck45 FIND v(dout0_44) AT=230.025n

* CHECK dout0_45 Vdout0_45ck45 = 0.9 time = 230
.meas tran vdout0_45ck45 FIND v(dout0_45) AT=230.025n

* CHECK dout0_46 Vdout0_46ck45 = 0 time = 230
.meas tran vdout0_46ck45 FIND v(dout0_46) AT=230.025n

* CHECK dout0_47 Vdout0_47ck45 = 0.9 time = 230
.meas tran vdout0_47ck45 FIND v(dout0_47) AT=230.025n

* CHECK dout0_48 Vdout0_48ck45 = 0 time = 230
.meas tran vdout0_48ck45 FIND v(dout0_48) AT=230.025n

* CHECK dout0_49 Vdout0_49ck45 = 0.9 time = 230
.meas tran vdout0_49ck45 FIND v(dout0_49) AT=230.025n

* CHECK dout0_50 Vdout0_50ck45 = 0.9 time = 230
.meas tran vdout0_50ck45 FIND v(dout0_50) AT=230.025n

* CHECK dout0_51 Vdout0_51ck45 = 0.9 time = 230
.meas tran vdout0_51ck45 FIND v(dout0_51) AT=230.025n

* CHECK dout0_52 Vdout0_52ck45 = 0 time = 230
.meas tran vdout0_52ck45 FIND v(dout0_52) AT=230.025n

* CHECK dout0_53 Vdout0_53ck45 = 0 time = 230
.meas tran vdout0_53ck45 FIND v(dout0_53) AT=230.025n

* CHECK dout0_54 Vdout0_54ck45 = 0.9 time = 230
.meas tran vdout0_54ck45 FIND v(dout0_54) AT=230.025n

* CHECK dout0_55 Vdout0_55ck45 = 0.9 time = 230
.meas tran vdout0_55ck45 FIND v(dout0_55) AT=230.025n

* CHECK dout0_56 Vdout0_56ck45 = 0.9 time = 230
.meas tran vdout0_56ck45 FIND v(dout0_56) AT=230.025n

* CHECK dout0_57 Vdout0_57ck45 = 0.9 time = 230
.meas tran vdout0_57ck45 FIND v(dout0_57) AT=230.025n

* CHECK dout0_58 Vdout0_58ck45 = 0 time = 230
.meas tran vdout0_58ck45 FIND v(dout0_58) AT=230.025n

* CHECK dout0_59 Vdout0_59ck45 = 0 time = 230
.meas tran vdout0_59ck45 FIND v(dout0_59) AT=230.025n

* CHECK dout0_60 Vdout0_60ck45 = 0.9 time = 230
.meas tran vdout0_60ck45 FIND v(dout0_60) AT=230.025n

* CHECK dout0_61 Vdout0_61ck45 = 0.9 time = 230
.meas tran vdout0_61ck45 FIND v(dout0_61) AT=230.025n

* CHECK dout0_62 Vdout0_62ck45 = 0 time = 230
.meas tran vdout0_62ck45 FIND v(dout0_62) AT=230.025n

* CHECK dout0_63 Vdout0_63ck45 = 0 time = 230
.meas tran vdout0_63ck45 FIND v(dout0_63) AT=230.025n

* CHECK dout0_0 Vdout0_0ck46 = 0.9 time = 235
.meas tran vdout0_0ck46 FIND v(dout0_0) AT=235.025n

* CHECK dout0_1 Vdout0_1ck46 = 0.9 time = 235
.meas tran vdout0_1ck46 FIND v(dout0_1) AT=235.025n

* CHECK dout0_2 Vdout0_2ck46 = 0.9 time = 235
.meas tran vdout0_2ck46 FIND v(dout0_2) AT=235.025n

* CHECK dout0_3 Vdout0_3ck46 = 0 time = 235
.meas tran vdout0_3ck46 FIND v(dout0_3) AT=235.025n

* CHECK dout0_4 Vdout0_4ck46 = 0.9 time = 235
.meas tran vdout0_4ck46 FIND v(dout0_4) AT=235.025n

* CHECK dout0_5 Vdout0_5ck46 = 0.9 time = 235
.meas tran vdout0_5ck46 FIND v(dout0_5) AT=235.025n

* CHECK dout0_6 Vdout0_6ck46 = 0.9 time = 235
.meas tran vdout0_6ck46 FIND v(dout0_6) AT=235.025n

* CHECK dout0_7 Vdout0_7ck46 = 0 time = 235
.meas tran vdout0_7ck46 FIND v(dout0_7) AT=235.025n

* CHECK dout0_8 Vdout0_8ck46 = 0.9 time = 235
.meas tran vdout0_8ck46 FIND v(dout0_8) AT=235.025n

* CHECK dout0_9 Vdout0_9ck46 = 0 time = 235
.meas tran vdout0_9ck46 FIND v(dout0_9) AT=235.025n

* CHECK dout0_10 Vdout0_10ck46 = 0.9 time = 235
.meas tran vdout0_10ck46 FIND v(dout0_10) AT=235.025n

* CHECK dout0_11 Vdout0_11ck46 = 0.9 time = 235
.meas tran vdout0_11ck46 FIND v(dout0_11) AT=235.025n

* CHECK dout0_12 Vdout0_12ck46 = 0.9 time = 235
.meas tran vdout0_12ck46 FIND v(dout0_12) AT=235.025n

* CHECK dout0_13 Vdout0_13ck46 = 0 time = 235
.meas tran vdout0_13ck46 FIND v(dout0_13) AT=235.025n

* CHECK dout0_14 Vdout0_14ck46 = 0.9 time = 235
.meas tran vdout0_14ck46 FIND v(dout0_14) AT=235.025n

* CHECK dout0_15 Vdout0_15ck46 = 0.9 time = 235
.meas tran vdout0_15ck46 FIND v(dout0_15) AT=235.025n

* CHECK dout0_16 Vdout0_16ck46 = 0.9 time = 235
.meas tran vdout0_16ck46 FIND v(dout0_16) AT=235.025n

* CHECK dout0_17 Vdout0_17ck46 = 0 time = 235
.meas tran vdout0_17ck46 FIND v(dout0_17) AT=235.025n

* CHECK dout0_18 Vdout0_18ck46 = 0 time = 235
.meas tran vdout0_18ck46 FIND v(dout0_18) AT=235.025n

* CHECK dout0_19 Vdout0_19ck46 = 0.9 time = 235
.meas tran vdout0_19ck46 FIND v(dout0_19) AT=235.025n

* CHECK dout0_20 Vdout0_20ck46 = 0 time = 235
.meas tran vdout0_20ck46 FIND v(dout0_20) AT=235.025n

* CHECK dout0_21 Vdout0_21ck46 = 0 time = 235
.meas tran vdout0_21ck46 FIND v(dout0_21) AT=235.025n

* CHECK dout0_22 Vdout0_22ck46 = 0.9 time = 235
.meas tran vdout0_22ck46 FIND v(dout0_22) AT=235.025n

* CHECK dout0_23 Vdout0_23ck46 = 0 time = 235
.meas tran vdout0_23ck46 FIND v(dout0_23) AT=235.025n

* CHECK dout0_24 Vdout0_24ck46 = 0.9 time = 235
.meas tran vdout0_24ck46 FIND v(dout0_24) AT=235.025n

* CHECK dout0_25 Vdout0_25ck46 = 0 time = 235
.meas tran vdout0_25ck46 FIND v(dout0_25) AT=235.025n

* CHECK dout0_26 Vdout0_26ck46 = 0 time = 235
.meas tran vdout0_26ck46 FIND v(dout0_26) AT=235.025n

* CHECK dout0_27 Vdout0_27ck46 = 0.9 time = 235
.meas tran vdout0_27ck46 FIND v(dout0_27) AT=235.025n

* CHECK dout0_28 Vdout0_28ck46 = 0.9 time = 235
.meas tran vdout0_28ck46 FIND v(dout0_28) AT=235.025n

* CHECK dout0_29 Vdout0_29ck46 = 0 time = 235
.meas tran vdout0_29ck46 FIND v(dout0_29) AT=235.025n

* CHECK dout0_30 Vdout0_30ck46 = 0 time = 235
.meas tran vdout0_30ck46 FIND v(dout0_30) AT=235.025n

* CHECK dout0_31 Vdout0_31ck46 = 0 time = 235
.meas tran vdout0_31ck46 FIND v(dout0_31) AT=235.025n

* CHECK dout0_32 Vdout0_32ck46 = 0.9 time = 235
.meas tran vdout0_32ck46 FIND v(dout0_32) AT=235.025n

* CHECK dout0_33 Vdout0_33ck46 = 0 time = 235
.meas tran vdout0_33ck46 FIND v(dout0_33) AT=235.025n

* CHECK dout0_34 Vdout0_34ck46 = 0 time = 235
.meas tran vdout0_34ck46 FIND v(dout0_34) AT=235.025n

* CHECK dout0_35 Vdout0_35ck46 = 0.9 time = 235
.meas tran vdout0_35ck46 FIND v(dout0_35) AT=235.025n

* CHECK dout0_36 Vdout0_36ck46 = 0 time = 235
.meas tran vdout0_36ck46 FIND v(dout0_36) AT=235.025n

* CHECK dout0_37 Vdout0_37ck46 = 0 time = 235
.meas tran vdout0_37ck46 FIND v(dout0_37) AT=235.025n

* CHECK dout0_38 Vdout0_38ck46 = 0.9 time = 235
.meas tran vdout0_38ck46 FIND v(dout0_38) AT=235.025n

* CHECK dout0_39 Vdout0_39ck46 = 0 time = 235
.meas tran vdout0_39ck46 FIND v(dout0_39) AT=235.025n

* CHECK dout0_40 Vdout0_40ck46 = 0 time = 235
.meas tran vdout0_40ck46 FIND v(dout0_40) AT=235.025n

* CHECK dout0_41 Vdout0_41ck46 = 0 time = 235
.meas tran vdout0_41ck46 FIND v(dout0_41) AT=235.025n

* CHECK dout0_42 Vdout0_42ck46 = 0 time = 235
.meas tran vdout0_42ck46 FIND v(dout0_42) AT=235.025n

* CHECK dout0_43 Vdout0_43ck46 = 0.9 time = 235
.meas tran vdout0_43ck46 FIND v(dout0_43) AT=235.025n

* CHECK dout0_44 Vdout0_44ck46 = 0.9 time = 235
.meas tran vdout0_44ck46 FIND v(dout0_44) AT=235.025n

* CHECK dout0_45 Vdout0_45ck46 = 0.9 time = 235
.meas tran vdout0_45ck46 FIND v(dout0_45) AT=235.025n

* CHECK dout0_46 Vdout0_46ck46 = 0 time = 235
.meas tran vdout0_46ck46 FIND v(dout0_46) AT=235.025n

* CHECK dout0_47 Vdout0_47ck46 = 0.9 time = 235
.meas tran vdout0_47ck46 FIND v(dout0_47) AT=235.025n

* CHECK dout0_48 Vdout0_48ck46 = 0 time = 235
.meas tran vdout0_48ck46 FIND v(dout0_48) AT=235.025n

* CHECK dout0_49 Vdout0_49ck46 = 0.9 time = 235
.meas tran vdout0_49ck46 FIND v(dout0_49) AT=235.025n

* CHECK dout0_50 Vdout0_50ck46 = 0.9 time = 235
.meas tran vdout0_50ck46 FIND v(dout0_50) AT=235.025n

* CHECK dout0_51 Vdout0_51ck46 = 0.9 time = 235
.meas tran vdout0_51ck46 FIND v(dout0_51) AT=235.025n

* CHECK dout0_52 Vdout0_52ck46 = 0 time = 235
.meas tran vdout0_52ck46 FIND v(dout0_52) AT=235.025n

* CHECK dout0_53 Vdout0_53ck46 = 0 time = 235
.meas tran vdout0_53ck46 FIND v(dout0_53) AT=235.025n

* CHECK dout0_54 Vdout0_54ck46 = 0.9 time = 235
.meas tran vdout0_54ck46 FIND v(dout0_54) AT=235.025n

* CHECK dout0_55 Vdout0_55ck46 = 0.9 time = 235
.meas tran vdout0_55ck46 FIND v(dout0_55) AT=235.025n

* CHECK dout0_56 Vdout0_56ck46 = 0.9 time = 235
.meas tran vdout0_56ck46 FIND v(dout0_56) AT=235.025n

* CHECK dout0_57 Vdout0_57ck46 = 0.9 time = 235
.meas tran vdout0_57ck46 FIND v(dout0_57) AT=235.025n

* CHECK dout0_58 Vdout0_58ck46 = 0 time = 235
.meas tran vdout0_58ck46 FIND v(dout0_58) AT=235.025n

* CHECK dout0_59 Vdout0_59ck46 = 0 time = 235
.meas tran vdout0_59ck46 FIND v(dout0_59) AT=235.025n

* CHECK dout0_60 Vdout0_60ck46 = 0.9 time = 235
.meas tran vdout0_60ck46 FIND v(dout0_60) AT=235.025n

* CHECK dout0_61 Vdout0_61ck46 = 0.9 time = 235
.meas tran vdout0_61ck46 FIND v(dout0_61) AT=235.025n

* CHECK dout0_62 Vdout0_62ck46 = 0 time = 235
.meas tran vdout0_62ck46 FIND v(dout0_62) AT=235.025n

* CHECK dout0_63 Vdout0_63ck46 = 0 time = 235
.meas tran vdout0_63ck46 FIND v(dout0_63) AT=235.025n

* CHECK dout0_0 Vdout0_0ck47 = 0.9 time = 240
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=240.025n

* CHECK dout0_1 Vdout0_1ck47 = 0.9 time = 240
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=240.025n

* CHECK dout0_2 Vdout0_2ck47 = 0.9 time = 240
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=240.025n

* CHECK dout0_3 Vdout0_3ck47 = 0.9 time = 240
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=240.025n

* CHECK dout0_4 Vdout0_4ck47 = 0 time = 240
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=240.025n

* CHECK dout0_5 Vdout0_5ck47 = 0.9 time = 240
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=240.025n

* CHECK dout0_6 Vdout0_6ck47 = 0 time = 240
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=240.025n

* CHECK dout0_7 Vdout0_7ck47 = 0.9 time = 240
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=240.025n

* CHECK dout0_8 Vdout0_8ck47 = 0.9 time = 240
.meas tran vdout0_8ck47 FIND v(dout0_8) AT=240.025n

* CHECK dout0_9 Vdout0_9ck47 = 0.9 time = 240
.meas tran vdout0_9ck47 FIND v(dout0_9) AT=240.025n

* CHECK dout0_10 Vdout0_10ck47 = 0 time = 240
.meas tran vdout0_10ck47 FIND v(dout0_10) AT=240.025n

* CHECK dout0_11 Vdout0_11ck47 = 0 time = 240
.meas tran vdout0_11ck47 FIND v(dout0_11) AT=240.025n

* CHECK dout0_12 Vdout0_12ck47 = 0 time = 240
.meas tran vdout0_12ck47 FIND v(dout0_12) AT=240.025n

* CHECK dout0_13 Vdout0_13ck47 = 0.9 time = 240
.meas tran vdout0_13ck47 FIND v(dout0_13) AT=240.025n

* CHECK dout0_14 Vdout0_14ck47 = 0.9 time = 240
.meas tran vdout0_14ck47 FIND v(dout0_14) AT=240.025n

* CHECK dout0_15 Vdout0_15ck47 = 0.9 time = 240
.meas tran vdout0_15ck47 FIND v(dout0_15) AT=240.025n

* CHECK dout0_16 Vdout0_16ck47 = 0 time = 240
.meas tran vdout0_16ck47 FIND v(dout0_16) AT=240.025n

* CHECK dout0_17 Vdout0_17ck47 = 0.9 time = 240
.meas tran vdout0_17ck47 FIND v(dout0_17) AT=240.025n

* CHECK dout0_18 Vdout0_18ck47 = 0 time = 240
.meas tran vdout0_18ck47 FIND v(dout0_18) AT=240.025n

* CHECK dout0_19 Vdout0_19ck47 = 0 time = 240
.meas tran vdout0_19ck47 FIND v(dout0_19) AT=240.025n

* CHECK dout0_20 Vdout0_20ck47 = 0.9 time = 240
.meas tran vdout0_20ck47 FIND v(dout0_20) AT=240.025n

* CHECK dout0_21 Vdout0_21ck47 = 0 time = 240
.meas tran vdout0_21ck47 FIND v(dout0_21) AT=240.025n

* CHECK dout0_22 Vdout0_22ck47 = 0.9 time = 240
.meas tran vdout0_22ck47 FIND v(dout0_22) AT=240.025n

* CHECK dout0_23 Vdout0_23ck47 = 0 time = 240
.meas tran vdout0_23ck47 FIND v(dout0_23) AT=240.025n

* CHECK dout0_24 Vdout0_24ck47 = 0 time = 240
.meas tran vdout0_24ck47 FIND v(dout0_24) AT=240.025n

* CHECK dout0_25 Vdout0_25ck47 = 0 time = 240
.meas tran vdout0_25ck47 FIND v(dout0_25) AT=240.025n

* CHECK dout0_26 Vdout0_26ck47 = 0 time = 240
.meas tran vdout0_26ck47 FIND v(dout0_26) AT=240.025n

* CHECK dout0_27 Vdout0_27ck47 = 0 time = 240
.meas tran vdout0_27ck47 FIND v(dout0_27) AT=240.025n

* CHECK dout0_28 Vdout0_28ck47 = 0 time = 240
.meas tran vdout0_28ck47 FIND v(dout0_28) AT=240.025n

* CHECK dout0_29 Vdout0_29ck47 = 0 time = 240
.meas tran vdout0_29ck47 FIND v(dout0_29) AT=240.025n

* CHECK dout0_30 Vdout0_30ck47 = 0 time = 240
.meas tran vdout0_30ck47 FIND v(dout0_30) AT=240.025n

* CHECK dout0_31 Vdout0_31ck47 = 0.9 time = 240
.meas tran vdout0_31ck47 FIND v(dout0_31) AT=240.025n

* CHECK dout0_32 Vdout0_32ck47 = 0 time = 240
.meas tran vdout0_32ck47 FIND v(dout0_32) AT=240.025n

* CHECK dout0_33 Vdout0_33ck47 = 0 time = 240
.meas tran vdout0_33ck47 FIND v(dout0_33) AT=240.025n

* CHECK dout0_34 Vdout0_34ck47 = 0 time = 240
.meas tran vdout0_34ck47 FIND v(dout0_34) AT=240.025n

* CHECK dout0_35 Vdout0_35ck47 = 0.9 time = 240
.meas tran vdout0_35ck47 FIND v(dout0_35) AT=240.025n

* CHECK dout0_36 Vdout0_36ck47 = 0 time = 240
.meas tran vdout0_36ck47 FIND v(dout0_36) AT=240.025n

* CHECK dout0_37 Vdout0_37ck47 = 0 time = 240
.meas tran vdout0_37ck47 FIND v(dout0_37) AT=240.025n

* CHECK dout0_38 Vdout0_38ck47 = 0 time = 240
.meas tran vdout0_38ck47 FIND v(dout0_38) AT=240.025n

* CHECK dout0_39 Vdout0_39ck47 = 0 time = 240
.meas tran vdout0_39ck47 FIND v(dout0_39) AT=240.025n

* CHECK dout0_40 Vdout0_40ck47 = 0 time = 240
.meas tran vdout0_40ck47 FIND v(dout0_40) AT=240.025n

* CHECK dout0_41 Vdout0_41ck47 = 0.9 time = 240
.meas tran vdout0_41ck47 FIND v(dout0_41) AT=240.025n

* CHECK dout0_42 Vdout0_42ck47 = 0 time = 240
.meas tran vdout0_42ck47 FIND v(dout0_42) AT=240.025n

* CHECK dout0_43 Vdout0_43ck47 = 0 time = 240
.meas tran vdout0_43ck47 FIND v(dout0_43) AT=240.025n

* CHECK dout0_44 Vdout0_44ck47 = 0 time = 240
.meas tran vdout0_44ck47 FIND v(dout0_44) AT=240.025n

* CHECK dout0_45 Vdout0_45ck47 = 0 time = 240
.meas tran vdout0_45ck47 FIND v(dout0_45) AT=240.025n

* CHECK dout0_46 Vdout0_46ck47 = 0.9 time = 240
.meas tran vdout0_46ck47 FIND v(dout0_46) AT=240.025n

* CHECK dout0_47 Vdout0_47ck47 = 0.9 time = 240
.meas tran vdout0_47ck47 FIND v(dout0_47) AT=240.025n

* CHECK dout0_48 Vdout0_48ck47 = 0.9 time = 240
.meas tran vdout0_48ck47 FIND v(dout0_48) AT=240.025n

* CHECK dout0_49 Vdout0_49ck47 = 0.9 time = 240
.meas tran vdout0_49ck47 FIND v(dout0_49) AT=240.025n

* CHECK dout0_50 Vdout0_50ck47 = 0 time = 240
.meas tran vdout0_50ck47 FIND v(dout0_50) AT=240.025n

* CHECK dout0_51 Vdout0_51ck47 = 0 time = 240
.meas tran vdout0_51ck47 FIND v(dout0_51) AT=240.025n

* CHECK dout0_52 Vdout0_52ck47 = 0 time = 240
.meas tran vdout0_52ck47 FIND v(dout0_52) AT=240.025n

* CHECK dout0_53 Vdout0_53ck47 = 0.9 time = 240
.meas tran vdout0_53ck47 FIND v(dout0_53) AT=240.025n

* CHECK dout0_54 Vdout0_54ck47 = 0 time = 240
.meas tran vdout0_54ck47 FIND v(dout0_54) AT=240.025n

* CHECK dout0_55 Vdout0_55ck47 = 0 time = 240
.meas tran vdout0_55ck47 FIND v(dout0_55) AT=240.025n

* CHECK dout0_56 Vdout0_56ck47 = 0 time = 240
.meas tran vdout0_56ck47 FIND v(dout0_56) AT=240.025n

* CHECK dout0_57 Vdout0_57ck47 = 0 time = 240
.meas tran vdout0_57ck47 FIND v(dout0_57) AT=240.025n

* CHECK dout0_58 Vdout0_58ck47 = 0 time = 240
.meas tran vdout0_58ck47 FIND v(dout0_58) AT=240.025n

* CHECK dout0_59 Vdout0_59ck47 = 0.9 time = 240
.meas tran vdout0_59ck47 FIND v(dout0_59) AT=240.025n

* CHECK dout0_60 Vdout0_60ck47 = 0.9 time = 240
.meas tran vdout0_60ck47 FIND v(dout0_60) AT=240.025n

* CHECK dout0_61 Vdout0_61ck47 = 0.9 time = 240
.meas tran vdout0_61ck47 FIND v(dout0_61) AT=240.025n

* CHECK dout0_62 Vdout0_62ck47 = 0 time = 240
.meas tran vdout0_62ck47 FIND v(dout0_62) AT=240.025n

* CHECK dout0_63 Vdout0_63ck47 = 0.9 time = 240
.meas tran vdout0_63ck47 FIND v(dout0_63) AT=240.025n

* CHECK dout0_0 Vdout0_0ck48 = 0.9 time = 245
.meas tran vdout0_0ck48 FIND v(dout0_0) AT=245.025n

* CHECK dout0_1 Vdout0_1ck48 = 0.9 time = 245
.meas tran vdout0_1ck48 FIND v(dout0_1) AT=245.025n

* CHECK dout0_2 Vdout0_2ck48 = 0.9 time = 245
.meas tran vdout0_2ck48 FIND v(dout0_2) AT=245.025n

* CHECK dout0_3 Vdout0_3ck48 = 0.9 time = 245
.meas tran vdout0_3ck48 FIND v(dout0_3) AT=245.025n

* CHECK dout0_4 Vdout0_4ck48 = 0 time = 245
.meas tran vdout0_4ck48 FIND v(dout0_4) AT=245.025n

* CHECK dout0_5 Vdout0_5ck48 = 0.9 time = 245
.meas tran vdout0_5ck48 FIND v(dout0_5) AT=245.025n

* CHECK dout0_6 Vdout0_6ck48 = 0 time = 245
.meas tran vdout0_6ck48 FIND v(dout0_6) AT=245.025n

* CHECK dout0_7 Vdout0_7ck48 = 0.9 time = 245
.meas tran vdout0_7ck48 FIND v(dout0_7) AT=245.025n

* CHECK dout0_8 Vdout0_8ck48 = 0.9 time = 245
.meas tran vdout0_8ck48 FIND v(dout0_8) AT=245.025n

* CHECK dout0_9 Vdout0_9ck48 = 0.9 time = 245
.meas tran vdout0_9ck48 FIND v(dout0_9) AT=245.025n

* CHECK dout0_10 Vdout0_10ck48 = 0 time = 245
.meas tran vdout0_10ck48 FIND v(dout0_10) AT=245.025n

* CHECK dout0_11 Vdout0_11ck48 = 0 time = 245
.meas tran vdout0_11ck48 FIND v(dout0_11) AT=245.025n

* CHECK dout0_12 Vdout0_12ck48 = 0 time = 245
.meas tran vdout0_12ck48 FIND v(dout0_12) AT=245.025n

* CHECK dout0_13 Vdout0_13ck48 = 0.9 time = 245
.meas tran vdout0_13ck48 FIND v(dout0_13) AT=245.025n

* CHECK dout0_14 Vdout0_14ck48 = 0.9 time = 245
.meas tran vdout0_14ck48 FIND v(dout0_14) AT=245.025n

* CHECK dout0_15 Vdout0_15ck48 = 0.9 time = 245
.meas tran vdout0_15ck48 FIND v(dout0_15) AT=245.025n

* CHECK dout0_16 Vdout0_16ck48 = 0 time = 245
.meas tran vdout0_16ck48 FIND v(dout0_16) AT=245.025n

* CHECK dout0_17 Vdout0_17ck48 = 0.9 time = 245
.meas tran vdout0_17ck48 FIND v(dout0_17) AT=245.025n

* CHECK dout0_18 Vdout0_18ck48 = 0 time = 245
.meas tran vdout0_18ck48 FIND v(dout0_18) AT=245.025n

* CHECK dout0_19 Vdout0_19ck48 = 0 time = 245
.meas tran vdout0_19ck48 FIND v(dout0_19) AT=245.025n

* CHECK dout0_20 Vdout0_20ck48 = 0.9 time = 245
.meas tran vdout0_20ck48 FIND v(dout0_20) AT=245.025n

* CHECK dout0_21 Vdout0_21ck48 = 0 time = 245
.meas tran vdout0_21ck48 FIND v(dout0_21) AT=245.025n

* CHECK dout0_22 Vdout0_22ck48 = 0.9 time = 245
.meas tran vdout0_22ck48 FIND v(dout0_22) AT=245.025n

* CHECK dout0_23 Vdout0_23ck48 = 0 time = 245
.meas tran vdout0_23ck48 FIND v(dout0_23) AT=245.025n

* CHECK dout0_24 Vdout0_24ck48 = 0 time = 245
.meas tran vdout0_24ck48 FIND v(dout0_24) AT=245.025n

* CHECK dout0_25 Vdout0_25ck48 = 0 time = 245
.meas tran vdout0_25ck48 FIND v(dout0_25) AT=245.025n

* CHECK dout0_26 Vdout0_26ck48 = 0 time = 245
.meas tran vdout0_26ck48 FIND v(dout0_26) AT=245.025n

* CHECK dout0_27 Vdout0_27ck48 = 0 time = 245
.meas tran vdout0_27ck48 FIND v(dout0_27) AT=245.025n

* CHECK dout0_28 Vdout0_28ck48 = 0 time = 245
.meas tran vdout0_28ck48 FIND v(dout0_28) AT=245.025n

* CHECK dout0_29 Vdout0_29ck48 = 0 time = 245
.meas tran vdout0_29ck48 FIND v(dout0_29) AT=245.025n

* CHECK dout0_30 Vdout0_30ck48 = 0 time = 245
.meas tran vdout0_30ck48 FIND v(dout0_30) AT=245.025n

* CHECK dout0_31 Vdout0_31ck48 = 0.9 time = 245
.meas tran vdout0_31ck48 FIND v(dout0_31) AT=245.025n

* CHECK dout0_32 Vdout0_32ck48 = 0 time = 245
.meas tran vdout0_32ck48 FIND v(dout0_32) AT=245.025n

* CHECK dout0_33 Vdout0_33ck48 = 0 time = 245
.meas tran vdout0_33ck48 FIND v(dout0_33) AT=245.025n

* CHECK dout0_34 Vdout0_34ck48 = 0 time = 245
.meas tran vdout0_34ck48 FIND v(dout0_34) AT=245.025n

* CHECK dout0_35 Vdout0_35ck48 = 0.9 time = 245
.meas tran vdout0_35ck48 FIND v(dout0_35) AT=245.025n

* CHECK dout0_36 Vdout0_36ck48 = 0 time = 245
.meas tran vdout0_36ck48 FIND v(dout0_36) AT=245.025n

* CHECK dout0_37 Vdout0_37ck48 = 0 time = 245
.meas tran vdout0_37ck48 FIND v(dout0_37) AT=245.025n

* CHECK dout0_38 Vdout0_38ck48 = 0 time = 245
.meas tran vdout0_38ck48 FIND v(dout0_38) AT=245.025n

* CHECK dout0_39 Vdout0_39ck48 = 0 time = 245
.meas tran vdout0_39ck48 FIND v(dout0_39) AT=245.025n

* CHECK dout0_40 Vdout0_40ck48 = 0 time = 245
.meas tran vdout0_40ck48 FIND v(dout0_40) AT=245.025n

* CHECK dout0_41 Vdout0_41ck48 = 0.9 time = 245
.meas tran vdout0_41ck48 FIND v(dout0_41) AT=245.025n

* CHECK dout0_42 Vdout0_42ck48 = 0 time = 245
.meas tran vdout0_42ck48 FIND v(dout0_42) AT=245.025n

* CHECK dout0_43 Vdout0_43ck48 = 0 time = 245
.meas tran vdout0_43ck48 FIND v(dout0_43) AT=245.025n

* CHECK dout0_44 Vdout0_44ck48 = 0 time = 245
.meas tran vdout0_44ck48 FIND v(dout0_44) AT=245.025n

* CHECK dout0_45 Vdout0_45ck48 = 0 time = 245
.meas tran vdout0_45ck48 FIND v(dout0_45) AT=245.025n

* CHECK dout0_46 Vdout0_46ck48 = 0.9 time = 245
.meas tran vdout0_46ck48 FIND v(dout0_46) AT=245.025n

* CHECK dout0_47 Vdout0_47ck48 = 0.9 time = 245
.meas tran vdout0_47ck48 FIND v(dout0_47) AT=245.025n

* CHECK dout0_48 Vdout0_48ck48 = 0.9 time = 245
.meas tran vdout0_48ck48 FIND v(dout0_48) AT=245.025n

* CHECK dout0_49 Vdout0_49ck48 = 0.9 time = 245
.meas tran vdout0_49ck48 FIND v(dout0_49) AT=245.025n

* CHECK dout0_50 Vdout0_50ck48 = 0 time = 245
.meas tran vdout0_50ck48 FIND v(dout0_50) AT=245.025n

* CHECK dout0_51 Vdout0_51ck48 = 0 time = 245
.meas tran vdout0_51ck48 FIND v(dout0_51) AT=245.025n

* CHECK dout0_52 Vdout0_52ck48 = 0 time = 245
.meas tran vdout0_52ck48 FIND v(dout0_52) AT=245.025n

* CHECK dout0_53 Vdout0_53ck48 = 0.9 time = 245
.meas tran vdout0_53ck48 FIND v(dout0_53) AT=245.025n

* CHECK dout0_54 Vdout0_54ck48 = 0 time = 245
.meas tran vdout0_54ck48 FIND v(dout0_54) AT=245.025n

* CHECK dout0_55 Vdout0_55ck48 = 0 time = 245
.meas tran vdout0_55ck48 FIND v(dout0_55) AT=245.025n

* CHECK dout0_56 Vdout0_56ck48 = 0 time = 245
.meas tran vdout0_56ck48 FIND v(dout0_56) AT=245.025n

* CHECK dout0_57 Vdout0_57ck48 = 0 time = 245
.meas tran vdout0_57ck48 FIND v(dout0_57) AT=245.025n

* CHECK dout0_58 Vdout0_58ck48 = 0 time = 245
.meas tran vdout0_58ck48 FIND v(dout0_58) AT=245.025n

* CHECK dout0_59 Vdout0_59ck48 = 0.9 time = 245
.meas tran vdout0_59ck48 FIND v(dout0_59) AT=245.025n

* CHECK dout0_60 Vdout0_60ck48 = 0.9 time = 245
.meas tran vdout0_60ck48 FIND v(dout0_60) AT=245.025n

* CHECK dout0_61 Vdout0_61ck48 = 0.9 time = 245
.meas tran vdout0_61ck48 FIND v(dout0_61) AT=245.025n

* CHECK dout0_62 Vdout0_62ck48 = 0 time = 245
.meas tran vdout0_62ck48 FIND v(dout0_62) AT=245.025n

* CHECK dout0_63 Vdout0_63ck48 = 0.9 time = 245
.meas tran vdout0_63ck48 FIND v(dout0_63) AT=245.025n

* CHECK dout0_0 Vdout0_0ck51 = 0 time = 260
.meas tran vdout0_0ck51 FIND v(dout0_0) AT=260.025n

* CHECK dout0_1 Vdout0_1ck51 = 0.9 time = 260
.meas tran vdout0_1ck51 FIND v(dout0_1) AT=260.025n

* CHECK dout0_2 Vdout0_2ck51 = 0.9 time = 260
.meas tran vdout0_2ck51 FIND v(dout0_2) AT=260.025n

* CHECK dout0_3 Vdout0_3ck51 = 0.9 time = 260
.meas tran vdout0_3ck51 FIND v(dout0_3) AT=260.025n

* CHECK dout0_4 Vdout0_4ck51 = 0 time = 260
.meas tran vdout0_4ck51 FIND v(dout0_4) AT=260.025n

* CHECK dout0_5 Vdout0_5ck51 = 0 time = 260
.meas tran vdout0_5ck51 FIND v(dout0_5) AT=260.025n

* CHECK dout0_6 Vdout0_6ck51 = 0 time = 260
.meas tran vdout0_6ck51 FIND v(dout0_6) AT=260.025n

* CHECK dout0_7 Vdout0_7ck51 = 0.9 time = 260
.meas tran vdout0_7ck51 FIND v(dout0_7) AT=260.025n

* CHECK dout0_8 Vdout0_8ck51 = 0 time = 260
.meas tran vdout0_8ck51 FIND v(dout0_8) AT=260.025n

* CHECK dout0_9 Vdout0_9ck51 = 0.9 time = 260
.meas tran vdout0_9ck51 FIND v(dout0_9) AT=260.025n

* CHECK dout0_10 Vdout0_10ck51 = 0.9 time = 260
.meas tran vdout0_10ck51 FIND v(dout0_10) AT=260.025n

* CHECK dout0_11 Vdout0_11ck51 = 0.9 time = 260
.meas tran vdout0_11ck51 FIND v(dout0_11) AT=260.025n

* CHECK dout0_12 Vdout0_12ck51 = 0 time = 260
.meas tran vdout0_12ck51 FIND v(dout0_12) AT=260.025n

* CHECK dout0_13 Vdout0_13ck51 = 0.9 time = 260
.meas tran vdout0_13ck51 FIND v(dout0_13) AT=260.025n

* CHECK dout0_14 Vdout0_14ck51 = 0.9 time = 260
.meas tran vdout0_14ck51 FIND v(dout0_14) AT=260.025n

* CHECK dout0_15 Vdout0_15ck51 = 0.9 time = 260
.meas tran vdout0_15ck51 FIND v(dout0_15) AT=260.025n

* CHECK dout0_16 Vdout0_16ck51 = 0 time = 260
.meas tran vdout0_16ck51 FIND v(dout0_16) AT=260.025n

* CHECK dout0_17 Vdout0_17ck51 = 0 time = 260
.meas tran vdout0_17ck51 FIND v(dout0_17) AT=260.025n

* CHECK dout0_18 Vdout0_18ck51 = 0 time = 260
.meas tran vdout0_18ck51 FIND v(dout0_18) AT=260.025n

* CHECK dout0_19 Vdout0_19ck51 = 0.9 time = 260
.meas tran vdout0_19ck51 FIND v(dout0_19) AT=260.025n

* CHECK dout0_20 Vdout0_20ck51 = 0.9 time = 260
.meas tran vdout0_20ck51 FIND v(dout0_20) AT=260.025n

* CHECK dout0_21 Vdout0_21ck51 = 0.9 time = 260
.meas tran vdout0_21ck51 FIND v(dout0_21) AT=260.025n

* CHECK dout0_22 Vdout0_22ck51 = 0 time = 260
.meas tran vdout0_22ck51 FIND v(dout0_22) AT=260.025n

* CHECK dout0_23 Vdout0_23ck51 = 0 time = 260
.meas tran vdout0_23ck51 FIND v(dout0_23) AT=260.025n

* CHECK dout0_24 Vdout0_24ck51 = 0 time = 260
.meas tran vdout0_24ck51 FIND v(dout0_24) AT=260.025n

* CHECK dout0_25 Vdout0_25ck51 = 0.9 time = 260
.meas tran vdout0_25ck51 FIND v(dout0_25) AT=260.025n

* CHECK dout0_26 Vdout0_26ck51 = 0.9 time = 260
.meas tran vdout0_26ck51 FIND v(dout0_26) AT=260.025n

* CHECK dout0_27 Vdout0_27ck51 = 0.9 time = 260
.meas tran vdout0_27ck51 FIND v(dout0_27) AT=260.025n

* CHECK dout0_28 Vdout0_28ck51 = 0 time = 260
.meas tran vdout0_28ck51 FIND v(dout0_28) AT=260.025n

* CHECK dout0_29 Vdout0_29ck51 = 0 time = 260
.meas tran vdout0_29ck51 FIND v(dout0_29) AT=260.025n

* CHECK dout0_30 Vdout0_30ck51 = 0.9 time = 260
.meas tran vdout0_30ck51 FIND v(dout0_30) AT=260.025n

* CHECK dout0_31 Vdout0_31ck51 = 0 time = 260
.meas tran vdout0_31ck51 FIND v(dout0_31) AT=260.025n

* CHECK dout0_32 Vdout0_32ck51 = 0.9 time = 260
.meas tran vdout0_32ck51 FIND v(dout0_32) AT=260.025n

* CHECK dout0_33 Vdout0_33ck51 = 0.9 time = 260
.meas tran vdout0_33ck51 FIND v(dout0_33) AT=260.025n

* CHECK dout0_34 Vdout0_34ck51 = 0.9 time = 260
.meas tran vdout0_34ck51 FIND v(dout0_34) AT=260.025n

* CHECK dout0_35 Vdout0_35ck51 = 0 time = 260
.meas tran vdout0_35ck51 FIND v(dout0_35) AT=260.025n

* CHECK dout0_36 Vdout0_36ck51 = 0.9 time = 260
.meas tran vdout0_36ck51 FIND v(dout0_36) AT=260.025n

* CHECK dout0_37 Vdout0_37ck51 = 0.9 time = 260
.meas tran vdout0_37ck51 FIND v(dout0_37) AT=260.025n

* CHECK dout0_38 Vdout0_38ck51 = 0.9 time = 260
.meas tran vdout0_38ck51 FIND v(dout0_38) AT=260.025n

* CHECK dout0_39 Vdout0_39ck51 = 0.9 time = 260
.meas tran vdout0_39ck51 FIND v(dout0_39) AT=260.025n

* CHECK dout0_40 Vdout0_40ck51 = 0.9 time = 260
.meas tran vdout0_40ck51 FIND v(dout0_40) AT=260.025n

* CHECK dout0_41 Vdout0_41ck51 = 0.9 time = 260
.meas tran vdout0_41ck51 FIND v(dout0_41) AT=260.025n

* CHECK dout0_42 Vdout0_42ck51 = 0.9 time = 260
.meas tran vdout0_42ck51 FIND v(dout0_42) AT=260.025n

* CHECK dout0_43 Vdout0_43ck51 = 0 time = 260
.meas tran vdout0_43ck51 FIND v(dout0_43) AT=260.025n

* CHECK dout0_44 Vdout0_44ck51 = 0 time = 260
.meas tran vdout0_44ck51 FIND v(dout0_44) AT=260.025n

* CHECK dout0_45 Vdout0_45ck51 = 0 time = 260
.meas tran vdout0_45ck51 FIND v(dout0_45) AT=260.025n

* CHECK dout0_46 Vdout0_46ck51 = 0 time = 260
.meas tran vdout0_46ck51 FIND v(dout0_46) AT=260.025n

* CHECK dout0_47 Vdout0_47ck51 = 0 time = 260
.meas tran vdout0_47ck51 FIND v(dout0_47) AT=260.025n

* CHECK dout0_48 Vdout0_48ck51 = 0 time = 260
.meas tran vdout0_48ck51 FIND v(dout0_48) AT=260.025n

* CHECK dout0_49 Vdout0_49ck51 = 0 time = 260
.meas tran vdout0_49ck51 FIND v(dout0_49) AT=260.025n

* CHECK dout0_50 Vdout0_50ck51 = 0.9 time = 260
.meas tran vdout0_50ck51 FIND v(dout0_50) AT=260.025n

* CHECK dout0_51 Vdout0_51ck51 = 0 time = 260
.meas tran vdout0_51ck51 FIND v(dout0_51) AT=260.025n

* CHECK dout0_52 Vdout0_52ck51 = 0.9 time = 260
.meas tran vdout0_52ck51 FIND v(dout0_52) AT=260.025n

* CHECK dout0_53 Vdout0_53ck51 = 0 time = 260
.meas tran vdout0_53ck51 FIND v(dout0_53) AT=260.025n

* CHECK dout0_54 Vdout0_54ck51 = 0.9 time = 260
.meas tran vdout0_54ck51 FIND v(dout0_54) AT=260.025n

* CHECK dout0_55 Vdout0_55ck51 = 0.9 time = 260
.meas tran vdout0_55ck51 FIND v(dout0_55) AT=260.025n

* CHECK dout0_56 Vdout0_56ck51 = 0.9 time = 260
.meas tran vdout0_56ck51 FIND v(dout0_56) AT=260.025n

* CHECK dout0_57 Vdout0_57ck51 = 0 time = 260
.meas tran vdout0_57ck51 FIND v(dout0_57) AT=260.025n

* CHECK dout0_58 Vdout0_58ck51 = 0.9 time = 260
.meas tran vdout0_58ck51 FIND v(dout0_58) AT=260.025n

* CHECK dout0_59 Vdout0_59ck51 = 0 time = 260
.meas tran vdout0_59ck51 FIND v(dout0_59) AT=260.025n

* CHECK dout0_60 Vdout0_60ck51 = 0 time = 260
.meas tran vdout0_60ck51 FIND v(dout0_60) AT=260.025n

* CHECK dout0_61 Vdout0_61ck51 = 0 time = 260
.meas tran vdout0_61ck51 FIND v(dout0_61) AT=260.025n

* CHECK dout0_62 Vdout0_62ck51 = 0.9 time = 260
.meas tran vdout0_62ck51 FIND v(dout0_62) AT=260.025n

* CHECK dout0_63 Vdout0_63ck51 = 0.9 time = 260
.meas tran vdout0_63ck51 FIND v(dout0_63) AT=260.025n

* CHECK dout0_0 Vdout0_0ck53 = 0 time = 270
.meas tran vdout0_0ck53 FIND v(dout0_0) AT=270.025n

* CHECK dout0_1 Vdout0_1ck53 = 0.9 time = 270
.meas tran vdout0_1ck53 FIND v(dout0_1) AT=270.025n

* CHECK dout0_2 Vdout0_2ck53 = 0.9 time = 270
.meas tran vdout0_2ck53 FIND v(dout0_2) AT=270.025n

* CHECK dout0_3 Vdout0_3ck53 = 0.9 time = 270
.meas tran vdout0_3ck53 FIND v(dout0_3) AT=270.025n

* CHECK dout0_4 Vdout0_4ck53 = 0 time = 270
.meas tran vdout0_4ck53 FIND v(dout0_4) AT=270.025n

* CHECK dout0_5 Vdout0_5ck53 = 0 time = 270
.meas tran vdout0_5ck53 FIND v(dout0_5) AT=270.025n

* CHECK dout0_6 Vdout0_6ck53 = 0 time = 270
.meas tran vdout0_6ck53 FIND v(dout0_6) AT=270.025n

* CHECK dout0_7 Vdout0_7ck53 = 0.9 time = 270
.meas tran vdout0_7ck53 FIND v(dout0_7) AT=270.025n

* CHECK dout0_8 Vdout0_8ck53 = 0 time = 270
.meas tran vdout0_8ck53 FIND v(dout0_8) AT=270.025n

* CHECK dout0_9 Vdout0_9ck53 = 0.9 time = 270
.meas tran vdout0_9ck53 FIND v(dout0_9) AT=270.025n

* CHECK dout0_10 Vdout0_10ck53 = 0.9 time = 270
.meas tran vdout0_10ck53 FIND v(dout0_10) AT=270.025n

* CHECK dout0_11 Vdout0_11ck53 = 0.9 time = 270
.meas tran vdout0_11ck53 FIND v(dout0_11) AT=270.025n

* CHECK dout0_12 Vdout0_12ck53 = 0 time = 270
.meas tran vdout0_12ck53 FIND v(dout0_12) AT=270.025n

* CHECK dout0_13 Vdout0_13ck53 = 0.9 time = 270
.meas tran vdout0_13ck53 FIND v(dout0_13) AT=270.025n

* CHECK dout0_14 Vdout0_14ck53 = 0.9 time = 270
.meas tran vdout0_14ck53 FIND v(dout0_14) AT=270.025n

* CHECK dout0_15 Vdout0_15ck53 = 0.9 time = 270
.meas tran vdout0_15ck53 FIND v(dout0_15) AT=270.025n

* CHECK dout0_16 Vdout0_16ck53 = 0 time = 270
.meas tran vdout0_16ck53 FIND v(dout0_16) AT=270.025n

* CHECK dout0_17 Vdout0_17ck53 = 0 time = 270
.meas tran vdout0_17ck53 FIND v(dout0_17) AT=270.025n

* CHECK dout0_18 Vdout0_18ck53 = 0 time = 270
.meas tran vdout0_18ck53 FIND v(dout0_18) AT=270.025n

* CHECK dout0_19 Vdout0_19ck53 = 0.9 time = 270
.meas tran vdout0_19ck53 FIND v(dout0_19) AT=270.025n

* CHECK dout0_20 Vdout0_20ck53 = 0.9 time = 270
.meas tran vdout0_20ck53 FIND v(dout0_20) AT=270.025n

* CHECK dout0_21 Vdout0_21ck53 = 0.9 time = 270
.meas tran vdout0_21ck53 FIND v(dout0_21) AT=270.025n

* CHECK dout0_22 Vdout0_22ck53 = 0 time = 270
.meas tran vdout0_22ck53 FIND v(dout0_22) AT=270.025n

* CHECK dout0_23 Vdout0_23ck53 = 0 time = 270
.meas tran vdout0_23ck53 FIND v(dout0_23) AT=270.025n

* CHECK dout0_24 Vdout0_24ck53 = 0 time = 270
.meas tran vdout0_24ck53 FIND v(dout0_24) AT=270.025n

* CHECK dout0_25 Vdout0_25ck53 = 0.9 time = 270
.meas tran vdout0_25ck53 FIND v(dout0_25) AT=270.025n

* CHECK dout0_26 Vdout0_26ck53 = 0.9 time = 270
.meas tran vdout0_26ck53 FIND v(dout0_26) AT=270.025n

* CHECK dout0_27 Vdout0_27ck53 = 0.9 time = 270
.meas tran vdout0_27ck53 FIND v(dout0_27) AT=270.025n

* CHECK dout0_28 Vdout0_28ck53 = 0 time = 270
.meas tran vdout0_28ck53 FIND v(dout0_28) AT=270.025n

* CHECK dout0_29 Vdout0_29ck53 = 0 time = 270
.meas tran vdout0_29ck53 FIND v(dout0_29) AT=270.025n

* CHECK dout0_30 Vdout0_30ck53 = 0.9 time = 270
.meas tran vdout0_30ck53 FIND v(dout0_30) AT=270.025n

* CHECK dout0_31 Vdout0_31ck53 = 0 time = 270
.meas tran vdout0_31ck53 FIND v(dout0_31) AT=270.025n

* CHECK dout0_32 Vdout0_32ck53 = 0.9 time = 270
.meas tran vdout0_32ck53 FIND v(dout0_32) AT=270.025n

* CHECK dout0_33 Vdout0_33ck53 = 0.9 time = 270
.meas tran vdout0_33ck53 FIND v(dout0_33) AT=270.025n

* CHECK dout0_34 Vdout0_34ck53 = 0.9 time = 270
.meas tran vdout0_34ck53 FIND v(dout0_34) AT=270.025n

* CHECK dout0_35 Vdout0_35ck53 = 0 time = 270
.meas tran vdout0_35ck53 FIND v(dout0_35) AT=270.025n

* CHECK dout0_36 Vdout0_36ck53 = 0.9 time = 270
.meas tran vdout0_36ck53 FIND v(dout0_36) AT=270.025n

* CHECK dout0_37 Vdout0_37ck53 = 0.9 time = 270
.meas tran vdout0_37ck53 FIND v(dout0_37) AT=270.025n

* CHECK dout0_38 Vdout0_38ck53 = 0.9 time = 270
.meas tran vdout0_38ck53 FIND v(dout0_38) AT=270.025n

* CHECK dout0_39 Vdout0_39ck53 = 0.9 time = 270
.meas tran vdout0_39ck53 FIND v(dout0_39) AT=270.025n

* CHECK dout0_40 Vdout0_40ck53 = 0.9 time = 270
.meas tran vdout0_40ck53 FIND v(dout0_40) AT=270.025n

* CHECK dout0_41 Vdout0_41ck53 = 0.9 time = 270
.meas tran vdout0_41ck53 FIND v(dout0_41) AT=270.025n

* CHECK dout0_42 Vdout0_42ck53 = 0.9 time = 270
.meas tran vdout0_42ck53 FIND v(dout0_42) AT=270.025n

* CHECK dout0_43 Vdout0_43ck53 = 0 time = 270
.meas tran vdout0_43ck53 FIND v(dout0_43) AT=270.025n

* CHECK dout0_44 Vdout0_44ck53 = 0 time = 270
.meas tran vdout0_44ck53 FIND v(dout0_44) AT=270.025n

* CHECK dout0_45 Vdout0_45ck53 = 0 time = 270
.meas tran vdout0_45ck53 FIND v(dout0_45) AT=270.025n

* CHECK dout0_46 Vdout0_46ck53 = 0 time = 270
.meas tran vdout0_46ck53 FIND v(dout0_46) AT=270.025n

* CHECK dout0_47 Vdout0_47ck53 = 0 time = 270
.meas tran vdout0_47ck53 FIND v(dout0_47) AT=270.025n

* CHECK dout0_48 Vdout0_48ck53 = 0 time = 270
.meas tran vdout0_48ck53 FIND v(dout0_48) AT=270.025n

* CHECK dout0_49 Vdout0_49ck53 = 0 time = 270
.meas tran vdout0_49ck53 FIND v(dout0_49) AT=270.025n

* CHECK dout0_50 Vdout0_50ck53 = 0.9 time = 270
.meas tran vdout0_50ck53 FIND v(dout0_50) AT=270.025n

* CHECK dout0_51 Vdout0_51ck53 = 0 time = 270
.meas tran vdout0_51ck53 FIND v(dout0_51) AT=270.025n

* CHECK dout0_52 Vdout0_52ck53 = 0.9 time = 270
.meas tran vdout0_52ck53 FIND v(dout0_52) AT=270.025n

* CHECK dout0_53 Vdout0_53ck53 = 0 time = 270
.meas tran vdout0_53ck53 FIND v(dout0_53) AT=270.025n

* CHECK dout0_54 Vdout0_54ck53 = 0.9 time = 270
.meas tran vdout0_54ck53 FIND v(dout0_54) AT=270.025n

* CHECK dout0_55 Vdout0_55ck53 = 0.9 time = 270
.meas tran vdout0_55ck53 FIND v(dout0_55) AT=270.025n

* CHECK dout0_56 Vdout0_56ck53 = 0.9 time = 270
.meas tran vdout0_56ck53 FIND v(dout0_56) AT=270.025n

* CHECK dout0_57 Vdout0_57ck53 = 0 time = 270
.meas tran vdout0_57ck53 FIND v(dout0_57) AT=270.025n

* CHECK dout0_58 Vdout0_58ck53 = 0.9 time = 270
.meas tran vdout0_58ck53 FIND v(dout0_58) AT=270.025n

* CHECK dout0_59 Vdout0_59ck53 = 0 time = 270
.meas tran vdout0_59ck53 FIND v(dout0_59) AT=270.025n

* CHECK dout0_60 Vdout0_60ck53 = 0 time = 270
.meas tran vdout0_60ck53 FIND v(dout0_60) AT=270.025n

* CHECK dout0_61 Vdout0_61ck53 = 0 time = 270
.meas tran vdout0_61ck53 FIND v(dout0_61) AT=270.025n

* CHECK dout0_62 Vdout0_62ck53 = 0.9 time = 270
.meas tran vdout0_62ck53 FIND v(dout0_62) AT=270.025n

* CHECK dout0_63 Vdout0_63ck53 = 0.9 time = 270
.meas tran vdout0_63ck53 FIND v(dout0_63) AT=270.025n

* CHECK dout0_0 Vdout0_0ck55 = 0 time = 280
.meas tran vdout0_0ck55 FIND v(dout0_0) AT=280.025n

* CHECK dout0_1 Vdout0_1ck55 = 0.9 time = 280
.meas tran vdout0_1ck55 FIND v(dout0_1) AT=280.025n

* CHECK dout0_2 Vdout0_2ck55 = 0.9 time = 280
.meas tran vdout0_2ck55 FIND v(dout0_2) AT=280.025n

* CHECK dout0_3 Vdout0_3ck55 = 0 time = 280
.meas tran vdout0_3ck55 FIND v(dout0_3) AT=280.025n

* CHECK dout0_4 Vdout0_4ck55 = 0 time = 280
.meas tran vdout0_4ck55 FIND v(dout0_4) AT=280.025n

* CHECK dout0_5 Vdout0_5ck55 = 0 time = 280
.meas tran vdout0_5ck55 FIND v(dout0_5) AT=280.025n

* CHECK dout0_6 Vdout0_6ck55 = 0 time = 280
.meas tran vdout0_6ck55 FIND v(dout0_6) AT=280.025n

* CHECK dout0_7 Vdout0_7ck55 = 0 time = 280
.meas tran vdout0_7ck55 FIND v(dout0_7) AT=280.025n

* CHECK dout0_8 Vdout0_8ck55 = 0 time = 280
.meas tran vdout0_8ck55 FIND v(dout0_8) AT=280.025n

* CHECK dout0_9 Vdout0_9ck55 = 0.9 time = 280
.meas tran vdout0_9ck55 FIND v(dout0_9) AT=280.025n

* CHECK dout0_10 Vdout0_10ck55 = 0.9 time = 280
.meas tran vdout0_10ck55 FIND v(dout0_10) AT=280.025n

* CHECK dout0_11 Vdout0_11ck55 = 0.9 time = 280
.meas tran vdout0_11ck55 FIND v(dout0_11) AT=280.025n

* CHECK dout0_12 Vdout0_12ck55 = 0.9 time = 280
.meas tran vdout0_12ck55 FIND v(dout0_12) AT=280.025n

* CHECK dout0_13 Vdout0_13ck55 = 0.9 time = 280
.meas tran vdout0_13ck55 FIND v(dout0_13) AT=280.025n

* CHECK dout0_14 Vdout0_14ck55 = 0.9 time = 280
.meas tran vdout0_14ck55 FIND v(dout0_14) AT=280.025n

* CHECK dout0_15 Vdout0_15ck55 = 0 time = 280
.meas tran vdout0_15ck55 FIND v(dout0_15) AT=280.025n

* CHECK dout0_16 Vdout0_16ck55 = 0 time = 280
.meas tran vdout0_16ck55 FIND v(dout0_16) AT=280.025n

* CHECK dout0_17 Vdout0_17ck55 = 0 time = 280
.meas tran vdout0_17ck55 FIND v(dout0_17) AT=280.025n

* CHECK dout0_18 Vdout0_18ck55 = 0 time = 280
.meas tran vdout0_18ck55 FIND v(dout0_18) AT=280.025n

* CHECK dout0_19 Vdout0_19ck55 = 0 time = 280
.meas tran vdout0_19ck55 FIND v(dout0_19) AT=280.025n

* CHECK dout0_20 Vdout0_20ck55 = 0.9 time = 280
.meas tran vdout0_20ck55 FIND v(dout0_20) AT=280.025n

* CHECK dout0_21 Vdout0_21ck55 = 0 time = 280
.meas tran vdout0_21ck55 FIND v(dout0_21) AT=280.025n

* CHECK dout0_22 Vdout0_22ck55 = 0.9 time = 280
.meas tran vdout0_22ck55 FIND v(dout0_22) AT=280.025n

* CHECK dout0_23 Vdout0_23ck55 = 0 time = 280
.meas tran vdout0_23ck55 FIND v(dout0_23) AT=280.025n

* CHECK dout0_24 Vdout0_24ck55 = 0 time = 280
.meas tran vdout0_24ck55 FIND v(dout0_24) AT=280.025n

* CHECK dout0_25 Vdout0_25ck55 = 0.9 time = 280
.meas tran vdout0_25ck55 FIND v(dout0_25) AT=280.025n

* CHECK dout0_26 Vdout0_26ck55 = 0.9 time = 280
.meas tran vdout0_26ck55 FIND v(dout0_26) AT=280.025n

* CHECK dout0_27 Vdout0_27ck55 = 0.9 time = 280
.meas tran vdout0_27ck55 FIND v(dout0_27) AT=280.025n

* CHECK dout0_28 Vdout0_28ck55 = 0.9 time = 280
.meas tran vdout0_28ck55 FIND v(dout0_28) AT=280.025n

* CHECK dout0_29 Vdout0_29ck55 = 0 time = 280
.meas tran vdout0_29ck55 FIND v(dout0_29) AT=280.025n

* CHECK dout0_30 Vdout0_30ck55 = 0 time = 280
.meas tran vdout0_30ck55 FIND v(dout0_30) AT=280.025n

* CHECK dout0_31 Vdout0_31ck55 = 0.9 time = 280
.meas tran vdout0_31ck55 FIND v(dout0_31) AT=280.025n

* CHECK dout0_32 Vdout0_32ck55 = 0 time = 280
.meas tran vdout0_32ck55 FIND v(dout0_32) AT=280.025n

* CHECK dout0_33 Vdout0_33ck55 = 0.9 time = 280
.meas tran vdout0_33ck55 FIND v(dout0_33) AT=280.025n

* CHECK dout0_34 Vdout0_34ck55 = 0 time = 280
.meas tran vdout0_34ck55 FIND v(dout0_34) AT=280.025n

* CHECK dout0_35 Vdout0_35ck55 = 0.9 time = 280
.meas tran vdout0_35ck55 FIND v(dout0_35) AT=280.025n

* CHECK dout0_36 Vdout0_36ck55 = 0.9 time = 280
.meas tran vdout0_36ck55 FIND v(dout0_36) AT=280.025n

* CHECK dout0_37 Vdout0_37ck55 = 0 time = 280
.meas tran vdout0_37ck55 FIND v(dout0_37) AT=280.025n

* CHECK dout0_38 Vdout0_38ck55 = 0.9 time = 280
.meas tran vdout0_38ck55 FIND v(dout0_38) AT=280.025n

* CHECK dout0_39 Vdout0_39ck55 = 0 time = 280
.meas tran vdout0_39ck55 FIND v(dout0_39) AT=280.025n

* CHECK dout0_40 Vdout0_40ck55 = 0 time = 280
.meas tran vdout0_40ck55 FIND v(dout0_40) AT=280.025n

* CHECK dout0_41 Vdout0_41ck55 = 0 time = 280
.meas tran vdout0_41ck55 FIND v(dout0_41) AT=280.025n

* CHECK dout0_42 Vdout0_42ck55 = 0.9 time = 280
.meas tran vdout0_42ck55 FIND v(dout0_42) AT=280.025n

* CHECK dout0_43 Vdout0_43ck55 = 0.9 time = 280
.meas tran vdout0_43ck55 FIND v(dout0_43) AT=280.025n

* CHECK dout0_44 Vdout0_44ck55 = 0 time = 280
.meas tran vdout0_44ck55 FIND v(dout0_44) AT=280.025n

* CHECK dout0_45 Vdout0_45ck55 = 0 time = 280
.meas tran vdout0_45ck55 FIND v(dout0_45) AT=280.025n

* CHECK dout0_46 Vdout0_46ck55 = 0 time = 280
.meas tran vdout0_46ck55 FIND v(dout0_46) AT=280.025n

* CHECK dout0_47 Vdout0_47ck55 = 0.9 time = 280
.meas tran vdout0_47ck55 FIND v(dout0_47) AT=280.025n

* CHECK dout0_48 Vdout0_48ck55 = 0.9 time = 280
.meas tran vdout0_48ck55 FIND v(dout0_48) AT=280.025n

* CHECK dout0_49 Vdout0_49ck55 = 0 time = 280
.meas tran vdout0_49ck55 FIND v(dout0_49) AT=280.025n

* CHECK dout0_50 Vdout0_50ck55 = 0.9 time = 280
.meas tran vdout0_50ck55 FIND v(dout0_50) AT=280.025n

* CHECK dout0_51 Vdout0_51ck55 = 0.9 time = 280
.meas tran vdout0_51ck55 FIND v(dout0_51) AT=280.025n

* CHECK dout0_52 Vdout0_52ck55 = 0 time = 280
.meas tran vdout0_52ck55 FIND v(dout0_52) AT=280.025n

* CHECK dout0_53 Vdout0_53ck55 = 0 time = 280
.meas tran vdout0_53ck55 FIND v(dout0_53) AT=280.025n

* CHECK dout0_54 Vdout0_54ck55 = 0.9 time = 280
.meas tran vdout0_54ck55 FIND v(dout0_54) AT=280.025n

* CHECK dout0_55 Vdout0_55ck55 = 0 time = 280
.meas tran vdout0_55ck55 FIND v(dout0_55) AT=280.025n

* CHECK dout0_56 Vdout0_56ck55 = 0 time = 280
.meas tran vdout0_56ck55 FIND v(dout0_56) AT=280.025n

* CHECK dout0_57 Vdout0_57ck55 = 0 time = 280
.meas tran vdout0_57ck55 FIND v(dout0_57) AT=280.025n

* CHECK dout0_58 Vdout0_58ck55 = 0 time = 280
.meas tran vdout0_58ck55 FIND v(dout0_58) AT=280.025n

* CHECK dout0_59 Vdout0_59ck55 = 0 time = 280
.meas tran vdout0_59ck55 FIND v(dout0_59) AT=280.025n

* CHECK dout0_60 Vdout0_60ck55 = 0.9 time = 280
.meas tran vdout0_60ck55 FIND v(dout0_60) AT=280.025n

* CHECK dout0_61 Vdout0_61ck55 = 0.9 time = 280
.meas tran vdout0_61ck55 FIND v(dout0_61) AT=280.025n

* CHECK dout0_62 Vdout0_62ck55 = 0.9 time = 280
.meas tran vdout0_62ck55 FIND v(dout0_62) AT=280.025n

* CHECK dout0_63 Vdout0_63ck55 = 0.9 time = 280
.meas tran vdout0_63ck55 FIND v(dout0_63) AT=280.025n

* CHECK dout0_0 Vdout0_0ck58 = 0.9 time = 295
.meas tran vdout0_0ck58 FIND v(dout0_0) AT=295.025n

* CHECK dout0_1 Vdout0_1ck58 = 0.9 time = 295
.meas tran vdout0_1ck58 FIND v(dout0_1) AT=295.025n

* CHECK dout0_2 Vdout0_2ck58 = 0 time = 295
.meas tran vdout0_2ck58 FIND v(dout0_2) AT=295.025n

* CHECK dout0_3 Vdout0_3ck58 = 0.9 time = 295
.meas tran vdout0_3ck58 FIND v(dout0_3) AT=295.025n

* CHECK dout0_4 Vdout0_4ck58 = 0.9 time = 295
.meas tran vdout0_4ck58 FIND v(dout0_4) AT=295.025n

* CHECK dout0_5 Vdout0_5ck58 = 0 time = 295
.meas tran vdout0_5ck58 FIND v(dout0_5) AT=295.025n

* CHECK dout0_6 Vdout0_6ck58 = 0.9 time = 295
.meas tran vdout0_6ck58 FIND v(dout0_6) AT=295.025n

* CHECK dout0_7 Vdout0_7ck58 = 0.9 time = 295
.meas tran vdout0_7ck58 FIND v(dout0_7) AT=295.025n

* CHECK dout0_8 Vdout0_8ck58 = 0 time = 295
.meas tran vdout0_8ck58 FIND v(dout0_8) AT=295.025n

* CHECK dout0_9 Vdout0_9ck58 = 0 time = 295
.meas tran vdout0_9ck58 FIND v(dout0_9) AT=295.025n

* CHECK dout0_10 Vdout0_10ck58 = 0 time = 295
.meas tran vdout0_10ck58 FIND v(dout0_10) AT=295.025n

* CHECK dout0_11 Vdout0_11ck58 = 0.9 time = 295
.meas tran vdout0_11ck58 FIND v(dout0_11) AT=295.025n

* CHECK dout0_12 Vdout0_12ck58 = 0 time = 295
.meas tran vdout0_12ck58 FIND v(dout0_12) AT=295.025n

* CHECK dout0_13 Vdout0_13ck58 = 0.9 time = 295
.meas tran vdout0_13ck58 FIND v(dout0_13) AT=295.025n

* CHECK dout0_14 Vdout0_14ck58 = 0 time = 295
.meas tran vdout0_14ck58 FIND v(dout0_14) AT=295.025n

* CHECK dout0_15 Vdout0_15ck58 = 0 time = 295
.meas tran vdout0_15ck58 FIND v(dout0_15) AT=295.025n

* CHECK dout0_16 Vdout0_16ck58 = 0.9 time = 295
.meas tran vdout0_16ck58 FIND v(dout0_16) AT=295.025n

* CHECK dout0_17 Vdout0_17ck58 = 0.9 time = 295
.meas tran vdout0_17ck58 FIND v(dout0_17) AT=295.025n

* CHECK dout0_18 Vdout0_18ck58 = 0 time = 295
.meas tran vdout0_18ck58 FIND v(dout0_18) AT=295.025n

* CHECK dout0_19 Vdout0_19ck58 = 0.9 time = 295
.meas tran vdout0_19ck58 FIND v(dout0_19) AT=295.025n

* CHECK dout0_20 Vdout0_20ck58 = 0 time = 295
.meas tran vdout0_20ck58 FIND v(dout0_20) AT=295.025n

* CHECK dout0_21 Vdout0_21ck58 = 0.9 time = 295
.meas tran vdout0_21ck58 FIND v(dout0_21) AT=295.025n

* CHECK dout0_22 Vdout0_22ck58 = 0 time = 295
.meas tran vdout0_22ck58 FIND v(dout0_22) AT=295.025n

* CHECK dout0_23 Vdout0_23ck58 = 0.9 time = 295
.meas tran vdout0_23ck58 FIND v(dout0_23) AT=295.025n

* CHECK dout0_24 Vdout0_24ck58 = 0.9 time = 295
.meas tran vdout0_24ck58 FIND v(dout0_24) AT=295.025n

* CHECK dout0_25 Vdout0_25ck58 = 0.9 time = 295
.meas tran vdout0_25ck58 FIND v(dout0_25) AT=295.025n

* CHECK dout0_26 Vdout0_26ck58 = 0.9 time = 295
.meas tran vdout0_26ck58 FIND v(dout0_26) AT=295.025n

* CHECK dout0_27 Vdout0_27ck58 = 0.9 time = 295
.meas tran vdout0_27ck58 FIND v(dout0_27) AT=295.025n

* CHECK dout0_28 Vdout0_28ck58 = 0 time = 295
.meas tran vdout0_28ck58 FIND v(dout0_28) AT=295.025n

* CHECK dout0_29 Vdout0_29ck58 = 0 time = 295
.meas tran vdout0_29ck58 FIND v(dout0_29) AT=295.025n

* CHECK dout0_30 Vdout0_30ck58 = 0 time = 295
.meas tran vdout0_30ck58 FIND v(dout0_30) AT=295.025n

* CHECK dout0_31 Vdout0_31ck58 = 0.9 time = 295
.meas tran vdout0_31ck58 FIND v(dout0_31) AT=295.025n

* CHECK dout0_32 Vdout0_32ck58 = 0 time = 295
.meas tran vdout0_32ck58 FIND v(dout0_32) AT=295.025n

* CHECK dout0_33 Vdout0_33ck58 = 0.9 time = 295
.meas tran vdout0_33ck58 FIND v(dout0_33) AT=295.025n

* CHECK dout0_34 Vdout0_34ck58 = 0 time = 295
.meas tran vdout0_34ck58 FIND v(dout0_34) AT=295.025n

* CHECK dout0_35 Vdout0_35ck58 = 0 time = 295
.meas tran vdout0_35ck58 FIND v(dout0_35) AT=295.025n

* CHECK dout0_36 Vdout0_36ck58 = 0.9 time = 295
.meas tran vdout0_36ck58 FIND v(dout0_36) AT=295.025n

* CHECK dout0_37 Vdout0_37ck58 = 0.9 time = 295
.meas tran vdout0_37ck58 FIND v(dout0_37) AT=295.025n

* CHECK dout0_38 Vdout0_38ck58 = 0 time = 295
.meas tran vdout0_38ck58 FIND v(dout0_38) AT=295.025n

* CHECK dout0_39 Vdout0_39ck58 = 0.9 time = 295
.meas tran vdout0_39ck58 FIND v(dout0_39) AT=295.025n

* CHECK dout0_40 Vdout0_40ck58 = 0.9 time = 295
.meas tran vdout0_40ck58 FIND v(dout0_40) AT=295.025n

* CHECK dout0_41 Vdout0_41ck58 = 0 time = 295
.meas tran vdout0_41ck58 FIND v(dout0_41) AT=295.025n

* CHECK dout0_42 Vdout0_42ck58 = 0.9 time = 295
.meas tran vdout0_42ck58 FIND v(dout0_42) AT=295.025n

* CHECK dout0_43 Vdout0_43ck58 = 0 time = 295
.meas tran vdout0_43ck58 FIND v(dout0_43) AT=295.025n

* CHECK dout0_44 Vdout0_44ck58 = 0.9 time = 295
.meas tran vdout0_44ck58 FIND v(dout0_44) AT=295.025n

* CHECK dout0_45 Vdout0_45ck58 = 0 time = 295
.meas tran vdout0_45ck58 FIND v(dout0_45) AT=295.025n

* CHECK dout0_46 Vdout0_46ck58 = 0 time = 295
.meas tran vdout0_46ck58 FIND v(dout0_46) AT=295.025n

* CHECK dout0_47 Vdout0_47ck58 = 0 time = 295
.meas tran vdout0_47ck58 FIND v(dout0_47) AT=295.025n

* CHECK dout0_48 Vdout0_48ck58 = 0 time = 295
.meas tran vdout0_48ck58 FIND v(dout0_48) AT=295.025n

* CHECK dout0_49 Vdout0_49ck58 = 0.9 time = 295
.meas tran vdout0_49ck58 FIND v(dout0_49) AT=295.025n

* CHECK dout0_50 Vdout0_50ck58 = 0 time = 295
.meas tran vdout0_50ck58 FIND v(dout0_50) AT=295.025n

* CHECK dout0_51 Vdout0_51ck58 = 0.9 time = 295
.meas tran vdout0_51ck58 FIND v(dout0_51) AT=295.025n

* CHECK dout0_52 Vdout0_52ck58 = 0.9 time = 295
.meas tran vdout0_52ck58 FIND v(dout0_52) AT=295.025n

* CHECK dout0_53 Vdout0_53ck58 = 0 time = 295
.meas tran vdout0_53ck58 FIND v(dout0_53) AT=295.025n

* CHECK dout0_54 Vdout0_54ck58 = 0.9 time = 295
.meas tran vdout0_54ck58 FIND v(dout0_54) AT=295.025n

* CHECK dout0_55 Vdout0_55ck58 = 0.9 time = 295
.meas tran vdout0_55ck58 FIND v(dout0_55) AT=295.025n

* CHECK dout0_56 Vdout0_56ck58 = 0 time = 295
.meas tran vdout0_56ck58 FIND v(dout0_56) AT=295.025n

* CHECK dout0_57 Vdout0_57ck58 = 0 time = 295
.meas tran vdout0_57ck58 FIND v(dout0_57) AT=295.025n

* CHECK dout0_58 Vdout0_58ck58 = 0.9 time = 295
.meas tran vdout0_58ck58 FIND v(dout0_58) AT=295.025n

* CHECK dout0_59 Vdout0_59ck58 = 0 time = 295
.meas tran vdout0_59ck58 FIND v(dout0_59) AT=295.025n

* CHECK dout0_60 Vdout0_60ck58 = 0.9 time = 295
.meas tran vdout0_60ck58 FIND v(dout0_60) AT=295.025n

* CHECK dout0_61 Vdout0_61ck58 = 0.9 time = 295
.meas tran vdout0_61ck58 FIND v(dout0_61) AT=295.025n

* CHECK dout0_62 Vdout0_62ck58 = 0.9 time = 295
.meas tran vdout0_62ck58 FIND v(dout0_62) AT=295.025n

* CHECK dout0_63 Vdout0_63ck58 = 0 time = 295
.meas tran vdout0_63ck58 FIND v(dout0_63) AT=295.025n

* CHECK dout0_0 Vdout0_0ck61 = 0 time = 310
.meas tran vdout0_0ck61 FIND v(dout0_0) AT=310.025n

* CHECK dout0_1 Vdout0_1ck61 = 0.9 time = 310
.meas tran vdout0_1ck61 FIND v(dout0_1) AT=310.025n

* CHECK dout0_2 Vdout0_2ck61 = 0.9 time = 310
.meas tran vdout0_2ck61 FIND v(dout0_2) AT=310.025n

* CHECK dout0_3 Vdout0_3ck61 = 0.9 time = 310
.meas tran vdout0_3ck61 FIND v(dout0_3) AT=310.025n

* CHECK dout0_4 Vdout0_4ck61 = 0 time = 310
.meas tran vdout0_4ck61 FIND v(dout0_4) AT=310.025n

* CHECK dout0_5 Vdout0_5ck61 = 0.9 time = 310
.meas tran vdout0_5ck61 FIND v(dout0_5) AT=310.025n

* CHECK dout0_6 Vdout0_6ck61 = 0.9 time = 310
.meas tran vdout0_6ck61 FIND v(dout0_6) AT=310.025n

* CHECK dout0_7 Vdout0_7ck61 = 0 time = 310
.meas tran vdout0_7ck61 FIND v(dout0_7) AT=310.025n

* CHECK dout0_8 Vdout0_8ck61 = 0.9 time = 310
.meas tran vdout0_8ck61 FIND v(dout0_8) AT=310.025n

* CHECK dout0_9 Vdout0_9ck61 = 0 time = 310
.meas tran vdout0_9ck61 FIND v(dout0_9) AT=310.025n

* CHECK dout0_10 Vdout0_10ck61 = 0 time = 310
.meas tran vdout0_10ck61 FIND v(dout0_10) AT=310.025n

* CHECK dout0_11 Vdout0_11ck61 = 0.9 time = 310
.meas tran vdout0_11ck61 FIND v(dout0_11) AT=310.025n

* CHECK dout0_12 Vdout0_12ck61 = 0.9 time = 310
.meas tran vdout0_12ck61 FIND v(dout0_12) AT=310.025n

* CHECK dout0_13 Vdout0_13ck61 = 0.9 time = 310
.meas tran vdout0_13ck61 FIND v(dout0_13) AT=310.025n

* CHECK dout0_14 Vdout0_14ck61 = 0.9 time = 310
.meas tran vdout0_14ck61 FIND v(dout0_14) AT=310.025n

* CHECK dout0_15 Vdout0_15ck61 = 0 time = 310
.meas tran vdout0_15ck61 FIND v(dout0_15) AT=310.025n

* CHECK dout0_16 Vdout0_16ck61 = 0.9 time = 310
.meas tran vdout0_16ck61 FIND v(dout0_16) AT=310.025n

* CHECK dout0_17 Vdout0_17ck61 = 0 time = 310
.meas tran vdout0_17ck61 FIND v(dout0_17) AT=310.025n

* CHECK dout0_18 Vdout0_18ck61 = 0 time = 310
.meas tran vdout0_18ck61 FIND v(dout0_18) AT=310.025n

* CHECK dout0_19 Vdout0_19ck61 = 0.9 time = 310
.meas tran vdout0_19ck61 FIND v(dout0_19) AT=310.025n

* CHECK dout0_20 Vdout0_20ck61 = 0.9 time = 310
.meas tran vdout0_20ck61 FIND v(dout0_20) AT=310.025n

* CHECK dout0_21 Vdout0_21ck61 = 0.9 time = 310
.meas tran vdout0_21ck61 FIND v(dout0_21) AT=310.025n

* CHECK dout0_22 Vdout0_22ck61 = 0 time = 310
.meas tran vdout0_22ck61 FIND v(dout0_22) AT=310.025n

* CHECK dout0_23 Vdout0_23ck61 = 0.9 time = 310
.meas tran vdout0_23ck61 FIND v(dout0_23) AT=310.025n

* CHECK dout0_24 Vdout0_24ck61 = 0 time = 310
.meas tran vdout0_24ck61 FIND v(dout0_24) AT=310.025n

* CHECK dout0_25 Vdout0_25ck61 = 0 time = 310
.meas tran vdout0_25ck61 FIND v(dout0_25) AT=310.025n

* CHECK dout0_26 Vdout0_26ck61 = 0 time = 310
.meas tran vdout0_26ck61 FIND v(dout0_26) AT=310.025n

* CHECK dout0_27 Vdout0_27ck61 = 0.9 time = 310
.meas tran vdout0_27ck61 FIND v(dout0_27) AT=310.025n

* CHECK dout0_28 Vdout0_28ck61 = 0.9 time = 310
.meas tran vdout0_28ck61 FIND v(dout0_28) AT=310.025n

* CHECK dout0_29 Vdout0_29ck61 = 0 time = 310
.meas tran vdout0_29ck61 FIND v(dout0_29) AT=310.025n

* CHECK dout0_30 Vdout0_30ck61 = 0.9 time = 310
.meas tran vdout0_30ck61 FIND v(dout0_30) AT=310.025n

* CHECK dout0_31 Vdout0_31ck61 = 0 time = 310
.meas tran vdout0_31ck61 FIND v(dout0_31) AT=310.025n

* CHECK dout0_32 Vdout0_32ck61 = 0.9 time = 310
.meas tran vdout0_32ck61 FIND v(dout0_32) AT=310.025n

* CHECK dout0_33 Vdout0_33ck61 = 0 time = 310
.meas tran vdout0_33ck61 FIND v(dout0_33) AT=310.025n

* CHECK dout0_34 Vdout0_34ck61 = 0 time = 310
.meas tran vdout0_34ck61 FIND v(dout0_34) AT=310.025n

* CHECK dout0_35 Vdout0_35ck61 = 0.9 time = 310
.meas tran vdout0_35ck61 FIND v(dout0_35) AT=310.025n

* CHECK dout0_36 Vdout0_36ck61 = 0.9 time = 310
.meas tran vdout0_36ck61 FIND v(dout0_36) AT=310.025n

* CHECK dout0_37 Vdout0_37ck61 = 0 time = 310
.meas tran vdout0_37ck61 FIND v(dout0_37) AT=310.025n

* CHECK dout0_38 Vdout0_38ck61 = 0.9 time = 310
.meas tran vdout0_38ck61 FIND v(dout0_38) AT=310.025n

* CHECK dout0_39 Vdout0_39ck61 = 0.9 time = 310
.meas tran vdout0_39ck61 FIND v(dout0_39) AT=310.025n

* CHECK dout0_40 Vdout0_40ck61 = 0.9 time = 310
.meas tran vdout0_40ck61 FIND v(dout0_40) AT=310.025n

* CHECK dout0_41 Vdout0_41ck61 = 0.9 time = 310
.meas tran vdout0_41ck61 FIND v(dout0_41) AT=310.025n

* CHECK dout0_42 Vdout0_42ck61 = 0.9 time = 310
.meas tran vdout0_42ck61 FIND v(dout0_42) AT=310.025n

* CHECK dout0_43 Vdout0_43ck61 = 0 time = 310
.meas tran vdout0_43ck61 FIND v(dout0_43) AT=310.025n

* CHECK dout0_44 Vdout0_44ck61 = 0 time = 310
.meas tran vdout0_44ck61 FIND v(dout0_44) AT=310.025n

* CHECK dout0_45 Vdout0_45ck61 = 0 time = 310
.meas tran vdout0_45ck61 FIND v(dout0_45) AT=310.025n

* CHECK dout0_46 Vdout0_46ck61 = 0.9 time = 310
.meas tran vdout0_46ck61 FIND v(dout0_46) AT=310.025n

* CHECK dout0_47 Vdout0_47ck61 = 0.9 time = 310
.meas tran vdout0_47ck61 FIND v(dout0_47) AT=310.025n

* CHECK dout0_48 Vdout0_48ck61 = 0 time = 310
.meas tran vdout0_48ck61 FIND v(dout0_48) AT=310.025n

* CHECK dout0_49 Vdout0_49ck61 = 0.9 time = 310
.meas tran vdout0_49ck61 FIND v(dout0_49) AT=310.025n

* CHECK dout0_50 Vdout0_50ck61 = 0.9 time = 310
.meas tran vdout0_50ck61 FIND v(dout0_50) AT=310.025n

* CHECK dout0_51 Vdout0_51ck61 = 0.9 time = 310
.meas tran vdout0_51ck61 FIND v(dout0_51) AT=310.025n

* CHECK dout0_52 Vdout0_52ck61 = 0 time = 310
.meas tran vdout0_52ck61 FIND v(dout0_52) AT=310.025n

* CHECK dout0_53 Vdout0_53ck61 = 0.9 time = 310
.meas tran vdout0_53ck61 FIND v(dout0_53) AT=310.025n

* CHECK dout0_54 Vdout0_54ck61 = 0 time = 310
.meas tran vdout0_54ck61 FIND v(dout0_54) AT=310.025n

* CHECK dout0_55 Vdout0_55ck61 = 0 time = 310
.meas tran vdout0_55ck61 FIND v(dout0_55) AT=310.025n

* CHECK dout0_56 Vdout0_56ck61 = 0 time = 310
.meas tran vdout0_56ck61 FIND v(dout0_56) AT=310.025n

* CHECK dout0_57 Vdout0_57ck61 = 0 time = 310
.meas tran vdout0_57ck61 FIND v(dout0_57) AT=310.025n

* CHECK dout0_58 Vdout0_58ck61 = 0.9 time = 310
.meas tran vdout0_58ck61 FIND v(dout0_58) AT=310.025n

* CHECK dout0_59 Vdout0_59ck61 = 0 time = 310
.meas tran vdout0_59ck61 FIND v(dout0_59) AT=310.025n

* CHECK dout0_60 Vdout0_60ck61 = 0 time = 310
.meas tran vdout0_60ck61 FIND v(dout0_60) AT=310.025n

* CHECK dout0_61 Vdout0_61ck61 = 0.9 time = 310
.meas tran vdout0_61ck61 FIND v(dout0_61) AT=310.025n

* CHECK dout0_62 Vdout0_62ck61 = 0 time = 310
.meas tran vdout0_62ck61 FIND v(dout0_62) AT=310.025n

* CHECK dout0_63 Vdout0_63ck61 = 0 time = 310
.meas tran vdout0_63ck61 FIND v(dout0_63) AT=310.025n

* CHECK dout0_0 Vdout0_0ck62 = 0 time = 315
.meas tran vdout0_0ck62 FIND v(dout0_0) AT=315.025n

* CHECK dout0_1 Vdout0_1ck62 = 0.9 time = 315
.meas tran vdout0_1ck62 FIND v(dout0_1) AT=315.025n

* CHECK dout0_2 Vdout0_2ck62 = 0.9 time = 315
.meas tran vdout0_2ck62 FIND v(dout0_2) AT=315.025n

* CHECK dout0_3 Vdout0_3ck62 = 0.9 time = 315
.meas tran vdout0_3ck62 FIND v(dout0_3) AT=315.025n

* CHECK dout0_4 Vdout0_4ck62 = 0 time = 315
.meas tran vdout0_4ck62 FIND v(dout0_4) AT=315.025n

* CHECK dout0_5 Vdout0_5ck62 = 0.9 time = 315
.meas tran vdout0_5ck62 FIND v(dout0_5) AT=315.025n

* CHECK dout0_6 Vdout0_6ck62 = 0.9 time = 315
.meas tran vdout0_6ck62 FIND v(dout0_6) AT=315.025n

* CHECK dout0_7 Vdout0_7ck62 = 0 time = 315
.meas tran vdout0_7ck62 FIND v(dout0_7) AT=315.025n

* CHECK dout0_8 Vdout0_8ck62 = 0.9 time = 315
.meas tran vdout0_8ck62 FIND v(dout0_8) AT=315.025n

* CHECK dout0_9 Vdout0_9ck62 = 0 time = 315
.meas tran vdout0_9ck62 FIND v(dout0_9) AT=315.025n

* CHECK dout0_10 Vdout0_10ck62 = 0 time = 315
.meas tran vdout0_10ck62 FIND v(dout0_10) AT=315.025n

* CHECK dout0_11 Vdout0_11ck62 = 0.9 time = 315
.meas tran vdout0_11ck62 FIND v(dout0_11) AT=315.025n

* CHECK dout0_12 Vdout0_12ck62 = 0.9 time = 315
.meas tran vdout0_12ck62 FIND v(dout0_12) AT=315.025n

* CHECK dout0_13 Vdout0_13ck62 = 0.9 time = 315
.meas tran vdout0_13ck62 FIND v(dout0_13) AT=315.025n

* CHECK dout0_14 Vdout0_14ck62 = 0.9 time = 315
.meas tran vdout0_14ck62 FIND v(dout0_14) AT=315.025n

* CHECK dout0_15 Vdout0_15ck62 = 0 time = 315
.meas tran vdout0_15ck62 FIND v(dout0_15) AT=315.025n

* CHECK dout0_16 Vdout0_16ck62 = 0.9 time = 315
.meas tran vdout0_16ck62 FIND v(dout0_16) AT=315.025n

* CHECK dout0_17 Vdout0_17ck62 = 0 time = 315
.meas tran vdout0_17ck62 FIND v(dout0_17) AT=315.025n

* CHECK dout0_18 Vdout0_18ck62 = 0 time = 315
.meas tran vdout0_18ck62 FIND v(dout0_18) AT=315.025n

* CHECK dout0_19 Vdout0_19ck62 = 0.9 time = 315
.meas tran vdout0_19ck62 FIND v(dout0_19) AT=315.025n

* CHECK dout0_20 Vdout0_20ck62 = 0.9 time = 315
.meas tran vdout0_20ck62 FIND v(dout0_20) AT=315.025n

* CHECK dout0_21 Vdout0_21ck62 = 0.9 time = 315
.meas tran vdout0_21ck62 FIND v(dout0_21) AT=315.025n

* CHECK dout0_22 Vdout0_22ck62 = 0 time = 315
.meas tran vdout0_22ck62 FIND v(dout0_22) AT=315.025n

* CHECK dout0_23 Vdout0_23ck62 = 0.9 time = 315
.meas tran vdout0_23ck62 FIND v(dout0_23) AT=315.025n

* CHECK dout0_24 Vdout0_24ck62 = 0 time = 315
.meas tran vdout0_24ck62 FIND v(dout0_24) AT=315.025n

* CHECK dout0_25 Vdout0_25ck62 = 0 time = 315
.meas tran vdout0_25ck62 FIND v(dout0_25) AT=315.025n

* CHECK dout0_26 Vdout0_26ck62 = 0 time = 315
.meas tran vdout0_26ck62 FIND v(dout0_26) AT=315.025n

* CHECK dout0_27 Vdout0_27ck62 = 0.9 time = 315
.meas tran vdout0_27ck62 FIND v(dout0_27) AT=315.025n

* CHECK dout0_28 Vdout0_28ck62 = 0.9 time = 315
.meas tran vdout0_28ck62 FIND v(dout0_28) AT=315.025n

* CHECK dout0_29 Vdout0_29ck62 = 0 time = 315
.meas tran vdout0_29ck62 FIND v(dout0_29) AT=315.025n

* CHECK dout0_30 Vdout0_30ck62 = 0.9 time = 315
.meas tran vdout0_30ck62 FIND v(dout0_30) AT=315.025n

* CHECK dout0_31 Vdout0_31ck62 = 0 time = 315
.meas tran vdout0_31ck62 FIND v(dout0_31) AT=315.025n

* CHECK dout0_32 Vdout0_32ck62 = 0.9 time = 315
.meas tran vdout0_32ck62 FIND v(dout0_32) AT=315.025n

* CHECK dout0_33 Vdout0_33ck62 = 0 time = 315
.meas tran vdout0_33ck62 FIND v(dout0_33) AT=315.025n

* CHECK dout0_34 Vdout0_34ck62 = 0 time = 315
.meas tran vdout0_34ck62 FIND v(dout0_34) AT=315.025n

* CHECK dout0_35 Vdout0_35ck62 = 0.9 time = 315
.meas tran vdout0_35ck62 FIND v(dout0_35) AT=315.025n

* CHECK dout0_36 Vdout0_36ck62 = 0.9 time = 315
.meas tran vdout0_36ck62 FIND v(dout0_36) AT=315.025n

* CHECK dout0_37 Vdout0_37ck62 = 0 time = 315
.meas tran vdout0_37ck62 FIND v(dout0_37) AT=315.025n

* CHECK dout0_38 Vdout0_38ck62 = 0.9 time = 315
.meas tran vdout0_38ck62 FIND v(dout0_38) AT=315.025n

* CHECK dout0_39 Vdout0_39ck62 = 0.9 time = 315
.meas tran vdout0_39ck62 FIND v(dout0_39) AT=315.025n

* CHECK dout0_40 Vdout0_40ck62 = 0.9 time = 315
.meas tran vdout0_40ck62 FIND v(dout0_40) AT=315.025n

* CHECK dout0_41 Vdout0_41ck62 = 0.9 time = 315
.meas tran vdout0_41ck62 FIND v(dout0_41) AT=315.025n

* CHECK dout0_42 Vdout0_42ck62 = 0.9 time = 315
.meas tran vdout0_42ck62 FIND v(dout0_42) AT=315.025n

* CHECK dout0_43 Vdout0_43ck62 = 0 time = 315
.meas tran vdout0_43ck62 FIND v(dout0_43) AT=315.025n

* CHECK dout0_44 Vdout0_44ck62 = 0 time = 315
.meas tran vdout0_44ck62 FIND v(dout0_44) AT=315.025n

* CHECK dout0_45 Vdout0_45ck62 = 0 time = 315
.meas tran vdout0_45ck62 FIND v(dout0_45) AT=315.025n

* CHECK dout0_46 Vdout0_46ck62 = 0.9 time = 315
.meas tran vdout0_46ck62 FIND v(dout0_46) AT=315.025n

* CHECK dout0_47 Vdout0_47ck62 = 0.9 time = 315
.meas tran vdout0_47ck62 FIND v(dout0_47) AT=315.025n

* CHECK dout0_48 Vdout0_48ck62 = 0 time = 315
.meas tran vdout0_48ck62 FIND v(dout0_48) AT=315.025n

* CHECK dout0_49 Vdout0_49ck62 = 0.9 time = 315
.meas tran vdout0_49ck62 FIND v(dout0_49) AT=315.025n

* CHECK dout0_50 Vdout0_50ck62 = 0.9 time = 315
.meas tran vdout0_50ck62 FIND v(dout0_50) AT=315.025n

* CHECK dout0_51 Vdout0_51ck62 = 0.9 time = 315
.meas tran vdout0_51ck62 FIND v(dout0_51) AT=315.025n

* CHECK dout0_52 Vdout0_52ck62 = 0 time = 315
.meas tran vdout0_52ck62 FIND v(dout0_52) AT=315.025n

* CHECK dout0_53 Vdout0_53ck62 = 0.9 time = 315
.meas tran vdout0_53ck62 FIND v(dout0_53) AT=315.025n

* CHECK dout0_54 Vdout0_54ck62 = 0 time = 315
.meas tran vdout0_54ck62 FIND v(dout0_54) AT=315.025n

* CHECK dout0_55 Vdout0_55ck62 = 0 time = 315
.meas tran vdout0_55ck62 FIND v(dout0_55) AT=315.025n

* CHECK dout0_56 Vdout0_56ck62 = 0 time = 315
.meas tran vdout0_56ck62 FIND v(dout0_56) AT=315.025n

* CHECK dout0_57 Vdout0_57ck62 = 0 time = 315
.meas tran vdout0_57ck62 FIND v(dout0_57) AT=315.025n

* CHECK dout0_58 Vdout0_58ck62 = 0.9 time = 315
.meas tran vdout0_58ck62 FIND v(dout0_58) AT=315.025n

* CHECK dout0_59 Vdout0_59ck62 = 0 time = 315
.meas tran vdout0_59ck62 FIND v(dout0_59) AT=315.025n

* CHECK dout0_60 Vdout0_60ck62 = 0 time = 315
.meas tran vdout0_60ck62 FIND v(dout0_60) AT=315.025n

* CHECK dout0_61 Vdout0_61ck62 = 0.9 time = 315
.meas tran vdout0_61ck62 FIND v(dout0_61) AT=315.025n

* CHECK dout0_62 Vdout0_62ck62 = 0 time = 315
.meas tran vdout0_62ck62 FIND v(dout0_62) AT=315.025n

* CHECK dout0_63 Vdout0_63ck62 = 0 time = 315
.meas tran vdout0_63ck62 FIND v(dout0_63) AT=315.025n

* CHECK dout0_0 Vdout0_0ck63 = 0.9 time = 320
.meas tran vdout0_0ck63 FIND v(dout0_0) AT=320.025n

* CHECK dout0_1 Vdout0_1ck63 = 0.9 time = 320
.meas tran vdout0_1ck63 FIND v(dout0_1) AT=320.025n

* CHECK dout0_2 Vdout0_2ck63 = 0 time = 320
.meas tran vdout0_2ck63 FIND v(dout0_2) AT=320.025n

* CHECK dout0_3 Vdout0_3ck63 = 0.9 time = 320
.meas tran vdout0_3ck63 FIND v(dout0_3) AT=320.025n

* CHECK dout0_4 Vdout0_4ck63 = 0.9 time = 320
.meas tran vdout0_4ck63 FIND v(dout0_4) AT=320.025n

* CHECK dout0_5 Vdout0_5ck63 = 0 time = 320
.meas tran vdout0_5ck63 FIND v(dout0_5) AT=320.025n

* CHECK dout0_6 Vdout0_6ck63 = 0.9 time = 320
.meas tran vdout0_6ck63 FIND v(dout0_6) AT=320.025n

* CHECK dout0_7 Vdout0_7ck63 = 0.9 time = 320
.meas tran vdout0_7ck63 FIND v(dout0_7) AT=320.025n

* CHECK dout0_8 Vdout0_8ck63 = 0 time = 320
.meas tran vdout0_8ck63 FIND v(dout0_8) AT=320.025n

* CHECK dout0_9 Vdout0_9ck63 = 0 time = 320
.meas tran vdout0_9ck63 FIND v(dout0_9) AT=320.025n

* CHECK dout0_10 Vdout0_10ck63 = 0 time = 320
.meas tran vdout0_10ck63 FIND v(dout0_10) AT=320.025n

* CHECK dout0_11 Vdout0_11ck63 = 0.9 time = 320
.meas tran vdout0_11ck63 FIND v(dout0_11) AT=320.025n

* CHECK dout0_12 Vdout0_12ck63 = 0 time = 320
.meas tran vdout0_12ck63 FIND v(dout0_12) AT=320.025n

* CHECK dout0_13 Vdout0_13ck63 = 0.9 time = 320
.meas tran vdout0_13ck63 FIND v(dout0_13) AT=320.025n

* CHECK dout0_14 Vdout0_14ck63 = 0 time = 320
.meas tran vdout0_14ck63 FIND v(dout0_14) AT=320.025n

* CHECK dout0_15 Vdout0_15ck63 = 0 time = 320
.meas tran vdout0_15ck63 FIND v(dout0_15) AT=320.025n

* CHECK dout0_16 Vdout0_16ck63 = 0.9 time = 320
.meas tran vdout0_16ck63 FIND v(dout0_16) AT=320.025n

* CHECK dout0_17 Vdout0_17ck63 = 0.9 time = 320
.meas tran vdout0_17ck63 FIND v(dout0_17) AT=320.025n

* CHECK dout0_18 Vdout0_18ck63 = 0 time = 320
.meas tran vdout0_18ck63 FIND v(dout0_18) AT=320.025n

* CHECK dout0_19 Vdout0_19ck63 = 0.9 time = 320
.meas tran vdout0_19ck63 FIND v(dout0_19) AT=320.025n

* CHECK dout0_20 Vdout0_20ck63 = 0 time = 320
.meas tran vdout0_20ck63 FIND v(dout0_20) AT=320.025n

* CHECK dout0_21 Vdout0_21ck63 = 0.9 time = 320
.meas tran vdout0_21ck63 FIND v(dout0_21) AT=320.025n

* CHECK dout0_22 Vdout0_22ck63 = 0 time = 320
.meas tran vdout0_22ck63 FIND v(dout0_22) AT=320.025n

* CHECK dout0_23 Vdout0_23ck63 = 0.9 time = 320
.meas tran vdout0_23ck63 FIND v(dout0_23) AT=320.025n

* CHECK dout0_24 Vdout0_24ck63 = 0.9 time = 320
.meas tran vdout0_24ck63 FIND v(dout0_24) AT=320.025n

* CHECK dout0_25 Vdout0_25ck63 = 0.9 time = 320
.meas tran vdout0_25ck63 FIND v(dout0_25) AT=320.025n

* CHECK dout0_26 Vdout0_26ck63 = 0.9 time = 320
.meas tran vdout0_26ck63 FIND v(dout0_26) AT=320.025n

* CHECK dout0_27 Vdout0_27ck63 = 0.9 time = 320
.meas tran vdout0_27ck63 FIND v(dout0_27) AT=320.025n

* CHECK dout0_28 Vdout0_28ck63 = 0 time = 320
.meas tran vdout0_28ck63 FIND v(dout0_28) AT=320.025n

* CHECK dout0_29 Vdout0_29ck63 = 0 time = 320
.meas tran vdout0_29ck63 FIND v(dout0_29) AT=320.025n

* CHECK dout0_30 Vdout0_30ck63 = 0 time = 320
.meas tran vdout0_30ck63 FIND v(dout0_30) AT=320.025n

* CHECK dout0_31 Vdout0_31ck63 = 0.9 time = 320
.meas tran vdout0_31ck63 FIND v(dout0_31) AT=320.025n

* CHECK dout0_32 Vdout0_32ck63 = 0 time = 320
.meas tran vdout0_32ck63 FIND v(dout0_32) AT=320.025n

* CHECK dout0_33 Vdout0_33ck63 = 0.9 time = 320
.meas tran vdout0_33ck63 FIND v(dout0_33) AT=320.025n

* CHECK dout0_34 Vdout0_34ck63 = 0 time = 320
.meas tran vdout0_34ck63 FIND v(dout0_34) AT=320.025n

* CHECK dout0_35 Vdout0_35ck63 = 0 time = 320
.meas tran vdout0_35ck63 FIND v(dout0_35) AT=320.025n

* CHECK dout0_36 Vdout0_36ck63 = 0.9 time = 320
.meas tran vdout0_36ck63 FIND v(dout0_36) AT=320.025n

* CHECK dout0_37 Vdout0_37ck63 = 0.9 time = 320
.meas tran vdout0_37ck63 FIND v(dout0_37) AT=320.025n

* CHECK dout0_38 Vdout0_38ck63 = 0 time = 320
.meas tran vdout0_38ck63 FIND v(dout0_38) AT=320.025n

* CHECK dout0_39 Vdout0_39ck63 = 0.9 time = 320
.meas tran vdout0_39ck63 FIND v(dout0_39) AT=320.025n

* CHECK dout0_40 Vdout0_40ck63 = 0.9 time = 320
.meas tran vdout0_40ck63 FIND v(dout0_40) AT=320.025n

* CHECK dout0_41 Vdout0_41ck63 = 0 time = 320
.meas tran vdout0_41ck63 FIND v(dout0_41) AT=320.025n

* CHECK dout0_42 Vdout0_42ck63 = 0.9 time = 320
.meas tran vdout0_42ck63 FIND v(dout0_42) AT=320.025n

* CHECK dout0_43 Vdout0_43ck63 = 0 time = 320
.meas tran vdout0_43ck63 FIND v(dout0_43) AT=320.025n

* CHECK dout0_44 Vdout0_44ck63 = 0.9 time = 320
.meas tran vdout0_44ck63 FIND v(dout0_44) AT=320.025n

* CHECK dout0_45 Vdout0_45ck63 = 0 time = 320
.meas tran vdout0_45ck63 FIND v(dout0_45) AT=320.025n

* CHECK dout0_46 Vdout0_46ck63 = 0 time = 320
.meas tran vdout0_46ck63 FIND v(dout0_46) AT=320.025n

* CHECK dout0_47 Vdout0_47ck63 = 0 time = 320
.meas tran vdout0_47ck63 FIND v(dout0_47) AT=320.025n

* CHECK dout0_48 Vdout0_48ck63 = 0 time = 320
.meas tran vdout0_48ck63 FIND v(dout0_48) AT=320.025n

* CHECK dout0_49 Vdout0_49ck63 = 0.9 time = 320
.meas tran vdout0_49ck63 FIND v(dout0_49) AT=320.025n

* CHECK dout0_50 Vdout0_50ck63 = 0 time = 320
.meas tran vdout0_50ck63 FIND v(dout0_50) AT=320.025n

* CHECK dout0_51 Vdout0_51ck63 = 0.9 time = 320
.meas tran vdout0_51ck63 FIND v(dout0_51) AT=320.025n

* CHECK dout0_52 Vdout0_52ck63 = 0.9 time = 320
.meas tran vdout0_52ck63 FIND v(dout0_52) AT=320.025n

* CHECK dout0_53 Vdout0_53ck63 = 0 time = 320
.meas tran vdout0_53ck63 FIND v(dout0_53) AT=320.025n

* CHECK dout0_54 Vdout0_54ck63 = 0.9 time = 320
.meas tran vdout0_54ck63 FIND v(dout0_54) AT=320.025n

* CHECK dout0_55 Vdout0_55ck63 = 0.9 time = 320
.meas tran vdout0_55ck63 FIND v(dout0_55) AT=320.025n

* CHECK dout0_56 Vdout0_56ck63 = 0 time = 320
.meas tran vdout0_56ck63 FIND v(dout0_56) AT=320.025n

* CHECK dout0_57 Vdout0_57ck63 = 0 time = 320
.meas tran vdout0_57ck63 FIND v(dout0_57) AT=320.025n

* CHECK dout0_58 Vdout0_58ck63 = 0.9 time = 320
.meas tran vdout0_58ck63 FIND v(dout0_58) AT=320.025n

* CHECK dout0_59 Vdout0_59ck63 = 0 time = 320
.meas tran vdout0_59ck63 FIND v(dout0_59) AT=320.025n

* CHECK dout0_60 Vdout0_60ck63 = 0.9 time = 320
.meas tran vdout0_60ck63 FIND v(dout0_60) AT=320.025n

* CHECK dout0_61 Vdout0_61ck63 = 0.9 time = 320
.meas tran vdout0_61ck63 FIND v(dout0_61) AT=320.025n

* CHECK dout0_62 Vdout0_62ck63 = 0.9 time = 320
.meas tran vdout0_62ck63 FIND v(dout0_62) AT=320.025n

* CHECK dout0_63 Vdout0_63ck63 = 0 time = 320
.meas tran vdout0_63ck63 FIND v(dout0_63) AT=320.025n

* CHECK dout0_0 Vdout0_0ck65 = 0 time = 330
.meas tran vdout0_0ck65 FIND v(dout0_0) AT=330.025n

* CHECK dout0_1 Vdout0_1ck65 = 0.9 time = 330
.meas tran vdout0_1ck65 FIND v(dout0_1) AT=330.025n

* CHECK dout0_2 Vdout0_2ck65 = 0 time = 330
.meas tran vdout0_2ck65 FIND v(dout0_2) AT=330.025n

* CHECK dout0_3 Vdout0_3ck65 = 0.9 time = 330
.meas tran vdout0_3ck65 FIND v(dout0_3) AT=330.025n

* CHECK dout0_4 Vdout0_4ck65 = 0 time = 330
.meas tran vdout0_4ck65 FIND v(dout0_4) AT=330.025n

* CHECK dout0_5 Vdout0_5ck65 = 0.9 time = 330
.meas tran vdout0_5ck65 FIND v(dout0_5) AT=330.025n

* CHECK dout0_6 Vdout0_6ck65 = 0.9 time = 330
.meas tran vdout0_6ck65 FIND v(dout0_6) AT=330.025n

* CHECK dout0_7 Vdout0_7ck65 = 0.9 time = 330
.meas tran vdout0_7ck65 FIND v(dout0_7) AT=330.025n

* CHECK dout0_8 Vdout0_8ck65 = 0 time = 330
.meas tran vdout0_8ck65 FIND v(dout0_8) AT=330.025n

* CHECK dout0_9 Vdout0_9ck65 = 0.9 time = 330
.meas tran vdout0_9ck65 FIND v(dout0_9) AT=330.025n

* CHECK dout0_10 Vdout0_10ck65 = 0.9 time = 330
.meas tran vdout0_10ck65 FIND v(dout0_10) AT=330.025n

* CHECK dout0_11 Vdout0_11ck65 = 0 time = 330
.meas tran vdout0_11ck65 FIND v(dout0_11) AT=330.025n

* CHECK dout0_12 Vdout0_12ck65 = 0.9 time = 330
.meas tran vdout0_12ck65 FIND v(dout0_12) AT=330.025n

* CHECK dout0_13 Vdout0_13ck65 = 0 time = 330
.meas tran vdout0_13ck65 FIND v(dout0_13) AT=330.025n

* CHECK dout0_14 Vdout0_14ck65 = 0 time = 330
.meas tran vdout0_14ck65 FIND v(dout0_14) AT=330.025n

* CHECK dout0_15 Vdout0_15ck65 = 0 time = 330
.meas tran vdout0_15ck65 FIND v(dout0_15) AT=330.025n

* CHECK dout0_16 Vdout0_16ck65 = 0 time = 330
.meas tran vdout0_16ck65 FIND v(dout0_16) AT=330.025n

* CHECK dout0_17 Vdout0_17ck65 = 0 time = 330
.meas tran vdout0_17ck65 FIND v(dout0_17) AT=330.025n

* CHECK dout0_18 Vdout0_18ck65 = 0.9 time = 330
.meas tran vdout0_18ck65 FIND v(dout0_18) AT=330.025n

* CHECK dout0_19 Vdout0_19ck65 = 0.9 time = 330
.meas tran vdout0_19ck65 FIND v(dout0_19) AT=330.025n

* CHECK dout0_20 Vdout0_20ck65 = 0.9 time = 330
.meas tran vdout0_20ck65 FIND v(dout0_20) AT=330.025n

* CHECK dout0_21 Vdout0_21ck65 = 0.9 time = 330
.meas tran vdout0_21ck65 FIND v(dout0_21) AT=330.025n

* CHECK dout0_22 Vdout0_22ck65 = 0.9 time = 330
.meas tran vdout0_22ck65 FIND v(dout0_22) AT=330.025n

* CHECK dout0_23 Vdout0_23ck65 = 0 time = 330
.meas tran vdout0_23ck65 FIND v(dout0_23) AT=330.025n

* CHECK dout0_24 Vdout0_24ck65 = 0 time = 330
.meas tran vdout0_24ck65 FIND v(dout0_24) AT=330.025n

* CHECK dout0_25 Vdout0_25ck65 = 0.9 time = 330
.meas tran vdout0_25ck65 FIND v(dout0_25) AT=330.025n

* CHECK dout0_26 Vdout0_26ck65 = 0.9 time = 330
.meas tran vdout0_26ck65 FIND v(dout0_26) AT=330.025n

* CHECK dout0_27 Vdout0_27ck65 = 0.9 time = 330
.meas tran vdout0_27ck65 FIND v(dout0_27) AT=330.025n

* CHECK dout0_28 Vdout0_28ck65 = 0 time = 330
.meas tran vdout0_28ck65 FIND v(dout0_28) AT=330.025n

* CHECK dout0_29 Vdout0_29ck65 = 0.9 time = 330
.meas tran vdout0_29ck65 FIND v(dout0_29) AT=330.025n

* CHECK dout0_30 Vdout0_30ck65 = 0.9 time = 330
.meas tran vdout0_30ck65 FIND v(dout0_30) AT=330.025n

* CHECK dout0_31 Vdout0_31ck65 = 0.9 time = 330
.meas tran vdout0_31ck65 FIND v(dout0_31) AT=330.025n

* CHECK dout0_32 Vdout0_32ck65 = 0.9 time = 330
.meas tran vdout0_32ck65 FIND v(dout0_32) AT=330.025n

* CHECK dout0_33 Vdout0_33ck65 = 0.9 time = 330
.meas tran vdout0_33ck65 FIND v(dout0_33) AT=330.025n

* CHECK dout0_34 Vdout0_34ck65 = 0 time = 330
.meas tran vdout0_34ck65 FIND v(dout0_34) AT=330.025n

* CHECK dout0_35 Vdout0_35ck65 = 0 time = 330
.meas tran vdout0_35ck65 FIND v(dout0_35) AT=330.025n

* CHECK dout0_36 Vdout0_36ck65 = 0 time = 330
.meas tran vdout0_36ck65 FIND v(dout0_36) AT=330.025n

* CHECK dout0_37 Vdout0_37ck65 = 0 time = 330
.meas tran vdout0_37ck65 FIND v(dout0_37) AT=330.025n

* CHECK dout0_38 Vdout0_38ck65 = 0.9 time = 330
.meas tran vdout0_38ck65 FIND v(dout0_38) AT=330.025n

* CHECK dout0_39 Vdout0_39ck65 = 0.9 time = 330
.meas tran vdout0_39ck65 FIND v(dout0_39) AT=330.025n

* CHECK dout0_40 Vdout0_40ck65 = 0 time = 330
.meas tran vdout0_40ck65 FIND v(dout0_40) AT=330.025n

* CHECK dout0_41 Vdout0_41ck65 = 0.9 time = 330
.meas tran vdout0_41ck65 FIND v(dout0_41) AT=330.025n

* CHECK dout0_42 Vdout0_42ck65 = 0 time = 330
.meas tran vdout0_42ck65 FIND v(dout0_42) AT=330.025n

* CHECK dout0_43 Vdout0_43ck65 = 0 time = 330
.meas tran vdout0_43ck65 FIND v(dout0_43) AT=330.025n

* CHECK dout0_44 Vdout0_44ck65 = 0.9 time = 330
.meas tran vdout0_44ck65 FIND v(dout0_44) AT=330.025n

* CHECK dout0_45 Vdout0_45ck65 = 0.9 time = 330
.meas tran vdout0_45ck65 FIND v(dout0_45) AT=330.025n

* CHECK dout0_46 Vdout0_46ck65 = 0.9 time = 330
.meas tran vdout0_46ck65 FIND v(dout0_46) AT=330.025n

* CHECK dout0_47 Vdout0_47ck65 = 0.9 time = 330
.meas tran vdout0_47ck65 FIND v(dout0_47) AT=330.025n

* CHECK dout0_48 Vdout0_48ck65 = 0 time = 330
.meas tran vdout0_48ck65 FIND v(dout0_48) AT=330.025n

* CHECK dout0_49 Vdout0_49ck65 = 0 time = 330
.meas tran vdout0_49ck65 FIND v(dout0_49) AT=330.025n

* CHECK dout0_50 Vdout0_50ck65 = 0.9 time = 330
.meas tran vdout0_50ck65 FIND v(dout0_50) AT=330.025n

* CHECK dout0_51 Vdout0_51ck65 = 0.9 time = 330
.meas tran vdout0_51ck65 FIND v(dout0_51) AT=330.025n

* CHECK dout0_52 Vdout0_52ck65 = 0.9 time = 330
.meas tran vdout0_52ck65 FIND v(dout0_52) AT=330.025n

* CHECK dout0_53 Vdout0_53ck65 = 0.9 time = 330
.meas tran vdout0_53ck65 FIND v(dout0_53) AT=330.025n

* CHECK dout0_54 Vdout0_54ck65 = 0.9 time = 330
.meas tran vdout0_54ck65 FIND v(dout0_54) AT=330.025n

* CHECK dout0_55 Vdout0_55ck65 = 0 time = 330
.meas tran vdout0_55ck65 FIND v(dout0_55) AT=330.025n

* CHECK dout0_56 Vdout0_56ck65 = 0.9 time = 330
.meas tran vdout0_56ck65 FIND v(dout0_56) AT=330.025n

* CHECK dout0_57 Vdout0_57ck65 = 0.9 time = 330
.meas tran vdout0_57ck65 FIND v(dout0_57) AT=330.025n

* CHECK dout0_58 Vdout0_58ck65 = 0 time = 330
.meas tran vdout0_58ck65 FIND v(dout0_58) AT=330.025n

* CHECK dout0_59 Vdout0_59ck65 = 0.9 time = 330
.meas tran vdout0_59ck65 FIND v(dout0_59) AT=330.025n

* CHECK dout0_60 Vdout0_60ck65 = 0 time = 330
.meas tran vdout0_60ck65 FIND v(dout0_60) AT=330.025n

* CHECK dout0_61 Vdout0_61ck65 = 0 time = 330
.meas tran vdout0_61ck65 FIND v(dout0_61) AT=330.025n

* CHECK dout0_62 Vdout0_62ck65 = 0 time = 330
.meas tran vdout0_62ck65 FIND v(dout0_62) AT=330.025n

* CHECK dout0_63 Vdout0_63ck65 = 0 time = 330
.meas tran vdout0_63ck65 FIND v(dout0_63) AT=330.025n

* CHECK dout0_0 Vdout0_0ck70 = 0 time = 355
.meas tran vdout0_0ck70 FIND v(dout0_0) AT=355.025n

* CHECK dout0_1 Vdout0_1ck70 = 0.9 time = 355
.meas tran vdout0_1ck70 FIND v(dout0_1) AT=355.025n

* CHECK dout0_2 Vdout0_2ck70 = 0 time = 355
.meas tran vdout0_2ck70 FIND v(dout0_2) AT=355.025n

* CHECK dout0_3 Vdout0_3ck70 = 0.9 time = 355
.meas tran vdout0_3ck70 FIND v(dout0_3) AT=355.025n

* CHECK dout0_4 Vdout0_4ck70 = 0 time = 355
.meas tran vdout0_4ck70 FIND v(dout0_4) AT=355.025n

* CHECK dout0_5 Vdout0_5ck70 = 0.9 time = 355
.meas tran vdout0_5ck70 FIND v(dout0_5) AT=355.025n

* CHECK dout0_6 Vdout0_6ck70 = 0.9 time = 355
.meas tran vdout0_6ck70 FIND v(dout0_6) AT=355.025n

* CHECK dout0_7 Vdout0_7ck70 = 0.9 time = 355
.meas tran vdout0_7ck70 FIND v(dout0_7) AT=355.025n

* CHECK dout0_8 Vdout0_8ck70 = 0 time = 355
.meas tran vdout0_8ck70 FIND v(dout0_8) AT=355.025n

* CHECK dout0_9 Vdout0_9ck70 = 0.9 time = 355
.meas tran vdout0_9ck70 FIND v(dout0_9) AT=355.025n

* CHECK dout0_10 Vdout0_10ck70 = 0.9 time = 355
.meas tran vdout0_10ck70 FIND v(dout0_10) AT=355.025n

* CHECK dout0_11 Vdout0_11ck70 = 0 time = 355
.meas tran vdout0_11ck70 FIND v(dout0_11) AT=355.025n

* CHECK dout0_12 Vdout0_12ck70 = 0.9 time = 355
.meas tran vdout0_12ck70 FIND v(dout0_12) AT=355.025n

* CHECK dout0_13 Vdout0_13ck70 = 0 time = 355
.meas tran vdout0_13ck70 FIND v(dout0_13) AT=355.025n

* CHECK dout0_14 Vdout0_14ck70 = 0 time = 355
.meas tran vdout0_14ck70 FIND v(dout0_14) AT=355.025n

* CHECK dout0_15 Vdout0_15ck70 = 0 time = 355
.meas tran vdout0_15ck70 FIND v(dout0_15) AT=355.025n

* CHECK dout0_16 Vdout0_16ck70 = 0 time = 355
.meas tran vdout0_16ck70 FIND v(dout0_16) AT=355.025n

* CHECK dout0_17 Vdout0_17ck70 = 0 time = 355
.meas tran vdout0_17ck70 FIND v(dout0_17) AT=355.025n

* CHECK dout0_18 Vdout0_18ck70 = 0.9 time = 355
.meas tran vdout0_18ck70 FIND v(dout0_18) AT=355.025n

* CHECK dout0_19 Vdout0_19ck70 = 0.9 time = 355
.meas tran vdout0_19ck70 FIND v(dout0_19) AT=355.025n

* CHECK dout0_20 Vdout0_20ck70 = 0.9 time = 355
.meas tran vdout0_20ck70 FIND v(dout0_20) AT=355.025n

* CHECK dout0_21 Vdout0_21ck70 = 0.9 time = 355
.meas tran vdout0_21ck70 FIND v(dout0_21) AT=355.025n

* CHECK dout0_22 Vdout0_22ck70 = 0.9 time = 355
.meas tran vdout0_22ck70 FIND v(dout0_22) AT=355.025n

* CHECK dout0_23 Vdout0_23ck70 = 0 time = 355
.meas tran vdout0_23ck70 FIND v(dout0_23) AT=355.025n

* CHECK dout0_24 Vdout0_24ck70 = 0 time = 355
.meas tran vdout0_24ck70 FIND v(dout0_24) AT=355.025n

* CHECK dout0_25 Vdout0_25ck70 = 0.9 time = 355
.meas tran vdout0_25ck70 FIND v(dout0_25) AT=355.025n

* CHECK dout0_26 Vdout0_26ck70 = 0.9 time = 355
.meas tran vdout0_26ck70 FIND v(dout0_26) AT=355.025n

* CHECK dout0_27 Vdout0_27ck70 = 0.9 time = 355
.meas tran vdout0_27ck70 FIND v(dout0_27) AT=355.025n

* CHECK dout0_28 Vdout0_28ck70 = 0 time = 355
.meas tran vdout0_28ck70 FIND v(dout0_28) AT=355.025n

* CHECK dout0_29 Vdout0_29ck70 = 0.9 time = 355
.meas tran vdout0_29ck70 FIND v(dout0_29) AT=355.025n

* CHECK dout0_30 Vdout0_30ck70 = 0.9 time = 355
.meas tran vdout0_30ck70 FIND v(dout0_30) AT=355.025n

* CHECK dout0_31 Vdout0_31ck70 = 0.9 time = 355
.meas tran vdout0_31ck70 FIND v(dout0_31) AT=355.025n

* CHECK dout0_32 Vdout0_32ck70 = 0.9 time = 355
.meas tran vdout0_32ck70 FIND v(dout0_32) AT=355.025n

* CHECK dout0_33 Vdout0_33ck70 = 0.9 time = 355
.meas tran vdout0_33ck70 FIND v(dout0_33) AT=355.025n

* CHECK dout0_34 Vdout0_34ck70 = 0 time = 355
.meas tran vdout0_34ck70 FIND v(dout0_34) AT=355.025n

* CHECK dout0_35 Vdout0_35ck70 = 0 time = 355
.meas tran vdout0_35ck70 FIND v(dout0_35) AT=355.025n

* CHECK dout0_36 Vdout0_36ck70 = 0 time = 355
.meas tran vdout0_36ck70 FIND v(dout0_36) AT=355.025n

* CHECK dout0_37 Vdout0_37ck70 = 0 time = 355
.meas tran vdout0_37ck70 FIND v(dout0_37) AT=355.025n

* CHECK dout0_38 Vdout0_38ck70 = 0.9 time = 355
.meas tran vdout0_38ck70 FIND v(dout0_38) AT=355.025n

* CHECK dout0_39 Vdout0_39ck70 = 0.9 time = 355
.meas tran vdout0_39ck70 FIND v(dout0_39) AT=355.025n

* CHECK dout0_40 Vdout0_40ck70 = 0 time = 355
.meas tran vdout0_40ck70 FIND v(dout0_40) AT=355.025n

* CHECK dout0_41 Vdout0_41ck70 = 0.9 time = 355
.meas tran vdout0_41ck70 FIND v(dout0_41) AT=355.025n

* CHECK dout0_42 Vdout0_42ck70 = 0 time = 355
.meas tran vdout0_42ck70 FIND v(dout0_42) AT=355.025n

* CHECK dout0_43 Vdout0_43ck70 = 0 time = 355
.meas tran vdout0_43ck70 FIND v(dout0_43) AT=355.025n

* CHECK dout0_44 Vdout0_44ck70 = 0.9 time = 355
.meas tran vdout0_44ck70 FIND v(dout0_44) AT=355.025n

* CHECK dout0_45 Vdout0_45ck70 = 0.9 time = 355
.meas tran vdout0_45ck70 FIND v(dout0_45) AT=355.025n

* CHECK dout0_46 Vdout0_46ck70 = 0.9 time = 355
.meas tran vdout0_46ck70 FIND v(dout0_46) AT=355.025n

* CHECK dout0_47 Vdout0_47ck70 = 0.9 time = 355
.meas tran vdout0_47ck70 FIND v(dout0_47) AT=355.025n

* CHECK dout0_48 Vdout0_48ck70 = 0 time = 355
.meas tran vdout0_48ck70 FIND v(dout0_48) AT=355.025n

* CHECK dout0_49 Vdout0_49ck70 = 0 time = 355
.meas tran vdout0_49ck70 FIND v(dout0_49) AT=355.025n

* CHECK dout0_50 Vdout0_50ck70 = 0.9 time = 355
.meas tran vdout0_50ck70 FIND v(dout0_50) AT=355.025n

* CHECK dout0_51 Vdout0_51ck70 = 0.9 time = 355
.meas tran vdout0_51ck70 FIND v(dout0_51) AT=355.025n

* CHECK dout0_52 Vdout0_52ck70 = 0.9 time = 355
.meas tran vdout0_52ck70 FIND v(dout0_52) AT=355.025n

* CHECK dout0_53 Vdout0_53ck70 = 0.9 time = 355
.meas tran vdout0_53ck70 FIND v(dout0_53) AT=355.025n

* CHECK dout0_54 Vdout0_54ck70 = 0.9 time = 355
.meas tran vdout0_54ck70 FIND v(dout0_54) AT=355.025n

* CHECK dout0_55 Vdout0_55ck70 = 0 time = 355
.meas tran vdout0_55ck70 FIND v(dout0_55) AT=355.025n

* CHECK dout0_56 Vdout0_56ck70 = 0.9 time = 355
.meas tran vdout0_56ck70 FIND v(dout0_56) AT=355.025n

* CHECK dout0_57 Vdout0_57ck70 = 0.9 time = 355
.meas tran vdout0_57ck70 FIND v(dout0_57) AT=355.025n

* CHECK dout0_58 Vdout0_58ck70 = 0 time = 355
.meas tran vdout0_58ck70 FIND v(dout0_58) AT=355.025n

* CHECK dout0_59 Vdout0_59ck70 = 0.9 time = 355
.meas tran vdout0_59ck70 FIND v(dout0_59) AT=355.025n

* CHECK dout0_60 Vdout0_60ck70 = 0 time = 355
.meas tran vdout0_60ck70 FIND v(dout0_60) AT=355.025n

* CHECK dout0_61 Vdout0_61ck70 = 0 time = 355
.meas tran vdout0_61ck70 FIND v(dout0_61) AT=355.025n

* CHECK dout0_62 Vdout0_62ck70 = 0 time = 355
.meas tran vdout0_62ck70 FIND v(dout0_62) AT=355.025n

* CHECK dout0_63 Vdout0_63ck70 = 0 time = 355
.meas tran vdout0_63ck70 FIND v(dout0_63) AT=355.025n

* CHECK dout0_0 Vdout0_0ck71 = 0 time = 360
.meas tran vdout0_0ck71 FIND v(dout0_0) AT=360.025n

* CHECK dout0_1 Vdout0_1ck71 = 0.9 time = 360
.meas tran vdout0_1ck71 FIND v(dout0_1) AT=360.025n

* CHECK dout0_2 Vdout0_2ck71 = 0.9 time = 360
.meas tran vdout0_2ck71 FIND v(dout0_2) AT=360.025n

* CHECK dout0_3 Vdout0_3ck71 = 0 time = 360
.meas tran vdout0_3ck71 FIND v(dout0_3) AT=360.025n

* CHECK dout0_4 Vdout0_4ck71 = 0.9 time = 360
.meas tran vdout0_4ck71 FIND v(dout0_4) AT=360.025n

* CHECK dout0_5 Vdout0_5ck71 = 0.9 time = 360
.meas tran vdout0_5ck71 FIND v(dout0_5) AT=360.025n

* CHECK dout0_6 Vdout0_6ck71 = 0.9 time = 360
.meas tran vdout0_6ck71 FIND v(dout0_6) AT=360.025n

* CHECK dout0_7 Vdout0_7ck71 = 0 time = 360
.meas tran vdout0_7ck71 FIND v(dout0_7) AT=360.025n

* CHECK dout0_8 Vdout0_8ck71 = 0.9 time = 360
.meas tran vdout0_8ck71 FIND v(dout0_8) AT=360.025n

* CHECK dout0_9 Vdout0_9ck71 = 0.9 time = 360
.meas tran vdout0_9ck71 FIND v(dout0_9) AT=360.025n

* CHECK dout0_10 Vdout0_10ck71 = 0 time = 360
.meas tran vdout0_10ck71 FIND v(dout0_10) AT=360.025n

* CHECK dout0_11 Vdout0_11ck71 = 0.9 time = 360
.meas tran vdout0_11ck71 FIND v(dout0_11) AT=360.025n

* CHECK dout0_12 Vdout0_12ck71 = 0.9 time = 360
.meas tran vdout0_12ck71 FIND v(dout0_12) AT=360.025n

* CHECK dout0_13 Vdout0_13ck71 = 0.9 time = 360
.meas tran vdout0_13ck71 FIND v(dout0_13) AT=360.025n

* CHECK dout0_14 Vdout0_14ck71 = 0 time = 360
.meas tran vdout0_14ck71 FIND v(dout0_14) AT=360.025n

* CHECK dout0_15 Vdout0_15ck71 = 0.9 time = 360
.meas tran vdout0_15ck71 FIND v(dout0_15) AT=360.025n

* CHECK dout0_16 Vdout0_16ck71 = 0 time = 360
.meas tran vdout0_16ck71 FIND v(dout0_16) AT=360.025n

* CHECK dout0_17 Vdout0_17ck71 = 0 time = 360
.meas tran vdout0_17ck71 FIND v(dout0_17) AT=360.025n

* CHECK dout0_18 Vdout0_18ck71 = 0 time = 360
.meas tran vdout0_18ck71 FIND v(dout0_18) AT=360.025n

* CHECK dout0_19 Vdout0_19ck71 = 0 time = 360
.meas tran vdout0_19ck71 FIND v(dout0_19) AT=360.025n

* CHECK dout0_20 Vdout0_20ck71 = 0.9 time = 360
.meas tran vdout0_20ck71 FIND v(dout0_20) AT=360.025n

* CHECK dout0_21 Vdout0_21ck71 = 0.9 time = 360
.meas tran vdout0_21ck71 FIND v(dout0_21) AT=360.025n

* CHECK dout0_22 Vdout0_22ck71 = 0 time = 360
.meas tran vdout0_22ck71 FIND v(dout0_22) AT=360.025n

* CHECK dout0_23 Vdout0_23ck71 = 0.9 time = 360
.meas tran vdout0_23ck71 FIND v(dout0_23) AT=360.025n

* CHECK dout0_24 Vdout0_24ck71 = 0.9 time = 360
.meas tran vdout0_24ck71 FIND v(dout0_24) AT=360.025n

* CHECK dout0_25 Vdout0_25ck71 = 0.9 time = 360
.meas tran vdout0_25ck71 FIND v(dout0_25) AT=360.025n

* CHECK dout0_26 Vdout0_26ck71 = 0.9 time = 360
.meas tran vdout0_26ck71 FIND v(dout0_26) AT=360.025n

* CHECK dout0_27 Vdout0_27ck71 = 0.9 time = 360
.meas tran vdout0_27ck71 FIND v(dout0_27) AT=360.025n

* CHECK dout0_28 Vdout0_28ck71 = 0 time = 360
.meas tran vdout0_28ck71 FIND v(dout0_28) AT=360.025n

* CHECK dout0_29 Vdout0_29ck71 = 0.9 time = 360
.meas tran vdout0_29ck71 FIND v(dout0_29) AT=360.025n

* CHECK dout0_30 Vdout0_30ck71 = 0.9 time = 360
.meas tran vdout0_30ck71 FIND v(dout0_30) AT=360.025n

* CHECK dout0_31 Vdout0_31ck71 = 0 time = 360
.meas tran vdout0_31ck71 FIND v(dout0_31) AT=360.025n

* CHECK dout0_32 Vdout0_32ck71 = 0 time = 360
.meas tran vdout0_32ck71 FIND v(dout0_32) AT=360.025n

* CHECK dout0_33 Vdout0_33ck71 = 0 time = 360
.meas tran vdout0_33ck71 FIND v(dout0_33) AT=360.025n

* CHECK dout0_34 Vdout0_34ck71 = 0.9 time = 360
.meas tran vdout0_34ck71 FIND v(dout0_34) AT=360.025n

* CHECK dout0_35 Vdout0_35ck71 = 0 time = 360
.meas tran vdout0_35ck71 FIND v(dout0_35) AT=360.025n

* CHECK dout0_36 Vdout0_36ck71 = 0.9 time = 360
.meas tran vdout0_36ck71 FIND v(dout0_36) AT=360.025n

* CHECK dout0_37 Vdout0_37ck71 = 0 time = 360
.meas tran vdout0_37ck71 FIND v(dout0_37) AT=360.025n

* CHECK dout0_38 Vdout0_38ck71 = 0 time = 360
.meas tran vdout0_38ck71 FIND v(dout0_38) AT=360.025n

* CHECK dout0_39 Vdout0_39ck71 = 0 time = 360
.meas tran vdout0_39ck71 FIND v(dout0_39) AT=360.025n

* CHECK dout0_40 Vdout0_40ck71 = 0 time = 360
.meas tran vdout0_40ck71 FIND v(dout0_40) AT=360.025n

* CHECK dout0_41 Vdout0_41ck71 = 0.9 time = 360
.meas tran vdout0_41ck71 FIND v(dout0_41) AT=360.025n

* CHECK dout0_42 Vdout0_42ck71 = 0.9 time = 360
.meas tran vdout0_42ck71 FIND v(dout0_42) AT=360.025n

* CHECK dout0_43 Vdout0_43ck71 = 0.9 time = 360
.meas tran vdout0_43ck71 FIND v(dout0_43) AT=360.025n

* CHECK dout0_44 Vdout0_44ck71 = 0 time = 360
.meas tran vdout0_44ck71 FIND v(dout0_44) AT=360.025n

* CHECK dout0_45 Vdout0_45ck71 = 0 time = 360
.meas tran vdout0_45ck71 FIND v(dout0_45) AT=360.025n

* CHECK dout0_46 Vdout0_46ck71 = 0.9 time = 360
.meas tran vdout0_46ck71 FIND v(dout0_46) AT=360.025n

* CHECK dout0_47 Vdout0_47ck71 = 0.9 time = 360
.meas tran vdout0_47ck71 FIND v(dout0_47) AT=360.025n

* CHECK dout0_48 Vdout0_48ck71 = 0 time = 360
.meas tran vdout0_48ck71 FIND v(dout0_48) AT=360.025n

* CHECK dout0_49 Vdout0_49ck71 = 0 time = 360
.meas tran vdout0_49ck71 FIND v(dout0_49) AT=360.025n

* CHECK dout0_50 Vdout0_50ck71 = 0 time = 360
.meas tran vdout0_50ck71 FIND v(dout0_50) AT=360.025n

* CHECK dout0_51 Vdout0_51ck71 = 0.9 time = 360
.meas tran vdout0_51ck71 FIND v(dout0_51) AT=360.025n

* CHECK dout0_52 Vdout0_52ck71 = 0.9 time = 360
.meas tran vdout0_52ck71 FIND v(dout0_52) AT=360.025n

* CHECK dout0_53 Vdout0_53ck71 = 0.9 time = 360
.meas tran vdout0_53ck71 FIND v(dout0_53) AT=360.025n

* CHECK dout0_54 Vdout0_54ck71 = 0 time = 360
.meas tran vdout0_54ck71 FIND v(dout0_54) AT=360.025n

* CHECK dout0_55 Vdout0_55ck71 = 0.9 time = 360
.meas tran vdout0_55ck71 FIND v(dout0_55) AT=360.025n

* CHECK dout0_56 Vdout0_56ck71 = 0.9 time = 360
.meas tran vdout0_56ck71 FIND v(dout0_56) AT=360.025n

* CHECK dout0_57 Vdout0_57ck71 = 0.9 time = 360
.meas tran vdout0_57ck71 FIND v(dout0_57) AT=360.025n

* CHECK dout0_58 Vdout0_58ck71 = 0 time = 360
.meas tran vdout0_58ck71 FIND v(dout0_58) AT=360.025n

* CHECK dout0_59 Vdout0_59ck71 = 0.9 time = 360
.meas tran vdout0_59ck71 FIND v(dout0_59) AT=360.025n

* CHECK dout0_60 Vdout0_60ck71 = 0.9 time = 360
.meas tran vdout0_60ck71 FIND v(dout0_60) AT=360.025n

* CHECK dout0_61 Vdout0_61ck71 = 0.9 time = 360
.meas tran vdout0_61ck71 FIND v(dout0_61) AT=360.025n

* CHECK dout0_62 Vdout0_62ck71 = 0 time = 360
.meas tran vdout0_62ck71 FIND v(dout0_62) AT=360.025n

* CHECK dout0_63 Vdout0_63ck71 = 0 time = 360
.meas tran vdout0_63ck71 FIND v(dout0_63) AT=360.025n

* CHECK dout0_0 Vdout0_0ck73 = 0.9 time = 370
.meas tran vdout0_0ck73 FIND v(dout0_0) AT=370.025n

* CHECK dout0_1 Vdout0_1ck73 = 0.9 time = 370
.meas tran vdout0_1ck73 FIND v(dout0_1) AT=370.025n

* CHECK dout0_2 Vdout0_2ck73 = 0 time = 370
.meas tran vdout0_2ck73 FIND v(dout0_2) AT=370.025n

* CHECK dout0_3 Vdout0_3ck73 = 0.9 time = 370
.meas tran vdout0_3ck73 FIND v(dout0_3) AT=370.025n

* CHECK dout0_4 Vdout0_4ck73 = 0.9 time = 370
.meas tran vdout0_4ck73 FIND v(dout0_4) AT=370.025n

* CHECK dout0_5 Vdout0_5ck73 = 0 time = 370
.meas tran vdout0_5ck73 FIND v(dout0_5) AT=370.025n

* CHECK dout0_6 Vdout0_6ck73 = 0.9 time = 370
.meas tran vdout0_6ck73 FIND v(dout0_6) AT=370.025n

* CHECK dout0_7 Vdout0_7ck73 = 0.9 time = 370
.meas tran vdout0_7ck73 FIND v(dout0_7) AT=370.025n

* CHECK dout0_8 Vdout0_8ck73 = 0 time = 370
.meas tran vdout0_8ck73 FIND v(dout0_8) AT=370.025n

* CHECK dout0_9 Vdout0_9ck73 = 0 time = 370
.meas tran vdout0_9ck73 FIND v(dout0_9) AT=370.025n

* CHECK dout0_10 Vdout0_10ck73 = 0 time = 370
.meas tran vdout0_10ck73 FIND v(dout0_10) AT=370.025n

* CHECK dout0_11 Vdout0_11ck73 = 0.9 time = 370
.meas tran vdout0_11ck73 FIND v(dout0_11) AT=370.025n

* CHECK dout0_12 Vdout0_12ck73 = 0 time = 370
.meas tran vdout0_12ck73 FIND v(dout0_12) AT=370.025n

* CHECK dout0_13 Vdout0_13ck73 = 0.9 time = 370
.meas tran vdout0_13ck73 FIND v(dout0_13) AT=370.025n

* CHECK dout0_14 Vdout0_14ck73 = 0 time = 370
.meas tran vdout0_14ck73 FIND v(dout0_14) AT=370.025n

* CHECK dout0_15 Vdout0_15ck73 = 0 time = 370
.meas tran vdout0_15ck73 FIND v(dout0_15) AT=370.025n

* CHECK dout0_16 Vdout0_16ck73 = 0.9 time = 370
.meas tran vdout0_16ck73 FIND v(dout0_16) AT=370.025n

* CHECK dout0_17 Vdout0_17ck73 = 0.9 time = 370
.meas tran vdout0_17ck73 FIND v(dout0_17) AT=370.025n

* CHECK dout0_18 Vdout0_18ck73 = 0 time = 370
.meas tran vdout0_18ck73 FIND v(dout0_18) AT=370.025n

* CHECK dout0_19 Vdout0_19ck73 = 0.9 time = 370
.meas tran vdout0_19ck73 FIND v(dout0_19) AT=370.025n

* CHECK dout0_20 Vdout0_20ck73 = 0 time = 370
.meas tran vdout0_20ck73 FIND v(dout0_20) AT=370.025n

* CHECK dout0_21 Vdout0_21ck73 = 0.9 time = 370
.meas tran vdout0_21ck73 FIND v(dout0_21) AT=370.025n

* CHECK dout0_22 Vdout0_22ck73 = 0 time = 370
.meas tran vdout0_22ck73 FIND v(dout0_22) AT=370.025n

* CHECK dout0_23 Vdout0_23ck73 = 0.9 time = 370
.meas tran vdout0_23ck73 FIND v(dout0_23) AT=370.025n

* CHECK dout0_24 Vdout0_24ck73 = 0.9 time = 370
.meas tran vdout0_24ck73 FIND v(dout0_24) AT=370.025n

* CHECK dout0_25 Vdout0_25ck73 = 0.9 time = 370
.meas tran vdout0_25ck73 FIND v(dout0_25) AT=370.025n

* CHECK dout0_26 Vdout0_26ck73 = 0.9 time = 370
.meas tran vdout0_26ck73 FIND v(dout0_26) AT=370.025n

* CHECK dout0_27 Vdout0_27ck73 = 0.9 time = 370
.meas tran vdout0_27ck73 FIND v(dout0_27) AT=370.025n

* CHECK dout0_28 Vdout0_28ck73 = 0 time = 370
.meas tran vdout0_28ck73 FIND v(dout0_28) AT=370.025n

* CHECK dout0_29 Vdout0_29ck73 = 0 time = 370
.meas tran vdout0_29ck73 FIND v(dout0_29) AT=370.025n

* CHECK dout0_30 Vdout0_30ck73 = 0 time = 370
.meas tran vdout0_30ck73 FIND v(dout0_30) AT=370.025n

* CHECK dout0_31 Vdout0_31ck73 = 0.9 time = 370
.meas tran vdout0_31ck73 FIND v(dout0_31) AT=370.025n

* CHECK dout0_32 Vdout0_32ck73 = 0 time = 370
.meas tran vdout0_32ck73 FIND v(dout0_32) AT=370.025n

* CHECK dout0_33 Vdout0_33ck73 = 0.9 time = 370
.meas tran vdout0_33ck73 FIND v(dout0_33) AT=370.025n

* CHECK dout0_34 Vdout0_34ck73 = 0 time = 370
.meas tran vdout0_34ck73 FIND v(dout0_34) AT=370.025n

* CHECK dout0_35 Vdout0_35ck73 = 0 time = 370
.meas tran vdout0_35ck73 FIND v(dout0_35) AT=370.025n

* CHECK dout0_36 Vdout0_36ck73 = 0.9 time = 370
.meas tran vdout0_36ck73 FIND v(dout0_36) AT=370.025n

* CHECK dout0_37 Vdout0_37ck73 = 0.9 time = 370
.meas tran vdout0_37ck73 FIND v(dout0_37) AT=370.025n

* CHECK dout0_38 Vdout0_38ck73 = 0 time = 370
.meas tran vdout0_38ck73 FIND v(dout0_38) AT=370.025n

* CHECK dout0_39 Vdout0_39ck73 = 0.9 time = 370
.meas tran vdout0_39ck73 FIND v(dout0_39) AT=370.025n

* CHECK dout0_40 Vdout0_40ck73 = 0.9 time = 370
.meas tran vdout0_40ck73 FIND v(dout0_40) AT=370.025n

* CHECK dout0_41 Vdout0_41ck73 = 0 time = 370
.meas tran vdout0_41ck73 FIND v(dout0_41) AT=370.025n

* CHECK dout0_42 Vdout0_42ck73 = 0.9 time = 370
.meas tran vdout0_42ck73 FIND v(dout0_42) AT=370.025n

* CHECK dout0_43 Vdout0_43ck73 = 0 time = 370
.meas tran vdout0_43ck73 FIND v(dout0_43) AT=370.025n

* CHECK dout0_44 Vdout0_44ck73 = 0.9 time = 370
.meas tran vdout0_44ck73 FIND v(dout0_44) AT=370.025n

* CHECK dout0_45 Vdout0_45ck73 = 0 time = 370
.meas tran vdout0_45ck73 FIND v(dout0_45) AT=370.025n

* CHECK dout0_46 Vdout0_46ck73 = 0 time = 370
.meas tran vdout0_46ck73 FIND v(dout0_46) AT=370.025n

* CHECK dout0_47 Vdout0_47ck73 = 0 time = 370
.meas tran vdout0_47ck73 FIND v(dout0_47) AT=370.025n

* CHECK dout0_48 Vdout0_48ck73 = 0 time = 370
.meas tran vdout0_48ck73 FIND v(dout0_48) AT=370.025n

* CHECK dout0_49 Vdout0_49ck73 = 0.9 time = 370
.meas tran vdout0_49ck73 FIND v(dout0_49) AT=370.025n

* CHECK dout0_50 Vdout0_50ck73 = 0 time = 370
.meas tran vdout0_50ck73 FIND v(dout0_50) AT=370.025n

* CHECK dout0_51 Vdout0_51ck73 = 0.9 time = 370
.meas tran vdout0_51ck73 FIND v(dout0_51) AT=370.025n

* CHECK dout0_52 Vdout0_52ck73 = 0.9 time = 370
.meas tran vdout0_52ck73 FIND v(dout0_52) AT=370.025n

* CHECK dout0_53 Vdout0_53ck73 = 0 time = 370
.meas tran vdout0_53ck73 FIND v(dout0_53) AT=370.025n

* CHECK dout0_54 Vdout0_54ck73 = 0.9 time = 370
.meas tran vdout0_54ck73 FIND v(dout0_54) AT=370.025n

* CHECK dout0_55 Vdout0_55ck73 = 0.9 time = 370
.meas tran vdout0_55ck73 FIND v(dout0_55) AT=370.025n

* CHECK dout0_56 Vdout0_56ck73 = 0 time = 370
.meas tran vdout0_56ck73 FIND v(dout0_56) AT=370.025n

* CHECK dout0_57 Vdout0_57ck73 = 0 time = 370
.meas tran vdout0_57ck73 FIND v(dout0_57) AT=370.025n

* CHECK dout0_58 Vdout0_58ck73 = 0.9 time = 370
.meas tran vdout0_58ck73 FIND v(dout0_58) AT=370.025n

* CHECK dout0_59 Vdout0_59ck73 = 0 time = 370
.meas tran vdout0_59ck73 FIND v(dout0_59) AT=370.025n

* CHECK dout0_60 Vdout0_60ck73 = 0.9 time = 370
.meas tran vdout0_60ck73 FIND v(dout0_60) AT=370.025n

* CHECK dout0_61 Vdout0_61ck73 = 0.9 time = 370
.meas tran vdout0_61ck73 FIND v(dout0_61) AT=370.025n

* CHECK dout0_62 Vdout0_62ck73 = 0.9 time = 370
.meas tran vdout0_62ck73 FIND v(dout0_62) AT=370.025n

* CHECK dout0_63 Vdout0_63ck73 = 0 time = 370
.meas tran vdout0_63ck73 FIND v(dout0_63) AT=370.025n

* CHECK dout0_0 Vdout0_0ck74 = 0.9 time = 375
.meas tran vdout0_0ck74 FIND v(dout0_0) AT=375.025n

* CHECK dout0_1 Vdout0_1ck74 = 0.9 time = 375
.meas tran vdout0_1ck74 FIND v(dout0_1) AT=375.025n

* CHECK dout0_2 Vdout0_2ck74 = 0 time = 375
.meas tran vdout0_2ck74 FIND v(dout0_2) AT=375.025n

* CHECK dout0_3 Vdout0_3ck74 = 0.9 time = 375
.meas tran vdout0_3ck74 FIND v(dout0_3) AT=375.025n

* CHECK dout0_4 Vdout0_4ck74 = 0.9 time = 375
.meas tran vdout0_4ck74 FIND v(dout0_4) AT=375.025n

* CHECK dout0_5 Vdout0_5ck74 = 0 time = 375
.meas tran vdout0_5ck74 FIND v(dout0_5) AT=375.025n

* CHECK dout0_6 Vdout0_6ck74 = 0.9 time = 375
.meas tran vdout0_6ck74 FIND v(dout0_6) AT=375.025n

* CHECK dout0_7 Vdout0_7ck74 = 0.9 time = 375
.meas tran vdout0_7ck74 FIND v(dout0_7) AT=375.025n

* CHECK dout0_8 Vdout0_8ck74 = 0 time = 375
.meas tran vdout0_8ck74 FIND v(dout0_8) AT=375.025n

* CHECK dout0_9 Vdout0_9ck74 = 0 time = 375
.meas tran vdout0_9ck74 FIND v(dout0_9) AT=375.025n

* CHECK dout0_10 Vdout0_10ck74 = 0 time = 375
.meas tran vdout0_10ck74 FIND v(dout0_10) AT=375.025n

* CHECK dout0_11 Vdout0_11ck74 = 0.9 time = 375
.meas tran vdout0_11ck74 FIND v(dout0_11) AT=375.025n

* CHECK dout0_12 Vdout0_12ck74 = 0 time = 375
.meas tran vdout0_12ck74 FIND v(dout0_12) AT=375.025n

* CHECK dout0_13 Vdout0_13ck74 = 0.9 time = 375
.meas tran vdout0_13ck74 FIND v(dout0_13) AT=375.025n

* CHECK dout0_14 Vdout0_14ck74 = 0 time = 375
.meas tran vdout0_14ck74 FIND v(dout0_14) AT=375.025n

* CHECK dout0_15 Vdout0_15ck74 = 0 time = 375
.meas tran vdout0_15ck74 FIND v(dout0_15) AT=375.025n

* CHECK dout0_16 Vdout0_16ck74 = 0.9 time = 375
.meas tran vdout0_16ck74 FIND v(dout0_16) AT=375.025n

* CHECK dout0_17 Vdout0_17ck74 = 0.9 time = 375
.meas tran vdout0_17ck74 FIND v(dout0_17) AT=375.025n

* CHECK dout0_18 Vdout0_18ck74 = 0 time = 375
.meas tran vdout0_18ck74 FIND v(dout0_18) AT=375.025n

* CHECK dout0_19 Vdout0_19ck74 = 0.9 time = 375
.meas tran vdout0_19ck74 FIND v(dout0_19) AT=375.025n

* CHECK dout0_20 Vdout0_20ck74 = 0 time = 375
.meas tran vdout0_20ck74 FIND v(dout0_20) AT=375.025n

* CHECK dout0_21 Vdout0_21ck74 = 0.9 time = 375
.meas tran vdout0_21ck74 FIND v(dout0_21) AT=375.025n

* CHECK dout0_22 Vdout0_22ck74 = 0 time = 375
.meas tran vdout0_22ck74 FIND v(dout0_22) AT=375.025n

* CHECK dout0_23 Vdout0_23ck74 = 0.9 time = 375
.meas tran vdout0_23ck74 FIND v(dout0_23) AT=375.025n

* CHECK dout0_24 Vdout0_24ck74 = 0.9 time = 375
.meas tran vdout0_24ck74 FIND v(dout0_24) AT=375.025n

* CHECK dout0_25 Vdout0_25ck74 = 0.9 time = 375
.meas tran vdout0_25ck74 FIND v(dout0_25) AT=375.025n

* CHECK dout0_26 Vdout0_26ck74 = 0.9 time = 375
.meas tran vdout0_26ck74 FIND v(dout0_26) AT=375.025n

* CHECK dout0_27 Vdout0_27ck74 = 0.9 time = 375
.meas tran vdout0_27ck74 FIND v(dout0_27) AT=375.025n

* CHECK dout0_28 Vdout0_28ck74 = 0 time = 375
.meas tran vdout0_28ck74 FIND v(dout0_28) AT=375.025n

* CHECK dout0_29 Vdout0_29ck74 = 0 time = 375
.meas tran vdout0_29ck74 FIND v(dout0_29) AT=375.025n

* CHECK dout0_30 Vdout0_30ck74 = 0 time = 375
.meas tran vdout0_30ck74 FIND v(dout0_30) AT=375.025n

* CHECK dout0_31 Vdout0_31ck74 = 0.9 time = 375
.meas tran vdout0_31ck74 FIND v(dout0_31) AT=375.025n

* CHECK dout0_32 Vdout0_32ck74 = 0 time = 375
.meas tran vdout0_32ck74 FIND v(dout0_32) AT=375.025n

* CHECK dout0_33 Vdout0_33ck74 = 0.9 time = 375
.meas tran vdout0_33ck74 FIND v(dout0_33) AT=375.025n

* CHECK dout0_34 Vdout0_34ck74 = 0 time = 375
.meas tran vdout0_34ck74 FIND v(dout0_34) AT=375.025n

* CHECK dout0_35 Vdout0_35ck74 = 0 time = 375
.meas tran vdout0_35ck74 FIND v(dout0_35) AT=375.025n

* CHECK dout0_36 Vdout0_36ck74 = 0.9 time = 375
.meas tran vdout0_36ck74 FIND v(dout0_36) AT=375.025n

* CHECK dout0_37 Vdout0_37ck74 = 0.9 time = 375
.meas tran vdout0_37ck74 FIND v(dout0_37) AT=375.025n

* CHECK dout0_38 Vdout0_38ck74 = 0 time = 375
.meas tran vdout0_38ck74 FIND v(dout0_38) AT=375.025n

* CHECK dout0_39 Vdout0_39ck74 = 0.9 time = 375
.meas tran vdout0_39ck74 FIND v(dout0_39) AT=375.025n

* CHECK dout0_40 Vdout0_40ck74 = 0.9 time = 375
.meas tran vdout0_40ck74 FIND v(dout0_40) AT=375.025n

* CHECK dout0_41 Vdout0_41ck74 = 0 time = 375
.meas tran vdout0_41ck74 FIND v(dout0_41) AT=375.025n

* CHECK dout0_42 Vdout0_42ck74 = 0.9 time = 375
.meas tran vdout0_42ck74 FIND v(dout0_42) AT=375.025n

* CHECK dout0_43 Vdout0_43ck74 = 0 time = 375
.meas tran vdout0_43ck74 FIND v(dout0_43) AT=375.025n

* CHECK dout0_44 Vdout0_44ck74 = 0.9 time = 375
.meas tran vdout0_44ck74 FIND v(dout0_44) AT=375.025n

* CHECK dout0_45 Vdout0_45ck74 = 0 time = 375
.meas tran vdout0_45ck74 FIND v(dout0_45) AT=375.025n

* CHECK dout0_46 Vdout0_46ck74 = 0 time = 375
.meas tran vdout0_46ck74 FIND v(dout0_46) AT=375.025n

* CHECK dout0_47 Vdout0_47ck74 = 0 time = 375
.meas tran vdout0_47ck74 FIND v(dout0_47) AT=375.025n

* CHECK dout0_48 Vdout0_48ck74 = 0 time = 375
.meas tran vdout0_48ck74 FIND v(dout0_48) AT=375.025n

* CHECK dout0_49 Vdout0_49ck74 = 0.9 time = 375
.meas tran vdout0_49ck74 FIND v(dout0_49) AT=375.025n

* CHECK dout0_50 Vdout0_50ck74 = 0 time = 375
.meas tran vdout0_50ck74 FIND v(dout0_50) AT=375.025n

* CHECK dout0_51 Vdout0_51ck74 = 0.9 time = 375
.meas tran vdout0_51ck74 FIND v(dout0_51) AT=375.025n

* CHECK dout0_52 Vdout0_52ck74 = 0.9 time = 375
.meas tran vdout0_52ck74 FIND v(dout0_52) AT=375.025n

* CHECK dout0_53 Vdout0_53ck74 = 0 time = 375
.meas tran vdout0_53ck74 FIND v(dout0_53) AT=375.025n

* CHECK dout0_54 Vdout0_54ck74 = 0.9 time = 375
.meas tran vdout0_54ck74 FIND v(dout0_54) AT=375.025n

* CHECK dout0_55 Vdout0_55ck74 = 0.9 time = 375
.meas tran vdout0_55ck74 FIND v(dout0_55) AT=375.025n

* CHECK dout0_56 Vdout0_56ck74 = 0 time = 375
.meas tran vdout0_56ck74 FIND v(dout0_56) AT=375.025n

* CHECK dout0_57 Vdout0_57ck74 = 0 time = 375
.meas tran vdout0_57ck74 FIND v(dout0_57) AT=375.025n

* CHECK dout0_58 Vdout0_58ck74 = 0.9 time = 375
.meas tran vdout0_58ck74 FIND v(dout0_58) AT=375.025n

* CHECK dout0_59 Vdout0_59ck74 = 0 time = 375
.meas tran vdout0_59ck74 FIND v(dout0_59) AT=375.025n

* CHECK dout0_60 Vdout0_60ck74 = 0.9 time = 375
.meas tran vdout0_60ck74 FIND v(dout0_60) AT=375.025n

* CHECK dout0_61 Vdout0_61ck74 = 0.9 time = 375
.meas tran vdout0_61ck74 FIND v(dout0_61) AT=375.025n

* CHECK dout0_62 Vdout0_62ck74 = 0.9 time = 375
.meas tran vdout0_62ck74 FIND v(dout0_62) AT=375.025n

* CHECK dout0_63 Vdout0_63ck74 = 0 time = 375
.meas tran vdout0_63ck74 FIND v(dout0_63) AT=375.025n

* CHECK dout0_0 Vdout0_0ck80 = 0 time = 405
.meas tran vdout0_0ck80 FIND v(dout0_0) AT=405.025n

* CHECK dout0_1 Vdout0_1ck80 = 0.9 time = 405
.meas tran vdout0_1ck80 FIND v(dout0_1) AT=405.025n

* CHECK dout0_2 Vdout0_2ck80 = 0.9 time = 405
.meas tran vdout0_2ck80 FIND v(dout0_2) AT=405.025n

* CHECK dout0_3 Vdout0_3ck80 = 0 time = 405
.meas tran vdout0_3ck80 FIND v(dout0_3) AT=405.025n

* CHECK dout0_4 Vdout0_4ck80 = 0.9 time = 405
.meas tran vdout0_4ck80 FIND v(dout0_4) AT=405.025n

* CHECK dout0_5 Vdout0_5ck80 = 0.9 time = 405
.meas tran vdout0_5ck80 FIND v(dout0_5) AT=405.025n

* CHECK dout0_6 Vdout0_6ck80 = 0.9 time = 405
.meas tran vdout0_6ck80 FIND v(dout0_6) AT=405.025n

* CHECK dout0_7 Vdout0_7ck80 = 0 time = 405
.meas tran vdout0_7ck80 FIND v(dout0_7) AT=405.025n

* CHECK dout0_8 Vdout0_8ck80 = 0.9 time = 405
.meas tran vdout0_8ck80 FIND v(dout0_8) AT=405.025n

* CHECK dout0_9 Vdout0_9ck80 = 0.9 time = 405
.meas tran vdout0_9ck80 FIND v(dout0_9) AT=405.025n

* CHECK dout0_10 Vdout0_10ck80 = 0 time = 405
.meas tran vdout0_10ck80 FIND v(dout0_10) AT=405.025n

* CHECK dout0_11 Vdout0_11ck80 = 0.9 time = 405
.meas tran vdout0_11ck80 FIND v(dout0_11) AT=405.025n

* CHECK dout0_12 Vdout0_12ck80 = 0.9 time = 405
.meas tran vdout0_12ck80 FIND v(dout0_12) AT=405.025n

* CHECK dout0_13 Vdout0_13ck80 = 0.9 time = 405
.meas tran vdout0_13ck80 FIND v(dout0_13) AT=405.025n

* CHECK dout0_14 Vdout0_14ck80 = 0 time = 405
.meas tran vdout0_14ck80 FIND v(dout0_14) AT=405.025n

* CHECK dout0_15 Vdout0_15ck80 = 0.9 time = 405
.meas tran vdout0_15ck80 FIND v(dout0_15) AT=405.025n

* CHECK dout0_16 Vdout0_16ck80 = 0 time = 405
.meas tran vdout0_16ck80 FIND v(dout0_16) AT=405.025n

* CHECK dout0_17 Vdout0_17ck80 = 0 time = 405
.meas tran vdout0_17ck80 FIND v(dout0_17) AT=405.025n

* CHECK dout0_18 Vdout0_18ck80 = 0 time = 405
.meas tran vdout0_18ck80 FIND v(dout0_18) AT=405.025n

* CHECK dout0_19 Vdout0_19ck80 = 0 time = 405
.meas tran vdout0_19ck80 FIND v(dout0_19) AT=405.025n

* CHECK dout0_20 Vdout0_20ck80 = 0.9 time = 405
.meas tran vdout0_20ck80 FIND v(dout0_20) AT=405.025n

* CHECK dout0_21 Vdout0_21ck80 = 0.9 time = 405
.meas tran vdout0_21ck80 FIND v(dout0_21) AT=405.025n

* CHECK dout0_22 Vdout0_22ck80 = 0 time = 405
.meas tran vdout0_22ck80 FIND v(dout0_22) AT=405.025n

* CHECK dout0_23 Vdout0_23ck80 = 0.9 time = 405
.meas tran vdout0_23ck80 FIND v(dout0_23) AT=405.025n

* CHECK dout0_24 Vdout0_24ck80 = 0.9 time = 405
.meas tran vdout0_24ck80 FIND v(dout0_24) AT=405.025n

* CHECK dout0_25 Vdout0_25ck80 = 0.9 time = 405
.meas tran vdout0_25ck80 FIND v(dout0_25) AT=405.025n

* CHECK dout0_26 Vdout0_26ck80 = 0.9 time = 405
.meas tran vdout0_26ck80 FIND v(dout0_26) AT=405.025n

* CHECK dout0_27 Vdout0_27ck80 = 0.9 time = 405
.meas tran vdout0_27ck80 FIND v(dout0_27) AT=405.025n

* CHECK dout0_28 Vdout0_28ck80 = 0 time = 405
.meas tran vdout0_28ck80 FIND v(dout0_28) AT=405.025n

* CHECK dout0_29 Vdout0_29ck80 = 0.9 time = 405
.meas tran vdout0_29ck80 FIND v(dout0_29) AT=405.025n

* CHECK dout0_30 Vdout0_30ck80 = 0.9 time = 405
.meas tran vdout0_30ck80 FIND v(dout0_30) AT=405.025n

* CHECK dout0_31 Vdout0_31ck80 = 0 time = 405
.meas tran vdout0_31ck80 FIND v(dout0_31) AT=405.025n

* CHECK dout0_32 Vdout0_32ck80 = 0 time = 405
.meas tran vdout0_32ck80 FIND v(dout0_32) AT=405.025n

* CHECK dout0_33 Vdout0_33ck80 = 0 time = 405
.meas tran vdout0_33ck80 FIND v(dout0_33) AT=405.025n

* CHECK dout0_34 Vdout0_34ck80 = 0.9 time = 405
.meas tran vdout0_34ck80 FIND v(dout0_34) AT=405.025n

* CHECK dout0_35 Vdout0_35ck80 = 0 time = 405
.meas tran vdout0_35ck80 FIND v(dout0_35) AT=405.025n

* CHECK dout0_36 Vdout0_36ck80 = 0.9 time = 405
.meas tran vdout0_36ck80 FIND v(dout0_36) AT=405.025n

* CHECK dout0_37 Vdout0_37ck80 = 0 time = 405
.meas tran vdout0_37ck80 FIND v(dout0_37) AT=405.025n

* CHECK dout0_38 Vdout0_38ck80 = 0 time = 405
.meas tran vdout0_38ck80 FIND v(dout0_38) AT=405.025n

* CHECK dout0_39 Vdout0_39ck80 = 0 time = 405
.meas tran vdout0_39ck80 FIND v(dout0_39) AT=405.025n

* CHECK dout0_40 Vdout0_40ck80 = 0 time = 405
.meas tran vdout0_40ck80 FIND v(dout0_40) AT=405.025n

* CHECK dout0_41 Vdout0_41ck80 = 0.9 time = 405
.meas tran vdout0_41ck80 FIND v(dout0_41) AT=405.025n

* CHECK dout0_42 Vdout0_42ck80 = 0.9 time = 405
.meas tran vdout0_42ck80 FIND v(dout0_42) AT=405.025n

* CHECK dout0_43 Vdout0_43ck80 = 0.9 time = 405
.meas tran vdout0_43ck80 FIND v(dout0_43) AT=405.025n

* CHECK dout0_44 Vdout0_44ck80 = 0 time = 405
.meas tran vdout0_44ck80 FIND v(dout0_44) AT=405.025n

* CHECK dout0_45 Vdout0_45ck80 = 0 time = 405
.meas tran vdout0_45ck80 FIND v(dout0_45) AT=405.025n

* CHECK dout0_46 Vdout0_46ck80 = 0.9 time = 405
.meas tran vdout0_46ck80 FIND v(dout0_46) AT=405.025n

* CHECK dout0_47 Vdout0_47ck80 = 0.9 time = 405
.meas tran vdout0_47ck80 FIND v(dout0_47) AT=405.025n

* CHECK dout0_48 Vdout0_48ck80 = 0 time = 405
.meas tran vdout0_48ck80 FIND v(dout0_48) AT=405.025n

* CHECK dout0_49 Vdout0_49ck80 = 0 time = 405
.meas tran vdout0_49ck80 FIND v(dout0_49) AT=405.025n

* CHECK dout0_50 Vdout0_50ck80 = 0 time = 405
.meas tran vdout0_50ck80 FIND v(dout0_50) AT=405.025n

* CHECK dout0_51 Vdout0_51ck80 = 0.9 time = 405
.meas tran vdout0_51ck80 FIND v(dout0_51) AT=405.025n

* CHECK dout0_52 Vdout0_52ck80 = 0.9 time = 405
.meas tran vdout0_52ck80 FIND v(dout0_52) AT=405.025n

* CHECK dout0_53 Vdout0_53ck80 = 0.9 time = 405
.meas tran vdout0_53ck80 FIND v(dout0_53) AT=405.025n

* CHECK dout0_54 Vdout0_54ck80 = 0 time = 405
.meas tran vdout0_54ck80 FIND v(dout0_54) AT=405.025n

* CHECK dout0_55 Vdout0_55ck80 = 0.9 time = 405
.meas tran vdout0_55ck80 FIND v(dout0_55) AT=405.025n

* CHECK dout0_56 Vdout0_56ck80 = 0.9 time = 405
.meas tran vdout0_56ck80 FIND v(dout0_56) AT=405.025n

* CHECK dout0_57 Vdout0_57ck80 = 0.9 time = 405
.meas tran vdout0_57ck80 FIND v(dout0_57) AT=405.025n

* CHECK dout0_58 Vdout0_58ck80 = 0 time = 405
.meas tran vdout0_58ck80 FIND v(dout0_58) AT=405.025n

* CHECK dout0_59 Vdout0_59ck80 = 0.9 time = 405
.meas tran vdout0_59ck80 FIND v(dout0_59) AT=405.025n

* CHECK dout0_60 Vdout0_60ck80 = 0.9 time = 405
.meas tran vdout0_60ck80 FIND v(dout0_60) AT=405.025n

* CHECK dout0_61 Vdout0_61ck80 = 0.9 time = 405
.meas tran vdout0_61ck80 FIND v(dout0_61) AT=405.025n

* CHECK dout0_62 Vdout0_62ck80 = 0 time = 405
.meas tran vdout0_62ck80 FIND v(dout0_62) AT=405.025n

* CHECK dout0_63 Vdout0_63ck80 = 0 time = 405
.meas tran vdout0_63ck80 FIND v(dout0_63) AT=405.025n

* CHECK dout0_0 Vdout0_0ck81 = 0 time = 410
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=410.025n

* CHECK dout0_1 Vdout0_1ck81 = 0.9 time = 410
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=410.025n

* CHECK dout0_2 Vdout0_2ck81 = 0 time = 410
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=410.025n

* CHECK dout0_3 Vdout0_3ck81 = 0.9 time = 410
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=410.025n

* CHECK dout0_4 Vdout0_4ck81 = 0 time = 410
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=410.025n

* CHECK dout0_5 Vdout0_5ck81 = 0.9 time = 410
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=410.025n

* CHECK dout0_6 Vdout0_6ck81 = 0.9 time = 410
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=410.025n

* CHECK dout0_7 Vdout0_7ck81 = 0.9 time = 410
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=410.025n

* CHECK dout0_8 Vdout0_8ck81 = 0 time = 410
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=410.025n

* CHECK dout0_9 Vdout0_9ck81 = 0.9 time = 410
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=410.025n

* CHECK dout0_10 Vdout0_10ck81 = 0.9 time = 410
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=410.025n

* CHECK dout0_11 Vdout0_11ck81 = 0 time = 410
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=410.025n

* CHECK dout0_12 Vdout0_12ck81 = 0.9 time = 410
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=410.025n

* CHECK dout0_13 Vdout0_13ck81 = 0 time = 410
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=410.025n

* CHECK dout0_14 Vdout0_14ck81 = 0 time = 410
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=410.025n

* CHECK dout0_15 Vdout0_15ck81 = 0 time = 410
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=410.025n

* CHECK dout0_16 Vdout0_16ck81 = 0 time = 410
.meas tran vdout0_16ck81 FIND v(dout0_16) AT=410.025n

* CHECK dout0_17 Vdout0_17ck81 = 0 time = 410
.meas tran vdout0_17ck81 FIND v(dout0_17) AT=410.025n

* CHECK dout0_18 Vdout0_18ck81 = 0.9 time = 410
.meas tran vdout0_18ck81 FIND v(dout0_18) AT=410.025n

* CHECK dout0_19 Vdout0_19ck81 = 0.9 time = 410
.meas tran vdout0_19ck81 FIND v(dout0_19) AT=410.025n

* CHECK dout0_20 Vdout0_20ck81 = 0.9 time = 410
.meas tran vdout0_20ck81 FIND v(dout0_20) AT=410.025n

* CHECK dout0_21 Vdout0_21ck81 = 0.9 time = 410
.meas tran vdout0_21ck81 FIND v(dout0_21) AT=410.025n

* CHECK dout0_22 Vdout0_22ck81 = 0.9 time = 410
.meas tran vdout0_22ck81 FIND v(dout0_22) AT=410.025n

* CHECK dout0_23 Vdout0_23ck81 = 0 time = 410
.meas tran vdout0_23ck81 FIND v(dout0_23) AT=410.025n

* CHECK dout0_24 Vdout0_24ck81 = 0 time = 410
.meas tran vdout0_24ck81 FIND v(dout0_24) AT=410.025n

* CHECK dout0_25 Vdout0_25ck81 = 0.9 time = 410
.meas tran vdout0_25ck81 FIND v(dout0_25) AT=410.025n

* CHECK dout0_26 Vdout0_26ck81 = 0.9 time = 410
.meas tran vdout0_26ck81 FIND v(dout0_26) AT=410.025n

* CHECK dout0_27 Vdout0_27ck81 = 0.9 time = 410
.meas tran vdout0_27ck81 FIND v(dout0_27) AT=410.025n

* CHECK dout0_28 Vdout0_28ck81 = 0 time = 410
.meas tran vdout0_28ck81 FIND v(dout0_28) AT=410.025n

* CHECK dout0_29 Vdout0_29ck81 = 0.9 time = 410
.meas tran vdout0_29ck81 FIND v(dout0_29) AT=410.025n

* CHECK dout0_30 Vdout0_30ck81 = 0.9 time = 410
.meas tran vdout0_30ck81 FIND v(dout0_30) AT=410.025n

* CHECK dout0_31 Vdout0_31ck81 = 0.9 time = 410
.meas tran vdout0_31ck81 FIND v(dout0_31) AT=410.025n

* CHECK dout0_32 Vdout0_32ck81 = 0.9 time = 410
.meas tran vdout0_32ck81 FIND v(dout0_32) AT=410.025n

* CHECK dout0_33 Vdout0_33ck81 = 0.9 time = 410
.meas tran vdout0_33ck81 FIND v(dout0_33) AT=410.025n

* CHECK dout0_34 Vdout0_34ck81 = 0 time = 410
.meas tran vdout0_34ck81 FIND v(dout0_34) AT=410.025n

* CHECK dout0_35 Vdout0_35ck81 = 0 time = 410
.meas tran vdout0_35ck81 FIND v(dout0_35) AT=410.025n

* CHECK dout0_36 Vdout0_36ck81 = 0 time = 410
.meas tran vdout0_36ck81 FIND v(dout0_36) AT=410.025n

* CHECK dout0_37 Vdout0_37ck81 = 0 time = 410
.meas tran vdout0_37ck81 FIND v(dout0_37) AT=410.025n

* CHECK dout0_38 Vdout0_38ck81 = 0.9 time = 410
.meas tran vdout0_38ck81 FIND v(dout0_38) AT=410.025n

* CHECK dout0_39 Vdout0_39ck81 = 0.9 time = 410
.meas tran vdout0_39ck81 FIND v(dout0_39) AT=410.025n

* CHECK dout0_40 Vdout0_40ck81 = 0 time = 410
.meas tran vdout0_40ck81 FIND v(dout0_40) AT=410.025n

* CHECK dout0_41 Vdout0_41ck81 = 0.9 time = 410
.meas tran vdout0_41ck81 FIND v(dout0_41) AT=410.025n

* CHECK dout0_42 Vdout0_42ck81 = 0 time = 410
.meas tran vdout0_42ck81 FIND v(dout0_42) AT=410.025n

* CHECK dout0_43 Vdout0_43ck81 = 0 time = 410
.meas tran vdout0_43ck81 FIND v(dout0_43) AT=410.025n

* CHECK dout0_44 Vdout0_44ck81 = 0.9 time = 410
.meas tran vdout0_44ck81 FIND v(dout0_44) AT=410.025n

* CHECK dout0_45 Vdout0_45ck81 = 0.9 time = 410
.meas tran vdout0_45ck81 FIND v(dout0_45) AT=410.025n

* CHECK dout0_46 Vdout0_46ck81 = 0.9 time = 410
.meas tran vdout0_46ck81 FIND v(dout0_46) AT=410.025n

* CHECK dout0_47 Vdout0_47ck81 = 0.9 time = 410
.meas tran vdout0_47ck81 FIND v(dout0_47) AT=410.025n

* CHECK dout0_48 Vdout0_48ck81 = 0 time = 410
.meas tran vdout0_48ck81 FIND v(dout0_48) AT=410.025n

* CHECK dout0_49 Vdout0_49ck81 = 0 time = 410
.meas tran vdout0_49ck81 FIND v(dout0_49) AT=410.025n

* CHECK dout0_50 Vdout0_50ck81 = 0.9 time = 410
.meas tran vdout0_50ck81 FIND v(dout0_50) AT=410.025n

* CHECK dout0_51 Vdout0_51ck81 = 0.9 time = 410
.meas tran vdout0_51ck81 FIND v(dout0_51) AT=410.025n

* CHECK dout0_52 Vdout0_52ck81 = 0.9 time = 410
.meas tran vdout0_52ck81 FIND v(dout0_52) AT=410.025n

* CHECK dout0_53 Vdout0_53ck81 = 0.9 time = 410
.meas tran vdout0_53ck81 FIND v(dout0_53) AT=410.025n

* CHECK dout0_54 Vdout0_54ck81 = 0.9 time = 410
.meas tran vdout0_54ck81 FIND v(dout0_54) AT=410.025n

* CHECK dout0_55 Vdout0_55ck81 = 0 time = 410
.meas tran vdout0_55ck81 FIND v(dout0_55) AT=410.025n

* CHECK dout0_56 Vdout0_56ck81 = 0.9 time = 410
.meas tran vdout0_56ck81 FIND v(dout0_56) AT=410.025n

* CHECK dout0_57 Vdout0_57ck81 = 0.9 time = 410
.meas tran vdout0_57ck81 FIND v(dout0_57) AT=410.025n

* CHECK dout0_58 Vdout0_58ck81 = 0 time = 410
.meas tran vdout0_58ck81 FIND v(dout0_58) AT=410.025n

* CHECK dout0_59 Vdout0_59ck81 = 0.9 time = 410
.meas tran vdout0_59ck81 FIND v(dout0_59) AT=410.025n

* CHECK dout0_60 Vdout0_60ck81 = 0 time = 410
.meas tran vdout0_60ck81 FIND v(dout0_60) AT=410.025n

* CHECK dout0_61 Vdout0_61ck81 = 0 time = 410
.meas tran vdout0_61ck81 FIND v(dout0_61) AT=410.025n

* CHECK dout0_62 Vdout0_62ck81 = 0 time = 410
.meas tran vdout0_62ck81 FIND v(dout0_62) AT=410.025n

* CHECK dout0_63 Vdout0_63ck81 = 0 time = 410
.meas tran vdout0_63ck81 FIND v(dout0_63) AT=410.025n

* CHECK dout0_0 Vdout0_0ck83 = 0 time = 420
.meas tran vdout0_0ck83 FIND v(dout0_0) AT=420.025n

* CHECK dout0_1 Vdout0_1ck83 = 0.9 time = 420
.meas tran vdout0_1ck83 FIND v(dout0_1) AT=420.025n

* CHECK dout0_2 Vdout0_2ck83 = 0 time = 420
.meas tran vdout0_2ck83 FIND v(dout0_2) AT=420.025n

* CHECK dout0_3 Vdout0_3ck83 = 0.9 time = 420
.meas tran vdout0_3ck83 FIND v(dout0_3) AT=420.025n

* CHECK dout0_4 Vdout0_4ck83 = 0.9 time = 420
.meas tran vdout0_4ck83 FIND v(dout0_4) AT=420.025n

* CHECK dout0_5 Vdout0_5ck83 = 0 time = 420
.meas tran vdout0_5ck83 FIND v(dout0_5) AT=420.025n

* CHECK dout0_6 Vdout0_6ck83 = 0.9 time = 420
.meas tran vdout0_6ck83 FIND v(dout0_6) AT=420.025n

* CHECK dout0_7 Vdout0_7ck83 = 0 time = 420
.meas tran vdout0_7ck83 FIND v(dout0_7) AT=420.025n

* CHECK dout0_8 Vdout0_8ck83 = 0 time = 420
.meas tran vdout0_8ck83 FIND v(dout0_8) AT=420.025n

* CHECK dout0_9 Vdout0_9ck83 = 0.9 time = 420
.meas tran vdout0_9ck83 FIND v(dout0_9) AT=420.025n

* CHECK dout0_10 Vdout0_10ck83 = 0.9 time = 420
.meas tran vdout0_10ck83 FIND v(dout0_10) AT=420.025n

* CHECK dout0_11 Vdout0_11ck83 = 0.9 time = 420
.meas tran vdout0_11ck83 FIND v(dout0_11) AT=420.025n

* CHECK dout0_12 Vdout0_12ck83 = 0.9 time = 420
.meas tran vdout0_12ck83 FIND v(dout0_12) AT=420.025n

* CHECK dout0_13 Vdout0_13ck83 = 0 time = 420
.meas tran vdout0_13ck83 FIND v(dout0_13) AT=420.025n

* CHECK dout0_14 Vdout0_14ck83 = 0.9 time = 420
.meas tran vdout0_14ck83 FIND v(dout0_14) AT=420.025n

* CHECK dout0_15 Vdout0_15ck83 = 0.9 time = 420
.meas tran vdout0_15ck83 FIND v(dout0_15) AT=420.025n

* CHECK dout0_16 Vdout0_16ck83 = 0 time = 420
.meas tran vdout0_16ck83 FIND v(dout0_16) AT=420.025n

* CHECK dout0_17 Vdout0_17ck83 = 0 time = 420
.meas tran vdout0_17ck83 FIND v(dout0_17) AT=420.025n

* CHECK dout0_18 Vdout0_18ck83 = 0.9 time = 420
.meas tran vdout0_18ck83 FIND v(dout0_18) AT=420.025n

* CHECK dout0_19 Vdout0_19ck83 = 0 time = 420
.meas tran vdout0_19ck83 FIND v(dout0_19) AT=420.025n

* CHECK dout0_20 Vdout0_20ck83 = 0 time = 420
.meas tran vdout0_20ck83 FIND v(dout0_20) AT=420.025n

* CHECK dout0_21 Vdout0_21ck83 = 0 time = 420
.meas tran vdout0_21ck83 FIND v(dout0_21) AT=420.025n

* CHECK dout0_22 Vdout0_22ck83 = 0 time = 420
.meas tran vdout0_22ck83 FIND v(dout0_22) AT=420.025n

* CHECK dout0_23 Vdout0_23ck83 = 0.9 time = 420
.meas tran vdout0_23ck83 FIND v(dout0_23) AT=420.025n

* CHECK dout0_24 Vdout0_24ck83 = 0 time = 420
.meas tran vdout0_24ck83 FIND v(dout0_24) AT=420.025n

* CHECK dout0_25 Vdout0_25ck83 = 0.9 time = 420
.meas tran vdout0_25ck83 FIND v(dout0_25) AT=420.025n

* CHECK dout0_26 Vdout0_26ck83 = 0.9 time = 420
.meas tran vdout0_26ck83 FIND v(dout0_26) AT=420.025n

* CHECK dout0_27 Vdout0_27ck83 = 0 time = 420
.meas tran vdout0_27ck83 FIND v(dout0_27) AT=420.025n

* CHECK dout0_28 Vdout0_28ck83 = 0.9 time = 420
.meas tran vdout0_28ck83 FIND v(dout0_28) AT=420.025n

* CHECK dout0_29 Vdout0_29ck83 = 0.9 time = 420
.meas tran vdout0_29ck83 FIND v(dout0_29) AT=420.025n

* CHECK dout0_30 Vdout0_30ck83 = 0 time = 420
.meas tran vdout0_30ck83 FIND v(dout0_30) AT=420.025n

* CHECK dout0_31 Vdout0_31ck83 = 0.9 time = 420
.meas tran vdout0_31ck83 FIND v(dout0_31) AT=420.025n

* CHECK dout0_32 Vdout0_32ck83 = 0 time = 420
.meas tran vdout0_32ck83 FIND v(dout0_32) AT=420.025n

* CHECK dout0_33 Vdout0_33ck83 = 0.9 time = 420
.meas tran vdout0_33ck83 FIND v(dout0_33) AT=420.025n

* CHECK dout0_34 Vdout0_34ck83 = 0.9 time = 420
.meas tran vdout0_34ck83 FIND v(dout0_34) AT=420.025n

* CHECK dout0_35 Vdout0_35ck83 = 0.9 time = 420
.meas tran vdout0_35ck83 FIND v(dout0_35) AT=420.025n

* CHECK dout0_36 Vdout0_36ck83 = 0 time = 420
.meas tran vdout0_36ck83 FIND v(dout0_36) AT=420.025n

* CHECK dout0_37 Vdout0_37ck83 = 0 time = 420
.meas tran vdout0_37ck83 FIND v(dout0_37) AT=420.025n

* CHECK dout0_38 Vdout0_38ck83 = 0 time = 420
.meas tran vdout0_38ck83 FIND v(dout0_38) AT=420.025n

* CHECK dout0_39 Vdout0_39ck83 = 0.9 time = 420
.meas tran vdout0_39ck83 FIND v(dout0_39) AT=420.025n

* CHECK dout0_40 Vdout0_40ck83 = 0 time = 420
.meas tran vdout0_40ck83 FIND v(dout0_40) AT=420.025n

* CHECK dout0_41 Vdout0_41ck83 = 0.9 time = 420
.meas tran vdout0_41ck83 FIND v(dout0_41) AT=420.025n

* CHECK dout0_42 Vdout0_42ck83 = 0.9 time = 420
.meas tran vdout0_42ck83 FIND v(dout0_42) AT=420.025n

* CHECK dout0_43 Vdout0_43ck83 = 0 time = 420
.meas tran vdout0_43ck83 FIND v(dout0_43) AT=420.025n

* CHECK dout0_44 Vdout0_44ck83 = 0 time = 420
.meas tran vdout0_44ck83 FIND v(dout0_44) AT=420.025n

* CHECK dout0_45 Vdout0_45ck83 = 0.9 time = 420
.meas tran vdout0_45ck83 FIND v(dout0_45) AT=420.025n

* CHECK dout0_46 Vdout0_46ck83 = 0 time = 420
.meas tran vdout0_46ck83 FIND v(dout0_46) AT=420.025n

* CHECK dout0_47 Vdout0_47ck83 = 0.9 time = 420
.meas tran vdout0_47ck83 FIND v(dout0_47) AT=420.025n

* CHECK dout0_48 Vdout0_48ck83 = 0 time = 420
.meas tran vdout0_48ck83 FIND v(dout0_48) AT=420.025n

* CHECK dout0_49 Vdout0_49ck83 = 0 time = 420
.meas tran vdout0_49ck83 FIND v(dout0_49) AT=420.025n

* CHECK dout0_50 Vdout0_50ck83 = 0.9 time = 420
.meas tran vdout0_50ck83 FIND v(dout0_50) AT=420.025n

* CHECK dout0_51 Vdout0_51ck83 = 0.9 time = 420
.meas tran vdout0_51ck83 FIND v(dout0_51) AT=420.025n

* CHECK dout0_52 Vdout0_52ck83 = 0 time = 420
.meas tran vdout0_52ck83 FIND v(dout0_52) AT=420.025n

* CHECK dout0_53 Vdout0_53ck83 = 0.9 time = 420
.meas tran vdout0_53ck83 FIND v(dout0_53) AT=420.025n

* CHECK dout0_54 Vdout0_54ck83 = 0.9 time = 420
.meas tran vdout0_54ck83 FIND v(dout0_54) AT=420.025n

* CHECK dout0_55 Vdout0_55ck83 = 0 time = 420
.meas tran vdout0_55ck83 FIND v(dout0_55) AT=420.025n

* CHECK dout0_56 Vdout0_56ck83 = 0 time = 420
.meas tran vdout0_56ck83 FIND v(dout0_56) AT=420.025n

* CHECK dout0_57 Vdout0_57ck83 = 0.9 time = 420
.meas tran vdout0_57ck83 FIND v(dout0_57) AT=420.025n

* CHECK dout0_58 Vdout0_58ck83 = 0.9 time = 420
.meas tran vdout0_58ck83 FIND v(dout0_58) AT=420.025n

* CHECK dout0_59 Vdout0_59ck83 = 0 time = 420
.meas tran vdout0_59ck83 FIND v(dout0_59) AT=420.025n

* CHECK dout0_60 Vdout0_60ck83 = 0 time = 420
.meas tran vdout0_60ck83 FIND v(dout0_60) AT=420.025n

* CHECK dout0_61 Vdout0_61ck83 = 0 time = 420
.meas tran vdout0_61ck83 FIND v(dout0_61) AT=420.025n

* CHECK dout0_62 Vdout0_62ck83 = 0.9 time = 420
.meas tran vdout0_62ck83 FIND v(dout0_62) AT=420.025n

* CHECK dout0_63 Vdout0_63ck83 = 0 time = 420
.meas tran vdout0_63ck83 FIND v(dout0_63) AT=420.025n

* CHECK dout0_0 Vdout0_0ck85 = 0.9 time = 430
.meas tran vdout0_0ck85 FIND v(dout0_0) AT=430.025n

* CHECK dout0_1 Vdout0_1ck85 = 0.9 time = 430
.meas tran vdout0_1ck85 FIND v(dout0_1) AT=430.025n

* CHECK dout0_2 Vdout0_2ck85 = 0 time = 430
.meas tran vdout0_2ck85 FIND v(dout0_2) AT=430.025n

* CHECK dout0_3 Vdout0_3ck85 = 0 time = 430
.meas tran vdout0_3ck85 FIND v(dout0_3) AT=430.025n

* CHECK dout0_4 Vdout0_4ck85 = 0.9 time = 430
.meas tran vdout0_4ck85 FIND v(dout0_4) AT=430.025n

* CHECK dout0_5 Vdout0_5ck85 = 0.9 time = 430
.meas tran vdout0_5ck85 FIND v(dout0_5) AT=430.025n

* CHECK dout0_6 Vdout0_6ck85 = 0.9 time = 430
.meas tran vdout0_6ck85 FIND v(dout0_6) AT=430.025n

* CHECK dout0_7 Vdout0_7ck85 = 0.9 time = 430
.meas tran vdout0_7ck85 FIND v(dout0_7) AT=430.025n

* CHECK dout0_8 Vdout0_8ck85 = 0 time = 430
.meas tran vdout0_8ck85 FIND v(dout0_8) AT=430.025n

* CHECK dout0_9 Vdout0_9ck85 = 0 time = 430
.meas tran vdout0_9ck85 FIND v(dout0_9) AT=430.025n

* CHECK dout0_10 Vdout0_10ck85 = 0 time = 430
.meas tran vdout0_10ck85 FIND v(dout0_10) AT=430.025n

* CHECK dout0_11 Vdout0_11ck85 = 0 time = 430
.meas tran vdout0_11ck85 FIND v(dout0_11) AT=430.025n

* CHECK dout0_12 Vdout0_12ck85 = 0.9 time = 430
.meas tran vdout0_12ck85 FIND v(dout0_12) AT=430.025n

* CHECK dout0_13 Vdout0_13ck85 = 0 time = 430
.meas tran vdout0_13ck85 FIND v(dout0_13) AT=430.025n

* CHECK dout0_14 Vdout0_14ck85 = 0.9 time = 430
.meas tran vdout0_14ck85 FIND v(dout0_14) AT=430.025n

* CHECK dout0_15 Vdout0_15ck85 = 0.9 time = 430
.meas tran vdout0_15ck85 FIND v(dout0_15) AT=430.025n

* CHECK dout0_16 Vdout0_16ck85 = 0 time = 430
.meas tran vdout0_16ck85 FIND v(dout0_16) AT=430.025n

* CHECK dout0_17 Vdout0_17ck85 = 0 time = 430
.meas tran vdout0_17ck85 FIND v(dout0_17) AT=430.025n

* CHECK dout0_18 Vdout0_18ck85 = 0.9 time = 430
.meas tran vdout0_18ck85 FIND v(dout0_18) AT=430.025n

* CHECK dout0_19 Vdout0_19ck85 = 0.9 time = 430
.meas tran vdout0_19ck85 FIND v(dout0_19) AT=430.025n

* CHECK dout0_20 Vdout0_20ck85 = 0.9 time = 430
.meas tran vdout0_20ck85 FIND v(dout0_20) AT=430.025n

* CHECK dout0_21 Vdout0_21ck85 = 0 time = 430
.meas tran vdout0_21ck85 FIND v(dout0_21) AT=430.025n

* CHECK dout0_22 Vdout0_22ck85 = 0 time = 430
.meas tran vdout0_22ck85 FIND v(dout0_22) AT=430.025n

* CHECK dout0_23 Vdout0_23ck85 = 0.9 time = 430
.meas tran vdout0_23ck85 FIND v(dout0_23) AT=430.025n

* CHECK dout0_24 Vdout0_24ck85 = 0.9 time = 430
.meas tran vdout0_24ck85 FIND v(dout0_24) AT=430.025n

* CHECK dout0_25 Vdout0_25ck85 = 0.9 time = 430
.meas tran vdout0_25ck85 FIND v(dout0_25) AT=430.025n

* CHECK dout0_26 Vdout0_26ck85 = 0.9 time = 430
.meas tran vdout0_26ck85 FIND v(dout0_26) AT=430.025n

* CHECK dout0_27 Vdout0_27ck85 = 0.9 time = 430
.meas tran vdout0_27ck85 FIND v(dout0_27) AT=430.025n

* CHECK dout0_28 Vdout0_28ck85 = 0.9 time = 430
.meas tran vdout0_28ck85 FIND v(dout0_28) AT=430.025n

* CHECK dout0_29 Vdout0_29ck85 = 0.9 time = 430
.meas tran vdout0_29ck85 FIND v(dout0_29) AT=430.025n

* CHECK dout0_30 Vdout0_30ck85 = 0.9 time = 430
.meas tran vdout0_30ck85 FIND v(dout0_30) AT=430.025n

* CHECK dout0_31 Vdout0_31ck85 = 0 time = 430
.meas tran vdout0_31ck85 FIND v(dout0_31) AT=430.025n

* CHECK dout0_32 Vdout0_32ck85 = 0.9 time = 430
.meas tran vdout0_32ck85 FIND v(dout0_32) AT=430.025n

* CHECK dout0_33 Vdout0_33ck85 = 0 time = 430
.meas tran vdout0_33ck85 FIND v(dout0_33) AT=430.025n

* CHECK dout0_34 Vdout0_34ck85 = 0.9 time = 430
.meas tran vdout0_34ck85 FIND v(dout0_34) AT=430.025n

* CHECK dout0_35 Vdout0_35ck85 = 0.9 time = 430
.meas tran vdout0_35ck85 FIND v(dout0_35) AT=430.025n

* CHECK dout0_36 Vdout0_36ck85 = 0 time = 430
.meas tran vdout0_36ck85 FIND v(dout0_36) AT=430.025n

* CHECK dout0_37 Vdout0_37ck85 = 0 time = 430
.meas tran vdout0_37ck85 FIND v(dout0_37) AT=430.025n

* CHECK dout0_38 Vdout0_38ck85 = 0.9 time = 430
.meas tran vdout0_38ck85 FIND v(dout0_38) AT=430.025n

* CHECK dout0_39 Vdout0_39ck85 = 0 time = 430
.meas tran vdout0_39ck85 FIND v(dout0_39) AT=430.025n

* CHECK dout0_40 Vdout0_40ck85 = 0 time = 430
.meas tran vdout0_40ck85 FIND v(dout0_40) AT=430.025n

* CHECK dout0_41 Vdout0_41ck85 = 0 time = 430
.meas tran vdout0_41ck85 FIND v(dout0_41) AT=430.025n

* CHECK dout0_42 Vdout0_42ck85 = 0 time = 430
.meas tran vdout0_42ck85 FIND v(dout0_42) AT=430.025n

* CHECK dout0_43 Vdout0_43ck85 = 0 time = 430
.meas tran vdout0_43ck85 FIND v(dout0_43) AT=430.025n

* CHECK dout0_44 Vdout0_44ck85 = 0 time = 430
.meas tran vdout0_44ck85 FIND v(dout0_44) AT=430.025n

* CHECK dout0_45 Vdout0_45ck85 = 0 time = 430
.meas tran vdout0_45ck85 FIND v(dout0_45) AT=430.025n

* CHECK dout0_46 Vdout0_46ck85 = 0 time = 430
.meas tran vdout0_46ck85 FIND v(dout0_46) AT=430.025n

* CHECK dout0_47 Vdout0_47ck85 = 0 time = 430
.meas tran vdout0_47ck85 FIND v(dout0_47) AT=430.025n

* CHECK dout0_48 Vdout0_48ck85 = 0 time = 430
.meas tran vdout0_48ck85 FIND v(dout0_48) AT=430.025n

* CHECK dout0_49 Vdout0_49ck85 = 0.9 time = 430
.meas tran vdout0_49ck85 FIND v(dout0_49) AT=430.025n

* CHECK dout0_50 Vdout0_50ck85 = 0.9 time = 430
.meas tran vdout0_50ck85 FIND v(dout0_50) AT=430.025n

* CHECK dout0_51 Vdout0_51ck85 = 0 time = 430
.meas tran vdout0_51ck85 FIND v(dout0_51) AT=430.025n

* CHECK dout0_52 Vdout0_52ck85 = 0.9 time = 430
.meas tran vdout0_52ck85 FIND v(dout0_52) AT=430.025n

* CHECK dout0_53 Vdout0_53ck85 = 0.9 time = 430
.meas tran vdout0_53ck85 FIND v(dout0_53) AT=430.025n

* CHECK dout0_54 Vdout0_54ck85 = 0 time = 430
.meas tran vdout0_54ck85 FIND v(dout0_54) AT=430.025n

* CHECK dout0_55 Vdout0_55ck85 = 0 time = 430
.meas tran vdout0_55ck85 FIND v(dout0_55) AT=430.025n

* CHECK dout0_56 Vdout0_56ck85 = 0.9 time = 430
.meas tran vdout0_56ck85 FIND v(dout0_56) AT=430.025n

* CHECK dout0_57 Vdout0_57ck85 = 0 time = 430
.meas tran vdout0_57ck85 FIND v(dout0_57) AT=430.025n

* CHECK dout0_58 Vdout0_58ck85 = 0.9 time = 430
.meas tran vdout0_58ck85 FIND v(dout0_58) AT=430.025n

* CHECK dout0_59 Vdout0_59ck85 = 0 time = 430
.meas tran vdout0_59ck85 FIND v(dout0_59) AT=430.025n

* CHECK dout0_60 Vdout0_60ck85 = 0.9 time = 430
.meas tran vdout0_60ck85 FIND v(dout0_60) AT=430.025n

* CHECK dout0_61 Vdout0_61ck85 = 0 time = 430
.meas tran vdout0_61ck85 FIND v(dout0_61) AT=430.025n

* CHECK dout0_62 Vdout0_62ck85 = 0 time = 430
.meas tran vdout0_62ck85 FIND v(dout0_62) AT=430.025n

* CHECK dout0_63 Vdout0_63ck85 = 0.9 time = 430
.meas tran vdout0_63ck85 FIND v(dout0_63) AT=430.025n

* CHECK dout0_0 Vdout0_0ck86 = 0.9 time = 435
.meas tran vdout0_0ck86 FIND v(dout0_0) AT=435.025n

* CHECK dout0_1 Vdout0_1ck86 = 0.9 time = 435
.meas tran vdout0_1ck86 FIND v(dout0_1) AT=435.025n

* CHECK dout0_2 Vdout0_2ck86 = 0 time = 435
.meas tran vdout0_2ck86 FIND v(dout0_2) AT=435.025n

* CHECK dout0_3 Vdout0_3ck86 = 0 time = 435
.meas tran vdout0_3ck86 FIND v(dout0_3) AT=435.025n

* CHECK dout0_4 Vdout0_4ck86 = 0.9 time = 435
.meas tran vdout0_4ck86 FIND v(dout0_4) AT=435.025n

* CHECK dout0_5 Vdout0_5ck86 = 0.9 time = 435
.meas tran vdout0_5ck86 FIND v(dout0_5) AT=435.025n

* CHECK dout0_6 Vdout0_6ck86 = 0.9 time = 435
.meas tran vdout0_6ck86 FIND v(dout0_6) AT=435.025n

* CHECK dout0_7 Vdout0_7ck86 = 0.9 time = 435
.meas tran vdout0_7ck86 FIND v(dout0_7) AT=435.025n

* CHECK dout0_8 Vdout0_8ck86 = 0 time = 435
.meas tran vdout0_8ck86 FIND v(dout0_8) AT=435.025n

* CHECK dout0_9 Vdout0_9ck86 = 0 time = 435
.meas tran vdout0_9ck86 FIND v(dout0_9) AT=435.025n

* CHECK dout0_10 Vdout0_10ck86 = 0 time = 435
.meas tran vdout0_10ck86 FIND v(dout0_10) AT=435.025n

* CHECK dout0_11 Vdout0_11ck86 = 0 time = 435
.meas tran vdout0_11ck86 FIND v(dout0_11) AT=435.025n

* CHECK dout0_12 Vdout0_12ck86 = 0.9 time = 435
.meas tran vdout0_12ck86 FIND v(dout0_12) AT=435.025n

* CHECK dout0_13 Vdout0_13ck86 = 0 time = 435
.meas tran vdout0_13ck86 FIND v(dout0_13) AT=435.025n

* CHECK dout0_14 Vdout0_14ck86 = 0.9 time = 435
.meas tran vdout0_14ck86 FIND v(dout0_14) AT=435.025n

* CHECK dout0_15 Vdout0_15ck86 = 0.9 time = 435
.meas tran vdout0_15ck86 FIND v(dout0_15) AT=435.025n

* CHECK dout0_16 Vdout0_16ck86 = 0 time = 435
.meas tran vdout0_16ck86 FIND v(dout0_16) AT=435.025n

* CHECK dout0_17 Vdout0_17ck86 = 0 time = 435
.meas tran vdout0_17ck86 FIND v(dout0_17) AT=435.025n

* CHECK dout0_18 Vdout0_18ck86 = 0.9 time = 435
.meas tran vdout0_18ck86 FIND v(dout0_18) AT=435.025n

* CHECK dout0_19 Vdout0_19ck86 = 0.9 time = 435
.meas tran vdout0_19ck86 FIND v(dout0_19) AT=435.025n

* CHECK dout0_20 Vdout0_20ck86 = 0.9 time = 435
.meas tran vdout0_20ck86 FIND v(dout0_20) AT=435.025n

* CHECK dout0_21 Vdout0_21ck86 = 0 time = 435
.meas tran vdout0_21ck86 FIND v(dout0_21) AT=435.025n

* CHECK dout0_22 Vdout0_22ck86 = 0 time = 435
.meas tran vdout0_22ck86 FIND v(dout0_22) AT=435.025n

* CHECK dout0_23 Vdout0_23ck86 = 0.9 time = 435
.meas tran vdout0_23ck86 FIND v(dout0_23) AT=435.025n

* CHECK dout0_24 Vdout0_24ck86 = 0.9 time = 435
.meas tran vdout0_24ck86 FIND v(dout0_24) AT=435.025n

* CHECK dout0_25 Vdout0_25ck86 = 0.9 time = 435
.meas tran vdout0_25ck86 FIND v(dout0_25) AT=435.025n

* CHECK dout0_26 Vdout0_26ck86 = 0.9 time = 435
.meas tran vdout0_26ck86 FIND v(dout0_26) AT=435.025n

* CHECK dout0_27 Vdout0_27ck86 = 0.9 time = 435
.meas tran vdout0_27ck86 FIND v(dout0_27) AT=435.025n

* CHECK dout0_28 Vdout0_28ck86 = 0.9 time = 435
.meas tran vdout0_28ck86 FIND v(dout0_28) AT=435.025n

* CHECK dout0_29 Vdout0_29ck86 = 0.9 time = 435
.meas tran vdout0_29ck86 FIND v(dout0_29) AT=435.025n

* CHECK dout0_30 Vdout0_30ck86 = 0.9 time = 435
.meas tran vdout0_30ck86 FIND v(dout0_30) AT=435.025n

* CHECK dout0_31 Vdout0_31ck86 = 0 time = 435
.meas tran vdout0_31ck86 FIND v(dout0_31) AT=435.025n

* CHECK dout0_32 Vdout0_32ck86 = 0.9 time = 435
.meas tran vdout0_32ck86 FIND v(dout0_32) AT=435.025n

* CHECK dout0_33 Vdout0_33ck86 = 0 time = 435
.meas tran vdout0_33ck86 FIND v(dout0_33) AT=435.025n

* CHECK dout0_34 Vdout0_34ck86 = 0.9 time = 435
.meas tran vdout0_34ck86 FIND v(dout0_34) AT=435.025n

* CHECK dout0_35 Vdout0_35ck86 = 0.9 time = 435
.meas tran vdout0_35ck86 FIND v(dout0_35) AT=435.025n

* CHECK dout0_36 Vdout0_36ck86 = 0 time = 435
.meas tran vdout0_36ck86 FIND v(dout0_36) AT=435.025n

* CHECK dout0_37 Vdout0_37ck86 = 0 time = 435
.meas tran vdout0_37ck86 FIND v(dout0_37) AT=435.025n

* CHECK dout0_38 Vdout0_38ck86 = 0.9 time = 435
.meas tran vdout0_38ck86 FIND v(dout0_38) AT=435.025n

* CHECK dout0_39 Vdout0_39ck86 = 0 time = 435
.meas tran vdout0_39ck86 FIND v(dout0_39) AT=435.025n

* CHECK dout0_40 Vdout0_40ck86 = 0 time = 435
.meas tran vdout0_40ck86 FIND v(dout0_40) AT=435.025n

* CHECK dout0_41 Vdout0_41ck86 = 0 time = 435
.meas tran vdout0_41ck86 FIND v(dout0_41) AT=435.025n

* CHECK dout0_42 Vdout0_42ck86 = 0 time = 435
.meas tran vdout0_42ck86 FIND v(dout0_42) AT=435.025n

* CHECK dout0_43 Vdout0_43ck86 = 0 time = 435
.meas tran vdout0_43ck86 FIND v(dout0_43) AT=435.025n

* CHECK dout0_44 Vdout0_44ck86 = 0 time = 435
.meas tran vdout0_44ck86 FIND v(dout0_44) AT=435.025n

* CHECK dout0_45 Vdout0_45ck86 = 0 time = 435
.meas tran vdout0_45ck86 FIND v(dout0_45) AT=435.025n

* CHECK dout0_46 Vdout0_46ck86 = 0 time = 435
.meas tran vdout0_46ck86 FIND v(dout0_46) AT=435.025n

* CHECK dout0_47 Vdout0_47ck86 = 0 time = 435
.meas tran vdout0_47ck86 FIND v(dout0_47) AT=435.025n

* CHECK dout0_48 Vdout0_48ck86 = 0 time = 435
.meas tran vdout0_48ck86 FIND v(dout0_48) AT=435.025n

* CHECK dout0_49 Vdout0_49ck86 = 0.9 time = 435
.meas tran vdout0_49ck86 FIND v(dout0_49) AT=435.025n

* CHECK dout0_50 Vdout0_50ck86 = 0.9 time = 435
.meas tran vdout0_50ck86 FIND v(dout0_50) AT=435.025n

* CHECK dout0_51 Vdout0_51ck86 = 0 time = 435
.meas tran vdout0_51ck86 FIND v(dout0_51) AT=435.025n

* CHECK dout0_52 Vdout0_52ck86 = 0.9 time = 435
.meas tran vdout0_52ck86 FIND v(dout0_52) AT=435.025n

* CHECK dout0_53 Vdout0_53ck86 = 0.9 time = 435
.meas tran vdout0_53ck86 FIND v(dout0_53) AT=435.025n

* CHECK dout0_54 Vdout0_54ck86 = 0 time = 435
.meas tran vdout0_54ck86 FIND v(dout0_54) AT=435.025n

* CHECK dout0_55 Vdout0_55ck86 = 0 time = 435
.meas tran vdout0_55ck86 FIND v(dout0_55) AT=435.025n

* CHECK dout0_56 Vdout0_56ck86 = 0.9 time = 435
.meas tran vdout0_56ck86 FIND v(dout0_56) AT=435.025n

* CHECK dout0_57 Vdout0_57ck86 = 0 time = 435
.meas tran vdout0_57ck86 FIND v(dout0_57) AT=435.025n

* CHECK dout0_58 Vdout0_58ck86 = 0.9 time = 435
.meas tran vdout0_58ck86 FIND v(dout0_58) AT=435.025n

* CHECK dout0_59 Vdout0_59ck86 = 0 time = 435
.meas tran vdout0_59ck86 FIND v(dout0_59) AT=435.025n

* CHECK dout0_60 Vdout0_60ck86 = 0.9 time = 435
.meas tran vdout0_60ck86 FIND v(dout0_60) AT=435.025n

* CHECK dout0_61 Vdout0_61ck86 = 0 time = 435
.meas tran vdout0_61ck86 FIND v(dout0_61) AT=435.025n

* CHECK dout0_62 Vdout0_62ck86 = 0 time = 435
.meas tran vdout0_62ck86 FIND v(dout0_62) AT=435.025n

* CHECK dout0_63 Vdout0_63ck86 = 0.9 time = 435
.meas tran vdout0_63ck86 FIND v(dout0_63) AT=435.025n

* CHECK dout0_0 Vdout0_0ck87 = 0 time = 440
.meas tran vdout0_0ck87 FIND v(dout0_0) AT=440.025n

* CHECK dout0_1 Vdout0_1ck87 = 0.9 time = 440
.meas tran vdout0_1ck87 FIND v(dout0_1) AT=440.025n

* CHECK dout0_2 Vdout0_2ck87 = 0 time = 440
.meas tran vdout0_2ck87 FIND v(dout0_2) AT=440.025n

* CHECK dout0_3 Vdout0_3ck87 = 0.9 time = 440
.meas tran vdout0_3ck87 FIND v(dout0_3) AT=440.025n

* CHECK dout0_4 Vdout0_4ck87 = 0.9 time = 440
.meas tran vdout0_4ck87 FIND v(dout0_4) AT=440.025n

* CHECK dout0_5 Vdout0_5ck87 = 0 time = 440
.meas tran vdout0_5ck87 FIND v(dout0_5) AT=440.025n

* CHECK dout0_6 Vdout0_6ck87 = 0.9 time = 440
.meas tran vdout0_6ck87 FIND v(dout0_6) AT=440.025n

* CHECK dout0_7 Vdout0_7ck87 = 0 time = 440
.meas tran vdout0_7ck87 FIND v(dout0_7) AT=440.025n

* CHECK dout0_8 Vdout0_8ck87 = 0 time = 440
.meas tran vdout0_8ck87 FIND v(dout0_8) AT=440.025n

* CHECK dout0_9 Vdout0_9ck87 = 0.9 time = 440
.meas tran vdout0_9ck87 FIND v(dout0_9) AT=440.025n

* CHECK dout0_10 Vdout0_10ck87 = 0.9 time = 440
.meas tran vdout0_10ck87 FIND v(dout0_10) AT=440.025n

* CHECK dout0_11 Vdout0_11ck87 = 0.9 time = 440
.meas tran vdout0_11ck87 FIND v(dout0_11) AT=440.025n

* CHECK dout0_12 Vdout0_12ck87 = 0.9 time = 440
.meas tran vdout0_12ck87 FIND v(dout0_12) AT=440.025n

* CHECK dout0_13 Vdout0_13ck87 = 0 time = 440
.meas tran vdout0_13ck87 FIND v(dout0_13) AT=440.025n

* CHECK dout0_14 Vdout0_14ck87 = 0.9 time = 440
.meas tran vdout0_14ck87 FIND v(dout0_14) AT=440.025n

* CHECK dout0_15 Vdout0_15ck87 = 0.9 time = 440
.meas tran vdout0_15ck87 FIND v(dout0_15) AT=440.025n

* CHECK dout0_16 Vdout0_16ck87 = 0 time = 440
.meas tran vdout0_16ck87 FIND v(dout0_16) AT=440.025n

* CHECK dout0_17 Vdout0_17ck87 = 0 time = 440
.meas tran vdout0_17ck87 FIND v(dout0_17) AT=440.025n

* CHECK dout0_18 Vdout0_18ck87 = 0.9 time = 440
.meas tran vdout0_18ck87 FIND v(dout0_18) AT=440.025n

* CHECK dout0_19 Vdout0_19ck87 = 0 time = 440
.meas tran vdout0_19ck87 FIND v(dout0_19) AT=440.025n

* CHECK dout0_20 Vdout0_20ck87 = 0 time = 440
.meas tran vdout0_20ck87 FIND v(dout0_20) AT=440.025n

* CHECK dout0_21 Vdout0_21ck87 = 0 time = 440
.meas tran vdout0_21ck87 FIND v(dout0_21) AT=440.025n

* CHECK dout0_22 Vdout0_22ck87 = 0 time = 440
.meas tran vdout0_22ck87 FIND v(dout0_22) AT=440.025n

* CHECK dout0_23 Vdout0_23ck87 = 0.9 time = 440
.meas tran vdout0_23ck87 FIND v(dout0_23) AT=440.025n

* CHECK dout0_24 Vdout0_24ck87 = 0 time = 440
.meas tran vdout0_24ck87 FIND v(dout0_24) AT=440.025n

* CHECK dout0_25 Vdout0_25ck87 = 0.9 time = 440
.meas tran vdout0_25ck87 FIND v(dout0_25) AT=440.025n

* CHECK dout0_26 Vdout0_26ck87 = 0.9 time = 440
.meas tran vdout0_26ck87 FIND v(dout0_26) AT=440.025n

* CHECK dout0_27 Vdout0_27ck87 = 0 time = 440
.meas tran vdout0_27ck87 FIND v(dout0_27) AT=440.025n

* CHECK dout0_28 Vdout0_28ck87 = 0.9 time = 440
.meas tran vdout0_28ck87 FIND v(dout0_28) AT=440.025n

* CHECK dout0_29 Vdout0_29ck87 = 0.9 time = 440
.meas tran vdout0_29ck87 FIND v(dout0_29) AT=440.025n

* CHECK dout0_30 Vdout0_30ck87 = 0 time = 440
.meas tran vdout0_30ck87 FIND v(dout0_30) AT=440.025n

* CHECK dout0_31 Vdout0_31ck87 = 0.9 time = 440
.meas tran vdout0_31ck87 FIND v(dout0_31) AT=440.025n

* CHECK dout0_32 Vdout0_32ck87 = 0 time = 440
.meas tran vdout0_32ck87 FIND v(dout0_32) AT=440.025n

* CHECK dout0_33 Vdout0_33ck87 = 0.9 time = 440
.meas tran vdout0_33ck87 FIND v(dout0_33) AT=440.025n

* CHECK dout0_34 Vdout0_34ck87 = 0.9 time = 440
.meas tran vdout0_34ck87 FIND v(dout0_34) AT=440.025n

* CHECK dout0_35 Vdout0_35ck87 = 0.9 time = 440
.meas tran vdout0_35ck87 FIND v(dout0_35) AT=440.025n

* CHECK dout0_36 Vdout0_36ck87 = 0 time = 440
.meas tran vdout0_36ck87 FIND v(dout0_36) AT=440.025n

* CHECK dout0_37 Vdout0_37ck87 = 0 time = 440
.meas tran vdout0_37ck87 FIND v(dout0_37) AT=440.025n

* CHECK dout0_38 Vdout0_38ck87 = 0 time = 440
.meas tran vdout0_38ck87 FIND v(dout0_38) AT=440.025n

* CHECK dout0_39 Vdout0_39ck87 = 0.9 time = 440
.meas tran vdout0_39ck87 FIND v(dout0_39) AT=440.025n

* CHECK dout0_40 Vdout0_40ck87 = 0 time = 440
.meas tran vdout0_40ck87 FIND v(dout0_40) AT=440.025n

* CHECK dout0_41 Vdout0_41ck87 = 0.9 time = 440
.meas tran vdout0_41ck87 FIND v(dout0_41) AT=440.025n

* CHECK dout0_42 Vdout0_42ck87 = 0.9 time = 440
.meas tran vdout0_42ck87 FIND v(dout0_42) AT=440.025n

* CHECK dout0_43 Vdout0_43ck87 = 0 time = 440
.meas tran vdout0_43ck87 FIND v(dout0_43) AT=440.025n

* CHECK dout0_44 Vdout0_44ck87 = 0 time = 440
.meas tran vdout0_44ck87 FIND v(dout0_44) AT=440.025n

* CHECK dout0_45 Vdout0_45ck87 = 0.9 time = 440
.meas tran vdout0_45ck87 FIND v(dout0_45) AT=440.025n

* CHECK dout0_46 Vdout0_46ck87 = 0 time = 440
.meas tran vdout0_46ck87 FIND v(dout0_46) AT=440.025n

* CHECK dout0_47 Vdout0_47ck87 = 0.9 time = 440
.meas tran vdout0_47ck87 FIND v(dout0_47) AT=440.025n

* CHECK dout0_48 Vdout0_48ck87 = 0 time = 440
.meas tran vdout0_48ck87 FIND v(dout0_48) AT=440.025n

* CHECK dout0_49 Vdout0_49ck87 = 0 time = 440
.meas tran vdout0_49ck87 FIND v(dout0_49) AT=440.025n

* CHECK dout0_50 Vdout0_50ck87 = 0.9 time = 440
.meas tran vdout0_50ck87 FIND v(dout0_50) AT=440.025n

* CHECK dout0_51 Vdout0_51ck87 = 0.9 time = 440
.meas tran vdout0_51ck87 FIND v(dout0_51) AT=440.025n

* CHECK dout0_52 Vdout0_52ck87 = 0 time = 440
.meas tran vdout0_52ck87 FIND v(dout0_52) AT=440.025n

* CHECK dout0_53 Vdout0_53ck87 = 0.9 time = 440
.meas tran vdout0_53ck87 FIND v(dout0_53) AT=440.025n

* CHECK dout0_54 Vdout0_54ck87 = 0.9 time = 440
.meas tran vdout0_54ck87 FIND v(dout0_54) AT=440.025n

* CHECK dout0_55 Vdout0_55ck87 = 0 time = 440
.meas tran vdout0_55ck87 FIND v(dout0_55) AT=440.025n

* CHECK dout0_56 Vdout0_56ck87 = 0 time = 440
.meas tran vdout0_56ck87 FIND v(dout0_56) AT=440.025n

* CHECK dout0_57 Vdout0_57ck87 = 0.9 time = 440
.meas tran vdout0_57ck87 FIND v(dout0_57) AT=440.025n

* CHECK dout0_58 Vdout0_58ck87 = 0.9 time = 440
.meas tran vdout0_58ck87 FIND v(dout0_58) AT=440.025n

* CHECK dout0_59 Vdout0_59ck87 = 0 time = 440
.meas tran vdout0_59ck87 FIND v(dout0_59) AT=440.025n

* CHECK dout0_60 Vdout0_60ck87 = 0 time = 440
.meas tran vdout0_60ck87 FIND v(dout0_60) AT=440.025n

* CHECK dout0_61 Vdout0_61ck87 = 0 time = 440
.meas tran vdout0_61ck87 FIND v(dout0_61) AT=440.025n

* CHECK dout0_62 Vdout0_62ck87 = 0.9 time = 440
.meas tran vdout0_62ck87 FIND v(dout0_62) AT=440.025n

* CHECK dout0_63 Vdout0_63ck87 = 0 time = 440
.meas tran vdout0_63ck87 FIND v(dout0_63) AT=440.025n

* CHECK dout0_0 Vdout0_0ck89 = 0 time = 450
.meas tran vdout0_0ck89 FIND v(dout0_0) AT=450.025n

* CHECK dout0_1 Vdout0_1ck89 = 0.9 time = 450
.meas tran vdout0_1ck89 FIND v(dout0_1) AT=450.025n

* CHECK dout0_2 Vdout0_2ck89 = 0 time = 450
.meas tran vdout0_2ck89 FIND v(dout0_2) AT=450.025n

* CHECK dout0_3 Vdout0_3ck89 = 0.9 time = 450
.meas tran vdout0_3ck89 FIND v(dout0_3) AT=450.025n

* CHECK dout0_4 Vdout0_4ck89 = 0 time = 450
.meas tran vdout0_4ck89 FIND v(dout0_4) AT=450.025n

* CHECK dout0_5 Vdout0_5ck89 = 0.9 time = 450
.meas tran vdout0_5ck89 FIND v(dout0_5) AT=450.025n

* CHECK dout0_6 Vdout0_6ck89 = 0.9 time = 450
.meas tran vdout0_6ck89 FIND v(dout0_6) AT=450.025n

* CHECK dout0_7 Vdout0_7ck89 = 0.9 time = 450
.meas tran vdout0_7ck89 FIND v(dout0_7) AT=450.025n

* CHECK dout0_8 Vdout0_8ck89 = 0 time = 450
.meas tran vdout0_8ck89 FIND v(dout0_8) AT=450.025n

* CHECK dout0_9 Vdout0_9ck89 = 0.9 time = 450
.meas tran vdout0_9ck89 FIND v(dout0_9) AT=450.025n

* CHECK dout0_10 Vdout0_10ck89 = 0.9 time = 450
.meas tran vdout0_10ck89 FIND v(dout0_10) AT=450.025n

* CHECK dout0_11 Vdout0_11ck89 = 0 time = 450
.meas tran vdout0_11ck89 FIND v(dout0_11) AT=450.025n

* CHECK dout0_12 Vdout0_12ck89 = 0.9 time = 450
.meas tran vdout0_12ck89 FIND v(dout0_12) AT=450.025n

* CHECK dout0_13 Vdout0_13ck89 = 0 time = 450
.meas tran vdout0_13ck89 FIND v(dout0_13) AT=450.025n

* CHECK dout0_14 Vdout0_14ck89 = 0 time = 450
.meas tran vdout0_14ck89 FIND v(dout0_14) AT=450.025n

* CHECK dout0_15 Vdout0_15ck89 = 0 time = 450
.meas tran vdout0_15ck89 FIND v(dout0_15) AT=450.025n

* CHECK dout0_16 Vdout0_16ck89 = 0 time = 450
.meas tran vdout0_16ck89 FIND v(dout0_16) AT=450.025n

* CHECK dout0_17 Vdout0_17ck89 = 0 time = 450
.meas tran vdout0_17ck89 FIND v(dout0_17) AT=450.025n

* CHECK dout0_18 Vdout0_18ck89 = 0.9 time = 450
.meas tran vdout0_18ck89 FIND v(dout0_18) AT=450.025n

* CHECK dout0_19 Vdout0_19ck89 = 0.9 time = 450
.meas tran vdout0_19ck89 FIND v(dout0_19) AT=450.025n

* CHECK dout0_20 Vdout0_20ck89 = 0.9 time = 450
.meas tran vdout0_20ck89 FIND v(dout0_20) AT=450.025n

* CHECK dout0_21 Vdout0_21ck89 = 0.9 time = 450
.meas tran vdout0_21ck89 FIND v(dout0_21) AT=450.025n

* CHECK dout0_22 Vdout0_22ck89 = 0.9 time = 450
.meas tran vdout0_22ck89 FIND v(dout0_22) AT=450.025n

* CHECK dout0_23 Vdout0_23ck89 = 0 time = 450
.meas tran vdout0_23ck89 FIND v(dout0_23) AT=450.025n

* CHECK dout0_24 Vdout0_24ck89 = 0 time = 450
.meas tran vdout0_24ck89 FIND v(dout0_24) AT=450.025n

* CHECK dout0_25 Vdout0_25ck89 = 0.9 time = 450
.meas tran vdout0_25ck89 FIND v(dout0_25) AT=450.025n

* CHECK dout0_26 Vdout0_26ck89 = 0.9 time = 450
.meas tran vdout0_26ck89 FIND v(dout0_26) AT=450.025n

* CHECK dout0_27 Vdout0_27ck89 = 0.9 time = 450
.meas tran vdout0_27ck89 FIND v(dout0_27) AT=450.025n

* CHECK dout0_28 Vdout0_28ck89 = 0 time = 450
.meas tran vdout0_28ck89 FIND v(dout0_28) AT=450.025n

* CHECK dout0_29 Vdout0_29ck89 = 0.9 time = 450
.meas tran vdout0_29ck89 FIND v(dout0_29) AT=450.025n

* CHECK dout0_30 Vdout0_30ck89 = 0.9 time = 450
.meas tran vdout0_30ck89 FIND v(dout0_30) AT=450.025n

* CHECK dout0_31 Vdout0_31ck89 = 0.9 time = 450
.meas tran vdout0_31ck89 FIND v(dout0_31) AT=450.025n

* CHECK dout0_32 Vdout0_32ck89 = 0.9 time = 450
.meas tran vdout0_32ck89 FIND v(dout0_32) AT=450.025n

* CHECK dout0_33 Vdout0_33ck89 = 0.9 time = 450
.meas tran vdout0_33ck89 FIND v(dout0_33) AT=450.025n

* CHECK dout0_34 Vdout0_34ck89 = 0 time = 450
.meas tran vdout0_34ck89 FIND v(dout0_34) AT=450.025n

* CHECK dout0_35 Vdout0_35ck89 = 0 time = 450
.meas tran vdout0_35ck89 FIND v(dout0_35) AT=450.025n

* CHECK dout0_36 Vdout0_36ck89 = 0 time = 450
.meas tran vdout0_36ck89 FIND v(dout0_36) AT=450.025n

* CHECK dout0_37 Vdout0_37ck89 = 0 time = 450
.meas tran vdout0_37ck89 FIND v(dout0_37) AT=450.025n

* CHECK dout0_38 Vdout0_38ck89 = 0.9 time = 450
.meas tran vdout0_38ck89 FIND v(dout0_38) AT=450.025n

* CHECK dout0_39 Vdout0_39ck89 = 0.9 time = 450
.meas tran vdout0_39ck89 FIND v(dout0_39) AT=450.025n

* CHECK dout0_40 Vdout0_40ck89 = 0 time = 450
.meas tran vdout0_40ck89 FIND v(dout0_40) AT=450.025n

* CHECK dout0_41 Vdout0_41ck89 = 0.9 time = 450
.meas tran vdout0_41ck89 FIND v(dout0_41) AT=450.025n

* CHECK dout0_42 Vdout0_42ck89 = 0 time = 450
.meas tran vdout0_42ck89 FIND v(dout0_42) AT=450.025n

* CHECK dout0_43 Vdout0_43ck89 = 0 time = 450
.meas tran vdout0_43ck89 FIND v(dout0_43) AT=450.025n

* CHECK dout0_44 Vdout0_44ck89 = 0.9 time = 450
.meas tran vdout0_44ck89 FIND v(dout0_44) AT=450.025n

* CHECK dout0_45 Vdout0_45ck89 = 0.9 time = 450
.meas tran vdout0_45ck89 FIND v(dout0_45) AT=450.025n

* CHECK dout0_46 Vdout0_46ck89 = 0.9 time = 450
.meas tran vdout0_46ck89 FIND v(dout0_46) AT=450.025n

* CHECK dout0_47 Vdout0_47ck89 = 0.9 time = 450
.meas tran vdout0_47ck89 FIND v(dout0_47) AT=450.025n

* CHECK dout0_48 Vdout0_48ck89 = 0 time = 450
.meas tran vdout0_48ck89 FIND v(dout0_48) AT=450.025n

* CHECK dout0_49 Vdout0_49ck89 = 0 time = 450
.meas tran vdout0_49ck89 FIND v(dout0_49) AT=450.025n

* CHECK dout0_50 Vdout0_50ck89 = 0.9 time = 450
.meas tran vdout0_50ck89 FIND v(dout0_50) AT=450.025n

* CHECK dout0_51 Vdout0_51ck89 = 0.9 time = 450
.meas tran vdout0_51ck89 FIND v(dout0_51) AT=450.025n

* CHECK dout0_52 Vdout0_52ck89 = 0.9 time = 450
.meas tran vdout0_52ck89 FIND v(dout0_52) AT=450.025n

* CHECK dout0_53 Vdout0_53ck89 = 0.9 time = 450
.meas tran vdout0_53ck89 FIND v(dout0_53) AT=450.025n

* CHECK dout0_54 Vdout0_54ck89 = 0.9 time = 450
.meas tran vdout0_54ck89 FIND v(dout0_54) AT=450.025n

* CHECK dout0_55 Vdout0_55ck89 = 0 time = 450
.meas tran vdout0_55ck89 FIND v(dout0_55) AT=450.025n

* CHECK dout0_56 Vdout0_56ck89 = 0.9 time = 450
.meas tran vdout0_56ck89 FIND v(dout0_56) AT=450.025n

* CHECK dout0_57 Vdout0_57ck89 = 0.9 time = 450
.meas tran vdout0_57ck89 FIND v(dout0_57) AT=450.025n

* CHECK dout0_58 Vdout0_58ck89 = 0 time = 450
.meas tran vdout0_58ck89 FIND v(dout0_58) AT=450.025n

* CHECK dout0_59 Vdout0_59ck89 = 0.9 time = 450
.meas tran vdout0_59ck89 FIND v(dout0_59) AT=450.025n

* CHECK dout0_60 Vdout0_60ck89 = 0 time = 450
.meas tran vdout0_60ck89 FIND v(dout0_60) AT=450.025n

* CHECK dout0_61 Vdout0_61ck89 = 0 time = 450
.meas tran vdout0_61ck89 FIND v(dout0_61) AT=450.025n

* CHECK dout0_62 Vdout0_62ck89 = 0 time = 450
.meas tran vdout0_62ck89 FIND v(dout0_62) AT=450.025n

* CHECK dout0_63 Vdout0_63ck89 = 0 time = 450
.meas tran vdout0_63ck89 FIND v(dout0_63) AT=450.025n

* CHECK dout0_0 Vdout0_0ck90 = 0 time = 455
.meas tran vdout0_0ck90 FIND v(dout0_0) AT=455.025n

* CHECK dout0_1 Vdout0_1ck90 = 0.9 time = 455
.meas tran vdout0_1ck90 FIND v(dout0_1) AT=455.025n

* CHECK dout0_2 Vdout0_2ck90 = 0.9 time = 455
.meas tran vdout0_2ck90 FIND v(dout0_2) AT=455.025n

* CHECK dout0_3 Vdout0_3ck90 = 0 time = 455
.meas tran vdout0_3ck90 FIND v(dout0_3) AT=455.025n

* CHECK dout0_4 Vdout0_4ck90 = 0.9 time = 455
.meas tran vdout0_4ck90 FIND v(dout0_4) AT=455.025n

* CHECK dout0_5 Vdout0_5ck90 = 0.9 time = 455
.meas tran vdout0_5ck90 FIND v(dout0_5) AT=455.025n

* CHECK dout0_6 Vdout0_6ck90 = 0.9 time = 455
.meas tran vdout0_6ck90 FIND v(dout0_6) AT=455.025n

* CHECK dout0_7 Vdout0_7ck90 = 0 time = 455
.meas tran vdout0_7ck90 FIND v(dout0_7) AT=455.025n

* CHECK dout0_8 Vdout0_8ck90 = 0.9 time = 455
.meas tran vdout0_8ck90 FIND v(dout0_8) AT=455.025n

* CHECK dout0_9 Vdout0_9ck90 = 0.9 time = 455
.meas tran vdout0_9ck90 FIND v(dout0_9) AT=455.025n

* CHECK dout0_10 Vdout0_10ck90 = 0 time = 455
.meas tran vdout0_10ck90 FIND v(dout0_10) AT=455.025n

* CHECK dout0_11 Vdout0_11ck90 = 0.9 time = 455
.meas tran vdout0_11ck90 FIND v(dout0_11) AT=455.025n

* CHECK dout0_12 Vdout0_12ck90 = 0.9 time = 455
.meas tran vdout0_12ck90 FIND v(dout0_12) AT=455.025n

* CHECK dout0_13 Vdout0_13ck90 = 0.9 time = 455
.meas tran vdout0_13ck90 FIND v(dout0_13) AT=455.025n

* CHECK dout0_14 Vdout0_14ck90 = 0 time = 455
.meas tran vdout0_14ck90 FIND v(dout0_14) AT=455.025n

* CHECK dout0_15 Vdout0_15ck90 = 0.9 time = 455
.meas tran vdout0_15ck90 FIND v(dout0_15) AT=455.025n

* CHECK dout0_16 Vdout0_16ck90 = 0 time = 455
.meas tran vdout0_16ck90 FIND v(dout0_16) AT=455.025n

* CHECK dout0_17 Vdout0_17ck90 = 0 time = 455
.meas tran vdout0_17ck90 FIND v(dout0_17) AT=455.025n

* CHECK dout0_18 Vdout0_18ck90 = 0 time = 455
.meas tran vdout0_18ck90 FIND v(dout0_18) AT=455.025n

* CHECK dout0_19 Vdout0_19ck90 = 0 time = 455
.meas tran vdout0_19ck90 FIND v(dout0_19) AT=455.025n

* CHECK dout0_20 Vdout0_20ck90 = 0.9 time = 455
.meas tran vdout0_20ck90 FIND v(dout0_20) AT=455.025n

* CHECK dout0_21 Vdout0_21ck90 = 0.9 time = 455
.meas tran vdout0_21ck90 FIND v(dout0_21) AT=455.025n

* CHECK dout0_22 Vdout0_22ck90 = 0 time = 455
.meas tran vdout0_22ck90 FIND v(dout0_22) AT=455.025n

* CHECK dout0_23 Vdout0_23ck90 = 0.9 time = 455
.meas tran vdout0_23ck90 FIND v(dout0_23) AT=455.025n

* CHECK dout0_24 Vdout0_24ck90 = 0.9 time = 455
.meas tran vdout0_24ck90 FIND v(dout0_24) AT=455.025n

* CHECK dout0_25 Vdout0_25ck90 = 0.9 time = 455
.meas tran vdout0_25ck90 FIND v(dout0_25) AT=455.025n

* CHECK dout0_26 Vdout0_26ck90 = 0.9 time = 455
.meas tran vdout0_26ck90 FIND v(dout0_26) AT=455.025n

* CHECK dout0_27 Vdout0_27ck90 = 0.9 time = 455
.meas tran vdout0_27ck90 FIND v(dout0_27) AT=455.025n

* CHECK dout0_28 Vdout0_28ck90 = 0 time = 455
.meas tran vdout0_28ck90 FIND v(dout0_28) AT=455.025n

* CHECK dout0_29 Vdout0_29ck90 = 0.9 time = 455
.meas tran vdout0_29ck90 FIND v(dout0_29) AT=455.025n

* CHECK dout0_30 Vdout0_30ck90 = 0.9 time = 455
.meas tran vdout0_30ck90 FIND v(dout0_30) AT=455.025n

* CHECK dout0_31 Vdout0_31ck90 = 0 time = 455
.meas tran vdout0_31ck90 FIND v(dout0_31) AT=455.025n

* CHECK dout0_32 Vdout0_32ck90 = 0 time = 455
.meas tran vdout0_32ck90 FIND v(dout0_32) AT=455.025n

* CHECK dout0_33 Vdout0_33ck90 = 0 time = 455
.meas tran vdout0_33ck90 FIND v(dout0_33) AT=455.025n

* CHECK dout0_34 Vdout0_34ck90 = 0.9 time = 455
.meas tran vdout0_34ck90 FIND v(dout0_34) AT=455.025n

* CHECK dout0_35 Vdout0_35ck90 = 0 time = 455
.meas tran vdout0_35ck90 FIND v(dout0_35) AT=455.025n

* CHECK dout0_36 Vdout0_36ck90 = 0.9 time = 455
.meas tran vdout0_36ck90 FIND v(dout0_36) AT=455.025n

* CHECK dout0_37 Vdout0_37ck90 = 0 time = 455
.meas tran vdout0_37ck90 FIND v(dout0_37) AT=455.025n

* CHECK dout0_38 Vdout0_38ck90 = 0 time = 455
.meas tran vdout0_38ck90 FIND v(dout0_38) AT=455.025n

* CHECK dout0_39 Vdout0_39ck90 = 0 time = 455
.meas tran vdout0_39ck90 FIND v(dout0_39) AT=455.025n

* CHECK dout0_40 Vdout0_40ck90 = 0 time = 455
.meas tran vdout0_40ck90 FIND v(dout0_40) AT=455.025n

* CHECK dout0_41 Vdout0_41ck90 = 0.9 time = 455
.meas tran vdout0_41ck90 FIND v(dout0_41) AT=455.025n

* CHECK dout0_42 Vdout0_42ck90 = 0.9 time = 455
.meas tran vdout0_42ck90 FIND v(dout0_42) AT=455.025n

* CHECK dout0_43 Vdout0_43ck90 = 0.9 time = 455
.meas tran vdout0_43ck90 FIND v(dout0_43) AT=455.025n

* CHECK dout0_44 Vdout0_44ck90 = 0 time = 455
.meas tran vdout0_44ck90 FIND v(dout0_44) AT=455.025n

* CHECK dout0_45 Vdout0_45ck90 = 0 time = 455
.meas tran vdout0_45ck90 FIND v(dout0_45) AT=455.025n

* CHECK dout0_46 Vdout0_46ck90 = 0.9 time = 455
.meas tran vdout0_46ck90 FIND v(dout0_46) AT=455.025n

* CHECK dout0_47 Vdout0_47ck90 = 0.9 time = 455
.meas tran vdout0_47ck90 FIND v(dout0_47) AT=455.025n

* CHECK dout0_48 Vdout0_48ck90 = 0 time = 455
.meas tran vdout0_48ck90 FIND v(dout0_48) AT=455.025n

* CHECK dout0_49 Vdout0_49ck90 = 0 time = 455
.meas tran vdout0_49ck90 FIND v(dout0_49) AT=455.025n

* CHECK dout0_50 Vdout0_50ck90 = 0 time = 455
.meas tran vdout0_50ck90 FIND v(dout0_50) AT=455.025n

* CHECK dout0_51 Vdout0_51ck90 = 0.9 time = 455
.meas tran vdout0_51ck90 FIND v(dout0_51) AT=455.025n

* CHECK dout0_52 Vdout0_52ck90 = 0.9 time = 455
.meas tran vdout0_52ck90 FIND v(dout0_52) AT=455.025n

* CHECK dout0_53 Vdout0_53ck90 = 0.9 time = 455
.meas tran vdout0_53ck90 FIND v(dout0_53) AT=455.025n

* CHECK dout0_54 Vdout0_54ck90 = 0 time = 455
.meas tran vdout0_54ck90 FIND v(dout0_54) AT=455.025n

* CHECK dout0_55 Vdout0_55ck90 = 0.9 time = 455
.meas tran vdout0_55ck90 FIND v(dout0_55) AT=455.025n

* CHECK dout0_56 Vdout0_56ck90 = 0.9 time = 455
.meas tran vdout0_56ck90 FIND v(dout0_56) AT=455.025n

* CHECK dout0_57 Vdout0_57ck90 = 0.9 time = 455
.meas tran vdout0_57ck90 FIND v(dout0_57) AT=455.025n

* CHECK dout0_58 Vdout0_58ck90 = 0 time = 455
.meas tran vdout0_58ck90 FIND v(dout0_58) AT=455.025n

* CHECK dout0_59 Vdout0_59ck90 = 0.9 time = 455
.meas tran vdout0_59ck90 FIND v(dout0_59) AT=455.025n

* CHECK dout0_60 Vdout0_60ck90 = 0.9 time = 455
.meas tran vdout0_60ck90 FIND v(dout0_60) AT=455.025n

* CHECK dout0_61 Vdout0_61ck90 = 0.9 time = 455
.meas tran vdout0_61ck90 FIND v(dout0_61) AT=455.025n

* CHECK dout0_62 Vdout0_62ck90 = 0 time = 455
.meas tran vdout0_62ck90 FIND v(dout0_62) AT=455.025n

* CHECK dout0_63 Vdout0_63ck90 = 0 time = 455
.meas tran vdout0_63ck90 FIND v(dout0_63) AT=455.025n

* CHECK dout0_0 Vdout0_0ck92 = 0 time = 465
.meas tran vdout0_0ck92 FIND v(dout0_0) AT=465.025n

* CHECK dout0_1 Vdout0_1ck92 = 0.9 time = 465
.meas tran vdout0_1ck92 FIND v(dout0_1) AT=465.025n

* CHECK dout0_2 Vdout0_2ck92 = 0.9 time = 465
.meas tran vdout0_2ck92 FIND v(dout0_2) AT=465.025n

* CHECK dout0_3 Vdout0_3ck92 = 0 time = 465
.meas tran vdout0_3ck92 FIND v(dout0_3) AT=465.025n

* CHECK dout0_4 Vdout0_4ck92 = 0.9 time = 465
.meas tran vdout0_4ck92 FIND v(dout0_4) AT=465.025n

* CHECK dout0_5 Vdout0_5ck92 = 0.9 time = 465
.meas tran vdout0_5ck92 FIND v(dout0_5) AT=465.025n

* CHECK dout0_6 Vdout0_6ck92 = 0.9 time = 465
.meas tran vdout0_6ck92 FIND v(dout0_6) AT=465.025n

* CHECK dout0_7 Vdout0_7ck92 = 0 time = 465
.meas tran vdout0_7ck92 FIND v(dout0_7) AT=465.025n

* CHECK dout0_8 Vdout0_8ck92 = 0.9 time = 465
.meas tran vdout0_8ck92 FIND v(dout0_8) AT=465.025n

* CHECK dout0_9 Vdout0_9ck92 = 0.9 time = 465
.meas tran vdout0_9ck92 FIND v(dout0_9) AT=465.025n

* CHECK dout0_10 Vdout0_10ck92 = 0 time = 465
.meas tran vdout0_10ck92 FIND v(dout0_10) AT=465.025n

* CHECK dout0_11 Vdout0_11ck92 = 0.9 time = 465
.meas tran vdout0_11ck92 FIND v(dout0_11) AT=465.025n

* CHECK dout0_12 Vdout0_12ck92 = 0.9 time = 465
.meas tran vdout0_12ck92 FIND v(dout0_12) AT=465.025n

* CHECK dout0_13 Vdout0_13ck92 = 0.9 time = 465
.meas tran vdout0_13ck92 FIND v(dout0_13) AT=465.025n

* CHECK dout0_14 Vdout0_14ck92 = 0 time = 465
.meas tran vdout0_14ck92 FIND v(dout0_14) AT=465.025n

* CHECK dout0_15 Vdout0_15ck92 = 0.9 time = 465
.meas tran vdout0_15ck92 FIND v(dout0_15) AT=465.025n

* CHECK dout0_16 Vdout0_16ck92 = 0 time = 465
.meas tran vdout0_16ck92 FIND v(dout0_16) AT=465.025n

* CHECK dout0_17 Vdout0_17ck92 = 0 time = 465
.meas tran vdout0_17ck92 FIND v(dout0_17) AT=465.025n

* CHECK dout0_18 Vdout0_18ck92 = 0 time = 465
.meas tran vdout0_18ck92 FIND v(dout0_18) AT=465.025n

* CHECK dout0_19 Vdout0_19ck92 = 0 time = 465
.meas tran vdout0_19ck92 FIND v(dout0_19) AT=465.025n

* CHECK dout0_20 Vdout0_20ck92 = 0.9 time = 465
.meas tran vdout0_20ck92 FIND v(dout0_20) AT=465.025n

* CHECK dout0_21 Vdout0_21ck92 = 0.9 time = 465
.meas tran vdout0_21ck92 FIND v(dout0_21) AT=465.025n

* CHECK dout0_22 Vdout0_22ck92 = 0 time = 465
.meas tran vdout0_22ck92 FIND v(dout0_22) AT=465.025n

* CHECK dout0_23 Vdout0_23ck92 = 0.9 time = 465
.meas tran vdout0_23ck92 FIND v(dout0_23) AT=465.025n

* CHECK dout0_24 Vdout0_24ck92 = 0.9 time = 465
.meas tran vdout0_24ck92 FIND v(dout0_24) AT=465.025n

* CHECK dout0_25 Vdout0_25ck92 = 0.9 time = 465
.meas tran vdout0_25ck92 FIND v(dout0_25) AT=465.025n

* CHECK dout0_26 Vdout0_26ck92 = 0.9 time = 465
.meas tran vdout0_26ck92 FIND v(dout0_26) AT=465.025n

* CHECK dout0_27 Vdout0_27ck92 = 0.9 time = 465
.meas tran vdout0_27ck92 FIND v(dout0_27) AT=465.025n

* CHECK dout0_28 Vdout0_28ck92 = 0 time = 465
.meas tran vdout0_28ck92 FIND v(dout0_28) AT=465.025n

* CHECK dout0_29 Vdout0_29ck92 = 0.9 time = 465
.meas tran vdout0_29ck92 FIND v(dout0_29) AT=465.025n

* CHECK dout0_30 Vdout0_30ck92 = 0.9 time = 465
.meas tran vdout0_30ck92 FIND v(dout0_30) AT=465.025n

* CHECK dout0_31 Vdout0_31ck92 = 0 time = 465
.meas tran vdout0_31ck92 FIND v(dout0_31) AT=465.025n

* CHECK dout0_32 Vdout0_32ck92 = 0 time = 465
.meas tran vdout0_32ck92 FIND v(dout0_32) AT=465.025n

* CHECK dout0_33 Vdout0_33ck92 = 0 time = 465
.meas tran vdout0_33ck92 FIND v(dout0_33) AT=465.025n

* CHECK dout0_34 Vdout0_34ck92 = 0.9 time = 465
.meas tran vdout0_34ck92 FIND v(dout0_34) AT=465.025n

* CHECK dout0_35 Vdout0_35ck92 = 0 time = 465
.meas tran vdout0_35ck92 FIND v(dout0_35) AT=465.025n

* CHECK dout0_36 Vdout0_36ck92 = 0.9 time = 465
.meas tran vdout0_36ck92 FIND v(dout0_36) AT=465.025n

* CHECK dout0_37 Vdout0_37ck92 = 0 time = 465
.meas tran vdout0_37ck92 FIND v(dout0_37) AT=465.025n

* CHECK dout0_38 Vdout0_38ck92 = 0 time = 465
.meas tran vdout0_38ck92 FIND v(dout0_38) AT=465.025n

* CHECK dout0_39 Vdout0_39ck92 = 0 time = 465
.meas tran vdout0_39ck92 FIND v(dout0_39) AT=465.025n

* CHECK dout0_40 Vdout0_40ck92 = 0 time = 465
.meas tran vdout0_40ck92 FIND v(dout0_40) AT=465.025n

* CHECK dout0_41 Vdout0_41ck92 = 0.9 time = 465
.meas tran vdout0_41ck92 FIND v(dout0_41) AT=465.025n

* CHECK dout0_42 Vdout0_42ck92 = 0.9 time = 465
.meas tran vdout0_42ck92 FIND v(dout0_42) AT=465.025n

* CHECK dout0_43 Vdout0_43ck92 = 0.9 time = 465
.meas tran vdout0_43ck92 FIND v(dout0_43) AT=465.025n

* CHECK dout0_44 Vdout0_44ck92 = 0 time = 465
.meas tran vdout0_44ck92 FIND v(dout0_44) AT=465.025n

* CHECK dout0_45 Vdout0_45ck92 = 0 time = 465
.meas tran vdout0_45ck92 FIND v(dout0_45) AT=465.025n

* CHECK dout0_46 Vdout0_46ck92 = 0.9 time = 465
.meas tran vdout0_46ck92 FIND v(dout0_46) AT=465.025n

* CHECK dout0_47 Vdout0_47ck92 = 0.9 time = 465
.meas tran vdout0_47ck92 FIND v(dout0_47) AT=465.025n

* CHECK dout0_48 Vdout0_48ck92 = 0 time = 465
.meas tran vdout0_48ck92 FIND v(dout0_48) AT=465.025n

* CHECK dout0_49 Vdout0_49ck92 = 0 time = 465
.meas tran vdout0_49ck92 FIND v(dout0_49) AT=465.025n

* CHECK dout0_50 Vdout0_50ck92 = 0 time = 465
.meas tran vdout0_50ck92 FIND v(dout0_50) AT=465.025n

* CHECK dout0_51 Vdout0_51ck92 = 0.9 time = 465
.meas tran vdout0_51ck92 FIND v(dout0_51) AT=465.025n

* CHECK dout0_52 Vdout0_52ck92 = 0.9 time = 465
.meas tran vdout0_52ck92 FIND v(dout0_52) AT=465.025n

* CHECK dout0_53 Vdout0_53ck92 = 0.9 time = 465
.meas tran vdout0_53ck92 FIND v(dout0_53) AT=465.025n

* CHECK dout0_54 Vdout0_54ck92 = 0 time = 465
.meas tran vdout0_54ck92 FIND v(dout0_54) AT=465.025n

* CHECK dout0_55 Vdout0_55ck92 = 0.9 time = 465
.meas tran vdout0_55ck92 FIND v(dout0_55) AT=465.025n

* CHECK dout0_56 Vdout0_56ck92 = 0.9 time = 465
.meas tran vdout0_56ck92 FIND v(dout0_56) AT=465.025n

* CHECK dout0_57 Vdout0_57ck92 = 0.9 time = 465
.meas tran vdout0_57ck92 FIND v(dout0_57) AT=465.025n

* CHECK dout0_58 Vdout0_58ck92 = 0 time = 465
.meas tran vdout0_58ck92 FIND v(dout0_58) AT=465.025n

* CHECK dout0_59 Vdout0_59ck92 = 0.9 time = 465
.meas tran vdout0_59ck92 FIND v(dout0_59) AT=465.025n

* CHECK dout0_60 Vdout0_60ck92 = 0.9 time = 465
.meas tran vdout0_60ck92 FIND v(dout0_60) AT=465.025n

* CHECK dout0_61 Vdout0_61ck92 = 0.9 time = 465
.meas tran vdout0_61ck92 FIND v(dout0_61) AT=465.025n

* CHECK dout0_62 Vdout0_62ck92 = 0 time = 465
.meas tran vdout0_62ck92 FIND v(dout0_62) AT=465.025n

* CHECK dout0_63 Vdout0_63ck92 = 0 time = 465
.meas tran vdout0_63ck92 FIND v(dout0_63) AT=465.025n

* CHECK dout0_0 Vdout0_0ck95 = 0 time = 480
.meas tran vdout0_0ck95 FIND v(dout0_0) AT=480.025n

* CHECK dout0_1 Vdout0_1ck95 = 0.9 time = 480
.meas tran vdout0_1ck95 FIND v(dout0_1) AT=480.025n

* CHECK dout0_2 Vdout0_2ck95 = 0 time = 480
.meas tran vdout0_2ck95 FIND v(dout0_2) AT=480.025n

* CHECK dout0_3 Vdout0_3ck95 = 0.9 time = 480
.meas tran vdout0_3ck95 FIND v(dout0_3) AT=480.025n

* CHECK dout0_4 Vdout0_4ck95 = 0.9 time = 480
.meas tran vdout0_4ck95 FIND v(dout0_4) AT=480.025n

* CHECK dout0_5 Vdout0_5ck95 = 0 time = 480
.meas tran vdout0_5ck95 FIND v(dout0_5) AT=480.025n

* CHECK dout0_6 Vdout0_6ck95 = 0.9 time = 480
.meas tran vdout0_6ck95 FIND v(dout0_6) AT=480.025n

* CHECK dout0_7 Vdout0_7ck95 = 0 time = 480
.meas tran vdout0_7ck95 FIND v(dout0_7) AT=480.025n

* CHECK dout0_8 Vdout0_8ck95 = 0 time = 480
.meas tran vdout0_8ck95 FIND v(dout0_8) AT=480.025n

* CHECK dout0_9 Vdout0_9ck95 = 0.9 time = 480
.meas tran vdout0_9ck95 FIND v(dout0_9) AT=480.025n

* CHECK dout0_10 Vdout0_10ck95 = 0.9 time = 480
.meas tran vdout0_10ck95 FIND v(dout0_10) AT=480.025n

* CHECK dout0_11 Vdout0_11ck95 = 0.9 time = 480
.meas tran vdout0_11ck95 FIND v(dout0_11) AT=480.025n

* CHECK dout0_12 Vdout0_12ck95 = 0.9 time = 480
.meas tran vdout0_12ck95 FIND v(dout0_12) AT=480.025n

* CHECK dout0_13 Vdout0_13ck95 = 0 time = 480
.meas tran vdout0_13ck95 FIND v(dout0_13) AT=480.025n

* CHECK dout0_14 Vdout0_14ck95 = 0.9 time = 480
.meas tran vdout0_14ck95 FIND v(dout0_14) AT=480.025n

* CHECK dout0_15 Vdout0_15ck95 = 0.9 time = 480
.meas tran vdout0_15ck95 FIND v(dout0_15) AT=480.025n

* CHECK dout0_16 Vdout0_16ck95 = 0 time = 480
.meas tran vdout0_16ck95 FIND v(dout0_16) AT=480.025n

* CHECK dout0_17 Vdout0_17ck95 = 0 time = 480
.meas tran vdout0_17ck95 FIND v(dout0_17) AT=480.025n

* CHECK dout0_18 Vdout0_18ck95 = 0.9 time = 480
.meas tran vdout0_18ck95 FIND v(dout0_18) AT=480.025n

* CHECK dout0_19 Vdout0_19ck95 = 0 time = 480
.meas tran vdout0_19ck95 FIND v(dout0_19) AT=480.025n

* CHECK dout0_20 Vdout0_20ck95 = 0 time = 480
.meas tran vdout0_20ck95 FIND v(dout0_20) AT=480.025n

* CHECK dout0_21 Vdout0_21ck95 = 0 time = 480
.meas tran vdout0_21ck95 FIND v(dout0_21) AT=480.025n

* CHECK dout0_22 Vdout0_22ck95 = 0 time = 480
.meas tran vdout0_22ck95 FIND v(dout0_22) AT=480.025n

* CHECK dout0_23 Vdout0_23ck95 = 0.9 time = 480
.meas tran vdout0_23ck95 FIND v(dout0_23) AT=480.025n

* CHECK dout0_24 Vdout0_24ck95 = 0 time = 480
.meas tran vdout0_24ck95 FIND v(dout0_24) AT=480.025n

* CHECK dout0_25 Vdout0_25ck95 = 0.9 time = 480
.meas tran vdout0_25ck95 FIND v(dout0_25) AT=480.025n

* CHECK dout0_26 Vdout0_26ck95 = 0.9 time = 480
.meas tran vdout0_26ck95 FIND v(dout0_26) AT=480.025n

* CHECK dout0_27 Vdout0_27ck95 = 0 time = 480
.meas tran vdout0_27ck95 FIND v(dout0_27) AT=480.025n

* CHECK dout0_28 Vdout0_28ck95 = 0.9 time = 480
.meas tran vdout0_28ck95 FIND v(dout0_28) AT=480.025n

* CHECK dout0_29 Vdout0_29ck95 = 0.9 time = 480
.meas tran vdout0_29ck95 FIND v(dout0_29) AT=480.025n

* CHECK dout0_30 Vdout0_30ck95 = 0 time = 480
.meas tran vdout0_30ck95 FIND v(dout0_30) AT=480.025n

* CHECK dout0_31 Vdout0_31ck95 = 0.9 time = 480
.meas tran vdout0_31ck95 FIND v(dout0_31) AT=480.025n

* CHECK dout0_32 Vdout0_32ck95 = 0 time = 480
.meas tran vdout0_32ck95 FIND v(dout0_32) AT=480.025n

* CHECK dout0_33 Vdout0_33ck95 = 0.9 time = 480
.meas tran vdout0_33ck95 FIND v(dout0_33) AT=480.025n

* CHECK dout0_34 Vdout0_34ck95 = 0.9 time = 480
.meas tran vdout0_34ck95 FIND v(dout0_34) AT=480.025n

* CHECK dout0_35 Vdout0_35ck95 = 0.9 time = 480
.meas tran vdout0_35ck95 FIND v(dout0_35) AT=480.025n

* CHECK dout0_36 Vdout0_36ck95 = 0 time = 480
.meas tran vdout0_36ck95 FIND v(dout0_36) AT=480.025n

* CHECK dout0_37 Vdout0_37ck95 = 0 time = 480
.meas tran vdout0_37ck95 FIND v(dout0_37) AT=480.025n

* CHECK dout0_38 Vdout0_38ck95 = 0 time = 480
.meas tran vdout0_38ck95 FIND v(dout0_38) AT=480.025n

* CHECK dout0_39 Vdout0_39ck95 = 0.9 time = 480
.meas tran vdout0_39ck95 FIND v(dout0_39) AT=480.025n

* CHECK dout0_40 Vdout0_40ck95 = 0 time = 480
.meas tran vdout0_40ck95 FIND v(dout0_40) AT=480.025n

* CHECK dout0_41 Vdout0_41ck95 = 0.9 time = 480
.meas tran vdout0_41ck95 FIND v(dout0_41) AT=480.025n

* CHECK dout0_42 Vdout0_42ck95 = 0.9 time = 480
.meas tran vdout0_42ck95 FIND v(dout0_42) AT=480.025n

* CHECK dout0_43 Vdout0_43ck95 = 0 time = 480
.meas tran vdout0_43ck95 FIND v(dout0_43) AT=480.025n

* CHECK dout0_44 Vdout0_44ck95 = 0 time = 480
.meas tran vdout0_44ck95 FIND v(dout0_44) AT=480.025n

* CHECK dout0_45 Vdout0_45ck95 = 0.9 time = 480
.meas tran vdout0_45ck95 FIND v(dout0_45) AT=480.025n

* CHECK dout0_46 Vdout0_46ck95 = 0 time = 480
.meas tran vdout0_46ck95 FIND v(dout0_46) AT=480.025n

* CHECK dout0_47 Vdout0_47ck95 = 0.9 time = 480
.meas tran vdout0_47ck95 FIND v(dout0_47) AT=480.025n

* CHECK dout0_48 Vdout0_48ck95 = 0 time = 480
.meas tran vdout0_48ck95 FIND v(dout0_48) AT=480.025n

* CHECK dout0_49 Vdout0_49ck95 = 0 time = 480
.meas tran vdout0_49ck95 FIND v(dout0_49) AT=480.025n

* CHECK dout0_50 Vdout0_50ck95 = 0.9 time = 480
.meas tran vdout0_50ck95 FIND v(dout0_50) AT=480.025n

* CHECK dout0_51 Vdout0_51ck95 = 0.9 time = 480
.meas tran vdout0_51ck95 FIND v(dout0_51) AT=480.025n

* CHECK dout0_52 Vdout0_52ck95 = 0 time = 480
.meas tran vdout0_52ck95 FIND v(dout0_52) AT=480.025n

* CHECK dout0_53 Vdout0_53ck95 = 0.9 time = 480
.meas tran vdout0_53ck95 FIND v(dout0_53) AT=480.025n

* CHECK dout0_54 Vdout0_54ck95 = 0.9 time = 480
.meas tran vdout0_54ck95 FIND v(dout0_54) AT=480.025n

* CHECK dout0_55 Vdout0_55ck95 = 0 time = 480
.meas tran vdout0_55ck95 FIND v(dout0_55) AT=480.025n

* CHECK dout0_56 Vdout0_56ck95 = 0 time = 480
.meas tran vdout0_56ck95 FIND v(dout0_56) AT=480.025n

* CHECK dout0_57 Vdout0_57ck95 = 0.9 time = 480
.meas tran vdout0_57ck95 FIND v(dout0_57) AT=480.025n

* CHECK dout0_58 Vdout0_58ck95 = 0.9 time = 480
.meas tran vdout0_58ck95 FIND v(dout0_58) AT=480.025n

* CHECK dout0_59 Vdout0_59ck95 = 0 time = 480
.meas tran vdout0_59ck95 FIND v(dout0_59) AT=480.025n

* CHECK dout0_60 Vdout0_60ck95 = 0 time = 480
.meas tran vdout0_60ck95 FIND v(dout0_60) AT=480.025n

* CHECK dout0_61 Vdout0_61ck95 = 0 time = 480
.meas tran vdout0_61ck95 FIND v(dout0_61) AT=480.025n

* CHECK dout0_62 Vdout0_62ck95 = 0.9 time = 480
.meas tran vdout0_62ck95 FIND v(dout0_62) AT=480.025n

* CHECK dout0_63 Vdout0_63ck95 = 0 time = 480
.meas tran vdout0_63ck95 FIND v(dout0_63) AT=480.025n

* CHECK dout0_0 Vdout0_0ck97 = 0 time = 490
.meas tran vdout0_0ck97 FIND v(dout0_0) AT=490.025n

* CHECK dout0_1 Vdout0_1ck97 = 0.9 time = 490
.meas tran vdout0_1ck97 FIND v(dout0_1) AT=490.025n

* CHECK dout0_2 Vdout0_2ck97 = 0 time = 490
.meas tran vdout0_2ck97 FIND v(dout0_2) AT=490.025n

* CHECK dout0_3 Vdout0_3ck97 = 0 time = 490
.meas tran vdout0_3ck97 FIND v(dout0_3) AT=490.025n

* CHECK dout0_4 Vdout0_4ck97 = 0 time = 490
.meas tran vdout0_4ck97 FIND v(dout0_4) AT=490.025n

* CHECK dout0_5 Vdout0_5ck97 = 0 time = 490
.meas tran vdout0_5ck97 FIND v(dout0_5) AT=490.025n

* CHECK dout0_6 Vdout0_6ck97 = 0.9 time = 490
.meas tran vdout0_6ck97 FIND v(dout0_6) AT=490.025n

* CHECK dout0_7 Vdout0_7ck97 = 0 time = 490
.meas tran vdout0_7ck97 FIND v(dout0_7) AT=490.025n

* CHECK dout0_8 Vdout0_8ck97 = 0 time = 490
.meas tran vdout0_8ck97 FIND v(dout0_8) AT=490.025n

* CHECK dout0_9 Vdout0_9ck97 = 0 time = 490
.meas tran vdout0_9ck97 FIND v(dout0_9) AT=490.025n

* CHECK dout0_10 Vdout0_10ck97 = 0 time = 490
.meas tran vdout0_10ck97 FIND v(dout0_10) AT=490.025n

* CHECK dout0_11 Vdout0_11ck97 = 0 time = 490
.meas tran vdout0_11ck97 FIND v(dout0_11) AT=490.025n

* CHECK dout0_12 Vdout0_12ck97 = 0 time = 490
.meas tran vdout0_12ck97 FIND v(dout0_12) AT=490.025n

* CHECK dout0_13 Vdout0_13ck97 = 0.9 time = 490
.meas tran vdout0_13ck97 FIND v(dout0_13) AT=490.025n

* CHECK dout0_14 Vdout0_14ck97 = 0.9 time = 490
.meas tran vdout0_14ck97 FIND v(dout0_14) AT=490.025n

* CHECK dout0_15 Vdout0_15ck97 = 0.9 time = 490
.meas tran vdout0_15ck97 FIND v(dout0_15) AT=490.025n

* CHECK dout0_16 Vdout0_16ck97 = 0.9 time = 490
.meas tran vdout0_16ck97 FIND v(dout0_16) AT=490.025n

* CHECK dout0_17 Vdout0_17ck97 = 0.9 time = 490
.meas tran vdout0_17ck97 FIND v(dout0_17) AT=490.025n

* CHECK dout0_18 Vdout0_18ck97 = 0.9 time = 490
.meas tran vdout0_18ck97 FIND v(dout0_18) AT=490.025n

* CHECK dout0_19 Vdout0_19ck97 = 0 time = 490
.meas tran vdout0_19ck97 FIND v(dout0_19) AT=490.025n

* CHECK dout0_20 Vdout0_20ck97 = 0 time = 490
.meas tran vdout0_20ck97 FIND v(dout0_20) AT=490.025n

* CHECK dout0_21 Vdout0_21ck97 = 0 time = 490
.meas tran vdout0_21ck97 FIND v(dout0_21) AT=490.025n

* CHECK dout0_22 Vdout0_22ck97 = 0 time = 490
.meas tran vdout0_22ck97 FIND v(dout0_22) AT=490.025n

* CHECK dout0_23 Vdout0_23ck97 = 0.9 time = 490
.meas tran vdout0_23ck97 FIND v(dout0_23) AT=490.025n

* CHECK dout0_24 Vdout0_24ck97 = 0 time = 490
.meas tran vdout0_24ck97 FIND v(dout0_24) AT=490.025n

* CHECK dout0_25 Vdout0_25ck97 = 0 time = 490
.meas tran vdout0_25ck97 FIND v(dout0_25) AT=490.025n

* CHECK dout0_26 Vdout0_26ck97 = 0.9 time = 490
.meas tran vdout0_26ck97 FIND v(dout0_26) AT=490.025n

* CHECK dout0_27 Vdout0_27ck97 = 0 time = 490
.meas tran vdout0_27ck97 FIND v(dout0_27) AT=490.025n

* CHECK dout0_28 Vdout0_28ck97 = 0.9 time = 490
.meas tran vdout0_28ck97 FIND v(dout0_28) AT=490.025n

* CHECK dout0_29 Vdout0_29ck97 = 0 time = 490
.meas tran vdout0_29ck97 FIND v(dout0_29) AT=490.025n

* CHECK dout0_30 Vdout0_30ck97 = 0.9 time = 490
.meas tran vdout0_30ck97 FIND v(dout0_30) AT=490.025n

* CHECK dout0_31 Vdout0_31ck97 = 0.9 time = 490
.meas tran vdout0_31ck97 FIND v(dout0_31) AT=490.025n

* CHECK dout0_32 Vdout0_32ck97 = 0 time = 490
.meas tran vdout0_32ck97 FIND v(dout0_32) AT=490.025n

* CHECK dout0_33 Vdout0_33ck97 = 0.9 time = 490
.meas tran vdout0_33ck97 FIND v(dout0_33) AT=490.025n

* CHECK dout0_34 Vdout0_34ck97 = 0.9 time = 490
.meas tran vdout0_34ck97 FIND v(dout0_34) AT=490.025n

* CHECK dout0_35 Vdout0_35ck97 = 0.9 time = 490
.meas tran vdout0_35ck97 FIND v(dout0_35) AT=490.025n

* CHECK dout0_36 Vdout0_36ck97 = 0.9 time = 490
.meas tran vdout0_36ck97 FIND v(dout0_36) AT=490.025n

* CHECK dout0_37 Vdout0_37ck97 = 0 time = 490
.meas tran vdout0_37ck97 FIND v(dout0_37) AT=490.025n

* CHECK dout0_38 Vdout0_38ck97 = 0 time = 490
.meas tran vdout0_38ck97 FIND v(dout0_38) AT=490.025n

* CHECK dout0_39 Vdout0_39ck97 = 0.9 time = 490
.meas tran vdout0_39ck97 FIND v(dout0_39) AT=490.025n

* CHECK dout0_40 Vdout0_40ck97 = 0.9 time = 490
.meas tran vdout0_40ck97 FIND v(dout0_40) AT=490.025n

* CHECK dout0_41 Vdout0_41ck97 = 0 time = 490
.meas tran vdout0_41ck97 FIND v(dout0_41) AT=490.025n

* CHECK dout0_42 Vdout0_42ck97 = 0 time = 490
.meas tran vdout0_42ck97 FIND v(dout0_42) AT=490.025n

* CHECK dout0_43 Vdout0_43ck97 = 0 time = 490
.meas tran vdout0_43ck97 FIND v(dout0_43) AT=490.025n

* CHECK dout0_44 Vdout0_44ck97 = 0.9 time = 490
.meas tran vdout0_44ck97 FIND v(dout0_44) AT=490.025n

* CHECK dout0_45 Vdout0_45ck97 = 0.9 time = 490
.meas tran vdout0_45ck97 FIND v(dout0_45) AT=490.025n

* CHECK dout0_46 Vdout0_46ck97 = 0.9 time = 490
.meas tran vdout0_46ck97 FIND v(dout0_46) AT=490.025n

* CHECK dout0_47 Vdout0_47ck97 = 0 time = 490
.meas tran vdout0_47ck97 FIND v(dout0_47) AT=490.025n

* CHECK dout0_48 Vdout0_48ck97 = 0 time = 490
.meas tran vdout0_48ck97 FIND v(dout0_48) AT=490.025n

* CHECK dout0_49 Vdout0_49ck97 = 0 time = 490
.meas tran vdout0_49ck97 FIND v(dout0_49) AT=490.025n

* CHECK dout0_50 Vdout0_50ck97 = 0 time = 490
.meas tran vdout0_50ck97 FIND v(dout0_50) AT=490.025n

* CHECK dout0_51 Vdout0_51ck97 = 0.9 time = 490
.meas tran vdout0_51ck97 FIND v(dout0_51) AT=490.025n

* CHECK dout0_52 Vdout0_52ck97 = 0.9 time = 490
.meas tran vdout0_52ck97 FIND v(dout0_52) AT=490.025n

* CHECK dout0_53 Vdout0_53ck97 = 0 time = 490
.meas tran vdout0_53ck97 FIND v(dout0_53) AT=490.025n

* CHECK dout0_54 Vdout0_54ck97 = 0 time = 490
.meas tran vdout0_54ck97 FIND v(dout0_54) AT=490.025n

* CHECK dout0_55 Vdout0_55ck97 = 0 time = 490
.meas tran vdout0_55ck97 FIND v(dout0_55) AT=490.025n

* CHECK dout0_56 Vdout0_56ck97 = 0 time = 490
.meas tran vdout0_56ck97 FIND v(dout0_56) AT=490.025n

* CHECK dout0_57 Vdout0_57ck97 = 0 time = 490
.meas tran vdout0_57ck97 FIND v(dout0_57) AT=490.025n

* CHECK dout0_58 Vdout0_58ck97 = 0 time = 490
.meas tran vdout0_58ck97 FIND v(dout0_58) AT=490.025n

* CHECK dout0_59 Vdout0_59ck97 = 0 time = 490
.meas tran vdout0_59ck97 FIND v(dout0_59) AT=490.025n

* CHECK dout0_60 Vdout0_60ck97 = 0.9 time = 490
.meas tran vdout0_60ck97 FIND v(dout0_60) AT=490.025n

* CHECK dout0_61 Vdout0_61ck97 = 0 time = 490
.meas tran vdout0_61ck97 FIND v(dout0_61) AT=490.025n

* CHECK dout0_62 Vdout0_62ck97 = 0.9 time = 490
.meas tran vdout0_62ck97 FIND v(dout0_62) AT=490.025n

* CHECK dout0_63 Vdout0_63ck97 = 0.9 time = 490
.meas tran vdout0_63ck97 FIND v(dout0_63) AT=490.025n

* CHECK dout0_0 Vdout0_0ck98 = 0 time = 495
.meas tran vdout0_0ck98 FIND v(dout0_0) AT=495.025n

* CHECK dout0_1 Vdout0_1ck98 = 0.9 time = 495
.meas tran vdout0_1ck98 FIND v(dout0_1) AT=495.025n

* CHECK dout0_2 Vdout0_2ck98 = 0 time = 495
.meas tran vdout0_2ck98 FIND v(dout0_2) AT=495.025n

* CHECK dout0_3 Vdout0_3ck98 = 0.9 time = 495
.meas tran vdout0_3ck98 FIND v(dout0_3) AT=495.025n

* CHECK dout0_4 Vdout0_4ck98 = 0.9 time = 495
.meas tran vdout0_4ck98 FIND v(dout0_4) AT=495.025n

* CHECK dout0_5 Vdout0_5ck98 = 0 time = 495
.meas tran vdout0_5ck98 FIND v(dout0_5) AT=495.025n

* CHECK dout0_6 Vdout0_6ck98 = 0.9 time = 495
.meas tran vdout0_6ck98 FIND v(dout0_6) AT=495.025n

* CHECK dout0_7 Vdout0_7ck98 = 0 time = 495
.meas tran vdout0_7ck98 FIND v(dout0_7) AT=495.025n

* CHECK dout0_8 Vdout0_8ck98 = 0 time = 495
.meas tran vdout0_8ck98 FIND v(dout0_8) AT=495.025n

* CHECK dout0_9 Vdout0_9ck98 = 0.9 time = 495
.meas tran vdout0_9ck98 FIND v(dout0_9) AT=495.025n

* CHECK dout0_10 Vdout0_10ck98 = 0.9 time = 495
.meas tran vdout0_10ck98 FIND v(dout0_10) AT=495.025n

* CHECK dout0_11 Vdout0_11ck98 = 0.9 time = 495
.meas tran vdout0_11ck98 FIND v(dout0_11) AT=495.025n

* CHECK dout0_12 Vdout0_12ck98 = 0.9 time = 495
.meas tran vdout0_12ck98 FIND v(dout0_12) AT=495.025n

* CHECK dout0_13 Vdout0_13ck98 = 0 time = 495
.meas tran vdout0_13ck98 FIND v(dout0_13) AT=495.025n

* CHECK dout0_14 Vdout0_14ck98 = 0.9 time = 495
.meas tran vdout0_14ck98 FIND v(dout0_14) AT=495.025n

* CHECK dout0_15 Vdout0_15ck98 = 0.9 time = 495
.meas tran vdout0_15ck98 FIND v(dout0_15) AT=495.025n

* CHECK dout0_16 Vdout0_16ck98 = 0 time = 495
.meas tran vdout0_16ck98 FIND v(dout0_16) AT=495.025n

* CHECK dout0_17 Vdout0_17ck98 = 0 time = 495
.meas tran vdout0_17ck98 FIND v(dout0_17) AT=495.025n

* CHECK dout0_18 Vdout0_18ck98 = 0.9 time = 495
.meas tran vdout0_18ck98 FIND v(dout0_18) AT=495.025n

* CHECK dout0_19 Vdout0_19ck98 = 0 time = 495
.meas tran vdout0_19ck98 FIND v(dout0_19) AT=495.025n

* CHECK dout0_20 Vdout0_20ck98 = 0 time = 495
.meas tran vdout0_20ck98 FIND v(dout0_20) AT=495.025n

* CHECK dout0_21 Vdout0_21ck98 = 0 time = 495
.meas tran vdout0_21ck98 FIND v(dout0_21) AT=495.025n

* CHECK dout0_22 Vdout0_22ck98 = 0 time = 495
.meas tran vdout0_22ck98 FIND v(dout0_22) AT=495.025n

* CHECK dout0_23 Vdout0_23ck98 = 0.9 time = 495
.meas tran vdout0_23ck98 FIND v(dout0_23) AT=495.025n

* CHECK dout0_24 Vdout0_24ck98 = 0 time = 495
.meas tran vdout0_24ck98 FIND v(dout0_24) AT=495.025n

* CHECK dout0_25 Vdout0_25ck98 = 0.9 time = 495
.meas tran vdout0_25ck98 FIND v(dout0_25) AT=495.025n

* CHECK dout0_26 Vdout0_26ck98 = 0.9 time = 495
.meas tran vdout0_26ck98 FIND v(dout0_26) AT=495.025n

* CHECK dout0_27 Vdout0_27ck98 = 0 time = 495
.meas tran vdout0_27ck98 FIND v(dout0_27) AT=495.025n

* CHECK dout0_28 Vdout0_28ck98 = 0.9 time = 495
.meas tran vdout0_28ck98 FIND v(dout0_28) AT=495.025n

* CHECK dout0_29 Vdout0_29ck98 = 0.9 time = 495
.meas tran vdout0_29ck98 FIND v(dout0_29) AT=495.025n

* CHECK dout0_30 Vdout0_30ck98 = 0 time = 495
.meas tran vdout0_30ck98 FIND v(dout0_30) AT=495.025n

* CHECK dout0_31 Vdout0_31ck98 = 0.9 time = 495
.meas tran vdout0_31ck98 FIND v(dout0_31) AT=495.025n

* CHECK dout0_32 Vdout0_32ck98 = 0 time = 495
.meas tran vdout0_32ck98 FIND v(dout0_32) AT=495.025n

* CHECK dout0_33 Vdout0_33ck98 = 0.9 time = 495
.meas tran vdout0_33ck98 FIND v(dout0_33) AT=495.025n

* CHECK dout0_34 Vdout0_34ck98 = 0.9 time = 495
.meas tran vdout0_34ck98 FIND v(dout0_34) AT=495.025n

* CHECK dout0_35 Vdout0_35ck98 = 0.9 time = 495
.meas tran vdout0_35ck98 FIND v(dout0_35) AT=495.025n

* CHECK dout0_36 Vdout0_36ck98 = 0 time = 495
.meas tran vdout0_36ck98 FIND v(dout0_36) AT=495.025n

* CHECK dout0_37 Vdout0_37ck98 = 0 time = 495
.meas tran vdout0_37ck98 FIND v(dout0_37) AT=495.025n

* CHECK dout0_38 Vdout0_38ck98 = 0 time = 495
.meas tran vdout0_38ck98 FIND v(dout0_38) AT=495.025n

* CHECK dout0_39 Vdout0_39ck98 = 0.9 time = 495
.meas tran vdout0_39ck98 FIND v(dout0_39) AT=495.025n

* CHECK dout0_40 Vdout0_40ck98 = 0 time = 495
.meas tran vdout0_40ck98 FIND v(dout0_40) AT=495.025n

* CHECK dout0_41 Vdout0_41ck98 = 0.9 time = 495
.meas tran vdout0_41ck98 FIND v(dout0_41) AT=495.025n

* CHECK dout0_42 Vdout0_42ck98 = 0.9 time = 495
.meas tran vdout0_42ck98 FIND v(dout0_42) AT=495.025n

* CHECK dout0_43 Vdout0_43ck98 = 0 time = 495
.meas tran vdout0_43ck98 FIND v(dout0_43) AT=495.025n

* CHECK dout0_44 Vdout0_44ck98 = 0 time = 495
.meas tran vdout0_44ck98 FIND v(dout0_44) AT=495.025n

* CHECK dout0_45 Vdout0_45ck98 = 0.9 time = 495
.meas tran vdout0_45ck98 FIND v(dout0_45) AT=495.025n

* CHECK dout0_46 Vdout0_46ck98 = 0 time = 495
.meas tran vdout0_46ck98 FIND v(dout0_46) AT=495.025n

* CHECK dout0_47 Vdout0_47ck98 = 0.9 time = 495
.meas tran vdout0_47ck98 FIND v(dout0_47) AT=495.025n

* CHECK dout0_48 Vdout0_48ck98 = 0 time = 495
.meas tran vdout0_48ck98 FIND v(dout0_48) AT=495.025n

* CHECK dout0_49 Vdout0_49ck98 = 0 time = 495
.meas tran vdout0_49ck98 FIND v(dout0_49) AT=495.025n

* CHECK dout0_50 Vdout0_50ck98 = 0.9 time = 495
.meas tran vdout0_50ck98 FIND v(dout0_50) AT=495.025n

* CHECK dout0_51 Vdout0_51ck98 = 0.9 time = 495
.meas tran vdout0_51ck98 FIND v(dout0_51) AT=495.025n

* CHECK dout0_52 Vdout0_52ck98 = 0 time = 495
.meas tran vdout0_52ck98 FIND v(dout0_52) AT=495.025n

* CHECK dout0_53 Vdout0_53ck98 = 0.9 time = 495
.meas tran vdout0_53ck98 FIND v(dout0_53) AT=495.025n

* CHECK dout0_54 Vdout0_54ck98 = 0.9 time = 495
.meas tran vdout0_54ck98 FIND v(dout0_54) AT=495.025n

* CHECK dout0_55 Vdout0_55ck98 = 0 time = 495
.meas tran vdout0_55ck98 FIND v(dout0_55) AT=495.025n

* CHECK dout0_56 Vdout0_56ck98 = 0 time = 495
.meas tran vdout0_56ck98 FIND v(dout0_56) AT=495.025n

* CHECK dout0_57 Vdout0_57ck98 = 0.9 time = 495
.meas tran vdout0_57ck98 FIND v(dout0_57) AT=495.025n

* CHECK dout0_58 Vdout0_58ck98 = 0.9 time = 495
.meas tran vdout0_58ck98 FIND v(dout0_58) AT=495.025n

* CHECK dout0_59 Vdout0_59ck98 = 0 time = 495
.meas tran vdout0_59ck98 FIND v(dout0_59) AT=495.025n

* CHECK dout0_60 Vdout0_60ck98 = 0 time = 495
.meas tran vdout0_60ck98 FIND v(dout0_60) AT=495.025n

* CHECK dout0_61 Vdout0_61ck98 = 0 time = 495
.meas tran vdout0_61ck98 FIND v(dout0_61) AT=495.025n

* CHECK dout0_62 Vdout0_62ck98 = 0.9 time = 495
.meas tran vdout0_62ck98 FIND v(dout0_62) AT=495.025n

* CHECK dout0_63 Vdout0_63ck98 = 0 time = 495
.meas tran vdout0_63ck98 FIND v(dout0_63) AT=495.025n

* CHECK dout0_0 Vdout0_0ck99 = 0 time = 500
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=500.025n

* CHECK dout0_1 Vdout0_1ck99 = 0.9 time = 500
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=500.025n

* CHECK dout0_2 Vdout0_2ck99 = 0.9 time = 500
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=500.025n

* CHECK dout0_3 Vdout0_3ck99 = 0.9 time = 500
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=500.025n

* CHECK dout0_4 Vdout0_4ck99 = 0 time = 500
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=500.025n

* CHECK dout0_5 Vdout0_5ck99 = 0 time = 500
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=500.025n

* CHECK dout0_6 Vdout0_6ck99 = 0 time = 500
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=500.025n

* CHECK dout0_7 Vdout0_7ck99 = 0 time = 500
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=500.025n

* CHECK dout0_8 Vdout0_8ck99 = 0.9 time = 500
.meas tran vdout0_8ck99 FIND v(dout0_8) AT=500.025n

* CHECK dout0_9 Vdout0_9ck99 = 0.9 time = 500
.meas tran vdout0_9ck99 FIND v(dout0_9) AT=500.025n

* CHECK dout0_10 Vdout0_10ck99 = 0 time = 500
.meas tran vdout0_10ck99 FIND v(dout0_10) AT=500.025n

* CHECK dout0_11 Vdout0_11ck99 = 0 time = 500
.meas tran vdout0_11ck99 FIND v(dout0_11) AT=500.025n

* CHECK dout0_12 Vdout0_12ck99 = 0 time = 500
.meas tran vdout0_12ck99 FIND v(dout0_12) AT=500.025n

* CHECK dout0_13 Vdout0_13ck99 = 0 time = 500
.meas tran vdout0_13ck99 FIND v(dout0_13) AT=500.025n

* CHECK dout0_14 Vdout0_14ck99 = 0 time = 500
.meas tran vdout0_14ck99 FIND v(dout0_14) AT=500.025n

* CHECK dout0_15 Vdout0_15ck99 = 0 time = 500
.meas tran vdout0_15ck99 FIND v(dout0_15) AT=500.025n

* CHECK dout0_16 Vdout0_16ck99 = 0 time = 500
.meas tran vdout0_16ck99 FIND v(dout0_16) AT=500.025n

* CHECK dout0_17 Vdout0_17ck99 = 0 time = 500
.meas tran vdout0_17ck99 FIND v(dout0_17) AT=500.025n

* CHECK dout0_18 Vdout0_18ck99 = 0 time = 500
.meas tran vdout0_18ck99 FIND v(dout0_18) AT=500.025n

* CHECK dout0_19 Vdout0_19ck99 = 0.9 time = 500
.meas tran vdout0_19ck99 FIND v(dout0_19) AT=500.025n

* CHECK dout0_20 Vdout0_20ck99 = 0 time = 500
.meas tran vdout0_20ck99 FIND v(dout0_20) AT=500.025n

* CHECK dout0_21 Vdout0_21ck99 = 0 time = 500
.meas tran vdout0_21ck99 FIND v(dout0_21) AT=500.025n

* CHECK dout0_22 Vdout0_22ck99 = 0.9 time = 500
.meas tran vdout0_22ck99 FIND v(dout0_22) AT=500.025n

* CHECK dout0_23 Vdout0_23ck99 = 0 time = 500
.meas tran vdout0_23ck99 FIND v(dout0_23) AT=500.025n

* CHECK dout0_24 Vdout0_24ck99 = 0 time = 500
.meas tran vdout0_24ck99 FIND v(dout0_24) AT=500.025n

* CHECK dout0_25 Vdout0_25ck99 = 0 time = 500
.meas tran vdout0_25ck99 FIND v(dout0_25) AT=500.025n

* CHECK dout0_26 Vdout0_26ck99 = 0 time = 500
.meas tran vdout0_26ck99 FIND v(dout0_26) AT=500.025n

* CHECK dout0_27 Vdout0_27ck99 = 0 time = 500
.meas tran vdout0_27ck99 FIND v(dout0_27) AT=500.025n

* CHECK dout0_28 Vdout0_28ck99 = 0 time = 500
.meas tran vdout0_28ck99 FIND v(dout0_28) AT=500.025n

* CHECK dout0_29 Vdout0_29ck99 = 0.9 time = 500
.meas tran vdout0_29ck99 FIND v(dout0_29) AT=500.025n

* CHECK dout0_30 Vdout0_30ck99 = 0 time = 500
.meas tran vdout0_30ck99 FIND v(dout0_30) AT=500.025n

* CHECK dout0_31 Vdout0_31ck99 = 0 time = 500
.meas tran vdout0_31ck99 FIND v(dout0_31) AT=500.025n

* CHECK dout0_32 Vdout0_32ck99 = 0.9 time = 500
.meas tran vdout0_32ck99 FIND v(dout0_32) AT=500.025n

* CHECK dout0_33 Vdout0_33ck99 = 0.9 time = 500
.meas tran vdout0_33ck99 FIND v(dout0_33) AT=500.025n

* CHECK dout0_34 Vdout0_34ck99 = 0.9 time = 500
.meas tran vdout0_34ck99 FIND v(dout0_34) AT=500.025n

* CHECK dout0_35 Vdout0_35ck99 = 0 time = 500
.meas tran vdout0_35ck99 FIND v(dout0_35) AT=500.025n

* CHECK dout0_36 Vdout0_36ck99 = 0.9 time = 500
.meas tran vdout0_36ck99 FIND v(dout0_36) AT=500.025n

* CHECK dout0_37 Vdout0_37ck99 = 0 time = 500
.meas tran vdout0_37ck99 FIND v(dout0_37) AT=500.025n

* CHECK dout0_38 Vdout0_38ck99 = 0 time = 500
.meas tran vdout0_38ck99 FIND v(dout0_38) AT=500.025n

* CHECK dout0_39 Vdout0_39ck99 = 0 time = 500
.meas tran vdout0_39ck99 FIND v(dout0_39) AT=500.025n

* CHECK dout0_40 Vdout0_40ck99 = 0 time = 500
.meas tran vdout0_40ck99 FIND v(dout0_40) AT=500.025n

* CHECK dout0_41 Vdout0_41ck99 = 0 time = 500
.meas tran vdout0_41ck99 FIND v(dout0_41) AT=500.025n

* CHECK dout0_42 Vdout0_42ck99 = 0.9 time = 500
.meas tran vdout0_42ck99 FIND v(dout0_42) AT=500.025n

* CHECK dout0_43 Vdout0_43ck99 = 0 time = 500
.meas tran vdout0_43ck99 FIND v(dout0_43) AT=500.025n

* CHECK dout0_44 Vdout0_44ck99 = 0.9 time = 500
.meas tran vdout0_44ck99 FIND v(dout0_44) AT=500.025n

* CHECK dout0_45 Vdout0_45ck99 = 0.9 time = 500
.meas tran vdout0_45ck99 FIND v(dout0_45) AT=500.025n

* CHECK dout0_46 Vdout0_46ck99 = 0.9 time = 500
.meas tran vdout0_46ck99 FIND v(dout0_46) AT=500.025n

* CHECK dout0_47 Vdout0_47ck99 = 0.9 time = 500
.meas tran vdout0_47ck99 FIND v(dout0_47) AT=500.025n

* CHECK dout0_48 Vdout0_48ck99 = 0 time = 500
.meas tran vdout0_48ck99 FIND v(dout0_48) AT=500.025n

* CHECK dout0_49 Vdout0_49ck99 = 0.9 time = 500
.meas tran vdout0_49ck99 FIND v(dout0_49) AT=500.025n

* CHECK dout0_50 Vdout0_50ck99 = 0 time = 500
.meas tran vdout0_50ck99 FIND v(dout0_50) AT=500.025n

* CHECK dout0_51 Vdout0_51ck99 = 0 time = 500
.meas tran vdout0_51ck99 FIND v(dout0_51) AT=500.025n

* CHECK dout0_52 Vdout0_52ck99 = 0.9 time = 500
.meas tran vdout0_52ck99 FIND v(dout0_52) AT=500.025n

* CHECK dout0_53 Vdout0_53ck99 = 0 time = 500
.meas tran vdout0_53ck99 FIND v(dout0_53) AT=500.025n

* CHECK dout0_54 Vdout0_54ck99 = 0.9 time = 500
.meas tran vdout0_54ck99 FIND v(dout0_54) AT=500.025n

* CHECK dout0_55 Vdout0_55ck99 = 0.9 time = 500
.meas tran vdout0_55ck99 FIND v(dout0_55) AT=500.025n

* CHECK dout0_56 Vdout0_56ck99 = 0.9 time = 500
.meas tran vdout0_56ck99 FIND v(dout0_56) AT=500.025n

* CHECK dout0_57 Vdout0_57ck99 = 0 time = 500
.meas tran vdout0_57ck99 FIND v(dout0_57) AT=500.025n

* CHECK dout0_58 Vdout0_58ck99 = 0.9 time = 500
.meas tran vdout0_58ck99 FIND v(dout0_58) AT=500.025n

* CHECK dout0_59 Vdout0_59ck99 = 0.9 time = 500
.meas tran vdout0_59ck99 FIND v(dout0_59) AT=500.025n

* CHECK dout0_60 Vdout0_60ck99 = 0 time = 500
.meas tran vdout0_60ck99 FIND v(dout0_60) AT=500.025n

* CHECK dout0_61 Vdout0_61ck99 = 0 time = 500
.meas tran vdout0_61ck99 FIND v(dout0_61) AT=500.025n

* CHECK dout0_62 Vdout0_62ck99 = 0 time = 500
.meas tran vdout0_62ck99 FIND v(dout0_62) AT=500.025n

* CHECK dout0_63 Vdout0_63ck99 = 0 time = 500
.meas tran vdout0_63ck99 FIND v(dout0_63) AT=500.025n

* CHECK dout0_0 Vdout0_0ck101 = 0 time = 510
.meas tran vdout0_0ck101 FIND v(dout0_0) AT=510.025n

* CHECK dout0_1 Vdout0_1ck101 = 0.9 time = 510
.meas tran vdout0_1ck101 FIND v(dout0_1) AT=510.025n

* CHECK dout0_2 Vdout0_2ck101 = 0 time = 510
.meas tran vdout0_2ck101 FIND v(dout0_2) AT=510.025n

* CHECK dout0_3 Vdout0_3ck101 = 0 time = 510
.meas tran vdout0_3ck101 FIND v(dout0_3) AT=510.025n

* CHECK dout0_4 Vdout0_4ck101 = 0 time = 510
.meas tran vdout0_4ck101 FIND v(dout0_4) AT=510.025n

* CHECK dout0_5 Vdout0_5ck101 = 0 time = 510
.meas tran vdout0_5ck101 FIND v(dout0_5) AT=510.025n

* CHECK dout0_6 Vdout0_6ck101 = 0.9 time = 510
.meas tran vdout0_6ck101 FIND v(dout0_6) AT=510.025n

* CHECK dout0_7 Vdout0_7ck101 = 0 time = 510
.meas tran vdout0_7ck101 FIND v(dout0_7) AT=510.025n

* CHECK dout0_8 Vdout0_8ck101 = 0 time = 510
.meas tran vdout0_8ck101 FIND v(dout0_8) AT=510.025n

* CHECK dout0_9 Vdout0_9ck101 = 0 time = 510
.meas tran vdout0_9ck101 FIND v(dout0_9) AT=510.025n

* CHECK dout0_10 Vdout0_10ck101 = 0 time = 510
.meas tran vdout0_10ck101 FIND v(dout0_10) AT=510.025n

* CHECK dout0_11 Vdout0_11ck101 = 0 time = 510
.meas tran vdout0_11ck101 FIND v(dout0_11) AT=510.025n

* CHECK dout0_12 Vdout0_12ck101 = 0 time = 510
.meas tran vdout0_12ck101 FIND v(dout0_12) AT=510.025n

* CHECK dout0_13 Vdout0_13ck101 = 0.9 time = 510
.meas tran vdout0_13ck101 FIND v(dout0_13) AT=510.025n

* CHECK dout0_14 Vdout0_14ck101 = 0.9 time = 510
.meas tran vdout0_14ck101 FIND v(dout0_14) AT=510.025n

* CHECK dout0_15 Vdout0_15ck101 = 0.9 time = 510
.meas tran vdout0_15ck101 FIND v(dout0_15) AT=510.025n

* CHECK dout0_16 Vdout0_16ck101 = 0.9 time = 510
.meas tran vdout0_16ck101 FIND v(dout0_16) AT=510.025n

* CHECK dout0_17 Vdout0_17ck101 = 0.9 time = 510
.meas tran vdout0_17ck101 FIND v(dout0_17) AT=510.025n

* CHECK dout0_18 Vdout0_18ck101 = 0.9 time = 510
.meas tran vdout0_18ck101 FIND v(dout0_18) AT=510.025n

* CHECK dout0_19 Vdout0_19ck101 = 0 time = 510
.meas tran vdout0_19ck101 FIND v(dout0_19) AT=510.025n

* CHECK dout0_20 Vdout0_20ck101 = 0 time = 510
.meas tran vdout0_20ck101 FIND v(dout0_20) AT=510.025n

* CHECK dout0_21 Vdout0_21ck101 = 0 time = 510
.meas tran vdout0_21ck101 FIND v(dout0_21) AT=510.025n

* CHECK dout0_22 Vdout0_22ck101 = 0 time = 510
.meas tran vdout0_22ck101 FIND v(dout0_22) AT=510.025n

* CHECK dout0_23 Vdout0_23ck101 = 0.9 time = 510
.meas tran vdout0_23ck101 FIND v(dout0_23) AT=510.025n

* CHECK dout0_24 Vdout0_24ck101 = 0 time = 510
.meas tran vdout0_24ck101 FIND v(dout0_24) AT=510.025n

* CHECK dout0_25 Vdout0_25ck101 = 0 time = 510
.meas tran vdout0_25ck101 FIND v(dout0_25) AT=510.025n

* CHECK dout0_26 Vdout0_26ck101 = 0.9 time = 510
.meas tran vdout0_26ck101 FIND v(dout0_26) AT=510.025n

* CHECK dout0_27 Vdout0_27ck101 = 0 time = 510
.meas tran vdout0_27ck101 FIND v(dout0_27) AT=510.025n

* CHECK dout0_28 Vdout0_28ck101 = 0.9 time = 510
.meas tran vdout0_28ck101 FIND v(dout0_28) AT=510.025n

* CHECK dout0_29 Vdout0_29ck101 = 0 time = 510
.meas tran vdout0_29ck101 FIND v(dout0_29) AT=510.025n

* CHECK dout0_30 Vdout0_30ck101 = 0.9 time = 510
.meas tran vdout0_30ck101 FIND v(dout0_30) AT=510.025n

* CHECK dout0_31 Vdout0_31ck101 = 0.9 time = 510
.meas tran vdout0_31ck101 FIND v(dout0_31) AT=510.025n

* CHECK dout0_32 Vdout0_32ck101 = 0 time = 510
.meas tran vdout0_32ck101 FIND v(dout0_32) AT=510.025n

* CHECK dout0_33 Vdout0_33ck101 = 0.9 time = 510
.meas tran vdout0_33ck101 FIND v(dout0_33) AT=510.025n

* CHECK dout0_34 Vdout0_34ck101 = 0.9 time = 510
.meas tran vdout0_34ck101 FIND v(dout0_34) AT=510.025n

* CHECK dout0_35 Vdout0_35ck101 = 0.9 time = 510
.meas tran vdout0_35ck101 FIND v(dout0_35) AT=510.025n

* CHECK dout0_36 Vdout0_36ck101 = 0.9 time = 510
.meas tran vdout0_36ck101 FIND v(dout0_36) AT=510.025n

* CHECK dout0_37 Vdout0_37ck101 = 0 time = 510
.meas tran vdout0_37ck101 FIND v(dout0_37) AT=510.025n

* CHECK dout0_38 Vdout0_38ck101 = 0 time = 510
.meas tran vdout0_38ck101 FIND v(dout0_38) AT=510.025n

* CHECK dout0_39 Vdout0_39ck101 = 0.9 time = 510
.meas tran vdout0_39ck101 FIND v(dout0_39) AT=510.025n

* CHECK dout0_40 Vdout0_40ck101 = 0.9 time = 510
.meas tran vdout0_40ck101 FIND v(dout0_40) AT=510.025n

* CHECK dout0_41 Vdout0_41ck101 = 0 time = 510
.meas tran vdout0_41ck101 FIND v(dout0_41) AT=510.025n

* CHECK dout0_42 Vdout0_42ck101 = 0 time = 510
.meas tran vdout0_42ck101 FIND v(dout0_42) AT=510.025n

* CHECK dout0_43 Vdout0_43ck101 = 0 time = 510
.meas tran vdout0_43ck101 FIND v(dout0_43) AT=510.025n

* CHECK dout0_44 Vdout0_44ck101 = 0.9 time = 510
.meas tran vdout0_44ck101 FIND v(dout0_44) AT=510.025n

* CHECK dout0_45 Vdout0_45ck101 = 0.9 time = 510
.meas tran vdout0_45ck101 FIND v(dout0_45) AT=510.025n

* CHECK dout0_46 Vdout0_46ck101 = 0.9 time = 510
.meas tran vdout0_46ck101 FIND v(dout0_46) AT=510.025n

* CHECK dout0_47 Vdout0_47ck101 = 0 time = 510
.meas tran vdout0_47ck101 FIND v(dout0_47) AT=510.025n

* CHECK dout0_48 Vdout0_48ck101 = 0 time = 510
.meas tran vdout0_48ck101 FIND v(dout0_48) AT=510.025n

* CHECK dout0_49 Vdout0_49ck101 = 0 time = 510
.meas tran vdout0_49ck101 FIND v(dout0_49) AT=510.025n

* CHECK dout0_50 Vdout0_50ck101 = 0 time = 510
.meas tran vdout0_50ck101 FIND v(dout0_50) AT=510.025n

* CHECK dout0_51 Vdout0_51ck101 = 0.9 time = 510
.meas tran vdout0_51ck101 FIND v(dout0_51) AT=510.025n

* CHECK dout0_52 Vdout0_52ck101 = 0.9 time = 510
.meas tran vdout0_52ck101 FIND v(dout0_52) AT=510.025n

* CHECK dout0_53 Vdout0_53ck101 = 0 time = 510
.meas tran vdout0_53ck101 FIND v(dout0_53) AT=510.025n

* CHECK dout0_54 Vdout0_54ck101 = 0 time = 510
.meas tran vdout0_54ck101 FIND v(dout0_54) AT=510.025n

* CHECK dout0_55 Vdout0_55ck101 = 0 time = 510
.meas tran vdout0_55ck101 FIND v(dout0_55) AT=510.025n

* CHECK dout0_56 Vdout0_56ck101 = 0 time = 510
.meas tran vdout0_56ck101 FIND v(dout0_56) AT=510.025n

* CHECK dout0_57 Vdout0_57ck101 = 0 time = 510
.meas tran vdout0_57ck101 FIND v(dout0_57) AT=510.025n

* CHECK dout0_58 Vdout0_58ck101 = 0 time = 510
.meas tran vdout0_58ck101 FIND v(dout0_58) AT=510.025n

* CHECK dout0_59 Vdout0_59ck101 = 0 time = 510
.meas tran vdout0_59ck101 FIND v(dout0_59) AT=510.025n

* CHECK dout0_60 Vdout0_60ck101 = 0.9 time = 510
.meas tran vdout0_60ck101 FIND v(dout0_60) AT=510.025n

* CHECK dout0_61 Vdout0_61ck101 = 0 time = 510
.meas tran vdout0_61ck101 FIND v(dout0_61) AT=510.025n

* CHECK dout0_62 Vdout0_62ck101 = 0.9 time = 510
.meas tran vdout0_62ck101 FIND v(dout0_62) AT=510.025n

* CHECK dout0_63 Vdout0_63ck101 = 0.9 time = 510
.meas tran vdout0_63ck101 FIND v(dout0_63) AT=510.025n

* CHECK dout0_0 Vdout0_0ck103 = 0 time = 520
.meas tran vdout0_0ck103 FIND v(dout0_0) AT=520.025n

* CHECK dout0_1 Vdout0_1ck103 = 0.9 time = 520
.meas tran vdout0_1ck103 FIND v(dout0_1) AT=520.025n

* CHECK dout0_2 Vdout0_2ck103 = 0 time = 520
.meas tran vdout0_2ck103 FIND v(dout0_2) AT=520.025n

* CHECK dout0_3 Vdout0_3ck103 = 0 time = 520
.meas tran vdout0_3ck103 FIND v(dout0_3) AT=520.025n

* CHECK dout0_4 Vdout0_4ck103 = 0 time = 520
.meas tran vdout0_4ck103 FIND v(dout0_4) AT=520.025n

* CHECK dout0_5 Vdout0_5ck103 = 0 time = 520
.meas tran vdout0_5ck103 FIND v(dout0_5) AT=520.025n

* CHECK dout0_6 Vdout0_6ck103 = 0.9 time = 520
.meas tran vdout0_6ck103 FIND v(dout0_6) AT=520.025n

* CHECK dout0_7 Vdout0_7ck103 = 0 time = 520
.meas tran vdout0_7ck103 FIND v(dout0_7) AT=520.025n

* CHECK dout0_8 Vdout0_8ck103 = 0 time = 520
.meas tran vdout0_8ck103 FIND v(dout0_8) AT=520.025n

* CHECK dout0_9 Vdout0_9ck103 = 0 time = 520
.meas tran vdout0_9ck103 FIND v(dout0_9) AT=520.025n

* CHECK dout0_10 Vdout0_10ck103 = 0 time = 520
.meas tran vdout0_10ck103 FIND v(dout0_10) AT=520.025n

* CHECK dout0_11 Vdout0_11ck103 = 0 time = 520
.meas tran vdout0_11ck103 FIND v(dout0_11) AT=520.025n

* CHECK dout0_12 Vdout0_12ck103 = 0 time = 520
.meas tran vdout0_12ck103 FIND v(dout0_12) AT=520.025n

* CHECK dout0_13 Vdout0_13ck103 = 0.9 time = 520
.meas tran vdout0_13ck103 FIND v(dout0_13) AT=520.025n

* CHECK dout0_14 Vdout0_14ck103 = 0.9 time = 520
.meas tran vdout0_14ck103 FIND v(dout0_14) AT=520.025n

* CHECK dout0_15 Vdout0_15ck103 = 0.9 time = 520
.meas tran vdout0_15ck103 FIND v(dout0_15) AT=520.025n

* CHECK dout0_16 Vdout0_16ck103 = 0.9 time = 520
.meas tran vdout0_16ck103 FIND v(dout0_16) AT=520.025n

* CHECK dout0_17 Vdout0_17ck103 = 0.9 time = 520
.meas tran vdout0_17ck103 FIND v(dout0_17) AT=520.025n

* CHECK dout0_18 Vdout0_18ck103 = 0.9 time = 520
.meas tran vdout0_18ck103 FIND v(dout0_18) AT=520.025n

* CHECK dout0_19 Vdout0_19ck103 = 0 time = 520
.meas tran vdout0_19ck103 FIND v(dout0_19) AT=520.025n

* CHECK dout0_20 Vdout0_20ck103 = 0 time = 520
.meas tran vdout0_20ck103 FIND v(dout0_20) AT=520.025n

* CHECK dout0_21 Vdout0_21ck103 = 0 time = 520
.meas tran vdout0_21ck103 FIND v(dout0_21) AT=520.025n

* CHECK dout0_22 Vdout0_22ck103 = 0 time = 520
.meas tran vdout0_22ck103 FIND v(dout0_22) AT=520.025n

* CHECK dout0_23 Vdout0_23ck103 = 0.9 time = 520
.meas tran vdout0_23ck103 FIND v(dout0_23) AT=520.025n

* CHECK dout0_24 Vdout0_24ck103 = 0 time = 520
.meas tran vdout0_24ck103 FIND v(dout0_24) AT=520.025n

* CHECK dout0_25 Vdout0_25ck103 = 0 time = 520
.meas tran vdout0_25ck103 FIND v(dout0_25) AT=520.025n

* CHECK dout0_26 Vdout0_26ck103 = 0.9 time = 520
.meas tran vdout0_26ck103 FIND v(dout0_26) AT=520.025n

* CHECK dout0_27 Vdout0_27ck103 = 0 time = 520
.meas tran vdout0_27ck103 FIND v(dout0_27) AT=520.025n

* CHECK dout0_28 Vdout0_28ck103 = 0.9 time = 520
.meas tran vdout0_28ck103 FIND v(dout0_28) AT=520.025n

* CHECK dout0_29 Vdout0_29ck103 = 0 time = 520
.meas tran vdout0_29ck103 FIND v(dout0_29) AT=520.025n

* CHECK dout0_30 Vdout0_30ck103 = 0.9 time = 520
.meas tran vdout0_30ck103 FIND v(dout0_30) AT=520.025n

* CHECK dout0_31 Vdout0_31ck103 = 0.9 time = 520
.meas tran vdout0_31ck103 FIND v(dout0_31) AT=520.025n

* CHECK dout0_32 Vdout0_32ck103 = 0 time = 520
.meas tran vdout0_32ck103 FIND v(dout0_32) AT=520.025n

* CHECK dout0_33 Vdout0_33ck103 = 0.9 time = 520
.meas tran vdout0_33ck103 FIND v(dout0_33) AT=520.025n

* CHECK dout0_34 Vdout0_34ck103 = 0.9 time = 520
.meas tran vdout0_34ck103 FIND v(dout0_34) AT=520.025n

* CHECK dout0_35 Vdout0_35ck103 = 0.9 time = 520
.meas tran vdout0_35ck103 FIND v(dout0_35) AT=520.025n

* CHECK dout0_36 Vdout0_36ck103 = 0.9 time = 520
.meas tran vdout0_36ck103 FIND v(dout0_36) AT=520.025n

* CHECK dout0_37 Vdout0_37ck103 = 0 time = 520
.meas tran vdout0_37ck103 FIND v(dout0_37) AT=520.025n

* CHECK dout0_38 Vdout0_38ck103 = 0 time = 520
.meas tran vdout0_38ck103 FIND v(dout0_38) AT=520.025n

* CHECK dout0_39 Vdout0_39ck103 = 0.9 time = 520
.meas tran vdout0_39ck103 FIND v(dout0_39) AT=520.025n

* CHECK dout0_40 Vdout0_40ck103 = 0.9 time = 520
.meas tran vdout0_40ck103 FIND v(dout0_40) AT=520.025n

* CHECK dout0_41 Vdout0_41ck103 = 0 time = 520
.meas tran vdout0_41ck103 FIND v(dout0_41) AT=520.025n

* CHECK dout0_42 Vdout0_42ck103 = 0 time = 520
.meas tran vdout0_42ck103 FIND v(dout0_42) AT=520.025n

* CHECK dout0_43 Vdout0_43ck103 = 0 time = 520
.meas tran vdout0_43ck103 FIND v(dout0_43) AT=520.025n

* CHECK dout0_44 Vdout0_44ck103 = 0.9 time = 520
.meas tran vdout0_44ck103 FIND v(dout0_44) AT=520.025n

* CHECK dout0_45 Vdout0_45ck103 = 0.9 time = 520
.meas tran vdout0_45ck103 FIND v(dout0_45) AT=520.025n

* CHECK dout0_46 Vdout0_46ck103 = 0.9 time = 520
.meas tran vdout0_46ck103 FIND v(dout0_46) AT=520.025n

* CHECK dout0_47 Vdout0_47ck103 = 0 time = 520
.meas tran vdout0_47ck103 FIND v(dout0_47) AT=520.025n

* CHECK dout0_48 Vdout0_48ck103 = 0 time = 520
.meas tran vdout0_48ck103 FIND v(dout0_48) AT=520.025n

* CHECK dout0_49 Vdout0_49ck103 = 0 time = 520
.meas tran vdout0_49ck103 FIND v(dout0_49) AT=520.025n

* CHECK dout0_50 Vdout0_50ck103 = 0 time = 520
.meas tran vdout0_50ck103 FIND v(dout0_50) AT=520.025n

* CHECK dout0_51 Vdout0_51ck103 = 0.9 time = 520
.meas tran vdout0_51ck103 FIND v(dout0_51) AT=520.025n

* CHECK dout0_52 Vdout0_52ck103 = 0.9 time = 520
.meas tran vdout0_52ck103 FIND v(dout0_52) AT=520.025n

* CHECK dout0_53 Vdout0_53ck103 = 0 time = 520
.meas tran vdout0_53ck103 FIND v(dout0_53) AT=520.025n

* CHECK dout0_54 Vdout0_54ck103 = 0 time = 520
.meas tran vdout0_54ck103 FIND v(dout0_54) AT=520.025n

* CHECK dout0_55 Vdout0_55ck103 = 0 time = 520
.meas tran vdout0_55ck103 FIND v(dout0_55) AT=520.025n

* CHECK dout0_56 Vdout0_56ck103 = 0 time = 520
.meas tran vdout0_56ck103 FIND v(dout0_56) AT=520.025n

* CHECK dout0_57 Vdout0_57ck103 = 0 time = 520
.meas tran vdout0_57ck103 FIND v(dout0_57) AT=520.025n

* CHECK dout0_58 Vdout0_58ck103 = 0 time = 520
.meas tran vdout0_58ck103 FIND v(dout0_58) AT=520.025n

* CHECK dout0_59 Vdout0_59ck103 = 0 time = 520
.meas tran vdout0_59ck103 FIND v(dout0_59) AT=520.025n

* CHECK dout0_60 Vdout0_60ck103 = 0.9 time = 520
.meas tran vdout0_60ck103 FIND v(dout0_60) AT=520.025n

* CHECK dout0_61 Vdout0_61ck103 = 0 time = 520
.meas tran vdout0_61ck103 FIND v(dout0_61) AT=520.025n

* CHECK dout0_62 Vdout0_62ck103 = 0.9 time = 520
.meas tran vdout0_62ck103 FIND v(dout0_62) AT=520.025n

* CHECK dout0_63 Vdout0_63ck103 = 0.9 time = 520
.meas tran vdout0_63ck103 FIND v(dout0_63) AT=520.025n

* CHECK dout0_0 Vdout0_0ck106 = 0 time = 535
.meas tran vdout0_0ck106 FIND v(dout0_0) AT=535.025n

* CHECK dout0_1 Vdout0_1ck106 = 0.9 time = 535
.meas tran vdout0_1ck106 FIND v(dout0_1) AT=535.025n

* CHECK dout0_2 Vdout0_2ck106 = 0.9 time = 535
.meas tran vdout0_2ck106 FIND v(dout0_2) AT=535.025n

* CHECK dout0_3 Vdout0_3ck106 = 0.9 time = 535
.meas tran vdout0_3ck106 FIND v(dout0_3) AT=535.025n

* CHECK dout0_4 Vdout0_4ck106 = 0 time = 535
.meas tran vdout0_4ck106 FIND v(dout0_4) AT=535.025n

* CHECK dout0_5 Vdout0_5ck106 = 0 time = 535
.meas tran vdout0_5ck106 FIND v(dout0_5) AT=535.025n

* CHECK dout0_6 Vdout0_6ck106 = 0 time = 535
.meas tran vdout0_6ck106 FIND v(dout0_6) AT=535.025n

* CHECK dout0_7 Vdout0_7ck106 = 0 time = 535
.meas tran vdout0_7ck106 FIND v(dout0_7) AT=535.025n

* CHECK dout0_8 Vdout0_8ck106 = 0.9 time = 535
.meas tran vdout0_8ck106 FIND v(dout0_8) AT=535.025n

* CHECK dout0_9 Vdout0_9ck106 = 0.9 time = 535
.meas tran vdout0_9ck106 FIND v(dout0_9) AT=535.025n

* CHECK dout0_10 Vdout0_10ck106 = 0 time = 535
.meas tran vdout0_10ck106 FIND v(dout0_10) AT=535.025n

* CHECK dout0_11 Vdout0_11ck106 = 0 time = 535
.meas tran vdout0_11ck106 FIND v(dout0_11) AT=535.025n

* CHECK dout0_12 Vdout0_12ck106 = 0 time = 535
.meas tran vdout0_12ck106 FIND v(dout0_12) AT=535.025n

* CHECK dout0_13 Vdout0_13ck106 = 0 time = 535
.meas tran vdout0_13ck106 FIND v(dout0_13) AT=535.025n

* CHECK dout0_14 Vdout0_14ck106 = 0 time = 535
.meas tran vdout0_14ck106 FIND v(dout0_14) AT=535.025n

* CHECK dout0_15 Vdout0_15ck106 = 0 time = 535
.meas tran vdout0_15ck106 FIND v(dout0_15) AT=535.025n

* CHECK dout0_16 Vdout0_16ck106 = 0 time = 535
.meas tran vdout0_16ck106 FIND v(dout0_16) AT=535.025n

* CHECK dout0_17 Vdout0_17ck106 = 0 time = 535
.meas tran vdout0_17ck106 FIND v(dout0_17) AT=535.025n

* CHECK dout0_18 Vdout0_18ck106 = 0 time = 535
.meas tran vdout0_18ck106 FIND v(dout0_18) AT=535.025n

* CHECK dout0_19 Vdout0_19ck106 = 0.9 time = 535
.meas tran vdout0_19ck106 FIND v(dout0_19) AT=535.025n

* CHECK dout0_20 Vdout0_20ck106 = 0 time = 535
.meas tran vdout0_20ck106 FIND v(dout0_20) AT=535.025n

* CHECK dout0_21 Vdout0_21ck106 = 0 time = 535
.meas tran vdout0_21ck106 FIND v(dout0_21) AT=535.025n

* CHECK dout0_22 Vdout0_22ck106 = 0.9 time = 535
.meas tran vdout0_22ck106 FIND v(dout0_22) AT=535.025n

* CHECK dout0_23 Vdout0_23ck106 = 0 time = 535
.meas tran vdout0_23ck106 FIND v(dout0_23) AT=535.025n

* CHECK dout0_24 Vdout0_24ck106 = 0 time = 535
.meas tran vdout0_24ck106 FIND v(dout0_24) AT=535.025n

* CHECK dout0_25 Vdout0_25ck106 = 0 time = 535
.meas tran vdout0_25ck106 FIND v(dout0_25) AT=535.025n

* CHECK dout0_26 Vdout0_26ck106 = 0 time = 535
.meas tran vdout0_26ck106 FIND v(dout0_26) AT=535.025n

* CHECK dout0_27 Vdout0_27ck106 = 0 time = 535
.meas tran vdout0_27ck106 FIND v(dout0_27) AT=535.025n

* CHECK dout0_28 Vdout0_28ck106 = 0 time = 535
.meas tran vdout0_28ck106 FIND v(dout0_28) AT=535.025n

* CHECK dout0_29 Vdout0_29ck106 = 0.9 time = 535
.meas tran vdout0_29ck106 FIND v(dout0_29) AT=535.025n

* CHECK dout0_30 Vdout0_30ck106 = 0 time = 535
.meas tran vdout0_30ck106 FIND v(dout0_30) AT=535.025n

* CHECK dout0_31 Vdout0_31ck106 = 0 time = 535
.meas tran vdout0_31ck106 FIND v(dout0_31) AT=535.025n

* CHECK dout0_32 Vdout0_32ck106 = 0.9 time = 535
.meas tran vdout0_32ck106 FIND v(dout0_32) AT=535.025n

* CHECK dout0_33 Vdout0_33ck106 = 0.9 time = 535
.meas tran vdout0_33ck106 FIND v(dout0_33) AT=535.025n

* CHECK dout0_34 Vdout0_34ck106 = 0.9 time = 535
.meas tran vdout0_34ck106 FIND v(dout0_34) AT=535.025n

* CHECK dout0_35 Vdout0_35ck106 = 0 time = 535
.meas tran vdout0_35ck106 FIND v(dout0_35) AT=535.025n

* CHECK dout0_36 Vdout0_36ck106 = 0.9 time = 535
.meas tran vdout0_36ck106 FIND v(dout0_36) AT=535.025n

* CHECK dout0_37 Vdout0_37ck106 = 0 time = 535
.meas tran vdout0_37ck106 FIND v(dout0_37) AT=535.025n

* CHECK dout0_38 Vdout0_38ck106 = 0 time = 535
.meas tran vdout0_38ck106 FIND v(dout0_38) AT=535.025n

* CHECK dout0_39 Vdout0_39ck106 = 0 time = 535
.meas tran vdout0_39ck106 FIND v(dout0_39) AT=535.025n

* CHECK dout0_40 Vdout0_40ck106 = 0 time = 535
.meas tran vdout0_40ck106 FIND v(dout0_40) AT=535.025n

* CHECK dout0_41 Vdout0_41ck106 = 0 time = 535
.meas tran vdout0_41ck106 FIND v(dout0_41) AT=535.025n

* CHECK dout0_42 Vdout0_42ck106 = 0.9 time = 535
.meas tran vdout0_42ck106 FIND v(dout0_42) AT=535.025n

* CHECK dout0_43 Vdout0_43ck106 = 0 time = 535
.meas tran vdout0_43ck106 FIND v(dout0_43) AT=535.025n

* CHECK dout0_44 Vdout0_44ck106 = 0.9 time = 535
.meas tran vdout0_44ck106 FIND v(dout0_44) AT=535.025n

* CHECK dout0_45 Vdout0_45ck106 = 0.9 time = 535
.meas tran vdout0_45ck106 FIND v(dout0_45) AT=535.025n

* CHECK dout0_46 Vdout0_46ck106 = 0.9 time = 535
.meas tran vdout0_46ck106 FIND v(dout0_46) AT=535.025n

* CHECK dout0_47 Vdout0_47ck106 = 0.9 time = 535
.meas tran vdout0_47ck106 FIND v(dout0_47) AT=535.025n

* CHECK dout0_48 Vdout0_48ck106 = 0 time = 535
.meas tran vdout0_48ck106 FIND v(dout0_48) AT=535.025n

* CHECK dout0_49 Vdout0_49ck106 = 0.9 time = 535
.meas tran vdout0_49ck106 FIND v(dout0_49) AT=535.025n

* CHECK dout0_50 Vdout0_50ck106 = 0 time = 535
.meas tran vdout0_50ck106 FIND v(dout0_50) AT=535.025n

* CHECK dout0_51 Vdout0_51ck106 = 0 time = 535
.meas tran vdout0_51ck106 FIND v(dout0_51) AT=535.025n

* CHECK dout0_52 Vdout0_52ck106 = 0.9 time = 535
.meas tran vdout0_52ck106 FIND v(dout0_52) AT=535.025n

* CHECK dout0_53 Vdout0_53ck106 = 0 time = 535
.meas tran vdout0_53ck106 FIND v(dout0_53) AT=535.025n

* CHECK dout0_54 Vdout0_54ck106 = 0.9 time = 535
.meas tran vdout0_54ck106 FIND v(dout0_54) AT=535.025n

* CHECK dout0_55 Vdout0_55ck106 = 0.9 time = 535
.meas tran vdout0_55ck106 FIND v(dout0_55) AT=535.025n

* CHECK dout0_56 Vdout0_56ck106 = 0.9 time = 535
.meas tran vdout0_56ck106 FIND v(dout0_56) AT=535.025n

* CHECK dout0_57 Vdout0_57ck106 = 0 time = 535
.meas tran vdout0_57ck106 FIND v(dout0_57) AT=535.025n

* CHECK dout0_58 Vdout0_58ck106 = 0.9 time = 535
.meas tran vdout0_58ck106 FIND v(dout0_58) AT=535.025n

* CHECK dout0_59 Vdout0_59ck106 = 0.9 time = 535
.meas tran vdout0_59ck106 FIND v(dout0_59) AT=535.025n

* CHECK dout0_60 Vdout0_60ck106 = 0 time = 535
.meas tran vdout0_60ck106 FIND v(dout0_60) AT=535.025n

* CHECK dout0_61 Vdout0_61ck106 = 0 time = 535
.meas tran vdout0_61ck106 FIND v(dout0_61) AT=535.025n

* CHECK dout0_62 Vdout0_62ck106 = 0 time = 535
.meas tran vdout0_62ck106 FIND v(dout0_62) AT=535.025n

* CHECK dout0_63 Vdout0_63ck106 = 0 time = 535
.meas tran vdout0_63ck106 FIND v(dout0_63) AT=535.025n

* CHECK dout0_0 Vdout0_0ck107 = 0 time = 540
.meas tran vdout0_0ck107 FIND v(dout0_0) AT=540.025n

* CHECK dout0_1 Vdout0_1ck107 = 0.9 time = 540
.meas tran vdout0_1ck107 FIND v(dout0_1) AT=540.025n

* CHECK dout0_2 Vdout0_2ck107 = 0 time = 540
.meas tran vdout0_2ck107 FIND v(dout0_2) AT=540.025n

* CHECK dout0_3 Vdout0_3ck107 = 0.9 time = 540
.meas tran vdout0_3ck107 FIND v(dout0_3) AT=540.025n

* CHECK dout0_4 Vdout0_4ck107 = 0.9 time = 540
.meas tran vdout0_4ck107 FIND v(dout0_4) AT=540.025n

* CHECK dout0_5 Vdout0_5ck107 = 0 time = 540
.meas tran vdout0_5ck107 FIND v(dout0_5) AT=540.025n

* CHECK dout0_6 Vdout0_6ck107 = 0.9 time = 540
.meas tran vdout0_6ck107 FIND v(dout0_6) AT=540.025n

* CHECK dout0_7 Vdout0_7ck107 = 0 time = 540
.meas tran vdout0_7ck107 FIND v(dout0_7) AT=540.025n

* CHECK dout0_8 Vdout0_8ck107 = 0 time = 540
.meas tran vdout0_8ck107 FIND v(dout0_8) AT=540.025n

* CHECK dout0_9 Vdout0_9ck107 = 0.9 time = 540
.meas tran vdout0_9ck107 FIND v(dout0_9) AT=540.025n

* CHECK dout0_10 Vdout0_10ck107 = 0.9 time = 540
.meas tran vdout0_10ck107 FIND v(dout0_10) AT=540.025n

* CHECK dout0_11 Vdout0_11ck107 = 0.9 time = 540
.meas tran vdout0_11ck107 FIND v(dout0_11) AT=540.025n

* CHECK dout0_12 Vdout0_12ck107 = 0.9 time = 540
.meas tran vdout0_12ck107 FIND v(dout0_12) AT=540.025n

* CHECK dout0_13 Vdout0_13ck107 = 0 time = 540
.meas tran vdout0_13ck107 FIND v(dout0_13) AT=540.025n

* CHECK dout0_14 Vdout0_14ck107 = 0.9 time = 540
.meas tran vdout0_14ck107 FIND v(dout0_14) AT=540.025n

* CHECK dout0_15 Vdout0_15ck107 = 0.9 time = 540
.meas tran vdout0_15ck107 FIND v(dout0_15) AT=540.025n

* CHECK dout0_16 Vdout0_16ck107 = 0 time = 540
.meas tran vdout0_16ck107 FIND v(dout0_16) AT=540.025n

* CHECK dout0_17 Vdout0_17ck107 = 0 time = 540
.meas tran vdout0_17ck107 FIND v(dout0_17) AT=540.025n

* CHECK dout0_18 Vdout0_18ck107 = 0.9 time = 540
.meas tran vdout0_18ck107 FIND v(dout0_18) AT=540.025n

* CHECK dout0_19 Vdout0_19ck107 = 0 time = 540
.meas tran vdout0_19ck107 FIND v(dout0_19) AT=540.025n

* CHECK dout0_20 Vdout0_20ck107 = 0 time = 540
.meas tran vdout0_20ck107 FIND v(dout0_20) AT=540.025n

* CHECK dout0_21 Vdout0_21ck107 = 0 time = 540
.meas tran vdout0_21ck107 FIND v(dout0_21) AT=540.025n

* CHECK dout0_22 Vdout0_22ck107 = 0 time = 540
.meas tran vdout0_22ck107 FIND v(dout0_22) AT=540.025n

* CHECK dout0_23 Vdout0_23ck107 = 0.9 time = 540
.meas tran vdout0_23ck107 FIND v(dout0_23) AT=540.025n

* CHECK dout0_24 Vdout0_24ck107 = 0 time = 540
.meas tran vdout0_24ck107 FIND v(dout0_24) AT=540.025n

* CHECK dout0_25 Vdout0_25ck107 = 0.9 time = 540
.meas tran vdout0_25ck107 FIND v(dout0_25) AT=540.025n

* CHECK dout0_26 Vdout0_26ck107 = 0.9 time = 540
.meas tran vdout0_26ck107 FIND v(dout0_26) AT=540.025n

* CHECK dout0_27 Vdout0_27ck107 = 0 time = 540
.meas tran vdout0_27ck107 FIND v(dout0_27) AT=540.025n

* CHECK dout0_28 Vdout0_28ck107 = 0.9 time = 540
.meas tran vdout0_28ck107 FIND v(dout0_28) AT=540.025n

* CHECK dout0_29 Vdout0_29ck107 = 0.9 time = 540
.meas tran vdout0_29ck107 FIND v(dout0_29) AT=540.025n

* CHECK dout0_30 Vdout0_30ck107 = 0 time = 540
.meas tran vdout0_30ck107 FIND v(dout0_30) AT=540.025n

* CHECK dout0_31 Vdout0_31ck107 = 0.9 time = 540
.meas tran vdout0_31ck107 FIND v(dout0_31) AT=540.025n

* CHECK dout0_32 Vdout0_32ck107 = 0 time = 540
.meas tran vdout0_32ck107 FIND v(dout0_32) AT=540.025n

* CHECK dout0_33 Vdout0_33ck107 = 0.9 time = 540
.meas tran vdout0_33ck107 FIND v(dout0_33) AT=540.025n

* CHECK dout0_34 Vdout0_34ck107 = 0.9 time = 540
.meas tran vdout0_34ck107 FIND v(dout0_34) AT=540.025n

* CHECK dout0_35 Vdout0_35ck107 = 0.9 time = 540
.meas tran vdout0_35ck107 FIND v(dout0_35) AT=540.025n

* CHECK dout0_36 Vdout0_36ck107 = 0 time = 540
.meas tran vdout0_36ck107 FIND v(dout0_36) AT=540.025n

* CHECK dout0_37 Vdout0_37ck107 = 0 time = 540
.meas tran vdout0_37ck107 FIND v(dout0_37) AT=540.025n

* CHECK dout0_38 Vdout0_38ck107 = 0 time = 540
.meas tran vdout0_38ck107 FIND v(dout0_38) AT=540.025n

* CHECK dout0_39 Vdout0_39ck107 = 0.9 time = 540
.meas tran vdout0_39ck107 FIND v(dout0_39) AT=540.025n

* CHECK dout0_40 Vdout0_40ck107 = 0 time = 540
.meas tran vdout0_40ck107 FIND v(dout0_40) AT=540.025n

* CHECK dout0_41 Vdout0_41ck107 = 0.9 time = 540
.meas tran vdout0_41ck107 FIND v(dout0_41) AT=540.025n

* CHECK dout0_42 Vdout0_42ck107 = 0.9 time = 540
.meas tran vdout0_42ck107 FIND v(dout0_42) AT=540.025n

* CHECK dout0_43 Vdout0_43ck107 = 0 time = 540
.meas tran vdout0_43ck107 FIND v(dout0_43) AT=540.025n

* CHECK dout0_44 Vdout0_44ck107 = 0 time = 540
.meas tran vdout0_44ck107 FIND v(dout0_44) AT=540.025n

* CHECK dout0_45 Vdout0_45ck107 = 0.9 time = 540
.meas tran vdout0_45ck107 FIND v(dout0_45) AT=540.025n

* CHECK dout0_46 Vdout0_46ck107 = 0 time = 540
.meas tran vdout0_46ck107 FIND v(dout0_46) AT=540.025n

* CHECK dout0_47 Vdout0_47ck107 = 0.9 time = 540
.meas tran vdout0_47ck107 FIND v(dout0_47) AT=540.025n

* CHECK dout0_48 Vdout0_48ck107 = 0 time = 540
.meas tran vdout0_48ck107 FIND v(dout0_48) AT=540.025n

* CHECK dout0_49 Vdout0_49ck107 = 0 time = 540
.meas tran vdout0_49ck107 FIND v(dout0_49) AT=540.025n

* CHECK dout0_50 Vdout0_50ck107 = 0.9 time = 540
.meas tran vdout0_50ck107 FIND v(dout0_50) AT=540.025n

* CHECK dout0_51 Vdout0_51ck107 = 0.9 time = 540
.meas tran vdout0_51ck107 FIND v(dout0_51) AT=540.025n

* CHECK dout0_52 Vdout0_52ck107 = 0 time = 540
.meas tran vdout0_52ck107 FIND v(dout0_52) AT=540.025n

* CHECK dout0_53 Vdout0_53ck107 = 0.9 time = 540
.meas tran vdout0_53ck107 FIND v(dout0_53) AT=540.025n

* CHECK dout0_54 Vdout0_54ck107 = 0.9 time = 540
.meas tran vdout0_54ck107 FIND v(dout0_54) AT=540.025n

* CHECK dout0_55 Vdout0_55ck107 = 0 time = 540
.meas tran vdout0_55ck107 FIND v(dout0_55) AT=540.025n

* CHECK dout0_56 Vdout0_56ck107 = 0 time = 540
.meas tran vdout0_56ck107 FIND v(dout0_56) AT=540.025n

* CHECK dout0_57 Vdout0_57ck107 = 0.9 time = 540
.meas tran vdout0_57ck107 FIND v(dout0_57) AT=540.025n

* CHECK dout0_58 Vdout0_58ck107 = 0.9 time = 540
.meas tran vdout0_58ck107 FIND v(dout0_58) AT=540.025n

* CHECK dout0_59 Vdout0_59ck107 = 0 time = 540
.meas tran vdout0_59ck107 FIND v(dout0_59) AT=540.025n

* CHECK dout0_60 Vdout0_60ck107 = 0 time = 540
.meas tran vdout0_60ck107 FIND v(dout0_60) AT=540.025n

* CHECK dout0_61 Vdout0_61ck107 = 0 time = 540
.meas tran vdout0_61ck107 FIND v(dout0_61) AT=540.025n

* CHECK dout0_62 Vdout0_62ck107 = 0.9 time = 540
.meas tran vdout0_62ck107 FIND v(dout0_62) AT=540.025n

* CHECK dout0_63 Vdout0_63ck107 = 0 time = 540
.meas tran vdout0_63ck107 FIND v(dout0_63) AT=540.025n

* CHECK dout0_0 Vdout0_0ck109 = 0 time = 550
.meas tran vdout0_0ck109 FIND v(dout0_0) AT=550.025n

* CHECK dout0_1 Vdout0_1ck109 = 0.9 time = 550
.meas tran vdout0_1ck109 FIND v(dout0_1) AT=550.025n

* CHECK dout0_2 Vdout0_2ck109 = 0 time = 550
.meas tran vdout0_2ck109 FIND v(dout0_2) AT=550.025n

* CHECK dout0_3 Vdout0_3ck109 = 0.9 time = 550
.meas tran vdout0_3ck109 FIND v(dout0_3) AT=550.025n

* CHECK dout0_4 Vdout0_4ck109 = 0.9 time = 550
.meas tran vdout0_4ck109 FIND v(dout0_4) AT=550.025n

* CHECK dout0_5 Vdout0_5ck109 = 0.9 time = 550
.meas tran vdout0_5ck109 FIND v(dout0_5) AT=550.025n

* CHECK dout0_6 Vdout0_6ck109 = 0.9 time = 550
.meas tran vdout0_6ck109 FIND v(dout0_6) AT=550.025n

* CHECK dout0_7 Vdout0_7ck109 = 0 time = 550
.meas tran vdout0_7ck109 FIND v(dout0_7) AT=550.025n

* CHECK dout0_8 Vdout0_8ck109 = 0.9 time = 550
.meas tran vdout0_8ck109 FIND v(dout0_8) AT=550.025n

* CHECK dout0_9 Vdout0_9ck109 = 0 time = 550
.meas tran vdout0_9ck109 FIND v(dout0_9) AT=550.025n

* CHECK dout0_10 Vdout0_10ck109 = 0 time = 550
.meas tran vdout0_10ck109 FIND v(dout0_10) AT=550.025n

* CHECK dout0_11 Vdout0_11ck109 = 0.9 time = 550
.meas tran vdout0_11ck109 FIND v(dout0_11) AT=550.025n

* CHECK dout0_12 Vdout0_12ck109 = 0.9 time = 550
.meas tran vdout0_12ck109 FIND v(dout0_12) AT=550.025n

* CHECK dout0_13 Vdout0_13ck109 = 0.9 time = 550
.meas tran vdout0_13ck109 FIND v(dout0_13) AT=550.025n

* CHECK dout0_14 Vdout0_14ck109 = 0.9 time = 550
.meas tran vdout0_14ck109 FIND v(dout0_14) AT=550.025n

* CHECK dout0_15 Vdout0_15ck109 = 0 time = 550
.meas tran vdout0_15ck109 FIND v(dout0_15) AT=550.025n

* CHECK dout0_16 Vdout0_16ck109 = 0 time = 550
.meas tran vdout0_16ck109 FIND v(dout0_16) AT=550.025n

* CHECK dout0_17 Vdout0_17ck109 = 0.9 time = 550
.meas tran vdout0_17ck109 FIND v(dout0_17) AT=550.025n

* CHECK dout0_18 Vdout0_18ck109 = 0 time = 550
.meas tran vdout0_18ck109 FIND v(dout0_18) AT=550.025n

* CHECK dout0_19 Vdout0_19ck109 = 0.9 time = 550
.meas tran vdout0_19ck109 FIND v(dout0_19) AT=550.025n

* CHECK dout0_20 Vdout0_20ck109 = 0 time = 550
.meas tran vdout0_20ck109 FIND v(dout0_20) AT=550.025n

* CHECK dout0_21 Vdout0_21ck109 = 0 time = 550
.meas tran vdout0_21ck109 FIND v(dout0_21) AT=550.025n

* CHECK dout0_22 Vdout0_22ck109 = 0.9 time = 550
.meas tran vdout0_22ck109 FIND v(dout0_22) AT=550.025n

* CHECK dout0_23 Vdout0_23ck109 = 0 time = 550
.meas tran vdout0_23ck109 FIND v(dout0_23) AT=550.025n

* CHECK dout0_24 Vdout0_24ck109 = 0.9 time = 550
.meas tran vdout0_24ck109 FIND v(dout0_24) AT=550.025n

* CHECK dout0_25 Vdout0_25ck109 = 0.9 time = 550
.meas tran vdout0_25ck109 FIND v(dout0_25) AT=550.025n

* CHECK dout0_26 Vdout0_26ck109 = 0.9 time = 550
.meas tran vdout0_26ck109 FIND v(dout0_26) AT=550.025n

* CHECK dout0_27 Vdout0_27ck109 = 0 time = 550
.meas tran vdout0_27ck109 FIND v(dout0_27) AT=550.025n

* CHECK dout0_28 Vdout0_28ck109 = 0 time = 550
.meas tran vdout0_28ck109 FIND v(dout0_28) AT=550.025n

* CHECK dout0_29 Vdout0_29ck109 = 0.9 time = 550
.meas tran vdout0_29ck109 FIND v(dout0_29) AT=550.025n

* CHECK dout0_30 Vdout0_30ck109 = 0.9 time = 550
.meas tran vdout0_30ck109 FIND v(dout0_30) AT=550.025n

* CHECK dout0_31 Vdout0_31ck109 = 0.9 time = 550
.meas tran vdout0_31ck109 FIND v(dout0_31) AT=550.025n

* CHECK dout0_32 Vdout0_32ck109 = 0 time = 550
.meas tran vdout0_32ck109 FIND v(dout0_32) AT=550.025n

* CHECK dout0_33 Vdout0_33ck109 = 0.9 time = 550
.meas tran vdout0_33ck109 FIND v(dout0_33) AT=550.025n

* CHECK dout0_34 Vdout0_34ck109 = 0 time = 550
.meas tran vdout0_34ck109 FIND v(dout0_34) AT=550.025n

* CHECK dout0_35 Vdout0_35ck109 = 0.9 time = 550
.meas tran vdout0_35ck109 FIND v(dout0_35) AT=550.025n

* CHECK dout0_36 Vdout0_36ck109 = 0 time = 550
.meas tran vdout0_36ck109 FIND v(dout0_36) AT=550.025n

* CHECK dout0_37 Vdout0_37ck109 = 0 time = 550
.meas tran vdout0_37ck109 FIND v(dout0_37) AT=550.025n

* CHECK dout0_38 Vdout0_38ck109 = 0 time = 550
.meas tran vdout0_38ck109 FIND v(dout0_38) AT=550.025n

* CHECK dout0_39 Vdout0_39ck109 = 0.9 time = 550
.meas tran vdout0_39ck109 FIND v(dout0_39) AT=550.025n

* CHECK dout0_40 Vdout0_40ck109 = 0 time = 550
.meas tran vdout0_40ck109 FIND v(dout0_40) AT=550.025n

* CHECK dout0_41 Vdout0_41ck109 = 0 time = 550
.meas tran vdout0_41ck109 FIND v(dout0_41) AT=550.025n

* CHECK dout0_42 Vdout0_42ck109 = 0 time = 550
.meas tran vdout0_42ck109 FIND v(dout0_42) AT=550.025n

* CHECK dout0_43 Vdout0_43ck109 = 0 time = 550
.meas tran vdout0_43ck109 FIND v(dout0_43) AT=550.025n

* CHECK dout0_44 Vdout0_44ck109 = 0.9 time = 550
.meas tran vdout0_44ck109 FIND v(dout0_44) AT=550.025n

* CHECK dout0_45 Vdout0_45ck109 = 0.9 time = 550
.meas tran vdout0_45ck109 FIND v(dout0_45) AT=550.025n

* CHECK dout0_46 Vdout0_46ck109 = 0 time = 550
.meas tran vdout0_46ck109 FIND v(dout0_46) AT=550.025n

* CHECK dout0_47 Vdout0_47ck109 = 0 time = 550
.meas tran vdout0_47ck109 FIND v(dout0_47) AT=550.025n

* CHECK dout0_48 Vdout0_48ck109 = 0 time = 550
.meas tran vdout0_48ck109 FIND v(dout0_48) AT=550.025n

* CHECK dout0_49 Vdout0_49ck109 = 0.9 time = 550
.meas tran vdout0_49ck109 FIND v(dout0_49) AT=550.025n

* CHECK dout0_50 Vdout0_50ck109 = 0.9 time = 550
.meas tran vdout0_50ck109 FIND v(dout0_50) AT=550.025n

* CHECK dout0_51 Vdout0_51ck109 = 0 time = 550
.meas tran vdout0_51ck109 FIND v(dout0_51) AT=550.025n

* CHECK dout0_52 Vdout0_52ck109 = 0.9 time = 550
.meas tran vdout0_52ck109 FIND v(dout0_52) AT=550.025n

* CHECK dout0_53 Vdout0_53ck109 = 0 time = 550
.meas tran vdout0_53ck109 FIND v(dout0_53) AT=550.025n

* CHECK dout0_54 Vdout0_54ck109 = 0 time = 550
.meas tran vdout0_54ck109 FIND v(dout0_54) AT=550.025n

* CHECK dout0_55 Vdout0_55ck109 = 0.9 time = 550
.meas tran vdout0_55ck109 FIND v(dout0_55) AT=550.025n

* CHECK dout0_56 Vdout0_56ck109 = 0.9 time = 550
.meas tran vdout0_56ck109 FIND v(dout0_56) AT=550.025n

* CHECK dout0_57 Vdout0_57ck109 = 0.9 time = 550
.meas tran vdout0_57ck109 FIND v(dout0_57) AT=550.025n

* CHECK dout0_58 Vdout0_58ck109 = 0.9 time = 550
.meas tran vdout0_58ck109 FIND v(dout0_58) AT=550.025n

* CHECK dout0_59 Vdout0_59ck109 = 0 time = 550
.meas tran vdout0_59ck109 FIND v(dout0_59) AT=550.025n

* CHECK dout0_60 Vdout0_60ck109 = 0.9 time = 550
.meas tran vdout0_60ck109 FIND v(dout0_60) AT=550.025n

* CHECK dout0_61 Vdout0_61ck109 = 0.9 time = 550
.meas tran vdout0_61ck109 FIND v(dout0_61) AT=550.025n

* CHECK dout0_62 Vdout0_62ck109 = 0.9 time = 550
.meas tran vdout0_62ck109 FIND v(dout0_62) AT=550.025n

* CHECK dout0_63 Vdout0_63ck109 = 0.9 time = 550
.meas tran vdout0_63ck109 FIND v(dout0_63) AT=550.025n

* CHECK dout0_0 Vdout0_0ck111 = 0 time = 560
.meas tran vdout0_0ck111 FIND v(dout0_0) AT=560.025n

* CHECK dout0_1 Vdout0_1ck111 = 0.9 time = 560
.meas tran vdout0_1ck111 FIND v(dout0_1) AT=560.025n

* CHECK dout0_2 Vdout0_2ck111 = 0 time = 560
.meas tran vdout0_2ck111 FIND v(dout0_2) AT=560.025n

* CHECK dout0_3 Vdout0_3ck111 = 0 time = 560
.meas tran vdout0_3ck111 FIND v(dout0_3) AT=560.025n

* CHECK dout0_4 Vdout0_4ck111 = 0 time = 560
.meas tran vdout0_4ck111 FIND v(dout0_4) AT=560.025n

* CHECK dout0_5 Vdout0_5ck111 = 0 time = 560
.meas tran vdout0_5ck111 FIND v(dout0_5) AT=560.025n

* CHECK dout0_6 Vdout0_6ck111 = 0.9 time = 560
.meas tran vdout0_6ck111 FIND v(dout0_6) AT=560.025n

* CHECK dout0_7 Vdout0_7ck111 = 0 time = 560
.meas tran vdout0_7ck111 FIND v(dout0_7) AT=560.025n

* CHECK dout0_8 Vdout0_8ck111 = 0 time = 560
.meas tran vdout0_8ck111 FIND v(dout0_8) AT=560.025n

* CHECK dout0_9 Vdout0_9ck111 = 0 time = 560
.meas tran vdout0_9ck111 FIND v(dout0_9) AT=560.025n

* CHECK dout0_10 Vdout0_10ck111 = 0 time = 560
.meas tran vdout0_10ck111 FIND v(dout0_10) AT=560.025n

* CHECK dout0_11 Vdout0_11ck111 = 0 time = 560
.meas tran vdout0_11ck111 FIND v(dout0_11) AT=560.025n

* CHECK dout0_12 Vdout0_12ck111 = 0 time = 560
.meas tran vdout0_12ck111 FIND v(dout0_12) AT=560.025n

* CHECK dout0_13 Vdout0_13ck111 = 0.9 time = 560
.meas tran vdout0_13ck111 FIND v(dout0_13) AT=560.025n

* CHECK dout0_14 Vdout0_14ck111 = 0.9 time = 560
.meas tran vdout0_14ck111 FIND v(dout0_14) AT=560.025n

* CHECK dout0_15 Vdout0_15ck111 = 0.9 time = 560
.meas tran vdout0_15ck111 FIND v(dout0_15) AT=560.025n

* CHECK dout0_16 Vdout0_16ck111 = 0.9 time = 560
.meas tran vdout0_16ck111 FIND v(dout0_16) AT=560.025n

* CHECK dout0_17 Vdout0_17ck111 = 0.9 time = 560
.meas tran vdout0_17ck111 FIND v(dout0_17) AT=560.025n

* CHECK dout0_18 Vdout0_18ck111 = 0.9 time = 560
.meas tran vdout0_18ck111 FIND v(dout0_18) AT=560.025n

* CHECK dout0_19 Vdout0_19ck111 = 0 time = 560
.meas tran vdout0_19ck111 FIND v(dout0_19) AT=560.025n

* CHECK dout0_20 Vdout0_20ck111 = 0 time = 560
.meas tran vdout0_20ck111 FIND v(dout0_20) AT=560.025n

* CHECK dout0_21 Vdout0_21ck111 = 0 time = 560
.meas tran vdout0_21ck111 FIND v(dout0_21) AT=560.025n

* CHECK dout0_22 Vdout0_22ck111 = 0 time = 560
.meas tran vdout0_22ck111 FIND v(dout0_22) AT=560.025n

* CHECK dout0_23 Vdout0_23ck111 = 0.9 time = 560
.meas tran vdout0_23ck111 FIND v(dout0_23) AT=560.025n

* CHECK dout0_24 Vdout0_24ck111 = 0 time = 560
.meas tran vdout0_24ck111 FIND v(dout0_24) AT=560.025n

* CHECK dout0_25 Vdout0_25ck111 = 0 time = 560
.meas tran vdout0_25ck111 FIND v(dout0_25) AT=560.025n

* CHECK dout0_26 Vdout0_26ck111 = 0.9 time = 560
.meas tran vdout0_26ck111 FIND v(dout0_26) AT=560.025n

* CHECK dout0_27 Vdout0_27ck111 = 0 time = 560
.meas tran vdout0_27ck111 FIND v(dout0_27) AT=560.025n

* CHECK dout0_28 Vdout0_28ck111 = 0.9 time = 560
.meas tran vdout0_28ck111 FIND v(dout0_28) AT=560.025n

* CHECK dout0_29 Vdout0_29ck111 = 0 time = 560
.meas tran vdout0_29ck111 FIND v(dout0_29) AT=560.025n

* CHECK dout0_30 Vdout0_30ck111 = 0.9 time = 560
.meas tran vdout0_30ck111 FIND v(dout0_30) AT=560.025n

* CHECK dout0_31 Vdout0_31ck111 = 0.9 time = 560
.meas tran vdout0_31ck111 FIND v(dout0_31) AT=560.025n

* CHECK dout0_32 Vdout0_32ck111 = 0 time = 560
.meas tran vdout0_32ck111 FIND v(dout0_32) AT=560.025n

* CHECK dout0_33 Vdout0_33ck111 = 0.9 time = 560
.meas tran vdout0_33ck111 FIND v(dout0_33) AT=560.025n

* CHECK dout0_34 Vdout0_34ck111 = 0.9 time = 560
.meas tran vdout0_34ck111 FIND v(dout0_34) AT=560.025n

* CHECK dout0_35 Vdout0_35ck111 = 0.9 time = 560
.meas tran vdout0_35ck111 FIND v(dout0_35) AT=560.025n

* CHECK dout0_36 Vdout0_36ck111 = 0.9 time = 560
.meas tran vdout0_36ck111 FIND v(dout0_36) AT=560.025n

* CHECK dout0_37 Vdout0_37ck111 = 0 time = 560
.meas tran vdout0_37ck111 FIND v(dout0_37) AT=560.025n

* CHECK dout0_38 Vdout0_38ck111 = 0 time = 560
.meas tran vdout0_38ck111 FIND v(dout0_38) AT=560.025n

* CHECK dout0_39 Vdout0_39ck111 = 0.9 time = 560
.meas tran vdout0_39ck111 FIND v(dout0_39) AT=560.025n

* CHECK dout0_40 Vdout0_40ck111 = 0.9 time = 560
.meas tran vdout0_40ck111 FIND v(dout0_40) AT=560.025n

* CHECK dout0_41 Vdout0_41ck111 = 0 time = 560
.meas tran vdout0_41ck111 FIND v(dout0_41) AT=560.025n

* CHECK dout0_42 Vdout0_42ck111 = 0 time = 560
.meas tran vdout0_42ck111 FIND v(dout0_42) AT=560.025n

* CHECK dout0_43 Vdout0_43ck111 = 0 time = 560
.meas tran vdout0_43ck111 FIND v(dout0_43) AT=560.025n

* CHECK dout0_44 Vdout0_44ck111 = 0.9 time = 560
.meas tran vdout0_44ck111 FIND v(dout0_44) AT=560.025n

* CHECK dout0_45 Vdout0_45ck111 = 0.9 time = 560
.meas tran vdout0_45ck111 FIND v(dout0_45) AT=560.025n

* CHECK dout0_46 Vdout0_46ck111 = 0.9 time = 560
.meas tran vdout0_46ck111 FIND v(dout0_46) AT=560.025n

* CHECK dout0_47 Vdout0_47ck111 = 0 time = 560
.meas tran vdout0_47ck111 FIND v(dout0_47) AT=560.025n

* CHECK dout0_48 Vdout0_48ck111 = 0 time = 560
.meas tran vdout0_48ck111 FIND v(dout0_48) AT=560.025n

* CHECK dout0_49 Vdout0_49ck111 = 0 time = 560
.meas tran vdout0_49ck111 FIND v(dout0_49) AT=560.025n

* CHECK dout0_50 Vdout0_50ck111 = 0 time = 560
.meas tran vdout0_50ck111 FIND v(dout0_50) AT=560.025n

* CHECK dout0_51 Vdout0_51ck111 = 0.9 time = 560
.meas tran vdout0_51ck111 FIND v(dout0_51) AT=560.025n

* CHECK dout0_52 Vdout0_52ck111 = 0.9 time = 560
.meas tran vdout0_52ck111 FIND v(dout0_52) AT=560.025n

* CHECK dout0_53 Vdout0_53ck111 = 0 time = 560
.meas tran vdout0_53ck111 FIND v(dout0_53) AT=560.025n

* CHECK dout0_54 Vdout0_54ck111 = 0 time = 560
.meas tran vdout0_54ck111 FIND v(dout0_54) AT=560.025n

* CHECK dout0_55 Vdout0_55ck111 = 0 time = 560
.meas tran vdout0_55ck111 FIND v(dout0_55) AT=560.025n

* CHECK dout0_56 Vdout0_56ck111 = 0 time = 560
.meas tran vdout0_56ck111 FIND v(dout0_56) AT=560.025n

* CHECK dout0_57 Vdout0_57ck111 = 0 time = 560
.meas tran vdout0_57ck111 FIND v(dout0_57) AT=560.025n

* CHECK dout0_58 Vdout0_58ck111 = 0 time = 560
.meas tran vdout0_58ck111 FIND v(dout0_58) AT=560.025n

* CHECK dout0_59 Vdout0_59ck111 = 0 time = 560
.meas tran vdout0_59ck111 FIND v(dout0_59) AT=560.025n

* CHECK dout0_60 Vdout0_60ck111 = 0.9 time = 560
.meas tran vdout0_60ck111 FIND v(dout0_60) AT=560.025n

* CHECK dout0_61 Vdout0_61ck111 = 0 time = 560
.meas tran vdout0_61ck111 FIND v(dout0_61) AT=560.025n

* CHECK dout0_62 Vdout0_62ck111 = 0.9 time = 560
.meas tran vdout0_62ck111 FIND v(dout0_62) AT=560.025n

* CHECK dout0_63 Vdout0_63ck111 = 0.9 time = 560
.meas tran vdout0_63ck111 FIND v(dout0_63) AT=560.025n

* CHECK dout0_0 Vdout0_0ck113 = 0.9 time = 570
.meas tran vdout0_0ck113 FIND v(dout0_0) AT=570.025n

* CHECK dout0_1 Vdout0_1ck113 = 0.9 time = 570
.meas tran vdout0_1ck113 FIND v(dout0_1) AT=570.025n

* CHECK dout0_2 Vdout0_2ck113 = 0 time = 570
.meas tran vdout0_2ck113 FIND v(dout0_2) AT=570.025n

* CHECK dout0_3 Vdout0_3ck113 = 0.9 time = 570
.meas tran vdout0_3ck113 FIND v(dout0_3) AT=570.025n

* CHECK dout0_4 Vdout0_4ck113 = 0 time = 570
.meas tran vdout0_4ck113 FIND v(dout0_4) AT=570.025n

* CHECK dout0_5 Vdout0_5ck113 = 0 time = 570
.meas tran vdout0_5ck113 FIND v(dout0_5) AT=570.025n

* CHECK dout0_6 Vdout0_6ck113 = 0 time = 570
.meas tran vdout0_6ck113 FIND v(dout0_6) AT=570.025n

* CHECK dout0_7 Vdout0_7ck113 = 0.9 time = 570
.meas tran vdout0_7ck113 FIND v(dout0_7) AT=570.025n

* CHECK dout0_8 Vdout0_8ck113 = 0.9 time = 570
.meas tran vdout0_8ck113 FIND v(dout0_8) AT=570.025n

* CHECK dout0_9 Vdout0_9ck113 = 0 time = 570
.meas tran vdout0_9ck113 FIND v(dout0_9) AT=570.025n

* CHECK dout0_10 Vdout0_10ck113 = 0.9 time = 570
.meas tran vdout0_10ck113 FIND v(dout0_10) AT=570.025n

* CHECK dout0_11 Vdout0_11ck113 = 0 time = 570
.meas tran vdout0_11ck113 FIND v(dout0_11) AT=570.025n

* CHECK dout0_12 Vdout0_12ck113 = 0 time = 570
.meas tran vdout0_12ck113 FIND v(dout0_12) AT=570.025n

* CHECK dout0_13 Vdout0_13ck113 = 0.9 time = 570
.meas tran vdout0_13ck113 FIND v(dout0_13) AT=570.025n

* CHECK dout0_14 Vdout0_14ck113 = 0 time = 570
.meas tran vdout0_14ck113 FIND v(dout0_14) AT=570.025n

* CHECK dout0_15 Vdout0_15ck113 = 0.9 time = 570
.meas tran vdout0_15ck113 FIND v(dout0_15) AT=570.025n

* CHECK dout0_16 Vdout0_16ck113 = 0.9 time = 570
.meas tran vdout0_16ck113 FIND v(dout0_16) AT=570.025n

* CHECK dout0_17 Vdout0_17ck113 = 0 time = 570
.meas tran vdout0_17ck113 FIND v(dout0_17) AT=570.025n

* CHECK dout0_18 Vdout0_18ck113 = 0 time = 570
.meas tran vdout0_18ck113 FIND v(dout0_18) AT=570.025n

* CHECK dout0_19 Vdout0_19ck113 = 0.9 time = 570
.meas tran vdout0_19ck113 FIND v(dout0_19) AT=570.025n

* CHECK dout0_20 Vdout0_20ck113 = 0.9 time = 570
.meas tran vdout0_20ck113 FIND v(dout0_20) AT=570.025n

* CHECK dout0_21 Vdout0_21ck113 = 0 time = 570
.meas tran vdout0_21ck113 FIND v(dout0_21) AT=570.025n

* CHECK dout0_22 Vdout0_22ck113 = 0.9 time = 570
.meas tran vdout0_22ck113 FIND v(dout0_22) AT=570.025n

* CHECK dout0_23 Vdout0_23ck113 = 0.9 time = 570
.meas tran vdout0_23ck113 FIND v(dout0_23) AT=570.025n

* CHECK dout0_24 Vdout0_24ck113 = 0 time = 570
.meas tran vdout0_24ck113 FIND v(dout0_24) AT=570.025n

* CHECK dout0_25 Vdout0_25ck113 = 0 time = 570
.meas tran vdout0_25ck113 FIND v(dout0_25) AT=570.025n

* CHECK dout0_26 Vdout0_26ck113 = 0 time = 570
.meas tran vdout0_26ck113 FIND v(dout0_26) AT=570.025n

* CHECK dout0_27 Vdout0_27ck113 = 0 time = 570
.meas tran vdout0_27ck113 FIND v(dout0_27) AT=570.025n

* CHECK dout0_28 Vdout0_28ck113 = 0 time = 570
.meas tran vdout0_28ck113 FIND v(dout0_28) AT=570.025n

* CHECK dout0_29 Vdout0_29ck113 = 0.9 time = 570
.meas tran vdout0_29ck113 FIND v(dout0_29) AT=570.025n

* CHECK dout0_30 Vdout0_30ck113 = 0 time = 570
.meas tran vdout0_30ck113 FIND v(dout0_30) AT=570.025n

* CHECK dout0_31 Vdout0_31ck113 = 0.9 time = 570
.meas tran vdout0_31ck113 FIND v(dout0_31) AT=570.025n

* CHECK dout0_32 Vdout0_32ck113 = 0.9 time = 570
.meas tran vdout0_32ck113 FIND v(dout0_32) AT=570.025n

* CHECK dout0_33 Vdout0_33ck113 = 0.9 time = 570
.meas tran vdout0_33ck113 FIND v(dout0_33) AT=570.025n

* CHECK dout0_34 Vdout0_34ck113 = 0.9 time = 570
.meas tran vdout0_34ck113 FIND v(dout0_34) AT=570.025n

* CHECK dout0_35 Vdout0_35ck113 = 0.9 time = 570
.meas tran vdout0_35ck113 FIND v(dout0_35) AT=570.025n

* CHECK dout0_36 Vdout0_36ck113 = 0.9 time = 570
.meas tran vdout0_36ck113 FIND v(dout0_36) AT=570.025n

* CHECK dout0_37 Vdout0_37ck113 = 0 time = 570
.meas tran vdout0_37ck113 FIND v(dout0_37) AT=570.025n

* CHECK dout0_38 Vdout0_38ck113 = 0 time = 570
.meas tran vdout0_38ck113 FIND v(dout0_38) AT=570.025n

* CHECK dout0_39 Vdout0_39ck113 = 0.9 time = 570
.meas tran vdout0_39ck113 FIND v(dout0_39) AT=570.025n

* CHECK dout0_40 Vdout0_40ck113 = 0.9 time = 570
.meas tran vdout0_40ck113 FIND v(dout0_40) AT=570.025n

* CHECK dout0_41 Vdout0_41ck113 = 0.9 time = 570
.meas tran vdout0_41ck113 FIND v(dout0_41) AT=570.025n

* CHECK dout0_42 Vdout0_42ck113 = 0.9 time = 570
.meas tran vdout0_42ck113 FIND v(dout0_42) AT=570.025n

* CHECK dout0_43 Vdout0_43ck113 = 0.9 time = 570
.meas tran vdout0_43ck113 FIND v(dout0_43) AT=570.025n

* CHECK dout0_44 Vdout0_44ck113 = 0 time = 570
.meas tran vdout0_44ck113 FIND v(dout0_44) AT=570.025n

* CHECK dout0_45 Vdout0_45ck113 = 0 time = 570
.meas tran vdout0_45ck113 FIND v(dout0_45) AT=570.025n

* CHECK dout0_46 Vdout0_46ck113 = 0.9 time = 570
.meas tran vdout0_46ck113 FIND v(dout0_46) AT=570.025n

* CHECK dout0_47 Vdout0_47ck113 = 0.9 time = 570
.meas tran vdout0_47ck113 FIND v(dout0_47) AT=570.025n

* CHECK dout0_48 Vdout0_48ck113 = 0 time = 570
.meas tran vdout0_48ck113 FIND v(dout0_48) AT=570.025n

* CHECK dout0_49 Vdout0_49ck113 = 0 time = 570
.meas tran vdout0_49ck113 FIND v(dout0_49) AT=570.025n

* CHECK dout0_50 Vdout0_50ck113 = 0.9 time = 570
.meas tran vdout0_50ck113 FIND v(dout0_50) AT=570.025n

* CHECK dout0_51 Vdout0_51ck113 = 0 time = 570
.meas tran vdout0_51ck113 FIND v(dout0_51) AT=570.025n

* CHECK dout0_52 Vdout0_52ck113 = 0.9 time = 570
.meas tran vdout0_52ck113 FIND v(dout0_52) AT=570.025n

* CHECK dout0_53 Vdout0_53ck113 = 0.9 time = 570
.meas tran vdout0_53ck113 FIND v(dout0_53) AT=570.025n

* CHECK dout0_54 Vdout0_54ck113 = 0 time = 570
.meas tran vdout0_54ck113 FIND v(dout0_54) AT=570.025n

* CHECK dout0_55 Vdout0_55ck113 = 0.9 time = 570
.meas tran vdout0_55ck113 FIND v(dout0_55) AT=570.025n

* CHECK dout0_56 Vdout0_56ck113 = 0.9 time = 570
.meas tran vdout0_56ck113 FIND v(dout0_56) AT=570.025n

* CHECK dout0_57 Vdout0_57ck113 = 0.9 time = 570
.meas tran vdout0_57ck113 FIND v(dout0_57) AT=570.025n

* CHECK dout0_58 Vdout0_58ck113 = 0 time = 570
.meas tran vdout0_58ck113 FIND v(dout0_58) AT=570.025n

* CHECK dout0_59 Vdout0_59ck113 = 0.9 time = 570
.meas tran vdout0_59ck113 FIND v(dout0_59) AT=570.025n

* CHECK dout0_60 Vdout0_60ck113 = 0.9 time = 570
.meas tran vdout0_60ck113 FIND v(dout0_60) AT=570.025n

* CHECK dout0_61 Vdout0_61ck113 = 0.9 time = 570
.meas tran vdout0_61ck113 FIND v(dout0_61) AT=570.025n

* CHECK dout0_62 Vdout0_62ck113 = 0 time = 570
.meas tran vdout0_62ck113 FIND v(dout0_62) AT=570.025n

* CHECK dout0_63 Vdout0_63ck113 = 0 time = 570
.meas tran vdout0_63ck113 FIND v(dout0_63) AT=570.025n

* CHECK dout0_0 Vdout0_0ck115 = 0.9 time = 580
.meas tran vdout0_0ck115 FIND v(dout0_0) AT=580.025n

* CHECK dout0_1 Vdout0_1ck115 = 0.9 time = 580
.meas tran vdout0_1ck115 FIND v(dout0_1) AT=580.025n

* CHECK dout0_2 Vdout0_2ck115 = 0 time = 580
.meas tran vdout0_2ck115 FIND v(dout0_2) AT=580.025n

* CHECK dout0_3 Vdout0_3ck115 = 0.9 time = 580
.meas tran vdout0_3ck115 FIND v(dout0_3) AT=580.025n

* CHECK dout0_4 Vdout0_4ck115 = 0 time = 580
.meas tran vdout0_4ck115 FIND v(dout0_4) AT=580.025n

* CHECK dout0_5 Vdout0_5ck115 = 0 time = 580
.meas tran vdout0_5ck115 FIND v(dout0_5) AT=580.025n

* CHECK dout0_6 Vdout0_6ck115 = 0 time = 580
.meas tran vdout0_6ck115 FIND v(dout0_6) AT=580.025n

* CHECK dout0_7 Vdout0_7ck115 = 0 time = 580
.meas tran vdout0_7ck115 FIND v(dout0_7) AT=580.025n

* CHECK dout0_8 Vdout0_8ck115 = 0.9 time = 580
.meas tran vdout0_8ck115 FIND v(dout0_8) AT=580.025n

* CHECK dout0_9 Vdout0_9ck115 = 0.9 time = 580
.meas tran vdout0_9ck115 FIND v(dout0_9) AT=580.025n

* CHECK dout0_10 Vdout0_10ck115 = 0.9 time = 580
.meas tran vdout0_10ck115 FIND v(dout0_10) AT=580.025n

* CHECK dout0_11 Vdout0_11ck115 = 0 time = 580
.meas tran vdout0_11ck115 FIND v(dout0_11) AT=580.025n

* CHECK dout0_12 Vdout0_12ck115 = 0.9 time = 580
.meas tran vdout0_12ck115 FIND v(dout0_12) AT=580.025n

* CHECK dout0_13 Vdout0_13ck115 = 0.9 time = 580
.meas tran vdout0_13ck115 FIND v(dout0_13) AT=580.025n

* CHECK dout0_14 Vdout0_14ck115 = 0.9 time = 580
.meas tran vdout0_14ck115 FIND v(dout0_14) AT=580.025n

* CHECK dout0_15 Vdout0_15ck115 = 0.9 time = 580
.meas tran vdout0_15ck115 FIND v(dout0_15) AT=580.025n

* CHECK dout0_16 Vdout0_16ck115 = 0.9 time = 580
.meas tran vdout0_16ck115 FIND v(dout0_16) AT=580.025n

* CHECK dout0_17 Vdout0_17ck115 = 0 time = 580
.meas tran vdout0_17ck115 FIND v(dout0_17) AT=580.025n

* CHECK dout0_18 Vdout0_18ck115 = 0 time = 580
.meas tran vdout0_18ck115 FIND v(dout0_18) AT=580.025n

* CHECK dout0_19 Vdout0_19ck115 = 0.9 time = 580
.meas tran vdout0_19ck115 FIND v(dout0_19) AT=580.025n

* CHECK dout0_20 Vdout0_20ck115 = 0.9 time = 580
.meas tran vdout0_20ck115 FIND v(dout0_20) AT=580.025n

* CHECK dout0_21 Vdout0_21ck115 = 0.9 time = 580
.meas tran vdout0_21ck115 FIND v(dout0_21) AT=580.025n

* CHECK dout0_22 Vdout0_22ck115 = 0.9 time = 580
.meas tran vdout0_22ck115 FIND v(dout0_22) AT=580.025n

* CHECK dout0_23 Vdout0_23ck115 = 0.9 time = 580
.meas tran vdout0_23ck115 FIND v(dout0_23) AT=580.025n

* CHECK dout0_24 Vdout0_24ck115 = 0.9 time = 580
.meas tran vdout0_24ck115 FIND v(dout0_24) AT=580.025n

* CHECK dout0_25 Vdout0_25ck115 = 0 time = 580
.meas tran vdout0_25ck115 FIND v(dout0_25) AT=580.025n

* CHECK dout0_26 Vdout0_26ck115 = 0.9 time = 580
.meas tran vdout0_26ck115 FIND v(dout0_26) AT=580.025n

* CHECK dout0_27 Vdout0_27ck115 = 0.9 time = 580
.meas tran vdout0_27ck115 FIND v(dout0_27) AT=580.025n

* CHECK dout0_28 Vdout0_28ck115 = 0 time = 580
.meas tran vdout0_28ck115 FIND v(dout0_28) AT=580.025n

* CHECK dout0_29 Vdout0_29ck115 = 0 time = 580
.meas tran vdout0_29ck115 FIND v(dout0_29) AT=580.025n

* CHECK dout0_30 Vdout0_30ck115 = 0 time = 580
.meas tran vdout0_30ck115 FIND v(dout0_30) AT=580.025n

* CHECK dout0_31 Vdout0_31ck115 = 0.9 time = 580
.meas tran vdout0_31ck115 FIND v(dout0_31) AT=580.025n

* CHECK dout0_32 Vdout0_32ck115 = 0.9 time = 580
.meas tran vdout0_32ck115 FIND v(dout0_32) AT=580.025n

* CHECK dout0_33 Vdout0_33ck115 = 0.9 time = 580
.meas tran vdout0_33ck115 FIND v(dout0_33) AT=580.025n

* CHECK dout0_34 Vdout0_34ck115 = 0 time = 580
.meas tran vdout0_34ck115 FIND v(dout0_34) AT=580.025n

* CHECK dout0_35 Vdout0_35ck115 = 0.9 time = 580
.meas tran vdout0_35ck115 FIND v(dout0_35) AT=580.025n

* CHECK dout0_36 Vdout0_36ck115 = 0.9 time = 580
.meas tran vdout0_36ck115 FIND v(dout0_36) AT=580.025n

* CHECK dout0_37 Vdout0_37ck115 = 0 time = 580
.meas tran vdout0_37ck115 FIND v(dout0_37) AT=580.025n

* CHECK dout0_38 Vdout0_38ck115 = 0.9 time = 580
.meas tran vdout0_38ck115 FIND v(dout0_38) AT=580.025n

* CHECK dout0_39 Vdout0_39ck115 = 0 time = 580
.meas tran vdout0_39ck115 FIND v(dout0_39) AT=580.025n

* CHECK dout0_40 Vdout0_40ck115 = 0.9 time = 580
.meas tran vdout0_40ck115 FIND v(dout0_40) AT=580.025n

* CHECK dout0_41 Vdout0_41ck115 = 0 time = 580
.meas tran vdout0_41ck115 FIND v(dout0_41) AT=580.025n

* CHECK dout0_42 Vdout0_42ck115 = 0 time = 580
.meas tran vdout0_42ck115 FIND v(dout0_42) AT=580.025n

* CHECK dout0_43 Vdout0_43ck115 = 0 time = 580
.meas tran vdout0_43ck115 FIND v(dout0_43) AT=580.025n

* CHECK dout0_44 Vdout0_44ck115 = 0 time = 580
.meas tran vdout0_44ck115 FIND v(dout0_44) AT=580.025n

* CHECK dout0_45 Vdout0_45ck115 = 0 time = 580
.meas tran vdout0_45ck115 FIND v(dout0_45) AT=580.025n

* CHECK dout0_46 Vdout0_46ck115 = 0.9 time = 580
.meas tran vdout0_46ck115 FIND v(dout0_46) AT=580.025n

* CHECK dout0_47 Vdout0_47ck115 = 0.9 time = 580
.meas tran vdout0_47ck115 FIND v(dout0_47) AT=580.025n

* CHECK dout0_48 Vdout0_48ck115 = 0.9 time = 580
.meas tran vdout0_48ck115 FIND v(dout0_48) AT=580.025n

* CHECK dout0_49 Vdout0_49ck115 = 0.9 time = 580
.meas tran vdout0_49ck115 FIND v(dout0_49) AT=580.025n

* CHECK dout0_50 Vdout0_50ck115 = 0.9 time = 580
.meas tran vdout0_50ck115 FIND v(dout0_50) AT=580.025n

* CHECK dout0_51 Vdout0_51ck115 = 0 time = 580
.meas tran vdout0_51ck115 FIND v(dout0_51) AT=580.025n

* CHECK dout0_52 Vdout0_52ck115 = 0 time = 580
.meas tran vdout0_52ck115 FIND v(dout0_52) AT=580.025n

* CHECK dout0_53 Vdout0_53ck115 = 0.9 time = 580
.meas tran vdout0_53ck115 FIND v(dout0_53) AT=580.025n

* CHECK dout0_54 Vdout0_54ck115 = 0.9 time = 580
.meas tran vdout0_54ck115 FIND v(dout0_54) AT=580.025n

* CHECK dout0_55 Vdout0_55ck115 = 0 time = 580
.meas tran vdout0_55ck115 FIND v(dout0_55) AT=580.025n

* CHECK dout0_56 Vdout0_56ck115 = 0 time = 580
.meas tran vdout0_56ck115 FIND v(dout0_56) AT=580.025n

* CHECK dout0_57 Vdout0_57ck115 = 0.9 time = 580
.meas tran vdout0_57ck115 FIND v(dout0_57) AT=580.025n

* CHECK dout0_58 Vdout0_58ck115 = 0 time = 580
.meas tran vdout0_58ck115 FIND v(dout0_58) AT=580.025n

* CHECK dout0_59 Vdout0_59ck115 = 0 time = 580
.meas tran vdout0_59ck115 FIND v(dout0_59) AT=580.025n

* CHECK dout0_60 Vdout0_60ck115 = 0 time = 580
.meas tran vdout0_60ck115 FIND v(dout0_60) AT=580.025n

* CHECK dout0_61 Vdout0_61ck115 = 0 time = 580
.meas tran vdout0_61ck115 FIND v(dout0_61) AT=580.025n

* CHECK dout0_62 Vdout0_62ck115 = 0.9 time = 580
.meas tran vdout0_62ck115 FIND v(dout0_62) AT=580.025n

* CHECK dout0_63 Vdout0_63ck115 = 0 time = 580
.meas tran vdout0_63ck115 FIND v(dout0_63) AT=580.025n

* CHECK dout0_0 Vdout0_0ck120 = 0.9 time = 605
.meas tran vdout0_0ck120 FIND v(dout0_0) AT=605.025n

* CHECK dout0_1 Vdout0_1ck120 = 0.9 time = 605
.meas tran vdout0_1ck120 FIND v(dout0_1) AT=605.025n

* CHECK dout0_2 Vdout0_2ck120 = 0.9 time = 605
.meas tran vdout0_2ck120 FIND v(dout0_2) AT=605.025n

* CHECK dout0_3 Vdout0_3ck120 = 0 time = 605
.meas tran vdout0_3ck120 FIND v(dout0_3) AT=605.025n

* CHECK dout0_4 Vdout0_4ck120 = 0.9 time = 605
.meas tran vdout0_4ck120 FIND v(dout0_4) AT=605.025n

* CHECK dout0_5 Vdout0_5ck120 = 0 time = 605
.meas tran vdout0_5ck120 FIND v(dout0_5) AT=605.025n

* CHECK dout0_6 Vdout0_6ck120 = 0 time = 605
.meas tran vdout0_6ck120 FIND v(dout0_6) AT=605.025n

* CHECK dout0_7 Vdout0_7ck120 = 0 time = 605
.meas tran vdout0_7ck120 FIND v(dout0_7) AT=605.025n

* CHECK dout0_8 Vdout0_8ck120 = 0.9 time = 605
.meas tran vdout0_8ck120 FIND v(dout0_8) AT=605.025n

* CHECK dout0_9 Vdout0_9ck120 = 0.9 time = 605
.meas tran vdout0_9ck120 FIND v(dout0_9) AT=605.025n

* CHECK dout0_10 Vdout0_10ck120 = 0.9 time = 605
.meas tran vdout0_10ck120 FIND v(dout0_10) AT=605.025n

* CHECK dout0_11 Vdout0_11ck120 = 0 time = 605
.meas tran vdout0_11ck120 FIND v(dout0_11) AT=605.025n

* CHECK dout0_12 Vdout0_12ck120 = 0 time = 605
.meas tran vdout0_12ck120 FIND v(dout0_12) AT=605.025n

* CHECK dout0_13 Vdout0_13ck120 = 0.9 time = 605
.meas tran vdout0_13ck120 FIND v(dout0_13) AT=605.025n

* CHECK dout0_14 Vdout0_14ck120 = 0 time = 605
.meas tran vdout0_14ck120 FIND v(dout0_14) AT=605.025n

* CHECK dout0_15 Vdout0_15ck120 = 0 time = 605
.meas tran vdout0_15ck120 FIND v(dout0_15) AT=605.025n

* CHECK dout0_16 Vdout0_16ck120 = 0 time = 605
.meas tran vdout0_16ck120 FIND v(dout0_16) AT=605.025n

* CHECK dout0_17 Vdout0_17ck120 = 0 time = 605
.meas tran vdout0_17ck120 FIND v(dout0_17) AT=605.025n

* CHECK dout0_18 Vdout0_18ck120 = 0.9 time = 605
.meas tran vdout0_18ck120 FIND v(dout0_18) AT=605.025n

* CHECK dout0_19 Vdout0_19ck120 = 0.9 time = 605
.meas tran vdout0_19ck120 FIND v(dout0_19) AT=605.025n

* CHECK dout0_20 Vdout0_20ck120 = 0 time = 605
.meas tran vdout0_20ck120 FIND v(dout0_20) AT=605.025n

* CHECK dout0_21 Vdout0_21ck120 = 0 time = 605
.meas tran vdout0_21ck120 FIND v(dout0_21) AT=605.025n

* CHECK dout0_22 Vdout0_22ck120 = 0.9 time = 605
.meas tran vdout0_22ck120 FIND v(dout0_22) AT=605.025n

* CHECK dout0_23 Vdout0_23ck120 = 0 time = 605
.meas tran vdout0_23ck120 FIND v(dout0_23) AT=605.025n

* CHECK dout0_24 Vdout0_24ck120 = 0 time = 605
.meas tran vdout0_24ck120 FIND v(dout0_24) AT=605.025n

* CHECK dout0_25 Vdout0_25ck120 = 0.9 time = 605
.meas tran vdout0_25ck120 FIND v(dout0_25) AT=605.025n

* CHECK dout0_26 Vdout0_26ck120 = 0 time = 605
.meas tran vdout0_26ck120 FIND v(dout0_26) AT=605.025n

* CHECK dout0_27 Vdout0_27ck120 = 0 time = 605
.meas tran vdout0_27ck120 FIND v(dout0_27) AT=605.025n

* CHECK dout0_28 Vdout0_28ck120 = 0 time = 605
.meas tran vdout0_28ck120 FIND v(dout0_28) AT=605.025n

* CHECK dout0_29 Vdout0_29ck120 = 0.9 time = 605
.meas tran vdout0_29ck120 FIND v(dout0_29) AT=605.025n

* CHECK dout0_30 Vdout0_30ck120 = 0.9 time = 605
.meas tran vdout0_30ck120 FIND v(dout0_30) AT=605.025n

* CHECK dout0_31 Vdout0_31ck120 = 0.9 time = 605
.meas tran vdout0_31ck120 FIND v(dout0_31) AT=605.025n

* CHECK dout0_32 Vdout0_32ck120 = 0.9 time = 605
.meas tran vdout0_32ck120 FIND v(dout0_32) AT=605.025n

* CHECK dout0_33 Vdout0_33ck120 = 0.9 time = 605
.meas tran vdout0_33ck120 FIND v(dout0_33) AT=605.025n

* CHECK dout0_34 Vdout0_34ck120 = 0.9 time = 605
.meas tran vdout0_34ck120 FIND v(dout0_34) AT=605.025n

* CHECK dout0_35 Vdout0_35ck120 = 0 time = 605
.meas tran vdout0_35ck120 FIND v(dout0_35) AT=605.025n

* CHECK dout0_36 Vdout0_36ck120 = 0 time = 605
.meas tran vdout0_36ck120 FIND v(dout0_36) AT=605.025n

* CHECK dout0_37 Vdout0_37ck120 = 0 time = 605
.meas tran vdout0_37ck120 FIND v(dout0_37) AT=605.025n

* CHECK dout0_38 Vdout0_38ck120 = 0.9 time = 605
.meas tran vdout0_38ck120 FIND v(dout0_38) AT=605.025n

* CHECK dout0_39 Vdout0_39ck120 = 0.9 time = 605
.meas tran vdout0_39ck120 FIND v(dout0_39) AT=605.025n

* CHECK dout0_40 Vdout0_40ck120 = 0 time = 605
.meas tran vdout0_40ck120 FIND v(dout0_40) AT=605.025n

* CHECK dout0_41 Vdout0_41ck120 = 0 time = 605
.meas tran vdout0_41ck120 FIND v(dout0_41) AT=605.025n

* CHECK dout0_42 Vdout0_42ck120 = 0 time = 605
.meas tran vdout0_42ck120 FIND v(dout0_42) AT=605.025n

* CHECK dout0_43 Vdout0_43ck120 = 0 time = 605
.meas tran vdout0_43ck120 FIND v(dout0_43) AT=605.025n

* CHECK dout0_44 Vdout0_44ck120 = 0.9 time = 605
.meas tran vdout0_44ck120 FIND v(dout0_44) AT=605.025n

* CHECK dout0_45 Vdout0_45ck120 = 0 time = 605
.meas tran vdout0_45ck120 FIND v(dout0_45) AT=605.025n

* CHECK dout0_46 Vdout0_46ck120 = 0.9 time = 605
.meas tran vdout0_46ck120 FIND v(dout0_46) AT=605.025n

* CHECK dout0_47 Vdout0_47ck120 = 0 time = 605
.meas tran vdout0_47ck120 FIND v(dout0_47) AT=605.025n

* CHECK dout0_48 Vdout0_48ck120 = 0.9 time = 605
.meas tran vdout0_48ck120 FIND v(dout0_48) AT=605.025n

* CHECK dout0_49 Vdout0_49ck120 = 0.9 time = 605
.meas tran vdout0_49ck120 FIND v(dout0_49) AT=605.025n

* CHECK dout0_50 Vdout0_50ck120 = 0 time = 605
.meas tran vdout0_50ck120 FIND v(dout0_50) AT=605.025n

* CHECK dout0_51 Vdout0_51ck120 = 0.9 time = 605
.meas tran vdout0_51ck120 FIND v(dout0_51) AT=605.025n

* CHECK dout0_52 Vdout0_52ck120 = 0.9 time = 605
.meas tran vdout0_52ck120 FIND v(dout0_52) AT=605.025n

* CHECK dout0_53 Vdout0_53ck120 = 0 time = 605
.meas tran vdout0_53ck120 FIND v(dout0_53) AT=605.025n

* CHECK dout0_54 Vdout0_54ck120 = 0 time = 605
.meas tran vdout0_54ck120 FIND v(dout0_54) AT=605.025n

* CHECK dout0_55 Vdout0_55ck120 = 0.9 time = 605
.meas tran vdout0_55ck120 FIND v(dout0_55) AT=605.025n

* CHECK dout0_56 Vdout0_56ck120 = 0 time = 605
.meas tran vdout0_56ck120 FIND v(dout0_56) AT=605.025n

* CHECK dout0_57 Vdout0_57ck120 = 0 time = 605
.meas tran vdout0_57ck120 FIND v(dout0_57) AT=605.025n

* CHECK dout0_58 Vdout0_58ck120 = 0.9 time = 605
.meas tran vdout0_58ck120 FIND v(dout0_58) AT=605.025n

* CHECK dout0_59 Vdout0_59ck120 = 0 time = 605
.meas tran vdout0_59ck120 FIND v(dout0_59) AT=605.025n

* CHECK dout0_60 Vdout0_60ck120 = 0 time = 605
.meas tran vdout0_60ck120 FIND v(dout0_60) AT=605.025n

* CHECK dout0_61 Vdout0_61ck120 = 0 time = 605
.meas tran vdout0_61ck120 FIND v(dout0_61) AT=605.025n

* CHECK dout0_62 Vdout0_62ck120 = 0.9 time = 605
.meas tran vdout0_62ck120 FIND v(dout0_62) AT=605.025n

* CHECK dout0_63 Vdout0_63ck120 = 0 time = 605
.meas tran vdout0_63ck120 FIND v(dout0_63) AT=605.025n

* CHECK dout0_0 Vdout0_0ck121 = 0 time = 610
.meas tran vdout0_0ck121 FIND v(dout0_0) AT=610.025n

* CHECK dout0_1 Vdout0_1ck121 = 0 time = 610
.meas tran vdout0_1ck121 FIND v(dout0_1) AT=610.025n

* CHECK dout0_2 Vdout0_2ck121 = 0 time = 610
.meas tran vdout0_2ck121 FIND v(dout0_2) AT=610.025n

* CHECK dout0_3 Vdout0_3ck121 = 0 time = 610
.meas tran vdout0_3ck121 FIND v(dout0_3) AT=610.025n

* CHECK dout0_4 Vdout0_4ck121 = 0 time = 610
.meas tran vdout0_4ck121 FIND v(dout0_4) AT=610.025n

* CHECK dout0_5 Vdout0_5ck121 = 0 time = 610
.meas tran vdout0_5ck121 FIND v(dout0_5) AT=610.025n

* CHECK dout0_6 Vdout0_6ck121 = 0.9 time = 610
.meas tran vdout0_6ck121 FIND v(dout0_6) AT=610.025n

* CHECK dout0_7 Vdout0_7ck121 = 0.9 time = 610
.meas tran vdout0_7ck121 FIND v(dout0_7) AT=610.025n

* CHECK dout0_8 Vdout0_8ck121 = 0 time = 610
.meas tran vdout0_8ck121 FIND v(dout0_8) AT=610.025n

* CHECK dout0_9 Vdout0_9ck121 = 0 time = 610
.meas tran vdout0_9ck121 FIND v(dout0_9) AT=610.025n

* CHECK dout0_10 Vdout0_10ck121 = 0.9 time = 610
.meas tran vdout0_10ck121 FIND v(dout0_10) AT=610.025n

* CHECK dout0_11 Vdout0_11ck121 = 0 time = 610
.meas tran vdout0_11ck121 FIND v(dout0_11) AT=610.025n

* CHECK dout0_12 Vdout0_12ck121 = 0.9 time = 610
.meas tran vdout0_12ck121 FIND v(dout0_12) AT=610.025n

* CHECK dout0_13 Vdout0_13ck121 = 0 time = 610
.meas tran vdout0_13ck121 FIND v(dout0_13) AT=610.025n

* CHECK dout0_14 Vdout0_14ck121 = 0.9 time = 610
.meas tran vdout0_14ck121 FIND v(dout0_14) AT=610.025n

* CHECK dout0_15 Vdout0_15ck121 = 0.9 time = 610
.meas tran vdout0_15ck121 FIND v(dout0_15) AT=610.025n

* CHECK dout0_16 Vdout0_16ck121 = 0 time = 610
.meas tran vdout0_16ck121 FIND v(dout0_16) AT=610.025n

* CHECK dout0_17 Vdout0_17ck121 = 0.9 time = 610
.meas tran vdout0_17ck121 FIND v(dout0_17) AT=610.025n

* CHECK dout0_18 Vdout0_18ck121 = 0 time = 610
.meas tran vdout0_18ck121 FIND v(dout0_18) AT=610.025n

* CHECK dout0_19 Vdout0_19ck121 = 0 time = 610
.meas tran vdout0_19ck121 FIND v(dout0_19) AT=610.025n

* CHECK dout0_20 Vdout0_20ck121 = 0 time = 610
.meas tran vdout0_20ck121 FIND v(dout0_20) AT=610.025n

* CHECK dout0_21 Vdout0_21ck121 = 0.9 time = 610
.meas tran vdout0_21ck121 FIND v(dout0_21) AT=610.025n

* CHECK dout0_22 Vdout0_22ck121 = 0 time = 610
.meas tran vdout0_22ck121 FIND v(dout0_22) AT=610.025n

* CHECK dout0_23 Vdout0_23ck121 = 0.9 time = 610
.meas tran vdout0_23ck121 FIND v(dout0_23) AT=610.025n

* CHECK dout0_24 Vdout0_24ck121 = 0.9 time = 610
.meas tran vdout0_24ck121 FIND v(dout0_24) AT=610.025n

* CHECK dout0_25 Vdout0_25ck121 = 0.9 time = 610
.meas tran vdout0_25ck121 FIND v(dout0_25) AT=610.025n

* CHECK dout0_26 Vdout0_26ck121 = 0.9 time = 610
.meas tran vdout0_26ck121 FIND v(dout0_26) AT=610.025n

* CHECK dout0_27 Vdout0_27ck121 = 0 time = 610
.meas tran vdout0_27ck121 FIND v(dout0_27) AT=610.025n

* CHECK dout0_28 Vdout0_28ck121 = 0 time = 610
.meas tran vdout0_28ck121 FIND v(dout0_28) AT=610.025n

* CHECK dout0_29 Vdout0_29ck121 = 0 time = 610
.meas tran vdout0_29ck121 FIND v(dout0_29) AT=610.025n

* CHECK dout0_30 Vdout0_30ck121 = 0 time = 610
.meas tran vdout0_30ck121 FIND v(dout0_30) AT=610.025n

* CHECK dout0_31 Vdout0_31ck121 = 0.9 time = 610
.meas tran vdout0_31ck121 FIND v(dout0_31) AT=610.025n

* CHECK dout0_32 Vdout0_32ck121 = 0.9 time = 610
.meas tran vdout0_32ck121 FIND v(dout0_32) AT=610.025n

* CHECK dout0_33 Vdout0_33ck121 = 0.9 time = 610
.meas tran vdout0_33ck121 FIND v(dout0_33) AT=610.025n

* CHECK dout0_34 Vdout0_34ck121 = 0 time = 610
.meas tran vdout0_34ck121 FIND v(dout0_34) AT=610.025n

* CHECK dout0_35 Vdout0_35ck121 = 0.9 time = 610
.meas tran vdout0_35ck121 FIND v(dout0_35) AT=610.025n

* CHECK dout0_36 Vdout0_36ck121 = 0.9 time = 610
.meas tran vdout0_36ck121 FIND v(dout0_36) AT=610.025n

* CHECK dout0_37 Vdout0_37ck121 = 0 time = 610
.meas tran vdout0_37ck121 FIND v(dout0_37) AT=610.025n

* CHECK dout0_38 Vdout0_38ck121 = 0.9 time = 610
.meas tran vdout0_38ck121 FIND v(dout0_38) AT=610.025n

* CHECK dout0_39 Vdout0_39ck121 = 0 time = 610
.meas tran vdout0_39ck121 FIND v(dout0_39) AT=610.025n

* CHECK dout0_40 Vdout0_40ck121 = 0 time = 610
.meas tran vdout0_40ck121 FIND v(dout0_40) AT=610.025n

* CHECK dout0_41 Vdout0_41ck121 = 0.9 time = 610
.meas tran vdout0_41ck121 FIND v(dout0_41) AT=610.025n

* CHECK dout0_42 Vdout0_42ck121 = 0 time = 610
.meas tran vdout0_42ck121 FIND v(dout0_42) AT=610.025n

* CHECK dout0_43 Vdout0_43ck121 = 0 time = 610
.meas tran vdout0_43ck121 FIND v(dout0_43) AT=610.025n

* CHECK dout0_44 Vdout0_44ck121 = 0.9 time = 610
.meas tran vdout0_44ck121 FIND v(dout0_44) AT=610.025n

* CHECK dout0_45 Vdout0_45ck121 = 0 time = 610
.meas tran vdout0_45ck121 FIND v(dout0_45) AT=610.025n

* CHECK dout0_46 Vdout0_46ck121 = 0 time = 610
.meas tran vdout0_46ck121 FIND v(dout0_46) AT=610.025n

* CHECK dout0_47 Vdout0_47ck121 = 0 time = 610
.meas tran vdout0_47ck121 FIND v(dout0_47) AT=610.025n

* CHECK dout0_48 Vdout0_48ck121 = 0 time = 610
.meas tran vdout0_48ck121 FIND v(dout0_48) AT=610.025n

* CHECK dout0_49 Vdout0_49ck121 = 0 time = 610
.meas tran vdout0_49ck121 FIND v(dout0_49) AT=610.025n

* CHECK dout0_50 Vdout0_50ck121 = 0.9 time = 610
.meas tran vdout0_50ck121 FIND v(dout0_50) AT=610.025n

* CHECK dout0_51 Vdout0_51ck121 = 0.9 time = 610
.meas tran vdout0_51ck121 FIND v(dout0_51) AT=610.025n

* CHECK dout0_52 Vdout0_52ck121 = 0.9 time = 610
.meas tran vdout0_52ck121 FIND v(dout0_52) AT=610.025n

* CHECK dout0_53 Vdout0_53ck121 = 0.9 time = 610
.meas tran vdout0_53ck121 FIND v(dout0_53) AT=610.025n

* CHECK dout0_54 Vdout0_54ck121 = 0.9 time = 610
.meas tran vdout0_54ck121 FIND v(dout0_54) AT=610.025n

* CHECK dout0_55 Vdout0_55ck121 = 0.9 time = 610
.meas tran vdout0_55ck121 FIND v(dout0_55) AT=610.025n

* CHECK dout0_56 Vdout0_56ck121 = 0 time = 610
.meas tran vdout0_56ck121 FIND v(dout0_56) AT=610.025n

* CHECK dout0_57 Vdout0_57ck121 = 0.9 time = 610
.meas tran vdout0_57ck121 FIND v(dout0_57) AT=610.025n

* CHECK dout0_58 Vdout0_58ck121 = 0.9 time = 610
.meas tran vdout0_58ck121 FIND v(dout0_58) AT=610.025n

* CHECK dout0_59 Vdout0_59ck121 = 0 time = 610
.meas tran vdout0_59ck121 FIND v(dout0_59) AT=610.025n

* CHECK dout0_60 Vdout0_60ck121 = 0 time = 610
.meas tran vdout0_60ck121 FIND v(dout0_60) AT=610.025n

* CHECK dout0_61 Vdout0_61ck121 = 0 time = 610
.meas tran vdout0_61ck121 FIND v(dout0_61) AT=610.025n

* CHECK dout0_62 Vdout0_62ck121 = 0 time = 610
.meas tran vdout0_62ck121 FIND v(dout0_62) AT=610.025n

* CHECK dout0_63 Vdout0_63ck121 = 0 time = 610
.meas tran vdout0_63ck121 FIND v(dout0_63) AT=610.025n

* CHECK dout0_0 Vdout0_0ck124 = 0 time = 625
.meas tran vdout0_0ck124 FIND v(dout0_0) AT=625.025n

* CHECK dout0_1 Vdout0_1ck124 = 0.9 time = 625
.meas tran vdout0_1ck124 FIND v(dout0_1) AT=625.025n

* CHECK dout0_2 Vdout0_2ck124 = 0 time = 625
.meas tran vdout0_2ck124 FIND v(dout0_2) AT=625.025n

* CHECK dout0_3 Vdout0_3ck124 = 0 time = 625
.meas tran vdout0_3ck124 FIND v(dout0_3) AT=625.025n

* CHECK dout0_4 Vdout0_4ck124 = 0 time = 625
.meas tran vdout0_4ck124 FIND v(dout0_4) AT=625.025n

* CHECK dout0_5 Vdout0_5ck124 = 0.9 time = 625
.meas tran vdout0_5ck124 FIND v(dout0_5) AT=625.025n

* CHECK dout0_6 Vdout0_6ck124 = 0.9 time = 625
.meas tran vdout0_6ck124 FIND v(dout0_6) AT=625.025n

* CHECK dout0_7 Vdout0_7ck124 = 0 time = 625
.meas tran vdout0_7ck124 FIND v(dout0_7) AT=625.025n

* CHECK dout0_8 Vdout0_8ck124 = 0 time = 625
.meas tran vdout0_8ck124 FIND v(dout0_8) AT=625.025n

* CHECK dout0_9 Vdout0_9ck124 = 0.9 time = 625
.meas tran vdout0_9ck124 FIND v(dout0_9) AT=625.025n

* CHECK dout0_10 Vdout0_10ck124 = 0 time = 625
.meas tran vdout0_10ck124 FIND v(dout0_10) AT=625.025n

* CHECK dout0_11 Vdout0_11ck124 = 0.9 time = 625
.meas tran vdout0_11ck124 FIND v(dout0_11) AT=625.025n

* CHECK dout0_12 Vdout0_12ck124 = 0 time = 625
.meas tran vdout0_12ck124 FIND v(dout0_12) AT=625.025n

* CHECK dout0_13 Vdout0_13ck124 = 0.9 time = 625
.meas tran vdout0_13ck124 FIND v(dout0_13) AT=625.025n

* CHECK dout0_14 Vdout0_14ck124 = 0.9 time = 625
.meas tran vdout0_14ck124 FIND v(dout0_14) AT=625.025n

* CHECK dout0_15 Vdout0_15ck124 = 0 time = 625
.meas tran vdout0_15ck124 FIND v(dout0_15) AT=625.025n

* CHECK dout0_16 Vdout0_16ck124 = 0.9 time = 625
.meas tran vdout0_16ck124 FIND v(dout0_16) AT=625.025n

* CHECK dout0_17 Vdout0_17ck124 = 0.9 time = 625
.meas tran vdout0_17ck124 FIND v(dout0_17) AT=625.025n

* CHECK dout0_18 Vdout0_18ck124 = 0 time = 625
.meas tran vdout0_18ck124 FIND v(dout0_18) AT=625.025n

* CHECK dout0_19 Vdout0_19ck124 = 0.9 time = 625
.meas tran vdout0_19ck124 FIND v(dout0_19) AT=625.025n

* CHECK dout0_20 Vdout0_20ck124 = 0.9 time = 625
.meas tran vdout0_20ck124 FIND v(dout0_20) AT=625.025n

* CHECK dout0_21 Vdout0_21ck124 = 0.9 time = 625
.meas tran vdout0_21ck124 FIND v(dout0_21) AT=625.025n

* CHECK dout0_22 Vdout0_22ck124 = 0 time = 625
.meas tran vdout0_22ck124 FIND v(dout0_22) AT=625.025n

* CHECK dout0_23 Vdout0_23ck124 = 0.9 time = 625
.meas tran vdout0_23ck124 FIND v(dout0_23) AT=625.025n

* CHECK dout0_24 Vdout0_24ck124 = 0 time = 625
.meas tran vdout0_24ck124 FIND v(dout0_24) AT=625.025n

* CHECK dout0_25 Vdout0_25ck124 = 0 time = 625
.meas tran vdout0_25ck124 FIND v(dout0_25) AT=625.025n

* CHECK dout0_26 Vdout0_26ck124 = 0.9 time = 625
.meas tran vdout0_26ck124 FIND v(dout0_26) AT=625.025n

* CHECK dout0_27 Vdout0_27ck124 = 0 time = 625
.meas tran vdout0_27ck124 FIND v(dout0_27) AT=625.025n

* CHECK dout0_28 Vdout0_28ck124 = 0.9 time = 625
.meas tran vdout0_28ck124 FIND v(dout0_28) AT=625.025n

* CHECK dout0_29 Vdout0_29ck124 = 0.9 time = 625
.meas tran vdout0_29ck124 FIND v(dout0_29) AT=625.025n

* CHECK dout0_30 Vdout0_30ck124 = 0.9 time = 625
.meas tran vdout0_30ck124 FIND v(dout0_30) AT=625.025n

* CHECK dout0_31 Vdout0_31ck124 = 0 time = 625
.meas tran vdout0_31ck124 FIND v(dout0_31) AT=625.025n

* CHECK dout0_32 Vdout0_32ck124 = 0 time = 625
.meas tran vdout0_32ck124 FIND v(dout0_32) AT=625.025n

* CHECK dout0_33 Vdout0_33ck124 = 0 time = 625
.meas tran vdout0_33ck124 FIND v(dout0_33) AT=625.025n

* CHECK dout0_34 Vdout0_34ck124 = 0.9 time = 625
.meas tran vdout0_34ck124 FIND v(dout0_34) AT=625.025n

* CHECK dout0_35 Vdout0_35ck124 = 0.9 time = 625
.meas tran vdout0_35ck124 FIND v(dout0_35) AT=625.025n

* CHECK dout0_36 Vdout0_36ck124 = 0.9 time = 625
.meas tran vdout0_36ck124 FIND v(dout0_36) AT=625.025n

* CHECK dout0_37 Vdout0_37ck124 = 0.9 time = 625
.meas tran vdout0_37ck124 FIND v(dout0_37) AT=625.025n

* CHECK dout0_38 Vdout0_38ck124 = 0.9 time = 625
.meas tran vdout0_38ck124 FIND v(dout0_38) AT=625.025n

* CHECK dout0_39 Vdout0_39ck124 = 0 time = 625
.meas tran vdout0_39ck124 FIND v(dout0_39) AT=625.025n

* CHECK dout0_40 Vdout0_40ck124 = 0 time = 625
.meas tran vdout0_40ck124 FIND v(dout0_40) AT=625.025n

* CHECK dout0_41 Vdout0_41ck124 = 0.9 time = 625
.meas tran vdout0_41ck124 FIND v(dout0_41) AT=625.025n

* CHECK dout0_42 Vdout0_42ck124 = 0.9 time = 625
.meas tran vdout0_42ck124 FIND v(dout0_42) AT=625.025n

* CHECK dout0_43 Vdout0_43ck124 = 0 time = 625
.meas tran vdout0_43ck124 FIND v(dout0_43) AT=625.025n

* CHECK dout0_44 Vdout0_44ck124 = 0 time = 625
.meas tran vdout0_44ck124 FIND v(dout0_44) AT=625.025n

* CHECK dout0_45 Vdout0_45ck124 = 0.9 time = 625
.meas tran vdout0_45ck124 FIND v(dout0_45) AT=625.025n

* CHECK dout0_46 Vdout0_46ck124 = 0 time = 625
.meas tran vdout0_46ck124 FIND v(dout0_46) AT=625.025n

* CHECK dout0_47 Vdout0_47ck124 = 0 time = 625
.meas tran vdout0_47ck124 FIND v(dout0_47) AT=625.025n

* CHECK dout0_48 Vdout0_48ck124 = 0 time = 625
.meas tran vdout0_48ck124 FIND v(dout0_48) AT=625.025n

* CHECK dout0_49 Vdout0_49ck124 = 0.9 time = 625
.meas tran vdout0_49ck124 FIND v(dout0_49) AT=625.025n

* CHECK dout0_50 Vdout0_50ck124 = 0 time = 625
.meas tran vdout0_50ck124 FIND v(dout0_50) AT=625.025n

* CHECK dout0_51 Vdout0_51ck124 = 0.9 time = 625
.meas tran vdout0_51ck124 FIND v(dout0_51) AT=625.025n

* CHECK dout0_52 Vdout0_52ck124 = 0 time = 625
.meas tran vdout0_52ck124 FIND v(dout0_52) AT=625.025n

* CHECK dout0_53 Vdout0_53ck124 = 0 time = 625
.meas tran vdout0_53ck124 FIND v(dout0_53) AT=625.025n

* CHECK dout0_54 Vdout0_54ck124 = 0 time = 625
.meas tran vdout0_54ck124 FIND v(dout0_54) AT=625.025n

* CHECK dout0_55 Vdout0_55ck124 = 0.9 time = 625
.meas tran vdout0_55ck124 FIND v(dout0_55) AT=625.025n

* CHECK dout0_56 Vdout0_56ck124 = 0.9 time = 625
.meas tran vdout0_56ck124 FIND v(dout0_56) AT=625.025n

* CHECK dout0_57 Vdout0_57ck124 = 0 time = 625
.meas tran vdout0_57ck124 FIND v(dout0_57) AT=625.025n

* CHECK dout0_58 Vdout0_58ck124 = 0 time = 625
.meas tran vdout0_58ck124 FIND v(dout0_58) AT=625.025n

* CHECK dout0_59 Vdout0_59ck124 = 0.9 time = 625
.meas tran vdout0_59ck124 FIND v(dout0_59) AT=625.025n

* CHECK dout0_60 Vdout0_60ck124 = 0 time = 625
.meas tran vdout0_60ck124 FIND v(dout0_60) AT=625.025n

* CHECK dout0_61 Vdout0_61ck124 = 0 time = 625
.meas tran vdout0_61ck124 FIND v(dout0_61) AT=625.025n

* CHECK dout0_62 Vdout0_62ck124 = 0 time = 625
.meas tran vdout0_62ck124 FIND v(dout0_62) AT=625.025n

* CHECK dout0_63 Vdout0_63ck124 = 0 time = 625
.meas tran vdout0_63ck124 FIND v(dout0_63) AT=625.025n

* CHECK dout0_0 Vdout0_0ck126 = 0 time = 635
.meas tran vdout0_0ck126 FIND v(dout0_0) AT=635.025n

* CHECK dout0_1 Vdout0_1ck126 = 0.9 time = 635
.meas tran vdout0_1ck126 FIND v(dout0_1) AT=635.025n

* CHECK dout0_2 Vdout0_2ck126 = 0 time = 635
.meas tran vdout0_2ck126 FIND v(dout0_2) AT=635.025n

* CHECK dout0_3 Vdout0_3ck126 = 0.9 time = 635
.meas tran vdout0_3ck126 FIND v(dout0_3) AT=635.025n

* CHECK dout0_4 Vdout0_4ck126 = 0.9 time = 635
.meas tran vdout0_4ck126 FIND v(dout0_4) AT=635.025n

* CHECK dout0_5 Vdout0_5ck126 = 0.9 time = 635
.meas tran vdout0_5ck126 FIND v(dout0_5) AT=635.025n

* CHECK dout0_6 Vdout0_6ck126 = 0.9 time = 635
.meas tran vdout0_6ck126 FIND v(dout0_6) AT=635.025n

* CHECK dout0_7 Vdout0_7ck126 = 0 time = 635
.meas tran vdout0_7ck126 FIND v(dout0_7) AT=635.025n

* CHECK dout0_8 Vdout0_8ck126 = 0.9 time = 635
.meas tran vdout0_8ck126 FIND v(dout0_8) AT=635.025n

* CHECK dout0_9 Vdout0_9ck126 = 0 time = 635
.meas tran vdout0_9ck126 FIND v(dout0_9) AT=635.025n

* CHECK dout0_10 Vdout0_10ck126 = 0 time = 635
.meas tran vdout0_10ck126 FIND v(dout0_10) AT=635.025n

* CHECK dout0_11 Vdout0_11ck126 = 0.9 time = 635
.meas tran vdout0_11ck126 FIND v(dout0_11) AT=635.025n

* CHECK dout0_12 Vdout0_12ck126 = 0.9 time = 635
.meas tran vdout0_12ck126 FIND v(dout0_12) AT=635.025n

* CHECK dout0_13 Vdout0_13ck126 = 0.9 time = 635
.meas tran vdout0_13ck126 FIND v(dout0_13) AT=635.025n

* CHECK dout0_14 Vdout0_14ck126 = 0.9 time = 635
.meas tran vdout0_14ck126 FIND v(dout0_14) AT=635.025n

* CHECK dout0_15 Vdout0_15ck126 = 0 time = 635
.meas tran vdout0_15ck126 FIND v(dout0_15) AT=635.025n

* CHECK dout0_16 Vdout0_16ck126 = 0 time = 635
.meas tran vdout0_16ck126 FIND v(dout0_16) AT=635.025n

* CHECK dout0_17 Vdout0_17ck126 = 0.9 time = 635
.meas tran vdout0_17ck126 FIND v(dout0_17) AT=635.025n

* CHECK dout0_18 Vdout0_18ck126 = 0 time = 635
.meas tran vdout0_18ck126 FIND v(dout0_18) AT=635.025n

* CHECK dout0_19 Vdout0_19ck126 = 0.9 time = 635
.meas tran vdout0_19ck126 FIND v(dout0_19) AT=635.025n

* CHECK dout0_20 Vdout0_20ck126 = 0 time = 635
.meas tran vdout0_20ck126 FIND v(dout0_20) AT=635.025n

* CHECK dout0_21 Vdout0_21ck126 = 0 time = 635
.meas tran vdout0_21ck126 FIND v(dout0_21) AT=635.025n

* CHECK dout0_22 Vdout0_22ck126 = 0.9 time = 635
.meas tran vdout0_22ck126 FIND v(dout0_22) AT=635.025n

* CHECK dout0_23 Vdout0_23ck126 = 0 time = 635
.meas tran vdout0_23ck126 FIND v(dout0_23) AT=635.025n

* CHECK dout0_24 Vdout0_24ck126 = 0.9 time = 635
.meas tran vdout0_24ck126 FIND v(dout0_24) AT=635.025n

* CHECK dout0_25 Vdout0_25ck126 = 0.9 time = 635
.meas tran vdout0_25ck126 FIND v(dout0_25) AT=635.025n

* CHECK dout0_26 Vdout0_26ck126 = 0.9 time = 635
.meas tran vdout0_26ck126 FIND v(dout0_26) AT=635.025n

* CHECK dout0_27 Vdout0_27ck126 = 0 time = 635
.meas tran vdout0_27ck126 FIND v(dout0_27) AT=635.025n

* CHECK dout0_28 Vdout0_28ck126 = 0 time = 635
.meas tran vdout0_28ck126 FIND v(dout0_28) AT=635.025n

* CHECK dout0_29 Vdout0_29ck126 = 0.9 time = 635
.meas tran vdout0_29ck126 FIND v(dout0_29) AT=635.025n

* CHECK dout0_30 Vdout0_30ck126 = 0.9 time = 635
.meas tran vdout0_30ck126 FIND v(dout0_30) AT=635.025n

* CHECK dout0_31 Vdout0_31ck126 = 0.9 time = 635
.meas tran vdout0_31ck126 FIND v(dout0_31) AT=635.025n

* CHECK dout0_32 Vdout0_32ck126 = 0 time = 635
.meas tran vdout0_32ck126 FIND v(dout0_32) AT=635.025n

* CHECK dout0_33 Vdout0_33ck126 = 0.9 time = 635
.meas tran vdout0_33ck126 FIND v(dout0_33) AT=635.025n

* CHECK dout0_34 Vdout0_34ck126 = 0 time = 635
.meas tran vdout0_34ck126 FIND v(dout0_34) AT=635.025n

* CHECK dout0_35 Vdout0_35ck126 = 0.9 time = 635
.meas tran vdout0_35ck126 FIND v(dout0_35) AT=635.025n

* CHECK dout0_36 Vdout0_36ck126 = 0 time = 635
.meas tran vdout0_36ck126 FIND v(dout0_36) AT=635.025n

* CHECK dout0_37 Vdout0_37ck126 = 0 time = 635
.meas tran vdout0_37ck126 FIND v(dout0_37) AT=635.025n

* CHECK dout0_38 Vdout0_38ck126 = 0 time = 635
.meas tran vdout0_38ck126 FIND v(dout0_38) AT=635.025n

* CHECK dout0_39 Vdout0_39ck126 = 0.9 time = 635
.meas tran vdout0_39ck126 FIND v(dout0_39) AT=635.025n

* CHECK dout0_40 Vdout0_40ck126 = 0 time = 635
.meas tran vdout0_40ck126 FIND v(dout0_40) AT=635.025n

* CHECK dout0_41 Vdout0_41ck126 = 0 time = 635
.meas tran vdout0_41ck126 FIND v(dout0_41) AT=635.025n

* CHECK dout0_42 Vdout0_42ck126 = 0 time = 635
.meas tran vdout0_42ck126 FIND v(dout0_42) AT=635.025n

* CHECK dout0_43 Vdout0_43ck126 = 0 time = 635
.meas tran vdout0_43ck126 FIND v(dout0_43) AT=635.025n

* CHECK dout0_44 Vdout0_44ck126 = 0.9 time = 635
.meas tran vdout0_44ck126 FIND v(dout0_44) AT=635.025n

* CHECK dout0_45 Vdout0_45ck126 = 0.9 time = 635
.meas tran vdout0_45ck126 FIND v(dout0_45) AT=635.025n

* CHECK dout0_46 Vdout0_46ck126 = 0 time = 635
.meas tran vdout0_46ck126 FIND v(dout0_46) AT=635.025n

* CHECK dout0_47 Vdout0_47ck126 = 0 time = 635
.meas tran vdout0_47ck126 FIND v(dout0_47) AT=635.025n

* CHECK dout0_48 Vdout0_48ck126 = 0 time = 635
.meas tran vdout0_48ck126 FIND v(dout0_48) AT=635.025n

* CHECK dout0_49 Vdout0_49ck126 = 0.9 time = 635
.meas tran vdout0_49ck126 FIND v(dout0_49) AT=635.025n

* CHECK dout0_50 Vdout0_50ck126 = 0.9 time = 635
.meas tran vdout0_50ck126 FIND v(dout0_50) AT=635.025n

* CHECK dout0_51 Vdout0_51ck126 = 0 time = 635
.meas tran vdout0_51ck126 FIND v(dout0_51) AT=635.025n

* CHECK dout0_52 Vdout0_52ck126 = 0.9 time = 635
.meas tran vdout0_52ck126 FIND v(dout0_52) AT=635.025n

* CHECK dout0_53 Vdout0_53ck126 = 0 time = 635
.meas tran vdout0_53ck126 FIND v(dout0_53) AT=635.025n

* CHECK dout0_54 Vdout0_54ck126 = 0 time = 635
.meas tran vdout0_54ck126 FIND v(dout0_54) AT=635.025n

* CHECK dout0_55 Vdout0_55ck126 = 0.9 time = 635
.meas tran vdout0_55ck126 FIND v(dout0_55) AT=635.025n

* CHECK dout0_56 Vdout0_56ck126 = 0.9 time = 635
.meas tran vdout0_56ck126 FIND v(dout0_56) AT=635.025n

* CHECK dout0_57 Vdout0_57ck126 = 0.9 time = 635
.meas tran vdout0_57ck126 FIND v(dout0_57) AT=635.025n

* CHECK dout0_58 Vdout0_58ck126 = 0.9 time = 635
.meas tran vdout0_58ck126 FIND v(dout0_58) AT=635.025n

* CHECK dout0_59 Vdout0_59ck126 = 0 time = 635
.meas tran vdout0_59ck126 FIND v(dout0_59) AT=635.025n

* CHECK dout0_60 Vdout0_60ck126 = 0.9 time = 635
.meas tran vdout0_60ck126 FIND v(dout0_60) AT=635.025n

* CHECK dout0_61 Vdout0_61ck126 = 0.9 time = 635
.meas tran vdout0_61ck126 FIND v(dout0_61) AT=635.025n

* CHECK dout0_62 Vdout0_62ck126 = 0.9 time = 635
.meas tran vdout0_62ck126 FIND v(dout0_62) AT=635.025n

* CHECK dout0_63 Vdout0_63ck126 = 0.9 time = 635
.meas tran vdout0_63ck126 FIND v(dout0_63) AT=635.025n

* CHECK dout0_0 Vdout0_0ck128 = 0.9 time = 645
.meas tran vdout0_0ck128 FIND v(dout0_0) AT=645.025n

* CHECK dout0_1 Vdout0_1ck128 = 0.9 time = 645
.meas tran vdout0_1ck128 FIND v(dout0_1) AT=645.025n

* CHECK dout0_2 Vdout0_2ck128 = 0 time = 645
.meas tran vdout0_2ck128 FIND v(dout0_2) AT=645.025n

* CHECK dout0_3 Vdout0_3ck128 = 0 time = 645
.meas tran vdout0_3ck128 FIND v(dout0_3) AT=645.025n

* CHECK dout0_4 Vdout0_4ck128 = 0 time = 645
.meas tran vdout0_4ck128 FIND v(dout0_4) AT=645.025n

* CHECK dout0_5 Vdout0_5ck128 = 0.9 time = 645
.meas tran vdout0_5ck128 FIND v(dout0_5) AT=645.025n

* CHECK dout0_6 Vdout0_6ck128 = 0.9 time = 645
.meas tran vdout0_6ck128 FIND v(dout0_6) AT=645.025n

* CHECK dout0_7 Vdout0_7ck128 = 0 time = 645
.meas tran vdout0_7ck128 FIND v(dout0_7) AT=645.025n

* CHECK dout0_8 Vdout0_8ck128 = 0 time = 645
.meas tran vdout0_8ck128 FIND v(dout0_8) AT=645.025n

* CHECK dout0_9 Vdout0_9ck128 = 0.9 time = 645
.meas tran vdout0_9ck128 FIND v(dout0_9) AT=645.025n

* CHECK dout0_10 Vdout0_10ck128 = 0 time = 645
.meas tran vdout0_10ck128 FIND v(dout0_10) AT=645.025n

* CHECK dout0_11 Vdout0_11ck128 = 0 time = 645
.meas tran vdout0_11ck128 FIND v(dout0_11) AT=645.025n

* CHECK dout0_12 Vdout0_12ck128 = 0.9 time = 645
.meas tran vdout0_12ck128 FIND v(dout0_12) AT=645.025n

* CHECK dout0_13 Vdout0_13ck128 = 0 time = 645
.meas tran vdout0_13ck128 FIND v(dout0_13) AT=645.025n

* CHECK dout0_14 Vdout0_14ck128 = 0.9 time = 645
.meas tran vdout0_14ck128 FIND v(dout0_14) AT=645.025n

* CHECK dout0_15 Vdout0_15ck128 = 0 time = 645
.meas tran vdout0_15ck128 FIND v(dout0_15) AT=645.025n

* CHECK dout0_16 Vdout0_16ck128 = 0.9 time = 645
.meas tran vdout0_16ck128 FIND v(dout0_16) AT=645.025n

* CHECK dout0_17 Vdout0_17ck128 = 0 time = 645
.meas tran vdout0_17ck128 FIND v(dout0_17) AT=645.025n

* CHECK dout0_18 Vdout0_18ck128 = 0.9 time = 645
.meas tran vdout0_18ck128 FIND v(dout0_18) AT=645.025n

* CHECK dout0_19 Vdout0_19ck128 = 0 time = 645
.meas tran vdout0_19ck128 FIND v(dout0_19) AT=645.025n

* CHECK dout0_20 Vdout0_20ck128 = 0.9 time = 645
.meas tran vdout0_20ck128 FIND v(dout0_20) AT=645.025n

* CHECK dout0_21 Vdout0_21ck128 = 0 time = 645
.meas tran vdout0_21ck128 FIND v(dout0_21) AT=645.025n

* CHECK dout0_22 Vdout0_22ck128 = 0 time = 645
.meas tran vdout0_22ck128 FIND v(dout0_22) AT=645.025n

* CHECK dout0_23 Vdout0_23ck128 = 0 time = 645
.meas tran vdout0_23ck128 FIND v(dout0_23) AT=645.025n

* CHECK dout0_24 Vdout0_24ck128 = 0.9 time = 645
.meas tran vdout0_24ck128 FIND v(dout0_24) AT=645.025n

* CHECK dout0_25 Vdout0_25ck128 = 0.9 time = 645
.meas tran vdout0_25ck128 FIND v(dout0_25) AT=645.025n

* CHECK dout0_26 Vdout0_26ck128 = 0 time = 645
.meas tran vdout0_26ck128 FIND v(dout0_26) AT=645.025n

* CHECK dout0_27 Vdout0_27ck128 = 0 time = 645
.meas tran vdout0_27ck128 FIND v(dout0_27) AT=645.025n

* CHECK dout0_28 Vdout0_28ck128 = 0.9 time = 645
.meas tran vdout0_28ck128 FIND v(dout0_28) AT=645.025n

* CHECK dout0_29 Vdout0_29ck128 = 0 time = 645
.meas tran vdout0_29ck128 FIND v(dout0_29) AT=645.025n

* CHECK dout0_30 Vdout0_30ck128 = 0 time = 645
.meas tran vdout0_30ck128 FIND v(dout0_30) AT=645.025n

* CHECK dout0_31 Vdout0_31ck128 = 0.9 time = 645
.meas tran vdout0_31ck128 FIND v(dout0_31) AT=645.025n

* CHECK dout0_32 Vdout0_32ck128 = 0 time = 645
.meas tran vdout0_32ck128 FIND v(dout0_32) AT=645.025n

* CHECK dout0_33 Vdout0_33ck128 = 0 time = 645
.meas tran vdout0_33ck128 FIND v(dout0_33) AT=645.025n

* CHECK dout0_34 Vdout0_34ck128 = 0 time = 645
.meas tran vdout0_34ck128 FIND v(dout0_34) AT=645.025n

* CHECK dout0_35 Vdout0_35ck128 = 0 time = 645
.meas tran vdout0_35ck128 FIND v(dout0_35) AT=645.025n

* CHECK dout0_36 Vdout0_36ck128 = 0 time = 645
.meas tran vdout0_36ck128 FIND v(dout0_36) AT=645.025n

* CHECK dout0_37 Vdout0_37ck128 = 0 time = 645
.meas tran vdout0_37ck128 FIND v(dout0_37) AT=645.025n

* CHECK dout0_38 Vdout0_38ck128 = 0.9 time = 645
.meas tran vdout0_38ck128 FIND v(dout0_38) AT=645.025n

* CHECK dout0_39 Vdout0_39ck128 = 0 time = 645
.meas tran vdout0_39ck128 FIND v(dout0_39) AT=645.025n

* CHECK dout0_40 Vdout0_40ck128 = 0 time = 645
.meas tran vdout0_40ck128 FIND v(dout0_40) AT=645.025n

* CHECK dout0_41 Vdout0_41ck128 = 0.9 time = 645
.meas tran vdout0_41ck128 FIND v(dout0_41) AT=645.025n

* CHECK dout0_42 Vdout0_42ck128 = 0.9 time = 645
.meas tran vdout0_42ck128 FIND v(dout0_42) AT=645.025n

* CHECK dout0_43 Vdout0_43ck128 = 0 time = 645
.meas tran vdout0_43ck128 FIND v(dout0_43) AT=645.025n

* CHECK dout0_44 Vdout0_44ck128 = 0 time = 645
.meas tran vdout0_44ck128 FIND v(dout0_44) AT=645.025n

* CHECK dout0_45 Vdout0_45ck128 = 0.9 time = 645
.meas tran vdout0_45ck128 FIND v(dout0_45) AT=645.025n

* CHECK dout0_46 Vdout0_46ck128 = 0 time = 645
.meas tran vdout0_46ck128 FIND v(dout0_46) AT=645.025n

* CHECK dout0_47 Vdout0_47ck128 = 0 time = 645
.meas tran vdout0_47ck128 FIND v(dout0_47) AT=645.025n

* CHECK dout0_48 Vdout0_48ck128 = 0.9 time = 645
.meas tran vdout0_48ck128 FIND v(dout0_48) AT=645.025n

* CHECK dout0_49 Vdout0_49ck128 = 0.9 time = 645
.meas tran vdout0_49ck128 FIND v(dout0_49) AT=645.025n

* CHECK dout0_50 Vdout0_50ck128 = 0.9 time = 645
.meas tran vdout0_50ck128 FIND v(dout0_50) AT=645.025n

* CHECK dout0_51 Vdout0_51ck128 = 0.9 time = 645
.meas tran vdout0_51ck128 FIND v(dout0_51) AT=645.025n

* CHECK dout0_52 Vdout0_52ck128 = 0 time = 645
.meas tran vdout0_52ck128 FIND v(dout0_52) AT=645.025n

* CHECK dout0_53 Vdout0_53ck128 = 0 time = 645
.meas tran vdout0_53ck128 FIND v(dout0_53) AT=645.025n

* CHECK dout0_54 Vdout0_54ck128 = 0 time = 645
.meas tran vdout0_54ck128 FIND v(dout0_54) AT=645.025n

* CHECK dout0_55 Vdout0_55ck128 = 0.9 time = 645
.meas tran vdout0_55ck128 FIND v(dout0_55) AT=645.025n

* CHECK dout0_56 Vdout0_56ck128 = 0 time = 645
.meas tran vdout0_56ck128 FIND v(dout0_56) AT=645.025n

* CHECK dout0_57 Vdout0_57ck128 = 0 time = 645
.meas tran vdout0_57ck128 FIND v(dout0_57) AT=645.025n

* CHECK dout0_58 Vdout0_58ck128 = 0.9 time = 645
.meas tran vdout0_58ck128 FIND v(dout0_58) AT=645.025n

* CHECK dout0_59 Vdout0_59ck128 = 0 time = 645
.meas tran vdout0_59ck128 FIND v(dout0_59) AT=645.025n

* CHECK dout0_60 Vdout0_60ck128 = 0 time = 645
.meas tran vdout0_60ck128 FIND v(dout0_60) AT=645.025n

* CHECK dout0_61 Vdout0_61ck128 = 0.9 time = 645
.meas tran vdout0_61ck128 FIND v(dout0_61) AT=645.025n

* CHECK dout0_62 Vdout0_62ck128 = 0 time = 645
.meas tran vdout0_62ck128 FIND v(dout0_62) AT=645.025n

* CHECK dout0_63 Vdout0_63ck128 = 0 time = 645
.meas tran vdout0_63ck128 FIND v(dout0_63) AT=645.025n

* CHECK dout0_0 Vdout0_0ck133 = 0.9 time = 670
.meas tran vdout0_0ck133 FIND v(dout0_0) AT=670.025n

* CHECK dout0_1 Vdout0_1ck133 = 0.9 time = 670
.meas tran vdout0_1ck133 FIND v(dout0_1) AT=670.025n

* CHECK dout0_2 Vdout0_2ck133 = 0.9 time = 670
.meas tran vdout0_2ck133 FIND v(dout0_2) AT=670.025n

* CHECK dout0_3 Vdout0_3ck133 = 0 time = 670
.meas tran vdout0_3ck133 FIND v(dout0_3) AT=670.025n

* CHECK dout0_4 Vdout0_4ck133 = 0.9 time = 670
.meas tran vdout0_4ck133 FIND v(dout0_4) AT=670.025n

* CHECK dout0_5 Vdout0_5ck133 = 0 time = 670
.meas tran vdout0_5ck133 FIND v(dout0_5) AT=670.025n

* CHECK dout0_6 Vdout0_6ck133 = 0 time = 670
.meas tran vdout0_6ck133 FIND v(dout0_6) AT=670.025n

* CHECK dout0_7 Vdout0_7ck133 = 0 time = 670
.meas tran vdout0_7ck133 FIND v(dout0_7) AT=670.025n

* CHECK dout0_8 Vdout0_8ck133 = 0.9 time = 670
.meas tran vdout0_8ck133 FIND v(dout0_8) AT=670.025n

* CHECK dout0_9 Vdout0_9ck133 = 0.9 time = 670
.meas tran vdout0_9ck133 FIND v(dout0_9) AT=670.025n

* CHECK dout0_10 Vdout0_10ck133 = 0.9 time = 670
.meas tran vdout0_10ck133 FIND v(dout0_10) AT=670.025n

* CHECK dout0_11 Vdout0_11ck133 = 0 time = 670
.meas tran vdout0_11ck133 FIND v(dout0_11) AT=670.025n

* CHECK dout0_12 Vdout0_12ck133 = 0 time = 670
.meas tran vdout0_12ck133 FIND v(dout0_12) AT=670.025n

* CHECK dout0_13 Vdout0_13ck133 = 0.9 time = 670
.meas tran vdout0_13ck133 FIND v(dout0_13) AT=670.025n

* CHECK dout0_14 Vdout0_14ck133 = 0 time = 670
.meas tran vdout0_14ck133 FIND v(dout0_14) AT=670.025n

* CHECK dout0_15 Vdout0_15ck133 = 0 time = 670
.meas tran vdout0_15ck133 FIND v(dout0_15) AT=670.025n

* CHECK dout0_16 Vdout0_16ck133 = 0 time = 670
.meas tran vdout0_16ck133 FIND v(dout0_16) AT=670.025n

* CHECK dout0_17 Vdout0_17ck133 = 0 time = 670
.meas tran vdout0_17ck133 FIND v(dout0_17) AT=670.025n

* CHECK dout0_18 Vdout0_18ck133 = 0.9 time = 670
.meas tran vdout0_18ck133 FIND v(dout0_18) AT=670.025n

* CHECK dout0_19 Vdout0_19ck133 = 0.9 time = 670
.meas tran vdout0_19ck133 FIND v(dout0_19) AT=670.025n

* CHECK dout0_20 Vdout0_20ck133 = 0 time = 670
.meas tran vdout0_20ck133 FIND v(dout0_20) AT=670.025n

* CHECK dout0_21 Vdout0_21ck133 = 0 time = 670
.meas tran vdout0_21ck133 FIND v(dout0_21) AT=670.025n

* CHECK dout0_22 Vdout0_22ck133 = 0.9 time = 670
.meas tran vdout0_22ck133 FIND v(dout0_22) AT=670.025n

* CHECK dout0_23 Vdout0_23ck133 = 0 time = 670
.meas tran vdout0_23ck133 FIND v(dout0_23) AT=670.025n

* CHECK dout0_24 Vdout0_24ck133 = 0 time = 670
.meas tran vdout0_24ck133 FIND v(dout0_24) AT=670.025n

* CHECK dout0_25 Vdout0_25ck133 = 0.9 time = 670
.meas tran vdout0_25ck133 FIND v(dout0_25) AT=670.025n

* CHECK dout0_26 Vdout0_26ck133 = 0 time = 670
.meas tran vdout0_26ck133 FIND v(dout0_26) AT=670.025n

* CHECK dout0_27 Vdout0_27ck133 = 0 time = 670
.meas tran vdout0_27ck133 FIND v(dout0_27) AT=670.025n

* CHECK dout0_28 Vdout0_28ck133 = 0 time = 670
.meas tran vdout0_28ck133 FIND v(dout0_28) AT=670.025n

* CHECK dout0_29 Vdout0_29ck133 = 0.9 time = 670
.meas tran vdout0_29ck133 FIND v(dout0_29) AT=670.025n

* CHECK dout0_30 Vdout0_30ck133 = 0.9 time = 670
.meas tran vdout0_30ck133 FIND v(dout0_30) AT=670.025n

* CHECK dout0_31 Vdout0_31ck133 = 0.9 time = 670
.meas tran vdout0_31ck133 FIND v(dout0_31) AT=670.025n

* CHECK dout0_32 Vdout0_32ck133 = 0.9 time = 670
.meas tran vdout0_32ck133 FIND v(dout0_32) AT=670.025n

* CHECK dout0_33 Vdout0_33ck133 = 0.9 time = 670
.meas tran vdout0_33ck133 FIND v(dout0_33) AT=670.025n

* CHECK dout0_34 Vdout0_34ck133 = 0.9 time = 670
.meas tran vdout0_34ck133 FIND v(dout0_34) AT=670.025n

* CHECK dout0_35 Vdout0_35ck133 = 0 time = 670
.meas tran vdout0_35ck133 FIND v(dout0_35) AT=670.025n

* CHECK dout0_36 Vdout0_36ck133 = 0 time = 670
.meas tran vdout0_36ck133 FIND v(dout0_36) AT=670.025n

* CHECK dout0_37 Vdout0_37ck133 = 0 time = 670
.meas tran vdout0_37ck133 FIND v(dout0_37) AT=670.025n

* CHECK dout0_38 Vdout0_38ck133 = 0.9 time = 670
.meas tran vdout0_38ck133 FIND v(dout0_38) AT=670.025n

* CHECK dout0_39 Vdout0_39ck133 = 0.9 time = 670
.meas tran vdout0_39ck133 FIND v(dout0_39) AT=670.025n

* CHECK dout0_40 Vdout0_40ck133 = 0 time = 670
.meas tran vdout0_40ck133 FIND v(dout0_40) AT=670.025n

* CHECK dout0_41 Vdout0_41ck133 = 0 time = 670
.meas tran vdout0_41ck133 FIND v(dout0_41) AT=670.025n

* CHECK dout0_42 Vdout0_42ck133 = 0 time = 670
.meas tran vdout0_42ck133 FIND v(dout0_42) AT=670.025n

* CHECK dout0_43 Vdout0_43ck133 = 0 time = 670
.meas tran vdout0_43ck133 FIND v(dout0_43) AT=670.025n

* CHECK dout0_44 Vdout0_44ck133 = 0.9 time = 670
.meas tran vdout0_44ck133 FIND v(dout0_44) AT=670.025n

* CHECK dout0_45 Vdout0_45ck133 = 0 time = 670
.meas tran vdout0_45ck133 FIND v(dout0_45) AT=670.025n

* CHECK dout0_46 Vdout0_46ck133 = 0.9 time = 670
.meas tran vdout0_46ck133 FIND v(dout0_46) AT=670.025n

* CHECK dout0_47 Vdout0_47ck133 = 0 time = 670
.meas tran vdout0_47ck133 FIND v(dout0_47) AT=670.025n

* CHECK dout0_48 Vdout0_48ck133 = 0.9 time = 670
.meas tran vdout0_48ck133 FIND v(dout0_48) AT=670.025n

* CHECK dout0_49 Vdout0_49ck133 = 0.9 time = 670
.meas tran vdout0_49ck133 FIND v(dout0_49) AT=670.025n

* CHECK dout0_50 Vdout0_50ck133 = 0 time = 670
.meas tran vdout0_50ck133 FIND v(dout0_50) AT=670.025n

* CHECK dout0_51 Vdout0_51ck133 = 0.9 time = 670
.meas tran vdout0_51ck133 FIND v(dout0_51) AT=670.025n

* CHECK dout0_52 Vdout0_52ck133 = 0.9 time = 670
.meas tran vdout0_52ck133 FIND v(dout0_52) AT=670.025n

* CHECK dout0_53 Vdout0_53ck133 = 0 time = 670
.meas tran vdout0_53ck133 FIND v(dout0_53) AT=670.025n

* CHECK dout0_54 Vdout0_54ck133 = 0 time = 670
.meas tran vdout0_54ck133 FIND v(dout0_54) AT=670.025n

* CHECK dout0_55 Vdout0_55ck133 = 0.9 time = 670
.meas tran vdout0_55ck133 FIND v(dout0_55) AT=670.025n

* CHECK dout0_56 Vdout0_56ck133 = 0 time = 670
.meas tran vdout0_56ck133 FIND v(dout0_56) AT=670.025n

* CHECK dout0_57 Vdout0_57ck133 = 0 time = 670
.meas tran vdout0_57ck133 FIND v(dout0_57) AT=670.025n

* CHECK dout0_58 Vdout0_58ck133 = 0.9 time = 670
.meas tran vdout0_58ck133 FIND v(dout0_58) AT=670.025n

* CHECK dout0_59 Vdout0_59ck133 = 0 time = 670
.meas tran vdout0_59ck133 FIND v(dout0_59) AT=670.025n

* CHECK dout0_60 Vdout0_60ck133 = 0 time = 670
.meas tran vdout0_60ck133 FIND v(dout0_60) AT=670.025n

* CHECK dout0_61 Vdout0_61ck133 = 0 time = 670
.meas tran vdout0_61ck133 FIND v(dout0_61) AT=670.025n

* CHECK dout0_62 Vdout0_62ck133 = 0.9 time = 670
.meas tran vdout0_62ck133 FIND v(dout0_62) AT=670.025n

* CHECK dout0_63 Vdout0_63ck133 = 0 time = 670
.meas tran vdout0_63ck133 FIND v(dout0_63) AT=670.025n

* CHECK dout0_0 Vdout0_0ck138 = 0.9 time = 695
.meas tran vdout0_0ck138 FIND v(dout0_0) AT=695.025n

* CHECK dout0_1 Vdout0_1ck138 = 0.9 time = 695
.meas tran vdout0_1ck138 FIND v(dout0_1) AT=695.025n

* CHECK dout0_2 Vdout0_2ck138 = 0.9 time = 695
.meas tran vdout0_2ck138 FIND v(dout0_2) AT=695.025n

* CHECK dout0_3 Vdout0_3ck138 = 0 time = 695
.meas tran vdout0_3ck138 FIND v(dout0_3) AT=695.025n

* CHECK dout0_4 Vdout0_4ck138 = 0 time = 695
.meas tran vdout0_4ck138 FIND v(dout0_4) AT=695.025n

* CHECK dout0_5 Vdout0_5ck138 = 0 time = 695
.meas tran vdout0_5ck138 FIND v(dout0_5) AT=695.025n

* CHECK dout0_6 Vdout0_6ck138 = 0.9 time = 695
.meas tran vdout0_6ck138 FIND v(dout0_6) AT=695.025n

* CHECK dout0_7 Vdout0_7ck138 = 0 time = 695
.meas tran vdout0_7ck138 FIND v(dout0_7) AT=695.025n

* CHECK dout0_8 Vdout0_8ck138 = 0 time = 695
.meas tran vdout0_8ck138 FIND v(dout0_8) AT=695.025n

* CHECK dout0_9 Vdout0_9ck138 = 0.9 time = 695
.meas tran vdout0_9ck138 FIND v(dout0_9) AT=695.025n

* CHECK dout0_10 Vdout0_10ck138 = 0.9 time = 695
.meas tran vdout0_10ck138 FIND v(dout0_10) AT=695.025n

* CHECK dout0_11 Vdout0_11ck138 = 0.9 time = 695
.meas tran vdout0_11ck138 FIND v(dout0_11) AT=695.025n

* CHECK dout0_12 Vdout0_12ck138 = 0.9 time = 695
.meas tran vdout0_12ck138 FIND v(dout0_12) AT=695.025n

* CHECK dout0_13 Vdout0_13ck138 = 0.9 time = 695
.meas tran vdout0_13ck138 FIND v(dout0_13) AT=695.025n

* CHECK dout0_14 Vdout0_14ck138 = 0 time = 695
.meas tran vdout0_14ck138 FIND v(dout0_14) AT=695.025n

* CHECK dout0_15 Vdout0_15ck138 = 0 time = 695
.meas tran vdout0_15ck138 FIND v(dout0_15) AT=695.025n

* CHECK dout0_16 Vdout0_16ck138 = 0 time = 695
.meas tran vdout0_16ck138 FIND v(dout0_16) AT=695.025n

* CHECK dout0_17 Vdout0_17ck138 = 0.9 time = 695
.meas tran vdout0_17ck138 FIND v(dout0_17) AT=695.025n

* CHECK dout0_18 Vdout0_18ck138 = 0 time = 695
.meas tran vdout0_18ck138 FIND v(dout0_18) AT=695.025n

* CHECK dout0_19 Vdout0_19ck138 = 0.9 time = 695
.meas tran vdout0_19ck138 FIND v(dout0_19) AT=695.025n

* CHECK dout0_20 Vdout0_20ck138 = 0 time = 695
.meas tran vdout0_20ck138 FIND v(dout0_20) AT=695.025n

* CHECK dout0_21 Vdout0_21ck138 = 0.9 time = 695
.meas tran vdout0_21ck138 FIND v(dout0_21) AT=695.025n

* CHECK dout0_22 Vdout0_22ck138 = 0 time = 695
.meas tran vdout0_22ck138 FIND v(dout0_22) AT=695.025n

* CHECK dout0_23 Vdout0_23ck138 = 0 time = 695
.meas tran vdout0_23ck138 FIND v(dout0_23) AT=695.025n

* CHECK dout0_24 Vdout0_24ck138 = 0.9 time = 695
.meas tran vdout0_24ck138 FIND v(dout0_24) AT=695.025n

* CHECK dout0_25 Vdout0_25ck138 = 0 time = 695
.meas tran vdout0_25ck138 FIND v(dout0_25) AT=695.025n

* CHECK dout0_26 Vdout0_26ck138 = 0.9 time = 695
.meas tran vdout0_26ck138 FIND v(dout0_26) AT=695.025n

* CHECK dout0_27 Vdout0_27ck138 = 0.9 time = 695
.meas tran vdout0_27ck138 FIND v(dout0_27) AT=695.025n

* CHECK dout0_28 Vdout0_28ck138 = 0 time = 695
.meas tran vdout0_28ck138 FIND v(dout0_28) AT=695.025n

* CHECK dout0_29 Vdout0_29ck138 = 0.9 time = 695
.meas tran vdout0_29ck138 FIND v(dout0_29) AT=695.025n

* CHECK dout0_30 Vdout0_30ck138 = 0.9 time = 695
.meas tran vdout0_30ck138 FIND v(dout0_30) AT=695.025n

* CHECK dout0_31 Vdout0_31ck138 = 0 time = 695
.meas tran vdout0_31ck138 FIND v(dout0_31) AT=695.025n

* CHECK dout0_32 Vdout0_32ck138 = 0.9 time = 695
.meas tran vdout0_32ck138 FIND v(dout0_32) AT=695.025n

* CHECK dout0_33 Vdout0_33ck138 = 0 time = 695
.meas tran vdout0_33ck138 FIND v(dout0_33) AT=695.025n

* CHECK dout0_34 Vdout0_34ck138 = 0 time = 695
.meas tran vdout0_34ck138 FIND v(dout0_34) AT=695.025n

* CHECK dout0_35 Vdout0_35ck138 = 0 time = 695
.meas tran vdout0_35ck138 FIND v(dout0_35) AT=695.025n

* CHECK dout0_36 Vdout0_36ck138 = 0.9 time = 695
.meas tran vdout0_36ck138 FIND v(dout0_36) AT=695.025n

* CHECK dout0_37 Vdout0_37ck138 = 0.9 time = 695
.meas tran vdout0_37ck138 FIND v(dout0_37) AT=695.025n

* CHECK dout0_38 Vdout0_38ck138 = 0 time = 695
.meas tran vdout0_38ck138 FIND v(dout0_38) AT=695.025n

* CHECK dout0_39 Vdout0_39ck138 = 0 time = 695
.meas tran vdout0_39ck138 FIND v(dout0_39) AT=695.025n

* CHECK dout0_40 Vdout0_40ck138 = 0.9 time = 695
.meas tran vdout0_40ck138 FIND v(dout0_40) AT=695.025n

* CHECK dout0_41 Vdout0_41ck138 = 0.9 time = 695
.meas tran vdout0_41ck138 FIND v(dout0_41) AT=695.025n

* CHECK dout0_42 Vdout0_42ck138 = 0.9 time = 695
.meas tran vdout0_42ck138 FIND v(dout0_42) AT=695.025n

* CHECK dout0_43 Vdout0_43ck138 = 0 time = 695
.meas tran vdout0_43ck138 FIND v(dout0_43) AT=695.025n

* CHECK dout0_44 Vdout0_44ck138 = 0 time = 695
.meas tran vdout0_44ck138 FIND v(dout0_44) AT=695.025n

* CHECK dout0_45 Vdout0_45ck138 = 0 time = 695
.meas tran vdout0_45ck138 FIND v(dout0_45) AT=695.025n

* CHECK dout0_46 Vdout0_46ck138 = 0 time = 695
.meas tran vdout0_46ck138 FIND v(dout0_46) AT=695.025n

* CHECK dout0_47 Vdout0_47ck138 = 0 time = 695
.meas tran vdout0_47ck138 FIND v(dout0_47) AT=695.025n

* CHECK dout0_48 Vdout0_48ck138 = 0.9 time = 695
.meas tran vdout0_48ck138 FIND v(dout0_48) AT=695.025n

* CHECK dout0_49 Vdout0_49ck138 = 0.9 time = 695
.meas tran vdout0_49ck138 FIND v(dout0_49) AT=695.025n

* CHECK dout0_50 Vdout0_50ck138 = 0.9 time = 695
.meas tran vdout0_50ck138 FIND v(dout0_50) AT=695.025n

* CHECK dout0_51 Vdout0_51ck138 = 0.9 time = 695
.meas tran vdout0_51ck138 FIND v(dout0_51) AT=695.025n

* CHECK dout0_52 Vdout0_52ck138 = 0 time = 695
.meas tran vdout0_52ck138 FIND v(dout0_52) AT=695.025n

* CHECK dout0_53 Vdout0_53ck138 = 0 time = 695
.meas tran vdout0_53ck138 FIND v(dout0_53) AT=695.025n

* CHECK dout0_54 Vdout0_54ck138 = 0.9 time = 695
.meas tran vdout0_54ck138 FIND v(dout0_54) AT=695.025n

* CHECK dout0_55 Vdout0_55ck138 = 0 time = 695
.meas tran vdout0_55ck138 FIND v(dout0_55) AT=695.025n

* CHECK dout0_56 Vdout0_56ck138 = 0.9 time = 695
.meas tran vdout0_56ck138 FIND v(dout0_56) AT=695.025n

* CHECK dout0_57 Vdout0_57ck138 = 0 time = 695
.meas tran vdout0_57ck138 FIND v(dout0_57) AT=695.025n

* CHECK dout0_58 Vdout0_58ck138 = 0.9 time = 695
.meas tran vdout0_58ck138 FIND v(dout0_58) AT=695.025n

* CHECK dout0_59 Vdout0_59ck138 = 0.9 time = 695
.meas tran vdout0_59ck138 FIND v(dout0_59) AT=695.025n

* CHECK dout0_60 Vdout0_60ck138 = 0.9 time = 695
.meas tran vdout0_60ck138 FIND v(dout0_60) AT=695.025n

* CHECK dout0_61 Vdout0_61ck138 = 0 time = 695
.meas tran vdout0_61ck138 FIND v(dout0_61) AT=695.025n

* CHECK dout0_62 Vdout0_62ck138 = 0 time = 695
.meas tran vdout0_62ck138 FIND v(dout0_62) AT=695.025n

* CHECK dout0_63 Vdout0_63ck138 = 0.9 time = 695
.meas tran vdout0_63ck138 FIND v(dout0_63) AT=695.025n

* CHECK dout0_0 Vdout0_0ck139 = 0.9 time = 700
.meas tran vdout0_0ck139 FIND v(dout0_0) AT=700.025n

* CHECK dout0_1 Vdout0_1ck139 = 0.9 time = 700
.meas tran vdout0_1ck139 FIND v(dout0_1) AT=700.025n

* CHECK dout0_2 Vdout0_2ck139 = 0.9 time = 700
.meas tran vdout0_2ck139 FIND v(dout0_2) AT=700.025n

* CHECK dout0_3 Vdout0_3ck139 = 0 time = 700
.meas tran vdout0_3ck139 FIND v(dout0_3) AT=700.025n

* CHECK dout0_4 Vdout0_4ck139 = 0 time = 700
.meas tran vdout0_4ck139 FIND v(dout0_4) AT=700.025n

* CHECK dout0_5 Vdout0_5ck139 = 0 time = 700
.meas tran vdout0_5ck139 FIND v(dout0_5) AT=700.025n

* CHECK dout0_6 Vdout0_6ck139 = 0.9 time = 700
.meas tran vdout0_6ck139 FIND v(dout0_6) AT=700.025n

* CHECK dout0_7 Vdout0_7ck139 = 0 time = 700
.meas tran vdout0_7ck139 FIND v(dout0_7) AT=700.025n

* CHECK dout0_8 Vdout0_8ck139 = 0 time = 700
.meas tran vdout0_8ck139 FIND v(dout0_8) AT=700.025n

* CHECK dout0_9 Vdout0_9ck139 = 0.9 time = 700
.meas tran vdout0_9ck139 FIND v(dout0_9) AT=700.025n

* CHECK dout0_10 Vdout0_10ck139 = 0.9 time = 700
.meas tran vdout0_10ck139 FIND v(dout0_10) AT=700.025n

* CHECK dout0_11 Vdout0_11ck139 = 0.9 time = 700
.meas tran vdout0_11ck139 FIND v(dout0_11) AT=700.025n

* CHECK dout0_12 Vdout0_12ck139 = 0.9 time = 700
.meas tran vdout0_12ck139 FIND v(dout0_12) AT=700.025n

* CHECK dout0_13 Vdout0_13ck139 = 0.9 time = 700
.meas tran vdout0_13ck139 FIND v(dout0_13) AT=700.025n

* CHECK dout0_14 Vdout0_14ck139 = 0 time = 700
.meas tran vdout0_14ck139 FIND v(dout0_14) AT=700.025n

* CHECK dout0_15 Vdout0_15ck139 = 0 time = 700
.meas tran vdout0_15ck139 FIND v(dout0_15) AT=700.025n

* CHECK dout0_16 Vdout0_16ck139 = 0 time = 700
.meas tran vdout0_16ck139 FIND v(dout0_16) AT=700.025n

* CHECK dout0_17 Vdout0_17ck139 = 0.9 time = 700
.meas tran vdout0_17ck139 FIND v(dout0_17) AT=700.025n

* CHECK dout0_18 Vdout0_18ck139 = 0 time = 700
.meas tran vdout0_18ck139 FIND v(dout0_18) AT=700.025n

* CHECK dout0_19 Vdout0_19ck139 = 0.9 time = 700
.meas tran vdout0_19ck139 FIND v(dout0_19) AT=700.025n

* CHECK dout0_20 Vdout0_20ck139 = 0 time = 700
.meas tran vdout0_20ck139 FIND v(dout0_20) AT=700.025n

* CHECK dout0_21 Vdout0_21ck139 = 0.9 time = 700
.meas tran vdout0_21ck139 FIND v(dout0_21) AT=700.025n

* CHECK dout0_22 Vdout0_22ck139 = 0 time = 700
.meas tran vdout0_22ck139 FIND v(dout0_22) AT=700.025n

* CHECK dout0_23 Vdout0_23ck139 = 0 time = 700
.meas tran vdout0_23ck139 FIND v(dout0_23) AT=700.025n

* CHECK dout0_24 Vdout0_24ck139 = 0.9 time = 700
.meas tran vdout0_24ck139 FIND v(dout0_24) AT=700.025n

* CHECK dout0_25 Vdout0_25ck139 = 0 time = 700
.meas tran vdout0_25ck139 FIND v(dout0_25) AT=700.025n

* CHECK dout0_26 Vdout0_26ck139 = 0.9 time = 700
.meas tran vdout0_26ck139 FIND v(dout0_26) AT=700.025n

* CHECK dout0_27 Vdout0_27ck139 = 0.9 time = 700
.meas tran vdout0_27ck139 FIND v(dout0_27) AT=700.025n

* CHECK dout0_28 Vdout0_28ck139 = 0 time = 700
.meas tran vdout0_28ck139 FIND v(dout0_28) AT=700.025n

* CHECK dout0_29 Vdout0_29ck139 = 0.9 time = 700
.meas tran vdout0_29ck139 FIND v(dout0_29) AT=700.025n

* CHECK dout0_30 Vdout0_30ck139 = 0.9 time = 700
.meas tran vdout0_30ck139 FIND v(dout0_30) AT=700.025n

* CHECK dout0_31 Vdout0_31ck139 = 0 time = 700
.meas tran vdout0_31ck139 FIND v(dout0_31) AT=700.025n

* CHECK dout0_32 Vdout0_32ck139 = 0.9 time = 700
.meas tran vdout0_32ck139 FIND v(dout0_32) AT=700.025n

* CHECK dout0_33 Vdout0_33ck139 = 0 time = 700
.meas tran vdout0_33ck139 FIND v(dout0_33) AT=700.025n

* CHECK dout0_34 Vdout0_34ck139 = 0 time = 700
.meas tran vdout0_34ck139 FIND v(dout0_34) AT=700.025n

* CHECK dout0_35 Vdout0_35ck139 = 0 time = 700
.meas tran vdout0_35ck139 FIND v(dout0_35) AT=700.025n

* CHECK dout0_36 Vdout0_36ck139 = 0.9 time = 700
.meas tran vdout0_36ck139 FIND v(dout0_36) AT=700.025n

* CHECK dout0_37 Vdout0_37ck139 = 0.9 time = 700
.meas tran vdout0_37ck139 FIND v(dout0_37) AT=700.025n

* CHECK dout0_38 Vdout0_38ck139 = 0 time = 700
.meas tran vdout0_38ck139 FIND v(dout0_38) AT=700.025n

* CHECK dout0_39 Vdout0_39ck139 = 0 time = 700
.meas tran vdout0_39ck139 FIND v(dout0_39) AT=700.025n

* CHECK dout0_40 Vdout0_40ck139 = 0.9 time = 700
.meas tran vdout0_40ck139 FIND v(dout0_40) AT=700.025n

* CHECK dout0_41 Vdout0_41ck139 = 0.9 time = 700
.meas tran vdout0_41ck139 FIND v(dout0_41) AT=700.025n

* CHECK dout0_42 Vdout0_42ck139 = 0.9 time = 700
.meas tran vdout0_42ck139 FIND v(dout0_42) AT=700.025n

* CHECK dout0_43 Vdout0_43ck139 = 0 time = 700
.meas tran vdout0_43ck139 FIND v(dout0_43) AT=700.025n

* CHECK dout0_44 Vdout0_44ck139 = 0 time = 700
.meas tran vdout0_44ck139 FIND v(dout0_44) AT=700.025n

* CHECK dout0_45 Vdout0_45ck139 = 0 time = 700
.meas tran vdout0_45ck139 FIND v(dout0_45) AT=700.025n

* CHECK dout0_46 Vdout0_46ck139 = 0 time = 700
.meas tran vdout0_46ck139 FIND v(dout0_46) AT=700.025n

* CHECK dout0_47 Vdout0_47ck139 = 0 time = 700
.meas tran vdout0_47ck139 FIND v(dout0_47) AT=700.025n

* CHECK dout0_48 Vdout0_48ck139 = 0.9 time = 700
.meas tran vdout0_48ck139 FIND v(dout0_48) AT=700.025n

* CHECK dout0_49 Vdout0_49ck139 = 0.9 time = 700
.meas tran vdout0_49ck139 FIND v(dout0_49) AT=700.025n

* CHECK dout0_50 Vdout0_50ck139 = 0.9 time = 700
.meas tran vdout0_50ck139 FIND v(dout0_50) AT=700.025n

* CHECK dout0_51 Vdout0_51ck139 = 0.9 time = 700
.meas tran vdout0_51ck139 FIND v(dout0_51) AT=700.025n

* CHECK dout0_52 Vdout0_52ck139 = 0 time = 700
.meas tran vdout0_52ck139 FIND v(dout0_52) AT=700.025n

* CHECK dout0_53 Vdout0_53ck139 = 0 time = 700
.meas tran vdout0_53ck139 FIND v(dout0_53) AT=700.025n

* CHECK dout0_54 Vdout0_54ck139 = 0.9 time = 700
.meas tran vdout0_54ck139 FIND v(dout0_54) AT=700.025n

* CHECK dout0_55 Vdout0_55ck139 = 0 time = 700
.meas tran vdout0_55ck139 FIND v(dout0_55) AT=700.025n

* CHECK dout0_56 Vdout0_56ck139 = 0.9 time = 700
.meas tran vdout0_56ck139 FIND v(dout0_56) AT=700.025n

* CHECK dout0_57 Vdout0_57ck139 = 0 time = 700
.meas tran vdout0_57ck139 FIND v(dout0_57) AT=700.025n

* CHECK dout0_58 Vdout0_58ck139 = 0.9 time = 700
.meas tran vdout0_58ck139 FIND v(dout0_58) AT=700.025n

* CHECK dout0_59 Vdout0_59ck139 = 0.9 time = 700
.meas tran vdout0_59ck139 FIND v(dout0_59) AT=700.025n

* CHECK dout0_60 Vdout0_60ck139 = 0.9 time = 700
.meas tran vdout0_60ck139 FIND v(dout0_60) AT=700.025n

* CHECK dout0_61 Vdout0_61ck139 = 0 time = 700
.meas tran vdout0_61ck139 FIND v(dout0_61) AT=700.025n

* CHECK dout0_62 Vdout0_62ck139 = 0 time = 700
.meas tran vdout0_62ck139 FIND v(dout0_62) AT=700.025n

* CHECK dout0_63 Vdout0_63ck139 = 0.9 time = 700
.meas tran vdout0_63ck139 FIND v(dout0_63) AT=700.025n

* CHECK dout0_0 Vdout0_0ck140 = 0 time = 705
.meas tran vdout0_0ck140 FIND v(dout0_0) AT=705.025n

* CHECK dout0_1 Vdout0_1ck140 = 0.9 time = 705
.meas tran vdout0_1ck140 FIND v(dout0_1) AT=705.025n

* CHECK dout0_2 Vdout0_2ck140 = 0 time = 705
.meas tran vdout0_2ck140 FIND v(dout0_2) AT=705.025n

* CHECK dout0_3 Vdout0_3ck140 = 0.9 time = 705
.meas tran vdout0_3ck140 FIND v(dout0_3) AT=705.025n

* CHECK dout0_4 Vdout0_4ck140 = 0 time = 705
.meas tran vdout0_4ck140 FIND v(dout0_4) AT=705.025n

* CHECK dout0_5 Vdout0_5ck140 = 0.9 time = 705
.meas tran vdout0_5ck140 FIND v(dout0_5) AT=705.025n

* CHECK dout0_6 Vdout0_6ck140 = 0.9 time = 705
.meas tran vdout0_6ck140 FIND v(dout0_6) AT=705.025n

* CHECK dout0_7 Vdout0_7ck140 = 0 time = 705
.meas tran vdout0_7ck140 FIND v(dout0_7) AT=705.025n

* CHECK dout0_8 Vdout0_8ck140 = 0 time = 705
.meas tran vdout0_8ck140 FIND v(dout0_8) AT=705.025n

* CHECK dout0_9 Vdout0_9ck140 = 0.9 time = 705
.meas tran vdout0_9ck140 FIND v(dout0_9) AT=705.025n

* CHECK dout0_10 Vdout0_10ck140 = 0 time = 705
.meas tran vdout0_10ck140 FIND v(dout0_10) AT=705.025n

* CHECK dout0_11 Vdout0_11ck140 = 0.9 time = 705
.meas tran vdout0_11ck140 FIND v(dout0_11) AT=705.025n

* CHECK dout0_12 Vdout0_12ck140 = 0.9 time = 705
.meas tran vdout0_12ck140 FIND v(dout0_12) AT=705.025n

* CHECK dout0_13 Vdout0_13ck140 = 0.9 time = 705
.meas tran vdout0_13ck140 FIND v(dout0_13) AT=705.025n

* CHECK dout0_14 Vdout0_14ck140 = 0 time = 705
.meas tran vdout0_14ck140 FIND v(dout0_14) AT=705.025n

* CHECK dout0_15 Vdout0_15ck140 = 0.9 time = 705
.meas tran vdout0_15ck140 FIND v(dout0_15) AT=705.025n

* CHECK dout0_16 Vdout0_16ck140 = 0.9 time = 705
.meas tran vdout0_16ck140 FIND v(dout0_16) AT=705.025n

* CHECK dout0_17 Vdout0_17ck140 = 0 time = 705
.meas tran vdout0_17ck140 FIND v(dout0_17) AT=705.025n

* CHECK dout0_18 Vdout0_18ck140 = 0 time = 705
.meas tran vdout0_18ck140 FIND v(dout0_18) AT=705.025n

* CHECK dout0_19 Vdout0_19ck140 = 0 time = 705
.meas tran vdout0_19ck140 FIND v(dout0_19) AT=705.025n

* CHECK dout0_20 Vdout0_20ck140 = 0.9 time = 705
.meas tran vdout0_20ck140 FIND v(dout0_20) AT=705.025n

* CHECK dout0_21 Vdout0_21ck140 = 0 time = 705
.meas tran vdout0_21ck140 FIND v(dout0_21) AT=705.025n

* CHECK dout0_22 Vdout0_22ck140 = 0 time = 705
.meas tran vdout0_22ck140 FIND v(dout0_22) AT=705.025n

* CHECK dout0_23 Vdout0_23ck140 = 0.9 time = 705
.meas tran vdout0_23ck140 FIND v(dout0_23) AT=705.025n

* CHECK dout0_24 Vdout0_24ck140 = 0 time = 705
.meas tran vdout0_24ck140 FIND v(dout0_24) AT=705.025n

* CHECK dout0_25 Vdout0_25ck140 = 0 time = 705
.meas tran vdout0_25ck140 FIND v(dout0_25) AT=705.025n

* CHECK dout0_26 Vdout0_26ck140 = 0 time = 705
.meas tran vdout0_26ck140 FIND v(dout0_26) AT=705.025n

* CHECK dout0_27 Vdout0_27ck140 = 0.9 time = 705
.meas tran vdout0_27ck140 FIND v(dout0_27) AT=705.025n

* CHECK dout0_28 Vdout0_28ck140 = 0 time = 705
.meas tran vdout0_28ck140 FIND v(dout0_28) AT=705.025n

* CHECK dout0_29 Vdout0_29ck140 = 0.9 time = 705
.meas tran vdout0_29ck140 FIND v(dout0_29) AT=705.025n

* CHECK dout0_30 Vdout0_30ck140 = 0.9 time = 705
.meas tran vdout0_30ck140 FIND v(dout0_30) AT=705.025n

* CHECK dout0_31 Vdout0_31ck140 = 0 time = 705
.meas tran vdout0_31ck140 FIND v(dout0_31) AT=705.025n

* CHECK dout0_32 Vdout0_32ck140 = 0 time = 705
.meas tran vdout0_32ck140 FIND v(dout0_32) AT=705.025n

* CHECK dout0_33 Vdout0_33ck140 = 0.9 time = 705
.meas tran vdout0_33ck140 FIND v(dout0_33) AT=705.025n

* CHECK dout0_34 Vdout0_34ck140 = 0 time = 705
.meas tran vdout0_34ck140 FIND v(dout0_34) AT=705.025n

* CHECK dout0_35 Vdout0_35ck140 = 0.9 time = 705
.meas tran vdout0_35ck140 FIND v(dout0_35) AT=705.025n

* CHECK dout0_36 Vdout0_36ck140 = 0 time = 705
.meas tran vdout0_36ck140 FIND v(dout0_36) AT=705.025n

* CHECK dout0_37 Vdout0_37ck140 = 0 time = 705
.meas tran vdout0_37ck140 FIND v(dout0_37) AT=705.025n

* CHECK dout0_38 Vdout0_38ck140 = 0.9 time = 705
.meas tran vdout0_38ck140 FIND v(dout0_38) AT=705.025n

* CHECK dout0_39 Vdout0_39ck140 = 0 time = 705
.meas tran vdout0_39ck140 FIND v(dout0_39) AT=705.025n

* CHECK dout0_40 Vdout0_40ck140 = 0 time = 705
.meas tran vdout0_40ck140 FIND v(dout0_40) AT=705.025n

* CHECK dout0_41 Vdout0_41ck140 = 0.9 time = 705
.meas tran vdout0_41ck140 FIND v(dout0_41) AT=705.025n

* CHECK dout0_42 Vdout0_42ck140 = 0.9 time = 705
.meas tran vdout0_42ck140 FIND v(dout0_42) AT=705.025n

* CHECK dout0_43 Vdout0_43ck140 = 0 time = 705
.meas tran vdout0_43ck140 FIND v(dout0_43) AT=705.025n

* CHECK dout0_44 Vdout0_44ck140 = 0.9 time = 705
.meas tran vdout0_44ck140 FIND v(dout0_44) AT=705.025n

* CHECK dout0_45 Vdout0_45ck140 = 0.9 time = 705
.meas tran vdout0_45ck140 FIND v(dout0_45) AT=705.025n

* CHECK dout0_46 Vdout0_46ck140 = 0 time = 705
.meas tran vdout0_46ck140 FIND v(dout0_46) AT=705.025n

* CHECK dout0_47 Vdout0_47ck140 = 0 time = 705
.meas tran vdout0_47ck140 FIND v(dout0_47) AT=705.025n

* CHECK dout0_48 Vdout0_48ck140 = 0 time = 705
.meas tran vdout0_48ck140 FIND v(dout0_48) AT=705.025n

* CHECK dout0_49 Vdout0_49ck140 = 0 time = 705
.meas tran vdout0_49ck140 FIND v(dout0_49) AT=705.025n

* CHECK dout0_50 Vdout0_50ck140 = 0 time = 705
.meas tran vdout0_50ck140 FIND v(dout0_50) AT=705.025n

* CHECK dout0_51 Vdout0_51ck140 = 0 time = 705
.meas tran vdout0_51ck140 FIND v(dout0_51) AT=705.025n

* CHECK dout0_52 Vdout0_52ck140 = 0.9 time = 705
.meas tran vdout0_52ck140 FIND v(dout0_52) AT=705.025n

* CHECK dout0_53 Vdout0_53ck140 = 0.9 time = 705
.meas tran vdout0_53ck140 FIND v(dout0_53) AT=705.025n

* CHECK dout0_54 Vdout0_54ck140 = 0.9 time = 705
.meas tran vdout0_54ck140 FIND v(dout0_54) AT=705.025n

* CHECK dout0_55 Vdout0_55ck140 = 0.9 time = 705
.meas tran vdout0_55ck140 FIND v(dout0_55) AT=705.025n

* CHECK dout0_56 Vdout0_56ck140 = 0 time = 705
.meas tran vdout0_56ck140 FIND v(dout0_56) AT=705.025n

* CHECK dout0_57 Vdout0_57ck140 = 0.9 time = 705
.meas tran vdout0_57ck140 FIND v(dout0_57) AT=705.025n

* CHECK dout0_58 Vdout0_58ck140 = 0 time = 705
.meas tran vdout0_58ck140 FIND v(dout0_58) AT=705.025n

* CHECK dout0_59 Vdout0_59ck140 = 0 time = 705
.meas tran vdout0_59ck140 FIND v(dout0_59) AT=705.025n

* CHECK dout0_60 Vdout0_60ck140 = 0 time = 705
.meas tran vdout0_60ck140 FIND v(dout0_60) AT=705.025n

* CHECK dout0_61 Vdout0_61ck140 = 0 time = 705
.meas tran vdout0_61ck140 FIND v(dout0_61) AT=705.025n

* CHECK dout0_62 Vdout0_62ck140 = 0.9 time = 705
.meas tran vdout0_62ck140 FIND v(dout0_62) AT=705.025n

* CHECK dout0_63 Vdout0_63ck140 = 0.9 time = 705
.meas tran vdout0_63ck140 FIND v(dout0_63) AT=705.025n

* CHECK dout0_0 Vdout0_0ck143 = 0 time = 720
.meas tran vdout0_0ck143 FIND v(dout0_0) AT=720.025n

* CHECK dout0_1 Vdout0_1ck143 = 0.9 time = 720
.meas tran vdout0_1ck143 FIND v(dout0_1) AT=720.025n

* CHECK dout0_2 Vdout0_2ck143 = 0 time = 720
.meas tran vdout0_2ck143 FIND v(dout0_2) AT=720.025n

* CHECK dout0_3 Vdout0_3ck143 = 0.9 time = 720
.meas tran vdout0_3ck143 FIND v(dout0_3) AT=720.025n

* CHECK dout0_4 Vdout0_4ck143 = 0.9 time = 720
.meas tran vdout0_4ck143 FIND v(dout0_4) AT=720.025n

* CHECK dout0_5 Vdout0_5ck143 = 0.9 time = 720
.meas tran vdout0_5ck143 FIND v(dout0_5) AT=720.025n

* CHECK dout0_6 Vdout0_6ck143 = 0.9 time = 720
.meas tran vdout0_6ck143 FIND v(dout0_6) AT=720.025n

* CHECK dout0_7 Vdout0_7ck143 = 0 time = 720
.meas tran vdout0_7ck143 FIND v(dout0_7) AT=720.025n

* CHECK dout0_8 Vdout0_8ck143 = 0.9 time = 720
.meas tran vdout0_8ck143 FIND v(dout0_8) AT=720.025n

* CHECK dout0_9 Vdout0_9ck143 = 0 time = 720
.meas tran vdout0_9ck143 FIND v(dout0_9) AT=720.025n

* CHECK dout0_10 Vdout0_10ck143 = 0 time = 720
.meas tran vdout0_10ck143 FIND v(dout0_10) AT=720.025n

* CHECK dout0_11 Vdout0_11ck143 = 0.9 time = 720
.meas tran vdout0_11ck143 FIND v(dout0_11) AT=720.025n

* CHECK dout0_12 Vdout0_12ck143 = 0.9 time = 720
.meas tran vdout0_12ck143 FIND v(dout0_12) AT=720.025n

* CHECK dout0_13 Vdout0_13ck143 = 0.9 time = 720
.meas tran vdout0_13ck143 FIND v(dout0_13) AT=720.025n

* CHECK dout0_14 Vdout0_14ck143 = 0.9 time = 720
.meas tran vdout0_14ck143 FIND v(dout0_14) AT=720.025n

* CHECK dout0_15 Vdout0_15ck143 = 0 time = 720
.meas tran vdout0_15ck143 FIND v(dout0_15) AT=720.025n

* CHECK dout0_16 Vdout0_16ck143 = 0 time = 720
.meas tran vdout0_16ck143 FIND v(dout0_16) AT=720.025n

* CHECK dout0_17 Vdout0_17ck143 = 0.9 time = 720
.meas tran vdout0_17ck143 FIND v(dout0_17) AT=720.025n

* CHECK dout0_18 Vdout0_18ck143 = 0 time = 720
.meas tran vdout0_18ck143 FIND v(dout0_18) AT=720.025n

* CHECK dout0_19 Vdout0_19ck143 = 0.9 time = 720
.meas tran vdout0_19ck143 FIND v(dout0_19) AT=720.025n

* CHECK dout0_20 Vdout0_20ck143 = 0 time = 720
.meas tran vdout0_20ck143 FIND v(dout0_20) AT=720.025n

* CHECK dout0_21 Vdout0_21ck143 = 0 time = 720
.meas tran vdout0_21ck143 FIND v(dout0_21) AT=720.025n

* CHECK dout0_22 Vdout0_22ck143 = 0.9 time = 720
.meas tran vdout0_22ck143 FIND v(dout0_22) AT=720.025n

* CHECK dout0_23 Vdout0_23ck143 = 0 time = 720
.meas tran vdout0_23ck143 FIND v(dout0_23) AT=720.025n

* CHECK dout0_24 Vdout0_24ck143 = 0.9 time = 720
.meas tran vdout0_24ck143 FIND v(dout0_24) AT=720.025n

* CHECK dout0_25 Vdout0_25ck143 = 0.9 time = 720
.meas tran vdout0_25ck143 FIND v(dout0_25) AT=720.025n

* CHECK dout0_26 Vdout0_26ck143 = 0.9 time = 720
.meas tran vdout0_26ck143 FIND v(dout0_26) AT=720.025n

* CHECK dout0_27 Vdout0_27ck143 = 0 time = 720
.meas tran vdout0_27ck143 FIND v(dout0_27) AT=720.025n

* CHECK dout0_28 Vdout0_28ck143 = 0 time = 720
.meas tran vdout0_28ck143 FIND v(dout0_28) AT=720.025n

* CHECK dout0_29 Vdout0_29ck143 = 0.9 time = 720
.meas tran vdout0_29ck143 FIND v(dout0_29) AT=720.025n

* CHECK dout0_30 Vdout0_30ck143 = 0.9 time = 720
.meas tran vdout0_30ck143 FIND v(dout0_30) AT=720.025n

* CHECK dout0_31 Vdout0_31ck143 = 0.9 time = 720
.meas tran vdout0_31ck143 FIND v(dout0_31) AT=720.025n

* CHECK dout0_32 Vdout0_32ck143 = 0 time = 720
.meas tran vdout0_32ck143 FIND v(dout0_32) AT=720.025n

* CHECK dout0_33 Vdout0_33ck143 = 0.9 time = 720
.meas tran vdout0_33ck143 FIND v(dout0_33) AT=720.025n

* CHECK dout0_34 Vdout0_34ck143 = 0 time = 720
.meas tran vdout0_34ck143 FIND v(dout0_34) AT=720.025n

* CHECK dout0_35 Vdout0_35ck143 = 0.9 time = 720
.meas tran vdout0_35ck143 FIND v(dout0_35) AT=720.025n

* CHECK dout0_36 Vdout0_36ck143 = 0 time = 720
.meas tran vdout0_36ck143 FIND v(dout0_36) AT=720.025n

* CHECK dout0_37 Vdout0_37ck143 = 0 time = 720
.meas tran vdout0_37ck143 FIND v(dout0_37) AT=720.025n

* CHECK dout0_38 Vdout0_38ck143 = 0 time = 720
.meas tran vdout0_38ck143 FIND v(dout0_38) AT=720.025n

* CHECK dout0_39 Vdout0_39ck143 = 0.9 time = 720
.meas tran vdout0_39ck143 FIND v(dout0_39) AT=720.025n

* CHECK dout0_40 Vdout0_40ck143 = 0 time = 720
.meas tran vdout0_40ck143 FIND v(dout0_40) AT=720.025n

* CHECK dout0_41 Vdout0_41ck143 = 0 time = 720
.meas tran vdout0_41ck143 FIND v(dout0_41) AT=720.025n

* CHECK dout0_42 Vdout0_42ck143 = 0 time = 720
.meas tran vdout0_42ck143 FIND v(dout0_42) AT=720.025n

* CHECK dout0_43 Vdout0_43ck143 = 0 time = 720
.meas tran vdout0_43ck143 FIND v(dout0_43) AT=720.025n

* CHECK dout0_44 Vdout0_44ck143 = 0.9 time = 720
.meas tran vdout0_44ck143 FIND v(dout0_44) AT=720.025n

* CHECK dout0_45 Vdout0_45ck143 = 0.9 time = 720
.meas tran vdout0_45ck143 FIND v(dout0_45) AT=720.025n

* CHECK dout0_46 Vdout0_46ck143 = 0 time = 720
.meas tran vdout0_46ck143 FIND v(dout0_46) AT=720.025n

* CHECK dout0_47 Vdout0_47ck143 = 0 time = 720
.meas tran vdout0_47ck143 FIND v(dout0_47) AT=720.025n

* CHECK dout0_48 Vdout0_48ck143 = 0 time = 720
.meas tran vdout0_48ck143 FIND v(dout0_48) AT=720.025n

* CHECK dout0_49 Vdout0_49ck143 = 0.9 time = 720
.meas tran vdout0_49ck143 FIND v(dout0_49) AT=720.025n

* CHECK dout0_50 Vdout0_50ck143 = 0.9 time = 720
.meas tran vdout0_50ck143 FIND v(dout0_50) AT=720.025n

* CHECK dout0_51 Vdout0_51ck143 = 0 time = 720
.meas tran vdout0_51ck143 FIND v(dout0_51) AT=720.025n

* CHECK dout0_52 Vdout0_52ck143 = 0.9 time = 720
.meas tran vdout0_52ck143 FIND v(dout0_52) AT=720.025n

* CHECK dout0_53 Vdout0_53ck143 = 0 time = 720
.meas tran vdout0_53ck143 FIND v(dout0_53) AT=720.025n

* CHECK dout0_54 Vdout0_54ck143 = 0 time = 720
.meas tran vdout0_54ck143 FIND v(dout0_54) AT=720.025n

* CHECK dout0_55 Vdout0_55ck143 = 0.9 time = 720
.meas tran vdout0_55ck143 FIND v(dout0_55) AT=720.025n

* CHECK dout0_56 Vdout0_56ck143 = 0.9 time = 720
.meas tran vdout0_56ck143 FIND v(dout0_56) AT=720.025n

* CHECK dout0_57 Vdout0_57ck143 = 0.9 time = 720
.meas tran vdout0_57ck143 FIND v(dout0_57) AT=720.025n

* CHECK dout0_58 Vdout0_58ck143 = 0.9 time = 720
.meas tran vdout0_58ck143 FIND v(dout0_58) AT=720.025n

* CHECK dout0_59 Vdout0_59ck143 = 0 time = 720
.meas tran vdout0_59ck143 FIND v(dout0_59) AT=720.025n

* CHECK dout0_60 Vdout0_60ck143 = 0.9 time = 720
.meas tran vdout0_60ck143 FIND v(dout0_60) AT=720.025n

* CHECK dout0_61 Vdout0_61ck143 = 0.9 time = 720
.meas tran vdout0_61ck143 FIND v(dout0_61) AT=720.025n

* CHECK dout0_62 Vdout0_62ck143 = 0.9 time = 720
.meas tran vdout0_62ck143 FIND v(dout0_62) AT=720.025n

* CHECK dout0_63 Vdout0_63ck143 = 0.9 time = 720
.meas tran vdout0_63ck143 FIND v(dout0_63) AT=720.025n

* CHECK dout0_0 Vdout0_0ck145 = 0 time = 730
.meas tran vdout0_0ck145 FIND v(dout0_0) AT=730.025n

* CHECK dout0_1 Vdout0_1ck145 = 0.9 time = 730
.meas tran vdout0_1ck145 FIND v(dout0_1) AT=730.025n

* CHECK dout0_2 Vdout0_2ck145 = 0 time = 730
.meas tran vdout0_2ck145 FIND v(dout0_2) AT=730.025n

* CHECK dout0_3 Vdout0_3ck145 = 0.9 time = 730
.meas tran vdout0_3ck145 FIND v(dout0_3) AT=730.025n

* CHECK dout0_4 Vdout0_4ck145 = 0.9 time = 730
.meas tran vdout0_4ck145 FIND v(dout0_4) AT=730.025n

* CHECK dout0_5 Vdout0_5ck145 = 0.9 time = 730
.meas tran vdout0_5ck145 FIND v(dout0_5) AT=730.025n

* CHECK dout0_6 Vdout0_6ck145 = 0.9 time = 730
.meas tran vdout0_6ck145 FIND v(dout0_6) AT=730.025n

* CHECK dout0_7 Vdout0_7ck145 = 0 time = 730
.meas tran vdout0_7ck145 FIND v(dout0_7) AT=730.025n

* CHECK dout0_8 Vdout0_8ck145 = 0.9 time = 730
.meas tran vdout0_8ck145 FIND v(dout0_8) AT=730.025n

* CHECK dout0_9 Vdout0_9ck145 = 0 time = 730
.meas tran vdout0_9ck145 FIND v(dout0_9) AT=730.025n

* CHECK dout0_10 Vdout0_10ck145 = 0 time = 730
.meas tran vdout0_10ck145 FIND v(dout0_10) AT=730.025n

* CHECK dout0_11 Vdout0_11ck145 = 0.9 time = 730
.meas tran vdout0_11ck145 FIND v(dout0_11) AT=730.025n

* CHECK dout0_12 Vdout0_12ck145 = 0.9 time = 730
.meas tran vdout0_12ck145 FIND v(dout0_12) AT=730.025n

* CHECK dout0_13 Vdout0_13ck145 = 0.9 time = 730
.meas tran vdout0_13ck145 FIND v(dout0_13) AT=730.025n

* CHECK dout0_14 Vdout0_14ck145 = 0.9 time = 730
.meas tran vdout0_14ck145 FIND v(dout0_14) AT=730.025n

* CHECK dout0_15 Vdout0_15ck145 = 0 time = 730
.meas tran vdout0_15ck145 FIND v(dout0_15) AT=730.025n

* CHECK dout0_16 Vdout0_16ck145 = 0 time = 730
.meas tran vdout0_16ck145 FIND v(dout0_16) AT=730.025n

* CHECK dout0_17 Vdout0_17ck145 = 0.9 time = 730
.meas tran vdout0_17ck145 FIND v(dout0_17) AT=730.025n

* CHECK dout0_18 Vdout0_18ck145 = 0 time = 730
.meas tran vdout0_18ck145 FIND v(dout0_18) AT=730.025n

* CHECK dout0_19 Vdout0_19ck145 = 0.9 time = 730
.meas tran vdout0_19ck145 FIND v(dout0_19) AT=730.025n

* CHECK dout0_20 Vdout0_20ck145 = 0 time = 730
.meas tran vdout0_20ck145 FIND v(dout0_20) AT=730.025n

* CHECK dout0_21 Vdout0_21ck145 = 0 time = 730
.meas tran vdout0_21ck145 FIND v(dout0_21) AT=730.025n

* CHECK dout0_22 Vdout0_22ck145 = 0.9 time = 730
.meas tran vdout0_22ck145 FIND v(dout0_22) AT=730.025n

* CHECK dout0_23 Vdout0_23ck145 = 0 time = 730
.meas tran vdout0_23ck145 FIND v(dout0_23) AT=730.025n

* CHECK dout0_24 Vdout0_24ck145 = 0.9 time = 730
.meas tran vdout0_24ck145 FIND v(dout0_24) AT=730.025n

* CHECK dout0_25 Vdout0_25ck145 = 0.9 time = 730
.meas tran vdout0_25ck145 FIND v(dout0_25) AT=730.025n

* CHECK dout0_26 Vdout0_26ck145 = 0.9 time = 730
.meas tran vdout0_26ck145 FIND v(dout0_26) AT=730.025n

* CHECK dout0_27 Vdout0_27ck145 = 0 time = 730
.meas tran vdout0_27ck145 FIND v(dout0_27) AT=730.025n

* CHECK dout0_28 Vdout0_28ck145 = 0 time = 730
.meas tran vdout0_28ck145 FIND v(dout0_28) AT=730.025n

* CHECK dout0_29 Vdout0_29ck145 = 0.9 time = 730
.meas tran vdout0_29ck145 FIND v(dout0_29) AT=730.025n

* CHECK dout0_30 Vdout0_30ck145 = 0.9 time = 730
.meas tran vdout0_30ck145 FIND v(dout0_30) AT=730.025n

* CHECK dout0_31 Vdout0_31ck145 = 0.9 time = 730
.meas tran vdout0_31ck145 FIND v(dout0_31) AT=730.025n

* CHECK dout0_32 Vdout0_32ck145 = 0 time = 730
.meas tran vdout0_32ck145 FIND v(dout0_32) AT=730.025n

* CHECK dout0_33 Vdout0_33ck145 = 0.9 time = 730
.meas tran vdout0_33ck145 FIND v(dout0_33) AT=730.025n

* CHECK dout0_34 Vdout0_34ck145 = 0 time = 730
.meas tran vdout0_34ck145 FIND v(dout0_34) AT=730.025n

* CHECK dout0_35 Vdout0_35ck145 = 0.9 time = 730
.meas tran vdout0_35ck145 FIND v(dout0_35) AT=730.025n

* CHECK dout0_36 Vdout0_36ck145 = 0 time = 730
.meas tran vdout0_36ck145 FIND v(dout0_36) AT=730.025n

* CHECK dout0_37 Vdout0_37ck145 = 0 time = 730
.meas tran vdout0_37ck145 FIND v(dout0_37) AT=730.025n

* CHECK dout0_38 Vdout0_38ck145 = 0 time = 730
.meas tran vdout0_38ck145 FIND v(dout0_38) AT=730.025n

* CHECK dout0_39 Vdout0_39ck145 = 0.9 time = 730
.meas tran vdout0_39ck145 FIND v(dout0_39) AT=730.025n

* CHECK dout0_40 Vdout0_40ck145 = 0 time = 730
.meas tran vdout0_40ck145 FIND v(dout0_40) AT=730.025n

* CHECK dout0_41 Vdout0_41ck145 = 0 time = 730
.meas tran vdout0_41ck145 FIND v(dout0_41) AT=730.025n

* CHECK dout0_42 Vdout0_42ck145 = 0 time = 730
.meas tran vdout0_42ck145 FIND v(dout0_42) AT=730.025n

* CHECK dout0_43 Vdout0_43ck145 = 0 time = 730
.meas tran vdout0_43ck145 FIND v(dout0_43) AT=730.025n

* CHECK dout0_44 Vdout0_44ck145 = 0.9 time = 730
.meas tran vdout0_44ck145 FIND v(dout0_44) AT=730.025n

* CHECK dout0_45 Vdout0_45ck145 = 0.9 time = 730
.meas tran vdout0_45ck145 FIND v(dout0_45) AT=730.025n

* CHECK dout0_46 Vdout0_46ck145 = 0 time = 730
.meas tran vdout0_46ck145 FIND v(dout0_46) AT=730.025n

* CHECK dout0_47 Vdout0_47ck145 = 0 time = 730
.meas tran vdout0_47ck145 FIND v(dout0_47) AT=730.025n

* CHECK dout0_48 Vdout0_48ck145 = 0 time = 730
.meas tran vdout0_48ck145 FIND v(dout0_48) AT=730.025n

* CHECK dout0_49 Vdout0_49ck145 = 0.9 time = 730
.meas tran vdout0_49ck145 FIND v(dout0_49) AT=730.025n

* CHECK dout0_50 Vdout0_50ck145 = 0.9 time = 730
.meas tran vdout0_50ck145 FIND v(dout0_50) AT=730.025n

* CHECK dout0_51 Vdout0_51ck145 = 0 time = 730
.meas tran vdout0_51ck145 FIND v(dout0_51) AT=730.025n

* CHECK dout0_52 Vdout0_52ck145 = 0.9 time = 730
.meas tran vdout0_52ck145 FIND v(dout0_52) AT=730.025n

* CHECK dout0_53 Vdout0_53ck145 = 0 time = 730
.meas tran vdout0_53ck145 FIND v(dout0_53) AT=730.025n

* CHECK dout0_54 Vdout0_54ck145 = 0 time = 730
.meas tran vdout0_54ck145 FIND v(dout0_54) AT=730.025n

* CHECK dout0_55 Vdout0_55ck145 = 0.9 time = 730
.meas tran vdout0_55ck145 FIND v(dout0_55) AT=730.025n

* CHECK dout0_56 Vdout0_56ck145 = 0.9 time = 730
.meas tran vdout0_56ck145 FIND v(dout0_56) AT=730.025n

* CHECK dout0_57 Vdout0_57ck145 = 0.9 time = 730
.meas tran vdout0_57ck145 FIND v(dout0_57) AT=730.025n

* CHECK dout0_58 Vdout0_58ck145 = 0.9 time = 730
.meas tran vdout0_58ck145 FIND v(dout0_58) AT=730.025n

* CHECK dout0_59 Vdout0_59ck145 = 0 time = 730
.meas tran vdout0_59ck145 FIND v(dout0_59) AT=730.025n

* CHECK dout0_60 Vdout0_60ck145 = 0.9 time = 730
.meas tran vdout0_60ck145 FIND v(dout0_60) AT=730.025n

* CHECK dout0_61 Vdout0_61ck145 = 0.9 time = 730
.meas tran vdout0_61ck145 FIND v(dout0_61) AT=730.025n

* CHECK dout0_62 Vdout0_62ck145 = 0.9 time = 730
.meas tran vdout0_62ck145 FIND v(dout0_62) AT=730.025n

* CHECK dout0_63 Vdout0_63ck145 = 0.9 time = 730
.meas tran vdout0_63ck145 FIND v(dout0_63) AT=730.025n

* CHECK dout0_0 Vdout0_0ck148 = 0 time = 745
.meas tran vdout0_0ck148 FIND v(dout0_0) AT=745.025n

* CHECK dout0_1 Vdout0_1ck148 = 0 time = 745
.meas tran vdout0_1ck148 FIND v(dout0_1) AT=745.025n

* CHECK dout0_2 Vdout0_2ck148 = 0 time = 745
.meas tran vdout0_2ck148 FIND v(dout0_2) AT=745.025n

* CHECK dout0_3 Vdout0_3ck148 = 0 time = 745
.meas tran vdout0_3ck148 FIND v(dout0_3) AT=745.025n

* CHECK dout0_4 Vdout0_4ck148 = 0.9 time = 745
.meas tran vdout0_4ck148 FIND v(dout0_4) AT=745.025n

* CHECK dout0_5 Vdout0_5ck148 = 0.9 time = 745
.meas tran vdout0_5ck148 FIND v(dout0_5) AT=745.025n

* CHECK dout0_6 Vdout0_6ck148 = 0.9 time = 745
.meas tran vdout0_6ck148 FIND v(dout0_6) AT=745.025n

* CHECK dout0_7 Vdout0_7ck148 = 0 time = 745
.meas tran vdout0_7ck148 FIND v(dout0_7) AT=745.025n

* CHECK dout0_8 Vdout0_8ck148 = 0.9 time = 745
.meas tran vdout0_8ck148 FIND v(dout0_8) AT=745.025n

* CHECK dout0_9 Vdout0_9ck148 = 0 time = 745
.meas tran vdout0_9ck148 FIND v(dout0_9) AT=745.025n

* CHECK dout0_10 Vdout0_10ck148 = 0.9 time = 745
.meas tran vdout0_10ck148 FIND v(dout0_10) AT=745.025n

* CHECK dout0_11 Vdout0_11ck148 = 0 time = 745
.meas tran vdout0_11ck148 FIND v(dout0_11) AT=745.025n

* CHECK dout0_12 Vdout0_12ck148 = 0.9 time = 745
.meas tran vdout0_12ck148 FIND v(dout0_12) AT=745.025n

* CHECK dout0_13 Vdout0_13ck148 = 0.9 time = 745
.meas tran vdout0_13ck148 FIND v(dout0_13) AT=745.025n

* CHECK dout0_14 Vdout0_14ck148 = 0 time = 745
.meas tran vdout0_14ck148 FIND v(dout0_14) AT=745.025n

* CHECK dout0_15 Vdout0_15ck148 = 0.9 time = 745
.meas tran vdout0_15ck148 FIND v(dout0_15) AT=745.025n

* CHECK dout0_16 Vdout0_16ck148 = 0 time = 745
.meas tran vdout0_16ck148 FIND v(dout0_16) AT=745.025n

* CHECK dout0_17 Vdout0_17ck148 = 0 time = 745
.meas tran vdout0_17ck148 FIND v(dout0_17) AT=745.025n

* CHECK dout0_18 Vdout0_18ck148 = 0 time = 745
.meas tran vdout0_18ck148 FIND v(dout0_18) AT=745.025n

* CHECK dout0_19 Vdout0_19ck148 = 0.9 time = 745
.meas tran vdout0_19ck148 FIND v(dout0_19) AT=745.025n

* CHECK dout0_20 Vdout0_20ck148 = 0.9 time = 745
.meas tran vdout0_20ck148 FIND v(dout0_20) AT=745.025n

* CHECK dout0_21 Vdout0_21ck148 = 0.9 time = 745
.meas tran vdout0_21ck148 FIND v(dout0_21) AT=745.025n

* CHECK dout0_22 Vdout0_22ck148 = 0.9 time = 745
.meas tran vdout0_22ck148 FIND v(dout0_22) AT=745.025n

* CHECK dout0_23 Vdout0_23ck148 = 0 time = 745
.meas tran vdout0_23ck148 FIND v(dout0_23) AT=745.025n

* CHECK dout0_24 Vdout0_24ck148 = 0 time = 745
.meas tran vdout0_24ck148 FIND v(dout0_24) AT=745.025n

* CHECK dout0_25 Vdout0_25ck148 = 0.9 time = 745
.meas tran vdout0_25ck148 FIND v(dout0_25) AT=745.025n

* CHECK dout0_26 Vdout0_26ck148 = 0.9 time = 745
.meas tran vdout0_26ck148 FIND v(dout0_26) AT=745.025n

* CHECK dout0_27 Vdout0_27ck148 = 0.9 time = 745
.meas tran vdout0_27ck148 FIND v(dout0_27) AT=745.025n

* CHECK dout0_28 Vdout0_28ck148 = 0 time = 745
.meas tran vdout0_28ck148 FIND v(dout0_28) AT=745.025n

* CHECK dout0_29 Vdout0_29ck148 = 0.9 time = 745
.meas tran vdout0_29ck148 FIND v(dout0_29) AT=745.025n

* CHECK dout0_30 Vdout0_30ck148 = 0.9 time = 745
.meas tran vdout0_30ck148 FIND v(dout0_30) AT=745.025n

* CHECK dout0_31 Vdout0_31ck148 = 0.9 time = 745
.meas tran vdout0_31ck148 FIND v(dout0_31) AT=745.025n

* CHECK dout0_32 Vdout0_32ck148 = 0.9 time = 745
.meas tran vdout0_32ck148 FIND v(dout0_32) AT=745.025n

* CHECK dout0_33 Vdout0_33ck148 = 0.9 time = 745
.meas tran vdout0_33ck148 FIND v(dout0_33) AT=745.025n

* CHECK dout0_34 Vdout0_34ck148 = 0 time = 745
.meas tran vdout0_34ck148 FIND v(dout0_34) AT=745.025n

* CHECK dout0_35 Vdout0_35ck148 = 0.9 time = 745
.meas tran vdout0_35ck148 FIND v(dout0_35) AT=745.025n

* CHECK dout0_36 Vdout0_36ck148 = 0 time = 745
.meas tran vdout0_36ck148 FIND v(dout0_36) AT=745.025n

* CHECK dout0_37 Vdout0_37ck148 = 0.9 time = 745
.meas tran vdout0_37ck148 FIND v(dout0_37) AT=745.025n

* CHECK dout0_38 Vdout0_38ck148 = 0 time = 745
.meas tran vdout0_38ck148 FIND v(dout0_38) AT=745.025n

* CHECK dout0_39 Vdout0_39ck148 = 0 time = 745
.meas tran vdout0_39ck148 FIND v(dout0_39) AT=745.025n

* CHECK dout0_40 Vdout0_40ck148 = 0.9 time = 745
.meas tran vdout0_40ck148 FIND v(dout0_40) AT=745.025n

* CHECK dout0_41 Vdout0_41ck148 = 0 time = 745
.meas tran vdout0_41ck148 FIND v(dout0_41) AT=745.025n

* CHECK dout0_42 Vdout0_42ck148 = 0 time = 745
.meas tran vdout0_42ck148 FIND v(dout0_42) AT=745.025n

* CHECK dout0_43 Vdout0_43ck148 = 0 time = 745
.meas tran vdout0_43ck148 FIND v(dout0_43) AT=745.025n

* CHECK dout0_44 Vdout0_44ck148 = 0.9 time = 745
.meas tran vdout0_44ck148 FIND v(dout0_44) AT=745.025n

* CHECK dout0_45 Vdout0_45ck148 = 0.9 time = 745
.meas tran vdout0_45ck148 FIND v(dout0_45) AT=745.025n

* CHECK dout0_46 Vdout0_46ck148 = 0.9 time = 745
.meas tran vdout0_46ck148 FIND v(dout0_46) AT=745.025n

* CHECK dout0_47 Vdout0_47ck148 = 0.9 time = 745
.meas tran vdout0_47ck148 FIND v(dout0_47) AT=745.025n

* CHECK dout0_48 Vdout0_48ck148 = 0 time = 745
.meas tran vdout0_48ck148 FIND v(dout0_48) AT=745.025n

* CHECK dout0_49 Vdout0_49ck148 = 0.9 time = 745
.meas tran vdout0_49ck148 FIND v(dout0_49) AT=745.025n

* CHECK dout0_50 Vdout0_50ck148 = 0.9 time = 745
.meas tran vdout0_50ck148 FIND v(dout0_50) AT=745.025n

* CHECK dout0_51 Vdout0_51ck148 = 0.9 time = 745
.meas tran vdout0_51ck148 FIND v(dout0_51) AT=745.025n

* CHECK dout0_52 Vdout0_52ck148 = 0.9 time = 745
.meas tran vdout0_52ck148 FIND v(dout0_52) AT=745.025n

* CHECK dout0_53 Vdout0_53ck148 = 0 time = 745
.meas tran vdout0_53ck148 FIND v(dout0_53) AT=745.025n

* CHECK dout0_54 Vdout0_54ck148 = 0 time = 745
.meas tran vdout0_54ck148 FIND v(dout0_54) AT=745.025n

* CHECK dout0_55 Vdout0_55ck148 = 0 time = 745
.meas tran vdout0_55ck148 FIND v(dout0_55) AT=745.025n

* CHECK dout0_56 Vdout0_56ck148 = 0 time = 745
.meas tran vdout0_56ck148 FIND v(dout0_56) AT=745.025n

* CHECK dout0_57 Vdout0_57ck148 = 0.9 time = 745
.meas tran vdout0_57ck148 FIND v(dout0_57) AT=745.025n

* CHECK dout0_58 Vdout0_58ck148 = 0.9 time = 745
.meas tran vdout0_58ck148 FIND v(dout0_58) AT=745.025n

* CHECK dout0_59 Vdout0_59ck148 = 0.9 time = 745
.meas tran vdout0_59ck148 FIND v(dout0_59) AT=745.025n

* CHECK dout0_60 Vdout0_60ck148 = 0 time = 745
.meas tran vdout0_60ck148 FIND v(dout0_60) AT=745.025n

* CHECK dout0_61 Vdout0_61ck148 = 0 time = 745
.meas tran vdout0_61ck148 FIND v(dout0_61) AT=745.025n

* CHECK dout0_62 Vdout0_62ck148 = 0 time = 745
.meas tran vdout0_62ck148 FIND v(dout0_62) AT=745.025n

* CHECK dout0_63 Vdout0_63ck148 = 0 time = 745
.meas tran vdout0_63ck148 FIND v(dout0_63) AT=745.025n

* CHECK dout0_0 Vdout0_0ck152 = 0 time = 765
.meas tran vdout0_0ck152 FIND v(dout0_0) AT=765.025n

* CHECK dout0_1 Vdout0_1ck152 = 0 time = 765
.meas tran vdout0_1ck152 FIND v(dout0_1) AT=765.025n

* CHECK dout0_2 Vdout0_2ck152 = 0 time = 765
.meas tran vdout0_2ck152 FIND v(dout0_2) AT=765.025n

* CHECK dout0_3 Vdout0_3ck152 = 0.9 time = 765
.meas tran vdout0_3ck152 FIND v(dout0_3) AT=765.025n

* CHECK dout0_4 Vdout0_4ck152 = 0 time = 765
.meas tran vdout0_4ck152 FIND v(dout0_4) AT=765.025n

* CHECK dout0_5 Vdout0_5ck152 = 0 time = 765
.meas tran vdout0_5ck152 FIND v(dout0_5) AT=765.025n

* CHECK dout0_6 Vdout0_6ck152 = 0 time = 765
.meas tran vdout0_6ck152 FIND v(dout0_6) AT=765.025n

* CHECK dout0_7 Vdout0_7ck152 = 0 time = 765
.meas tran vdout0_7ck152 FIND v(dout0_7) AT=765.025n

* CHECK dout0_8 Vdout0_8ck152 = 0.9 time = 765
.meas tran vdout0_8ck152 FIND v(dout0_8) AT=765.025n

* CHECK dout0_9 Vdout0_9ck152 = 0 time = 765
.meas tran vdout0_9ck152 FIND v(dout0_9) AT=765.025n

* CHECK dout0_10 Vdout0_10ck152 = 0.9 time = 765
.meas tran vdout0_10ck152 FIND v(dout0_10) AT=765.025n

* CHECK dout0_11 Vdout0_11ck152 = 0 time = 765
.meas tran vdout0_11ck152 FIND v(dout0_11) AT=765.025n

* CHECK dout0_12 Vdout0_12ck152 = 0 time = 765
.meas tran vdout0_12ck152 FIND v(dout0_12) AT=765.025n

* CHECK dout0_13 Vdout0_13ck152 = 0.9 time = 765
.meas tran vdout0_13ck152 FIND v(dout0_13) AT=765.025n

* CHECK dout0_14 Vdout0_14ck152 = 0.9 time = 765
.meas tran vdout0_14ck152 FIND v(dout0_14) AT=765.025n

* CHECK dout0_15 Vdout0_15ck152 = 0.9 time = 765
.meas tran vdout0_15ck152 FIND v(dout0_15) AT=765.025n

* CHECK dout0_16 Vdout0_16ck152 = 0 time = 765
.meas tran vdout0_16ck152 FIND v(dout0_16) AT=765.025n

* CHECK dout0_17 Vdout0_17ck152 = 0.9 time = 765
.meas tran vdout0_17ck152 FIND v(dout0_17) AT=765.025n

* CHECK dout0_18 Vdout0_18ck152 = 0 time = 765
.meas tran vdout0_18ck152 FIND v(dout0_18) AT=765.025n

* CHECK dout0_19 Vdout0_19ck152 = 0.9 time = 765
.meas tran vdout0_19ck152 FIND v(dout0_19) AT=765.025n

* CHECK dout0_20 Vdout0_20ck152 = 0 time = 765
.meas tran vdout0_20ck152 FIND v(dout0_20) AT=765.025n

* CHECK dout0_21 Vdout0_21ck152 = 0 time = 765
.meas tran vdout0_21ck152 FIND v(dout0_21) AT=765.025n

* CHECK dout0_22 Vdout0_22ck152 = 0.9 time = 765
.meas tran vdout0_22ck152 FIND v(dout0_22) AT=765.025n

* CHECK dout0_23 Vdout0_23ck152 = 0.9 time = 765
.meas tran vdout0_23ck152 FIND v(dout0_23) AT=765.025n

* CHECK dout0_24 Vdout0_24ck152 = 0 time = 765
.meas tran vdout0_24ck152 FIND v(dout0_24) AT=765.025n

* CHECK dout0_25 Vdout0_25ck152 = 0 time = 765
.meas tran vdout0_25ck152 FIND v(dout0_25) AT=765.025n

* CHECK dout0_26 Vdout0_26ck152 = 0.9 time = 765
.meas tran vdout0_26ck152 FIND v(dout0_26) AT=765.025n

* CHECK dout0_27 Vdout0_27ck152 = 0 time = 765
.meas tran vdout0_27ck152 FIND v(dout0_27) AT=765.025n

* CHECK dout0_28 Vdout0_28ck152 = 0 time = 765
.meas tran vdout0_28ck152 FIND v(dout0_28) AT=765.025n

* CHECK dout0_29 Vdout0_29ck152 = 0.9 time = 765
.meas tran vdout0_29ck152 FIND v(dout0_29) AT=765.025n

* CHECK dout0_30 Vdout0_30ck152 = 0 time = 765
.meas tran vdout0_30ck152 FIND v(dout0_30) AT=765.025n

* CHECK dout0_31 Vdout0_31ck152 = 0 time = 765
.meas tran vdout0_31ck152 FIND v(dout0_31) AT=765.025n

* CHECK dout0_32 Vdout0_32ck152 = 0.9 time = 765
.meas tran vdout0_32ck152 FIND v(dout0_32) AT=765.025n

* CHECK dout0_33 Vdout0_33ck152 = 0 time = 765
.meas tran vdout0_33ck152 FIND v(dout0_33) AT=765.025n

* CHECK dout0_34 Vdout0_34ck152 = 0.9 time = 765
.meas tran vdout0_34ck152 FIND v(dout0_34) AT=765.025n

* CHECK dout0_35 Vdout0_35ck152 = 0.9 time = 765
.meas tran vdout0_35ck152 FIND v(dout0_35) AT=765.025n

* CHECK dout0_36 Vdout0_36ck152 = 0.9 time = 765
.meas tran vdout0_36ck152 FIND v(dout0_36) AT=765.025n

* CHECK dout0_37 Vdout0_37ck152 = 0 time = 765
.meas tran vdout0_37ck152 FIND v(dout0_37) AT=765.025n

* CHECK dout0_38 Vdout0_38ck152 = 0.9 time = 765
.meas tran vdout0_38ck152 FIND v(dout0_38) AT=765.025n

* CHECK dout0_39 Vdout0_39ck152 = 0 time = 765
.meas tran vdout0_39ck152 FIND v(dout0_39) AT=765.025n

* CHECK dout0_40 Vdout0_40ck152 = 0.9 time = 765
.meas tran vdout0_40ck152 FIND v(dout0_40) AT=765.025n

* CHECK dout0_41 Vdout0_41ck152 = 0.9 time = 765
.meas tran vdout0_41ck152 FIND v(dout0_41) AT=765.025n

* CHECK dout0_42 Vdout0_42ck152 = 0 time = 765
.meas tran vdout0_42ck152 FIND v(dout0_42) AT=765.025n

* CHECK dout0_43 Vdout0_43ck152 = 0 time = 765
.meas tran vdout0_43ck152 FIND v(dout0_43) AT=765.025n

* CHECK dout0_44 Vdout0_44ck152 = 0.9 time = 765
.meas tran vdout0_44ck152 FIND v(dout0_44) AT=765.025n

* CHECK dout0_45 Vdout0_45ck152 = 0 time = 765
.meas tran vdout0_45ck152 FIND v(dout0_45) AT=765.025n

* CHECK dout0_46 Vdout0_46ck152 = 0 time = 765
.meas tran vdout0_46ck152 FIND v(dout0_46) AT=765.025n

* CHECK dout0_47 Vdout0_47ck152 = 0 time = 765
.meas tran vdout0_47ck152 FIND v(dout0_47) AT=765.025n

* CHECK dout0_48 Vdout0_48ck152 = 0 time = 765
.meas tran vdout0_48ck152 FIND v(dout0_48) AT=765.025n

* CHECK dout0_49 Vdout0_49ck152 = 0.9 time = 765
.meas tran vdout0_49ck152 FIND v(dout0_49) AT=765.025n

* CHECK dout0_50 Vdout0_50ck152 = 0.9 time = 765
.meas tran vdout0_50ck152 FIND v(dout0_50) AT=765.025n

* CHECK dout0_51 Vdout0_51ck152 = 0 time = 765
.meas tran vdout0_51ck152 FIND v(dout0_51) AT=765.025n

* CHECK dout0_52 Vdout0_52ck152 = 0 time = 765
.meas tran vdout0_52ck152 FIND v(dout0_52) AT=765.025n

* CHECK dout0_53 Vdout0_53ck152 = 0.9 time = 765
.meas tran vdout0_53ck152 FIND v(dout0_53) AT=765.025n

* CHECK dout0_54 Vdout0_54ck152 = 0 time = 765
.meas tran vdout0_54ck152 FIND v(dout0_54) AT=765.025n

* CHECK dout0_55 Vdout0_55ck152 = 0 time = 765
.meas tran vdout0_55ck152 FIND v(dout0_55) AT=765.025n

* CHECK dout0_56 Vdout0_56ck152 = 0.9 time = 765
.meas tran vdout0_56ck152 FIND v(dout0_56) AT=765.025n

* CHECK dout0_57 Vdout0_57ck152 = 0 time = 765
.meas tran vdout0_57ck152 FIND v(dout0_57) AT=765.025n

* CHECK dout0_58 Vdout0_58ck152 = 0 time = 765
.meas tran vdout0_58ck152 FIND v(dout0_58) AT=765.025n

* CHECK dout0_59 Vdout0_59ck152 = 0.9 time = 765
.meas tran vdout0_59ck152 FIND v(dout0_59) AT=765.025n

* CHECK dout0_60 Vdout0_60ck152 = 0 time = 765
.meas tran vdout0_60ck152 FIND v(dout0_60) AT=765.025n

* CHECK dout0_61 Vdout0_61ck152 = 0.9 time = 765
.meas tran vdout0_61ck152 FIND v(dout0_61) AT=765.025n

* CHECK dout0_62 Vdout0_62ck152 = 0.9 time = 765
.meas tran vdout0_62ck152 FIND v(dout0_62) AT=765.025n

* CHECK dout0_63 Vdout0_63ck152 = 0.9 time = 765
.meas tran vdout0_63ck152 FIND v(dout0_63) AT=765.025n

* CHECK dout0_0 Vdout0_0ck153 = 0 time = 770
.meas tran vdout0_0ck153 FIND v(dout0_0) AT=770.025n

* CHECK dout0_1 Vdout0_1ck153 = 0 time = 770
.meas tran vdout0_1ck153 FIND v(dout0_1) AT=770.025n

* CHECK dout0_2 Vdout0_2ck153 = 0 time = 770
.meas tran vdout0_2ck153 FIND v(dout0_2) AT=770.025n

* CHECK dout0_3 Vdout0_3ck153 = 0.9 time = 770
.meas tran vdout0_3ck153 FIND v(dout0_3) AT=770.025n

* CHECK dout0_4 Vdout0_4ck153 = 0 time = 770
.meas tran vdout0_4ck153 FIND v(dout0_4) AT=770.025n

* CHECK dout0_5 Vdout0_5ck153 = 0 time = 770
.meas tran vdout0_5ck153 FIND v(dout0_5) AT=770.025n

* CHECK dout0_6 Vdout0_6ck153 = 0 time = 770
.meas tran vdout0_6ck153 FIND v(dout0_6) AT=770.025n

* CHECK dout0_7 Vdout0_7ck153 = 0 time = 770
.meas tran vdout0_7ck153 FIND v(dout0_7) AT=770.025n

* CHECK dout0_8 Vdout0_8ck153 = 0.9 time = 770
.meas tran vdout0_8ck153 FIND v(dout0_8) AT=770.025n

* CHECK dout0_9 Vdout0_9ck153 = 0 time = 770
.meas tran vdout0_9ck153 FIND v(dout0_9) AT=770.025n

* CHECK dout0_10 Vdout0_10ck153 = 0.9 time = 770
.meas tran vdout0_10ck153 FIND v(dout0_10) AT=770.025n

* CHECK dout0_11 Vdout0_11ck153 = 0 time = 770
.meas tran vdout0_11ck153 FIND v(dout0_11) AT=770.025n

* CHECK dout0_12 Vdout0_12ck153 = 0 time = 770
.meas tran vdout0_12ck153 FIND v(dout0_12) AT=770.025n

* CHECK dout0_13 Vdout0_13ck153 = 0.9 time = 770
.meas tran vdout0_13ck153 FIND v(dout0_13) AT=770.025n

* CHECK dout0_14 Vdout0_14ck153 = 0.9 time = 770
.meas tran vdout0_14ck153 FIND v(dout0_14) AT=770.025n

* CHECK dout0_15 Vdout0_15ck153 = 0.9 time = 770
.meas tran vdout0_15ck153 FIND v(dout0_15) AT=770.025n

* CHECK dout0_16 Vdout0_16ck153 = 0 time = 770
.meas tran vdout0_16ck153 FIND v(dout0_16) AT=770.025n

* CHECK dout0_17 Vdout0_17ck153 = 0.9 time = 770
.meas tran vdout0_17ck153 FIND v(dout0_17) AT=770.025n

* CHECK dout0_18 Vdout0_18ck153 = 0 time = 770
.meas tran vdout0_18ck153 FIND v(dout0_18) AT=770.025n

* CHECK dout0_19 Vdout0_19ck153 = 0.9 time = 770
.meas tran vdout0_19ck153 FIND v(dout0_19) AT=770.025n

* CHECK dout0_20 Vdout0_20ck153 = 0 time = 770
.meas tran vdout0_20ck153 FIND v(dout0_20) AT=770.025n

* CHECK dout0_21 Vdout0_21ck153 = 0 time = 770
.meas tran vdout0_21ck153 FIND v(dout0_21) AT=770.025n

* CHECK dout0_22 Vdout0_22ck153 = 0.9 time = 770
.meas tran vdout0_22ck153 FIND v(dout0_22) AT=770.025n

* CHECK dout0_23 Vdout0_23ck153 = 0.9 time = 770
.meas tran vdout0_23ck153 FIND v(dout0_23) AT=770.025n

* CHECK dout0_24 Vdout0_24ck153 = 0 time = 770
.meas tran vdout0_24ck153 FIND v(dout0_24) AT=770.025n

* CHECK dout0_25 Vdout0_25ck153 = 0 time = 770
.meas tran vdout0_25ck153 FIND v(dout0_25) AT=770.025n

* CHECK dout0_26 Vdout0_26ck153 = 0.9 time = 770
.meas tran vdout0_26ck153 FIND v(dout0_26) AT=770.025n

* CHECK dout0_27 Vdout0_27ck153 = 0 time = 770
.meas tran vdout0_27ck153 FIND v(dout0_27) AT=770.025n

* CHECK dout0_28 Vdout0_28ck153 = 0 time = 770
.meas tran vdout0_28ck153 FIND v(dout0_28) AT=770.025n

* CHECK dout0_29 Vdout0_29ck153 = 0.9 time = 770
.meas tran vdout0_29ck153 FIND v(dout0_29) AT=770.025n

* CHECK dout0_30 Vdout0_30ck153 = 0 time = 770
.meas tran vdout0_30ck153 FIND v(dout0_30) AT=770.025n

* CHECK dout0_31 Vdout0_31ck153 = 0 time = 770
.meas tran vdout0_31ck153 FIND v(dout0_31) AT=770.025n

* CHECK dout0_32 Vdout0_32ck153 = 0.9 time = 770
.meas tran vdout0_32ck153 FIND v(dout0_32) AT=770.025n

* CHECK dout0_33 Vdout0_33ck153 = 0 time = 770
.meas tran vdout0_33ck153 FIND v(dout0_33) AT=770.025n

* CHECK dout0_34 Vdout0_34ck153 = 0.9 time = 770
.meas tran vdout0_34ck153 FIND v(dout0_34) AT=770.025n

* CHECK dout0_35 Vdout0_35ck153 = 0.9 time = 770
.meas tran vdout0_35ck153 FIND v(dout0_35) AT=770.025n

* CHECK dout0_36 Vdout0_36ck153 = 0.9 time = 770
.meas tran vdout0_36ck153 FIND v(dout0_36) AT=770.025n

* CHECK dout0_37 Vdout0_37ck153 = 0 time = 770
.meas tran vdout0_37ck153 FIND v(dout0_37) AT=770.025n

* CHECK dout0_38 Vdout0_38ck153 = 0.9 time = 770
.meas tran vdout0_38ck153 FIND v(dout0_38) AT=770.025n

* CHECK dout0_39 Vdout0_39ck153 = 0 time = 770
.meas tran vdout0_39ck153 FIND v(dout0_39) AT=770.025n

* CHECK dout0_40 Vdout0_40ck153 = 0.9 time = 770
.meas tran vdout0_40ck153 FIND v(dout0_40) AT=770.025n

* CHECK dout0_41 Vdout0_41ck153 = 0.9 time = 770
.meas tran vdout0_41ck153 FIND v(dout0_41) AT=770.025n

* CHECK dout0_42 Vdout0_42ck153 = 0 time = 770
.meas tran vdout0_42ck153 FIND v(dout0_42) AT=770.025n

* CHECK dout0_43 Vdout0_43ck153 = 0 time = 770
.meas tran vdout0_43ck153 FIND v(dout0_43) AT=770.025n

* CHECK dout0_44 Vdout0_44ck153 = 0.9 time = 770
.meas tran vdout0_44ck153 FIND v(dout0_44) AT=770.025n

* CHECK dout0_45 Vdout0_45ck153 = 0 time = 770
.meas tran vdout0_45ck153 FIND v(dout0_45) AT=770.025n

* CHECK dout0_46 Vdout0_46ck153 = 0 time = 770
.meas tran vdout0_46ck153 FIND v(dout0_46) AT=770.025n

* CHECK dout0_47 Vdout0_47ck153 = 0 time = 770
.meas tran vdout0_47ck153 FIND v(dout0_47) AT=770.025n

* CHECK dout0_48 Vdout0_48ck153 = 0 time = 770
.meas tran vdout0_48ck153 FIND v(dout0_48) AT=770.025n

* CHECK dout0_49 Vdout0_49ck153 = 0.9 time = 770
.meas tran vdout0_49ck153 FIND v(dout0_49) AT=770.025n

* CHECK dout0_50 Vdout0_50ck153 = 0.9 time = 770
.meas tran vdout0_50ck153 FIND v(dout0_50) AT=770.025n

* CHECK dout0_51 Vdout0_51ck153 = 0 time = 770
.meas tran vdout0_51ck153 FIND v(dout0_51) AT=770.025n

* CHECK dout0_52 Vdout0_52ck153 = 0 time = 770
.meas tran vdout0_52ck153 FIND v(dout0_52) AT=770.025n

* CHECK dout0_53 Vdout0_53ck153 = 0.9 time = 770
.meas tran vdout0_53ck153 FIND v(dout0_53) AT=770.025n

* CHECK dout0_54 Vdout0_54ck153 = 0 time = 770
.meas tran vdout0_54ck153 FIND v(dout0_54) AT=770.025n

* CHECK dout0_55 Vdout0_55ck153 = 0 time = 770
.meas tran vdout0_55ck153 FIND v(dout0_55) AT=770.025n

* CHECK dout0_56 Vdout0_56ck153 = 0.9 time = 770
.meas tran vdout0_56ck153 FIND v(dout0_56) AT=770.025n

* CHECK dout0_57 Vdout0_57ck153 = 0 time = 770
.meas tran vdout0_57ck153 FIND v(dout0_57) AT=770.025n

* CHECK dout0_58 Vdout0_58ck153 = 0 time = 770
.meas tran vdout0_58ck153 FIND v(dout0_58) AT=770.025n

* CHECK dout0_59 Vdout0_59ck153 = 0.9 time = 770
.meas tran vdout0_59ck153 FIND v(dout0_59) AT=770.025n

* CHECK dout0_60 Vdout0_60ck153 = 0 time = 770
.meas tran vdout0_60ck153 FIND v(dout0_60) AT=770.025n

* CHECK dout0_61 Vdout0_61ck153 = 0.9 time = 770
.meas tran vdout0_61ck153 FIND v(dout0_61) AT=770.025n

* CHECK dout0_62 Vdout0_62ck153 = 0.9 time = 770
.meas tran vdout0_62ck153 FIND v(dout0_62) AT=770.025n

* CHECK dout0_63 Vdout0_63ck153 = 0.9 time = 770
.meas tran vdout0_63ck153 FIND v(dout0_63) AT=770.025n

* CHECK dout0_0 Vdout0_0ck154 = 0.9 time = 775
.meas tran vdout0_0ck154 FIND v(dout0_0) AT=775.025n

* CHECK dout0_1 Vdout0_1ck154 = 0.9 time = 775
.meas tran vdout0_1ck154 FIND v(dout0_1) AT=775.025n

* CHECK dout0_2 Vdout0_2ck154 = 0.9 time = 775
.meas tran vdout0_2ck154 FIND v(dout0_2) AT=775.025n

* CHECK dout0_3 Vdout0_3ck154 = 0.9 time = 775
.meas tran vdout0_3ck154 FIND v(dout0_3) AT=775.025n

* CHECK dout0_4 Vdout0_4ck154 = 0.9 time = 775
.meas tran vdout0_4ck154 FIND v(dout0_4) AT=775.025n

* CHECK dout0_5 Vdout0_5ck154 = 0.9 time = 775
.meas tran vdout0_5ck154 FIND v(dout0_5) AT=775.025n

* CHECK dout0_6 Vdout0_6ck154 = 0.9 time = 775
.meas tran vdout0_6ck154 FIND v(dout0_6) AT=775.025n

* CHECK dout0_7 Vdout0_7ck154 = 0 time = 775
.meas tran vdout0_7ck154 FIND v(dout0_7) AT=775.025n

* CHECK dout0_8 Vdout0_8ck154 = 0 time = 775
.meas tran vdout0_8ck154 FIND v(dout0_8) AT=775.025n

* CHECK dout0_9 Vdout0_9ck154 = 0.9 time = 775
.meas tran vdout0_9ck154 FIND v(dout0_9) AT=775.025n

* CHECK dout0_10 Vdout0_10ck154 = 0 time = 775
.meas tran vdout0_10ck154 FIND v(dout0_10) AT=775.025n

* CHECK dout0_11 Vdout0_11ck154 = 0 time = 775
.meas tran vdout0_11ck154 FIND v(dout0_11) AT=775.025n

* CHECK dout0_12 Vdout0_12ck154 = 0.9 time = 775
.meas tran vdout0_12ck154 FIND v(dout0_12) AT=775.025n

* CHECK dout0_13 Vdout0_13ck154 = 0.9 time = 775
.meas tran vdout0_13ck154 FIND v(dout0_13) AT=775.025n

* CHECK dout0_14 Vdout0_14ck154 = 0 time = 775
.meas tran vdout0_14ck154 FIND v(dout0_14) AT=775.025n

* CHECK dout0_15 Vdout0_15ck154 = 0 time = 775
.meas tran vdout0_15ck154 FIND v(dout0_15) AT=775.025n

* CHECK dout0_16 Vdout0_16ck154 = 0.9 time = 775
.meas tran vdout0_16ck154 FIND v(dout0_16) AT=775.025n

* CHECK dout0_17 Vdout0_17ck154 = 0.9 time = 775
.meas tran vdout0_17ck154 FIND v(dout0_17) AT=775.025n

* CHECK dout0_18 Vdout0_18ck154 = 0.9 time = 775
.meas tran vdout0_18ck154 FIND v(dout0_18) AT=775.025n

* CHECK dout0_19 Vdout0_19ck154 = 0 time = 775
.meas tran vdout0_19ck154 FIND v(dout0_19) AT=775.025n

* CHECK dout0_20 Vdout0_20ck154 = 0 time = 775
.meas tran vdout0_20ck154 FIND v(dout0_20) AT=775.025n

* CHECK dout0_21 Vdout0_21ck154 = 0.9 time = 775
.meas tran vdout0_21ck154 FIND v(dout0_21) AT=775.025n

* CHECK dout0_22 Vdout0_22ck154 = 0.9 time = 775
.meas tran vdout0_22ck154 FIND v(dout0_22) AT=775.025n

* CHECK dout0_23 Vdout0_23ck154 = 0.9 time = 775
.meas tran vdout0_23ck154 FIND v(dout0_23) AT=775.025n

* CHECK dout0_24 Vdout0_24ck154 = 0.9 time = 775
.meas tran vdout0_24ck154 FIND v(dout0_24) AT=775.025n

* CHECK dout0_25 Vdout0_25ck154 = 0 time = 775
.meas tran vdout0_25ck154 FIND v(dout0_25) AT=775.025n

* CHECK dout0_26 Vdout0_26ck154 = 0.9 time = 775
.meas tran vdout0_26ck154 FIND v(dout0_26) AT=775.025n

* CHECK dout0_27 Vdout0_27ck154 = 0.9 time = 775
.meas tran vdout0_27ck154 FIND v(dout0_27) AT=775.025n

* CHECK dout0_28 Vdout0_28ck154 = 0.9 time = 775
.meas tran vdout0_28ck154 FIND v(dout0_28) AT=775.025n

* CHECK dout0_29 Vdout0_29ck154 = 0.9 time = 775
.meas tran vdout0_29ck154 FIND v(dout0_29) AT=775.025n

* CHECK dout0_30 Vdout0_30ck154 = 0.9 time = 775
.meas tran vdout0_30ck154 FIND v(dout0_30) AT=775.025n

* CHECK dout0_31 Vdout0_31ck154 = 0.9 time = 775
.meas tran vdout0_31ck154 FIND v(dout0_31) AT=775.025n

* CHECK dout0_32 Vdout0_32ck154 = 0 time = 775
.meas tran vdout0_32ck154 FIND v(dout0_32) AT=775.025n

* CHECK dout0_33 Vdout0_33ck154 = 0.9 time = 775
.meas tran vdout0_33ck154 FIND v(dout0_33) AT=775.025n

* CHECK dout0_34 Vdout0_34ck154 = 0.9 time = 775
.meas tran vdout0_34ck154 FIND v(dout0_34) AT=775.025n

* CHECK dout0_35 Vdout0_35ck154 = 0.9 time = 775
.meas tran vdout0_35ck154 FIND v(dout0_35) AT=775.025n

* CHECK dout0_36 Vdout0_36ck154 = 0.9 time = 775
.meas tran vdout0_36ck154 FIND v(dout0_36) AT=775.025n

* CHECK dout0_37 Vdout0_37ck154 = 0.9 time = 775
.meas tran vdout0_37ck154 FIND v(dout0_37) AT=775.025n

* CHECK dout0_38 Vdout0_38ck154 = 0.9 time = 775
.meas tran vdout0_38ck154 FIND v(dout0_38) AT=775.025n

* CHECK dout0_39 Vdout0_39ck154 = 0 time = 775
.meas tran vdout0_39ck154 FIND v(dout0_39) AT=775.025n

* CHECK dout0_40 Vdout0_40ck154 = 0 time = 775
.meas tran vdout0_40ck154 FIND v(dout0_40) AT=775.025n

* CHECK dout0_41 Vdout0_41ck154 = 0.9 time = 775
.meas tran vdout0_41ck154 FIND v(dout0_41) AT=775.025n

* CHECK dout0_42 Vdout0_42ck154 = 0.9 time = 775
.meas tran vdout0_42ck154 FIND v(dout0_42) AT=775.025n

* CHECK dout0_43 Vdout0_43ck154 = 0.9 time = 775
.meas tran vdout0_43ck154 FIND v(dout0_43) AT=775.025n

* CHECK dout0_44 Vdout0_44ck154 = 0 time = 775
.meas tran vdout0_44ck154 FIND v(dout0_44) AT=775.025n

* CHECK dout0_45 Vdout0_45ck154 = 0.9 time = 775
.meas tran vdout0_45ck154 FIND v(dout0_45) AT=775.025n

* CHECK dout0_46 Vdout0_46ck154 = 0 time = 775
.meas tran vdout0_46ck154 FIND v(dout0_46) AT=775.025n

* CHECK dout0_47 Vdout0_47ck154 = 0 time = 775
.meas tran vdout0_47ck154 FIND v(dout0_47) AT=775.025n

* CHECK dout0_48 Vdout0_48ck154 = 0 time = 775
.meas tran vdout0_48ck154 FIND v(dout0_48) AT=775.025n

* CHECK dout0_49 Vdout0_49ck154 = 0.9 time = 775
.meas tran vdout0_49ck154 FIND v(dout0_49) AT=775.025n

* CHECK dout0_50 Vdout0_50ck154 = 0 time = 775
.meas tran vdout0_50ck154 FIND v(dout0_50) AT=775.025n

* CHECK dout0_51 Vdout0_51ck154 = 0.9 time = 775
.meas tran vdout0_51ck154 FIND v(dout0_51) AT=775.025n

* CHECK dout0_52 Vdout0_52ck154 = 0 time = 775
.meas tran vdout0_52ck154 FIND v(dout0_52) AT=775.025n

* CHECK dout0_53 Vdout0_53ck154 = 0.9 time = 775
.meas tran vdout0_53ck154 FIND v(dout0_53) AT=775.025n

* CHECK dout0_54 Vdout0_54ck154 = 0.9 time = 775
.meas tran vdout0_54ck154 FIND v(dout0_54) AT=775.025n

* CHECK dout0_55 Vdout0_55ck154 = 0 time = 775
.meas tran vdout0_55ck154 FIND v(dout0_55) AT=775.025n

* CHECK dout0_56 Vdout0_56ck154 = 0.9 time = 775
.meas tran vdout0_56ck154 FIND v(dout0_56) AT=775.025n

* CHECK dout0_57 Vdout0_57ck154 = 0.9 time = 775
.meas tran vdout0_57ck154 FIND v(dout0_57) AT=775.025n

* CHECK dout0_58 Vdout0_58ck154 = 0.9 time = 775
.meas tran vdout0_58ck154 FIND v(dout0_58) AT=775.025n

* CHECK dout0_59 Vdout0_59ck154 = 0 time = 775
.meas tran vdout0_59ck154 FIND v(dout0_59) AT=775.025n

* CHECK dout0_60 Vdout0_60ck154 = 0 time = 775
.meas tran vdout0_60ck154 FIND v(dout0_60) AT=775.025n

* CHECK dout0_61 Vdout0_61ck154 = 0.9 time = 775
.meas tran vdout0_61ck154 FIND v(dout0_61) AT=775.025n

* CHECK dout0_62 Vdout0_62ck154 = 0.9 time = 775
.meas tran vdout0_62ck154 FIND v(dout0_62) AT=775.025n

* CHECK dout0_63 Vdout0_63ck154 = 0 time = 775
.meas tran vdout0_63ck154 FIND v(dout0_63) AT=775.025n

* CHECK dout0_0 Vdout0_0ck156 = 0 time = 785
.meas tran vdout0_0ck156 FIND v(dout0_0) AT=785.025n

* CHECK dout0_1 Vdout0_1ck156 = 0 time = 785
.meas tran vdout0_1ck156 FIND v(dout0_1) AT=785.025n

* CHECK dout0_2 Vdout0_2ck156 = 0 time = 785
.meas tran vdout0_2ck156 FIND v(dout0_2) AT=785.025n

* CHECK dout0_3 Vdout0_3ck156 = 0.9 time = 785
.meas tran vdout0_3ck156 FIND v(dout0_3) AT=785.025n

* CHECK dout0_4 Vdout0_4ck156 = 0 time = 785
.meas tran vdout0_4ck156 FIND v(dout0_4) AT=785.025n

* CHECK dout0_5 Vdout0_5ck156 = 0 time = 785
.meas tran vdout0_5ck156 FIND v(dout0_5) AT=785.025n

* CHECK dout0_6 Vdout0_6ck156 = 0 time = 785
.meas tran vdout0_6ck156 FIND v(dout0_6) AT=785.025n

* CHECK dout0_7 Vdout0_7ck156 = 0 time = 785
.meas tran vdout0_7ck156 FIND v(dout0_7) AT=785.025n

* CHECK dout0_8 Vdout0_8ck156 = 0.9 time = 785
.meas tran vdout0_8ck156 FIND v(dout0_8) AT=785.025n

* CHECK dout0_9 Vdout0_9ck156 = 0 time = 785
.meas tran vdout0_9ck156 FIND v(dout0_9) AT=785.025n

* CHECK dout0_10 Vdout0_10ck156 = 0.9 time = 785
.meas tran vdout0_10ck156 FIND v(dout0_10) AT=785.025n

* CHECK dout0_11 Vdout0_11ck156 = 0 time = 785
.meas tran vdout0_11ck156 FIND v(dout0_11) AT=785.025n

* CHECK dout0_12 Vdout0_12ck156 = 0 time = 785
.meas tran vdout0_12ck156 FIND v(dout0_12) AT=785.025n

* CHECK dout0_13 Vdout0_13ck156 = 0.9 time = 785
.meas tran vdout0_13ck156 FIND v(dout0_13) AT=785.025n

* CHECK dout0_14 Vdout0_14ck156 = 0.9 time = 785
.meas tran vdout0_14ck156 FIND v(dout0_14) AT=785.025n

* CHECK dout0_15 Vdout0_15ck156 = 0.9 time = 785
.meas tran vdout0_15ck156 FIND v(dout0_15) AT=785.025n

* CHECK dout0_16 Vdout0_16ck156 = 0 time = 785
.meas tran vdout0_16ck156 FIND v(dout0_16) AT=785.025n

* CHECK dout0_17 Vdout0_17ck156 = 0.9 time = 785
.meas tran vdout0_17ck156 FIND v(dout0_17) AT=785.025n

* CHECK dout0_18 Vdout0_18ck156 = 0 time = 785
.meas tran vdout0_18ck156 FIND v(dout0_18) AT=785.025n

* CHECK dout0_19 Vdout0_19ck156 = 0.9 time = 785
.meas tran vdout0_19ck156 FIND v(dout0_19) AT=785.025n

* CHECK dout0_20 Vdout0_20ck156 = 0 time = 785
.meas tran vdout0_20ck156 FIND v(dout0_20) AT=785.025n

* CHECK dout0_21 Vdout0_21ck156 = 0 time = 785
.meas tran vdout0_21ck156 FIND v(dout0_21) AT=785.025n

* CHECK dout0_22 Vdout0_22ck156 = 0.9 time = 785
.meas tran vdout0_22ck156 FIND v(dout0_22) AT=785.025n

* CHECK dout0_23 Vdout0_23ck156 = 0.9 time = 785
.meas tran vdout0_23ck156 FIND v(dout0_23) AT=785.025n

* CHECK dout0_24 Vdout0_24ck156 = 0 time = 785
.meas tran vdout0_24ck156 FIND v(dout0_24) AT=785.025n

* CHECK dout0_25 Vdout0_25ck156 = 0 time = 785
.meas tran vdout0_25ck156 FIND v(dout0_25) AT=785.025n

* CHECK dout0_26 Vdout0_26ck156 = 0.9 time = 785
.meas tran vdout0_26ck156 FIND v(dout0_26) AT=785.025n

* CHECK dout0_27 Vdout0_27ck156 = 0 time = 785
.meas tran vdout0_27ck156 FIND v(dout0_27) AT=785.025n

* CHECK dout0_28 Vdout0_28ck156 = 0 time = 785
.meas tran vdout0_28ck156 FIND v(dout0_28) AT=785.025n

* CHECK dout0_29 Vdout0_29ck156 = 0.9 time = 785
.meas tran vdout0_29ck156 FIND v(dout0_29) AT=785.025n

* CHECK dout0_30 Vdout0_30ck156 = 0 time = 785
.meas tran vdout0_30ck156 FIND v(dout0_30) AT=785.025n

* CHECK dout0_31 Vdout0_31ck156 = 0 time = 785
.meas tran vdout0_31ck156 FIND v(dout0_31) AT=785.025n

* CHECK dout0_32 Vdout0_32ck156 = 0.9 time = 785
.meas tran vdout0_32ck156 FIND v(dout0_32) AT=785.025n

* CHECK dout0_33 Vdout0_33ck156 = 0 time = 785
.meas tran vdout0_33ck156 FIND v(dout0_33) AT=785.025n

* CHECK dout0_34 Vdout0_34ck156 = 0.9 time = 785
.meas tran vdout0_34ck156 FIND v(dout0_34) AT=785.025n

* CHECK dout0_35 Vdout0_35ck156 = 0.9 time = 785
.meas tran vdout0_35ck156 FIND v(dout0_35) AT=785.025n

* CHECK dout0_36 Vdout0_36ck156 = 0.9 time = 785
.meas tran vdout0_36ck156 FIND v(dout0_36) AT=785.025n

* CHECK dout0_37 Vdout0_37ck156 = 0 time = 785
.meas tran vdout0_37ck156 FIND v(dout0_37) AT=785.025n

* CHECK dout0_38 Vdout0_38ck156 = 0.9 time = 785
.meas tran vdout0_38ck156 FIND v(dout0_38) AT=785.025n

* CHECK dout0_39 Vdout0_39ck156 = 0 time = 785
.meas tran vdout0_39ck156 FIND v(dout0_39) AT=785.025n

* CHECK dout0_40 Vdout0_40ck156 = 0.9 time = 785
.meas tran vdout0_40ck156 FIND v(dout0_40) AT=785.025n

* CHECK dout0_41 Vdout0_41ck156 = 0.9 time = 785
.meas tran vdout0_41ck156 FIND v(dout0_41) AT=785.025n

* CHECK dout0_42 Vdout0_42ck156 = 0 time = 785
.meas tran vdout0_42ck156 FIND v(dout0_42) AT=785.025n

* CHECK dout0_43 Vdout0_43ck156 = 0 time = 785
.meas tran vdout0_43ck156 FIND v(dout0_43) AT=785.025n

* CHECK dout0_44 Vdout0_44ck156 = 0.9 time = 785
.meas tran vdout0_44ck156 FIND v(dout0_44) AT=785.025n

* CHECK dout0_45 Vdout0_45ck156 = 0 time = 785
.meas tran vdout0_45ck156 FIND v(dout0_45) AT=785.025n

* CHECK dout0_46 Vdout0_46ck156 = 0 time = 785
.meas tran vdout0_46ck156 FIND v(dout0_46) AT=785.025n

* CHECK dout0_47 Vdout0_47ck156 = 0 time = 785
.meas tran vdout0_47ck156 FIND v(dout0_47) AT=785.025n

* CHECK dout0_48 Vdout0_48ck156 = 0 time = 785
.meas tran vdout0_48ck156 FIND v(dout0_48) AT=785.025n

* CHECK dout0_49 Vdout0_49ck156 = 0.9 time = 785
.meas tran vdout0_49ck156 FIND v(dout0_49) AT=785.025n

* CHECK dout0_50 Vdout0_50ck156 = 0.9 time = 785
.meas tran vdout0_50ck156 FIND v(dout0_50) AT=785.025n

* CHECK dout0_51 Vdout0_51ck156 = 0 time = 785
.meas tran vdout0_51ck156 FIND v(dout0_51) AT=785.025n

* CHECK dout0_52 Vdout0_52ck156 = 0 time = 785
.meas tran vdout0_52ck156 FIND v(dout0_52) AT=785.025n

* CHECK dout0_53 Vdout0_53ck156 = 0.9 time = 785
.meas tran vdout0_53ck156 FIND v(dout0_53) AT=785.025n

* CHECK dout0_54 Vdout0_54ck156 = 0 time = 785
.meas tran vdout0_54ck156 FIND v(dout0_54) AT=785.025n

* CHECK dout0_55 Vdout0_55ck156 = 0 time = 785
.meas tran vdout0_55ck156 FIND v(dout0_55) AT=785.025n

* CHECK dout0_56 Vdout0_56ck156 = 0.9 time = 785
.meas tran vdout0_56ck156 FIND v(dout0_56) AT=785.025n

* CHECK dout0_57 Vdout0_57ck156 = 0 time = 785
.meas tran vdout0_57ck156 FIND v(dout0_57) AT=785.025n

* CHECK dout0_58 Vdout0_58ck156 = 0 time = 785
.meas tran vdout0_58ck156 FIND v(dout0_58) AT=785.025n

* CHECK dout0_59 Vdout0_59ck156 = 0.9 time = 785
.meas tran vdout0_59ck156 FIND v(dout0_59) AT=785.025n

* CHECK dout0_60 Vdout0_60ck156 = 0 time = 785
.meas tran vdout0_60ck156 FIND v(dout0_60) AT=785.025n

* CHECK dout0_61 Vdout0_61ck156 = 0.9 time = 785
.meas tran vdout0_61ck156 FIND v(dout0_61) AT=785.025n

* CHECK dout0_62 Vdout0_62ck156 = 0.9 time = 785
.meas tran vdout0_62ck156 FIND v(dout0_62) AT=785.025n

* CHECK dout0_63 Vdout0_63ck156 = 0.9 time = 785
.meas tran vdout0_63ck156 FIND v(dout0_63) AT=785.025n

* CHECK dout0_0 Vdout0_0ck158 = 0 time = 795
.meas tran vdout0_0ck158 FIND v(dout0_0) AT=795.025n

* CHECK dout0_1 Vdout0_1ck158 = 0 time = 795
.meas tran vdout0_1ck158 FIND v(dout0_1) AT=795.025n

* CHECK dout0_2 Vdout0_2ck158 = 0 time = 795
.meas tran vdout0_2ck158 FIND v(dout0_2) AT=795.025n

* CHECK dout0_3 Vdout0_3ck158 = 0.9 time = 795
.meas tran vdout0_3ck158 FIND v(dout0_3) AT=795.025n

* CHECK dout0_4 Vdout0_4ck158 = 0 time = 795
.meas tran vdout0_4ck158 FIND v(dout0_4) AT=795.025n

* CHECK dout0_5 Vdout0_5ck158 = 0 time = 795
.meas tran vdout0_5ck158 FIND v(dout0_5) AT=795.025n

* CHECK dout0_6 Vdout0_6ck158 = 0 time = 795
.meas tran vdout0_6ck158 FIND v(dout0_6) AT=795.025n

* CHECK dout0_7 Vdout0_7ck158 = 0 time = 795
.meas tran vdout0_7ck158 FIND v(dout0_7) AT=795.025n

* CHECK dout0_8 Vdout0_8ck158 = 0.9 time = 795
.meas tran vdout0_8ck158 FIND v(dout0_8) AT=795.025n

* CHECK dout0_9 Vdout0_9ck158 = 0 time = 795
.meas tran vdout0_9ck158 FIND v(dout0_9) AT=795.025n

* CHECK dout0_10 Vdout0_10ck158 = 0.9 time = 795
.meas tran vdout0_10ck158 FIND v(dout0_10) AT=795.025n

* CHECK dout0_11 Vdout0_11ck158 = 0 time = 795
.meas tran vdout0_11ck158 FIND v(dout0_11) AT=795.025n

* CHECK dout0_12 Vdout0_12ck158 = 0 time = 795
.meas tran vdout0_12ck158 FIND v(dout0_12) AT=795.025n

* CHECK dout0_13 Vdout0_13ck158 = 0.9 time = 795
.meas tran vdout0_13ck158 FIND v(dout0_13) AT=795.025n

* CHECK dout0_14 Vdout0_14ck158 = 0.9 time = 795
.meas tran vdout0_14ck158 FIND v(dout0_14) AT=795.025n

* CHECK dout0_15 Vdout0_15ck158 = 0.9 time = 795
.meas tran vdout0_15ck158 FIND v(dout0_15) AT=795.025n

* CHECK dout0_16 Vdout0_16ck158 = 0 time = 795
.meas tran vdout0_16ck158 FIND v(dout0_16) AT=795.025n

* CHECK dout0_17 Vdout0_17ck158 = 0.9 time = 795
.meas tran vdout0_17ck158 FIND v(dout0_17) AT=795.025n

* CHECK dout0_18 Vdout0_18ck158 = 0 time = 795
.meas tran vdout0_18ck158 FIND v(dout0_18) AT=795.025n

* CHECK dout0_19 Vdout0_19ck158 = 0.9 time = 795
.meas tran vdout0_19ck158 FIND v(dout0_19) AT=795.025n

* CHECK dout0_20 Vdout0_20ck158 = 0 time = 795
.meas tran vdout0_20ck158 FIND v(dout0_20) AT=795.025n

* CHECK dout0_21 Vdout0_21ck158 = 0 time = 795
.meas tran vdout0_21ck158 FIND v(dout0_21) AT=795.025n

* CHECK dout0_22 Vdout0_22ck158 = 0.9 time = 795
.meas tran vdout0_22ck158 FIND v(dout0_22) AT=795.025n

* CHECK dout0_23 Vdout0_23ck158 = 0.9 time = 795
.meas tran vdout0_23ck158 FIND v(dout0_23) AT=795.025n

* CHECK dout0_24 Vdout0_24ck158 = 0 time = 795
.meas tran vdout0_24ck158 FIND v(dout0_24) AT=795.025n

* CHECK dout0_25 Vdout0_25ck158 = 0 time = 795
.meas tran vdout0_25ck158 FIND v(dout0_25) AT=795.025n

* CHECK dout0_26 Vdout0_26ck158 = 0.9 time = 795
.meas tran vdout0_26ck158 FIND v(dout0_26) AT=795.025n

* CHECK dout0_27 Vdout0_27ck158 = 0 time = 795
.meas tran vdout0_27ck158 FIND v(dout0_27) AT=795.025n

* CHECK dout0_28 Vdout0_28ck158 = 0 time = 795
.meas tran vdout0_28ck158 FIND v(dout0_28) AT=795.025n

* CHECK dout0_29 Vdout0_29ck158 = 0.9 time = 795
.meas tran vdout0_29ck158 FIND v(dout0_29) AT=795.025n

* CHECK dout0_30 Vdout0_30ck158 = 0 time = 795
.meas tran vdout0_30ck158 FIND v(dout0_30) AT=795.025n

* CHECK dout0_31 Vdout0_31ck158 = 0 time = 795
.meas tran vdout0_31ck158 FIND v(dout0_31) AT=795.025n

* CHECK dout0_32 Vdout0_32ck158 = 0.9 time = 795
.meas tran vdout0_32ck158 FIND v(dout0_32) AT=795.025n

* CHECK dout0_33 Vdout0_33ck158 = 0 time = 795
.meas tran vdout0_33ck158 FIND v(dout0_33) AT=795.025n

* CHECK dout0_34 Vdout0_34ck158 = 0.9 time = 795
.meas tran vdout0_34ck158 FIND v(dout0_34) AT=795.025n

* CHECK dout0_35 Vdout0_35ck158 = 0.9 time = 795
.meas tran vdout0_35ck158 FIND v(dout0_35) AT=795.025n

* CHECK dout0_36 Vdout0_36ck158 = 0.9 time = 795
.meas tran vdout0_36ck158 FIND v(dout0_36) AT=795.025n

* CHECK dout0_37 Vdout0_37ck158 = 0 time = 795
.meas tran vdout0_37ck158 FIND v(dout0_37) AT=795.025n

* CHECK dout0_38 Vdout0_38ck158 = 0.9 time = 795
.meas tran vdout0_38ck158 FIND v(dout0_38) AT=795.025n

* CHECK dout0_39 Vdout0_39ck158 = 0 time = 795
.meas tran vdout0_39ck158 FIND v(dout0_39) AT=795.025n

* CHECK dout0_40 Vdout0_40ck158 = 0.9 time = 795
.meas tran vdout0_40ck158 FIND v(dout0_40) AT=795.025n

* CHECK dout0_41 Vdout0_41ck158 = 0.9 time = 795
.meas tran vdout0_41ck158 FIND v(dout0_41) AT=795.025n

* CHECK dout0_42 Vdout0_42ck158 = 0 time = 795
.meas tran vdout0_42ck158 FIND v(dout0_42) AT=795.025n

* CHECK dout0_43 Vdout0_43ck158 = 0 time = 795
.meas tran vdout0_43ck158 FIND v(dout0_43) AT=795.025n

* CHECK dout0_44 Vdout0_44ck158 = 0.9 time = 795
.meas tran vdout0_44ck158 FIND v(dout0_44) AT=795.025n

* CHECK dout0_45 Vdout0_45ck158 = 0 time = 795
.meas tran vdout0_45ck158 FIND v(dout0_45) AT=795.025n

* CHECK dout0_46 Vdout0_46ck158 = 0 time = 795
.meas tran vdout0_46ck158 FIND v(dout0_46) AT=795.025n

* CHECK dout0_47 Vdout0_47ck158 = 0 time = 795
.meas tran vdout0_47ck158 FIND v(dout0_47) AT=795.025n

* CHECK dout0_48 Vdout0_48ck158 = 0 time = 795
.meas tran vdout0_48ck158 FIND v(dout0_48) AT=795.025n

* CHECK dout0_49 Vdout0_49ck158 = 0.9 time = 795
.meas tran vdout0_49ck158 FIND v(dout0_49) AT=795.025n

* CHECK dout0_50 Vdout0_50ck158 = 0.9 time = 795
.meas tran vdout0_50ck158 FIND v(dout0_50) AT=795.025n

* CHECK dout0_51 Vdout0_51ck158 = 0 time = 795
.meas tran vdout0_51ck158 FIND v(dout0_51) AT=795.025n

* CHECK dout0_52 Vdout0_52ck158 = 0 time = 795
.meas tran vdout0_52ck158 FIND v(dout0_52) AT=795.025n

* CHECK dout0_53 Vdout0_53ck158 = 0.9 time = 795
.meas tran vdout0_53ck158 FIND v(dout0_53) AT=795.025n

* CHECK dout0_54 Vdout0_54ck158 = 0 time = 795
.meas tran vdout0_54ck158 FIND v(dout0_54) AT=795.025n

* CHECK dout0_55 Vdout0_55ck158 = 0 time = 795
.meas tran vdout0_55ck158 FIND v(dout0_55) AT=795.025n

* CHECK dout0_56 Vdout0_56ck158 = 0.9 time = 795
.meas tran vdout0_56ck158 FIND v(dout0_56) AT=795.025n

* CHECK dout0_57 Vdout0_57ck158 = 0 time = 795
.meas tran vdout0_57ck158 FIND v(dout0_57) AT=795.025n

* CHECK dout0_58 Vdout0_58ck158 = 0 time = 795
.meas tran vdout0_58ck158 FIND v(dout0_58) AT=795.025n

* CHECK dout0_59 Vdout0_59ck158 = 0.9 time = 795
.meas tran vdout0_59ck158 FIND v(dout0_59) AT=795.025n

* CHECK dout0_60 Vdout0_60ck158 = 0 time = 795
.meas tran vdout0_60ck158 FIND v(dout0_60) AT=795.025n

* CHECK dout0_61 Vdout0_61ck158 = 0.9 time = 795
.meas tran vdout0_61ck158 FIND v(dout0_61) AT=795.025n

* CHECK dout0_62 Vdout0_62ck158 = 0.9 time = 795
.meas tran vdout0_62ck158 FIND v(dout0_62) AT=795.025n

* CHECK dout0_63 Vdout0_63ck158 = 0.9 time = 795
.meas tran vdout0_63ck158 FIND v(dout0_63) AT=795.025n

* CHECK dout0_0 Vdout0_0ck163 = 0.9 time = 820
.meas tran vdout0_0ck163 FIND v(dout0_0) AT=820.025n

* CHECK dout0_1 Vdout0_1ck163 = 0 time = 820
.meas tran vdout0_1ck163 FIND v(dout0_1) AT=820.025n

* CHECK dout0_2 Vdout0_2ck163 = 0.9 time = 820
.meas tran vdout0_2ck163 FIND v(dout0_2) AT=820.025n

* CHECK dout0_3 Vdout0_3ck163 = 0 time = 820
.meas tran vdout0_3ck163 FIND v(dout0_3) AT=820.025n

* CHECK dout0_4 Vdout0_4ck163 = 0 time = 820
.meas tran vdout0_4ck163 FIND v(dout0_4) AT=820.025n

* CHECK dout0_5 Vdout0_5ck163 = 0 time = 820
.meas tran vdout0_5ck163 FIND v(dout0_5) AT=820.025n

* CHECK dout0_6 Vdout0_6ck163 = 0.9 time = 820
.meas tran vdout0_6ck163 FIND v(dout0_6) AT=820.025n

* CHECK dout0_7 Vdout0_7ck163 = 0 time = 820
.meas tran vdout0_7ck163 FIND v(dout0_7) AT=820.025n

* CHECK dout0_8 Vdout0_8ck163 = 0 time = 820
.meas tran vdout0_8ck163 FIND v(dout0_8) AT=820.025n

* CHECK dout0_9 Vdout0_9ck163 = 0 time = 820
.meas tran vdout0_9ck163 FIND v(dout0_9) AT=820.025n

* CHECK dout0_10 Vdout0_10ck163 = 0 time = 820
.meas tran vdout0_10ck163 FIND v(dout0_10) AT=820.025n

* CHECK dout0_11 Vdout0_11ck163 = 0.9 time = 820
.meas tran vdout0_11ck163 FIND v(dout0_11) AT=820.025n

* CHECK dout0_12 Vdout0_12ck163 = 0 time = 820
.meas tran vdout0_12ck163 FIND v(dout0_12) AT=820.025n

* CHECK dout0_13 Vdout0_13ck163 = 0 time = 820
.meas tran vdout0_13ck163 FIND v(dout0_13) AT=820.025n

* CHECK dout0_14 Vdout0_14ck163 = 0 time = 820
.meas tran vdout0_14ck163 FIND v(dout0_14) AT=820.025n

* CHECK dout0_15 Vdout0_15ck163 = 0 time = 820
.meas tran vdout0_15ck163 FIND v(dout0_15) AT=820.025n

* CHECK dout0_16 Vdout0_16ck163 = 0.9 time = 820
.meas tran vdout0_16ck163 FIND v(dout0_16) AT=820.025n

* CHECK dout0_17 Vdout0_17ck163 = 0.9 time = 820
.meas tran vdout0_17ck163 FIND v(dout0_17) AT=820.025n

* CHECK dout0_18 Vdout0_18ck163 = 0 time = 820
.meas tran vdout0_18ck163 FIND v(dout0_18) AT=820.025n

* CHECK dout0_19 Vdout0_19ck163 = 0.9 time = 820
.meas tran vdout0_19ck163 FIND v(dout0_19) AT=820.025n

* CHECK dout0_20 Vdout0_20ck163 = 0.9 time = 820
.meas tran vdout0_20ck163 FIND v(dout0_20) AT=820.025n

* CHECK dout0_21 Vdout0_21ck163 = 0.9 time = 820
.meas tran vdout0_21ck163 FIND v(dout0_21) AT=820.025n

* CHECK dout0_22 Vdout0_22ck163 = 0.9 time = 820
.meas tran vdout0_22ck163 FIND v(dout0_22) AT=820.025n

* CHECK dout0_23 Vdout0_23ck163 = 0.9 time = 820
.meas tran vdout0_23ck163 FIND v(dout0_23) AT=820.025n

* CHECK dout0_24 Vdout0_24ck163 = 0 time = 820
.meas tran vdout0_24ck163 FIND v(dout0_24) AT=820.025n

* CHECK dout0_25 Vdout0_25ck163 = 0 time = 820
.meas tran vdout0_25ck163 FIND v(dout0_25) AT=820.025n

* CHECK dout0_26 Vdout0_26ck163 = 0.9 time = 820
.meas tran vdout0_26ck163 FIND v(dout0_26) AT=820.025n

* CHECK dout0_27 Vdout0_27ck163 = 0 time = 820
.meas tran vdout0_27ck163 FIND v(dout0_27) AT=820.025n

* CHECK dout0_28 Vdout0_28ck163 = 0 time = 820
.meas tran vdout0_28ck163 FIND v(dout0_28) AT=820.025n

* CHECK dout0_29 Vdout0_29ck163 = 0.9 time = 820
.meas tran vdout0_29ck163 FIND v(dout0_29) AT=820.025n

* CHECK dout0_30 Vdout0_30ck163 = 0 time = 820
.meas tran vdout0_30ck163 FIND v(dout0_30) AT=820.025n

* CHECK dout0_31 Vdout0_31ck163 = 0 time = 820
.meas tran vdout0_31ck163 FIND v(dout0_31) AT=820.025n

* CHECK dout0_32 Vdout0_32ck163 = 0 time = 820
.meas tran vdout0_32ck163 FIND v(dout0_32) AT=820.025n

* CHECK dout0_33 Vdout0_33ck163 = 0.9 time = 820
.meas tran vdout0_33ck163 FIND v(dout0_33) AT=820.025n

* CHECK dout0_34 Vdout0_34ck163 = 0 time = 820
.meas tran vdout0_34ck163 FIND v(dout0_34) AT=820.025n

* CHECK dout0_35 Vdout0_35ck163 = 0 time = 820
.meas tran vdout0_35ck163 FIND v(dout0_35) AT=820.025n

* CHECK dout0_36 Vdout0_36ck163 = 0.9 time = 820
.meas tran vdout0_36ck163 FIND v(dout0_36) AT=820.025n

* CHECK dout0_37 Vdout0_37ck163 = 0.9 time = 820
.meas tran vdout0_37ck163 FIND v(dout0_37) AT=820.025n

* CHECK dout0_38 Vdout0_38ck163 = 0 time = 820
.meas tran vdout0_38ck163 FIND v(dout0_38) AT=820.025n

* CHECK dout0_39 Vdout0_39ck163 = 0.9 time = 820
.meas tran vdout0_39ck163 FIND v(dout0_39) AT=820.025n

* CHECK dout0_40 Vdout0_40ck163 = 0.9 time = 820
.meas tran vdout0_40ck163 FIND v(dout0_40) AT=820.025n

* CHECK dout0_41 Vdout0_41ck163 = 0.9 time = 820
.meas tran vdout0_41ck163 FIND v(dout0_41) AT=820.025n

* CHECK dout0_42 Vdout0_42ck163 = 0.9 time = 820
.meas tran vdout0_42ck163 FIND v(dout0_42) AT=820.025n

* CHECK dout0_43 Vdout0_43ck163 = 0 time = 820
.meas tran vdout0_43ck163 FIND v(dout0_43) AT=820.025n

* CHECK dout0_44 Vdout0_44ck163 = 0 time = 820
.meas tran vdout0_44ck163 FIND v(dout0_44) AT=820.025n

* CHECK dout0_45 Vdout0_45ck163 = 0 time = 820
.meas tran vdout0_45ck163 FIND v(dout0_45) AT=820.025n

* CHECK dout0_46 Vdout0_46ck163 = 0 time = 820
.meas tran vdout0_46ck163 FIND v(dout0_46) AT=820.025n

* CHECK dout0_47 Vdout0_47ck163 = 0.9 time = 820
.meas tran vdout0_47ck163 FIND v(dout0_47) AT=820.025n

* CHECK dout0_48 Vdout0_48ck163 = 0 time = 820
.meas tran vdout0_48ck163 FIND v(dout0_48) AT=820.025n

* CHECK dout0_49 Vdout0_49ck163 = 0.9 time = 820
.meas tran vdout0_49ck163 FIND v(dout0_49) AT=820.025n

* CHECK dout0_50 Vdout0_50ck163 = 0.9 time = 820
.meas tran vdout0_50ck163 FIND v(dout0_50) AT=820.025n

* CHECK dout0_51 Vdout0_51ck163 = 0.9 time = 820
.meas tran vdout0_51ck163 FIND v(dout0_51) AT=820.025n

* CHECK dout0_52 Vdout0_52ck163 = 0 time = 820
.meas tran vdout0_52ck163 FIND v(dout0_52) AT=820.025n

* CHECK dout0_53 Vdout0_53ck163 = 0 time = 820
.meas tran vdout0_53ck163 FIND v(dout0_53) AT=820.025n

* CHECK dout0_54 Vdout0_54ck163 = 0 time = 820
.meas tran vdout0_54ck163 FIND v(dout0_54) AT=820.025n

* CHECK dout0_55 Vdout0_55ck163 = 0.9 time = 820
.meas tran vdout0_55ck163 FIND v(dout0_55) AT=820.025n

* CHECK dout0_56 Vdout0_56ck163 = 0 time = 820
.meas tran vdout0_56ck163 FIND v(dout0_56) AT=820.025n

* CHECK dout0_57 Vdout0_57ck163 = 0 time = 820
.meas tran vdout0_57ck163 FIND v(dout0_57) AT=820.025n

* CHECK dout0_58 Vdout0_58ck163 = 0 time = 820
.meas tran vdout0_58ck163 FIND v(dout0_58) AT=820.025n

* CHECK dout0_59 Vdout0_59ck163 = 0.9 time = 820
.meas tran vdout0_59ck163 FIND v(dout0_59) AT=820.025n

* CHECK dout0_60 Vdout0_60ck163 = 0 time = 820
.meas tran vdout0_60ck163 FIND v(dout0_60) AT=820.025n

* CHECK dout0_61 Vdout0_61ck163 = 0.9 time = 820
.meas tran vdout0_61ck163 FIND v(dout0_61) AT=820.025n

* CHECK dout0_62 Vdout0_62ck163 = 0 time = 820
.meas tran vdout0_62ck163 FIND v(dout0_62) AT=820.025n

* CHECK dout0_63 Vdout0_63ck163 = 0 time = 820
.meas tran vdout0_63ck163 FIND v(dout0_63) AT=820.025n

* CHECK dout0_0 Vdout0_0ck164 = 0.9 time = 825
.meas tran vdout0_0ck164 FIND v(dout0_0) AT=825.025n

* CHECK dout0_1 Vdout0_1ck164 = 0 time = 825
.meas tran vdout0_1ck164 FIND v(dout0_1) AT=825.025n

* CHECK dout0_2 Vdout0_2ck164 = 0.9 time = 825
.meas tran vdout0_2ck164 FIND v(dout0_2) AT=825.025n

* CHECK dout0_3 Vdout0_3ck164 = 0 time = 825
.meas tran vdout0_3ck164 FIND v(dout0_3) AT=825.025n

* CHECK dout0_4 Vdout0_4ck164 = 0 time = 825
.meas tran vdout0_4ck164 FIND v(dout0_4) AT=825.025n

* CHECK dout0_5 Vdout0_5ck164 = 0 time = 825
.meas tran vdout0_5ck164 FIND v(dout0_5) AT=825.025n

* CHECK dout0_6 Vdout0_6ck164 = 0.9 time = 825
.meas tran vdout0_6ck164 FIND v(dout0_6) AT=825.025n

* CHECK dout0_7 Vdout0_7ck164 = 0 time = 825
.meas tran vdout0_7ck164 FIND v(dout0_7) AT=825.025n

* CHECK dout0_8 Vdout0_8ck164 = 0 time = 825
.meas tran vdout0_8ck164 FIND v(dout0_8) AT=825.025n

* CHECK dout0_9 Vdout0_9ck164 = 0 time = 825
.meas tran vdout0_9ck164 FIND v(dout0_9) AT=825.025n

* CHECK dout0_10 Vdout0_10ck164 = 0 time = 825
.meas tran vdout0_10ck164 FIND v(dout0_10) AT=825.025n

* CHECK dout0_11 Vdout0_11ck164 = 0.9 time = 825
.meas tran vdout0_11ck164 FIND v(dout0_11) AT=825.025n

* CHECK dout0_12 Vdout0_12ck164 = 0 time = 825
.meas tran vdout0_12ck164 FIND v(dout0_12) AT=825.025n

* CHECK dout0_13 Vdout0_13ck164 = 0 time = 825
.meas tran vdout0_13ck164 FIND v(dout0_13) AT=825.025n

* CHECK dout0_14 Vdout0_14ck164 = 0 time = 825
.meas tran vdout0_14ck164 FIND v(dout0_14) AT=825.025n

* CHECK dout0_15 Vdout0_15ck164 = 0 time = 825
.meas tran vdout0_15ck164 FIND v(dout0_15) AT=825.025n

* CHECK dout0_16 Vdout0_16ck164 = 0.9 time = 825
.meas tran vdout0_16ck164 FIND v(dout0_16) AT=825.025n

* CHECK dout0_17 Vdout0_17ck164 = 0.9 time = 825
.meas tran vdout0_17ck164 FIND v(dout0_17) AT=825.025n

* CHECK dout0_18 Vdout0_18ck164 = 0 time = 825
.meas tran vdout0_18ck164 FIND v(dout0_18) AT=825.025n

* CHECK dout0_19 Vdout0_19ck164 = 0.9 time = 825
.meas tran vdout0_19ck164 FIND v(dout0_19) AT=825.025n

* CHECK dout0_20 Vdout0_20ck164 = 0.9 time = 825
.meas tran vdout0_20ck164 FIND v(dout0_20) AT=825.025n

* CHECK dout0_21 Vdout0_21ck164 = 0.9 time = 825
.meas tran vdout0_21ck164 FIND v(dout0_21) AT=825.025n

* CHECK dout0_22 Vdout0_22ck164 = 0.9 time = 825
.meas tran vdout0_22ck164 FIND v(dout0_22) AT=825.025n

* CHECK dout0_23 Vdout0_23ck164 = 0.9 time = 825
.meas tran vdout0_23ck164 FIND v(dout0_23) AT=825.025n

* CHECK dout0_24 Vdout0_24ck164 = 0 time = 825
.meas tran vdout0_24ck164 FIND v(dout0_24) AT=825.025n

* CHECK dout0_25 Vdout0_25ck164 = 0 time = 825
.meas tran vdout0_25ck164 FIND v(dout0_25) AT=825.025n

* CHECK dout0_26 Vdout0_26ck164 = 0.9 time = 825
.meas tran vdout0_26ck164 FIND v(dout0_26) AT=825.025n

* CHECK dout0_27 Vdout0_27ck164 = 0 time = 825
.meas tran vdout0_27ck164 FIND v(dout0_27) AT=825.025n

* CHECK dout0_28 Vdout0_28ck164 = 0 time = 825
.meas tran vdout0_28ck164 FIND v(dout0_28) AT=825.025n

* CHECK dout0_29 Vdout0_29ck164 = 0.9 time = 825
.meas tran vdout0_29ck164 FIND v(dout0_29) AT=825.025n

* CHECK dout0_30 Vdout0_30ck164 = 0 time = 825
.meas tran vdout0_30ck164 FIND v(dout0_30) AT=825.025n

* CHECK dout0_31 Vdout0_31ck164 = 0 time = 825
.meas tran vdout0_31ck164 FIND v(dout0_31) AT=825.025n

* CHECK dout0_32 Vdout0_32ck164 = 0 time = 825
.meas tran vdout0_32ck164 FIND v(dout0_32) AT=825.025n

* CHECK dout0_33 Vdout0_33ck164 = 0.9 time = 825
.meas tran vdout0_33ck164 FIND v(dout0_33) AT=825.025n

* CHECK dout0_34 Vdout0_34ck164 = 0 time = 825
.meas tran vdout0_34ck164 FIND v(dout0_34) AT=825.025n

* CHECK dout0_35 Vdout0_35ck164 = 0 time = 825
.meas tran vdout0_35ck164 FIND v(dout0_35) AT=825.025n

* CHECK dout0_36 Vdout0_36ck164 = 0.9 time = 825
.meas tran vdout0_36ck164 FIND v(dout0_36) AT=825.025n

* CHECK dout0_37 Vdout0_37ck164 = 0.9 time = 825
.meas tran vdout0_37ck164 FIND v(dout0_37) AT=825.025n

* CHECK dout0_38 Vdout0_38ck164 = 0 time = 825
.meas tran vdout0_38ck164 FIND v(dout0_38) AT=825.025n

* CHECK dout0_39 Vdout0_39ck164 = 0.9 time = 825
.meas tran vdout0_39ck164 FIND v(dout0_39) AT=825.025n

* CHECK dout0_40 Vdout0_40ck164 = 0.9 time = 825
.meas tran vdout0_40ck164 FIND v(dout0_40) AT=825.025n

* CHECK dout0_41 Vdout0_41ck164 = 0.9 time = 825
.meas tran vdout0_41ck164 FIND v(dout0_41) AT=825.025n

* CHECK dout0_42 Vdout0_42ck164 = 0.9 time = 825
.meas tran vdout0_42ck164 FIND v(dout0_42) AT=825.025n

* CHECK dout0_43 Vdout0_43ck164 = 0 time = 825
.meas tran vdout0_43ck164 FIND v(dout0_43) AT=825.025n

* CHECK dout0_44 Vdout0_44ck164 = 0 time = 825
.meas tran vdout0_44ck164 FIND v(dout0_44) AT=825.025n

* CHECK dout0_45 Vdout0_45ck164 = 0 time = 825
.meas tran vdout0_45ck164 FIND v(dout0_45) AT=825.025n

* CHECK dout0_46 Vdout0_46ck164 = 0 time = 825
.meas tran vdout0_46ck164 FIND v(dout0_46) AT=825.025n

* CHECK dout0_47 Vdout0_47ck164 = 0.9 time = 825
.meas tran vdout0_47ck164 FIND v(dout0_47) AT=825.025n

* CHECK dout0_48 Vdout0_48ck164 = 0 time = 825
.meas tran vdout0_48ck164 FIND v(dout0_48) AT=825.025n

* CHECK dout0_49 Vdout0_49ck164 = 0.9 time = 825
.meas tran vdout0_49ck164 FIND v(dout0_49) AT=825.025n

* CHECK dout0_50 Vdout0_50ck164 = 0.9 time = 825
.meas tran vdout0_50ck164 FIND v(dout0_50) AT=825.025n

* CHECK dout0_51 Vdout0_51ck164 = 0.9 time = 825
.meas tran vdout0_51ck164 FIND v(dout0_51) AT=825.025n

* CHECK dout0_52 Vdout0_52ck164 = 0 time = 825
.meas tran vdout0_52ck164 FIND v(dout0_52) AT=825.025n

* CHECK dout0_53 Vdout0_53ck164 = 0 time = 825
.meas tran vdout0_53ck164 FIND v(dout0_53) AT=825.025n

* CHECK dout0_54 Vdout0_54ck164 = 0 time = 825
.meas tran vdout0_54ck164 FIND v(dout0_54) AT=825.025n

* CHECK dout0_55 Vdout0_55ck164 = 0.9 time = 825
.meas tran vdout0_55ck164 FIND v(dout0_55) AT=825.025n

* CHECK dout0_56 Vdout0_56ck164 = 0 time = 825
.meas tran vdout0_56ck164 FIND v(dout0_56) AT=825.025n

* CHECK dout0_57 Vdout0_57ck164 = 0 time = 825
.meas tran vdout0_57ck164 FIND v(dout0_57) AT=825.025n

* CHECK dout0_58 Vdout0_58ck164 = 0 time = 825
.meas tran vdout0_58ck164 FIND v(dout0_58) AT=825.025n

* CHECK dout0_59 Vdout0_59ck164 = 0.9 time = 825
.meas tran vdout0_59ck164 FIND v(dout0_59) AT=825.025n

* CHECK dout0_60 Vdout0_60ck164 = 0 time = 825
.meas tran vdout0_60ck164 FIND v(dout0_60) AT=825.025n

* CHECK dout0_61 Vdout0_61ck164 = 0.9 time = 825
.meas tran vdout0_61ck164 FIND v(dout0_61) AT=825.025n

* CHECK dout0_62 Vdout0_62ck164 = 0 time = 825
.meas tran vdout0_62ck164 FIND v(dout0_62) AT=825.025n

* CHECK dout0_63 Vdout0_63ck164 = 0 time = 825
.meas tran vdout0_63ck164 FIND v(dout0_63) AT=825.025n

* CHECK dout0_0 Vdout0_0ck165 = 0 time = 830
.meas tran vdout0_0ck165 FIND v(dout0_0) AT=830.025n

* CHECK dout0_1 Vdout0_1ck165 = 0.9 time = 830
.meas tran vdout0_1ck165 FIND v(dout0_1) AT=830.025n

* CHECK dout0_2 Vdout0_2ck165 = 0 time = 830
.meas tran vdout0_2ck165 FIND v(dout0_2) AT=830.025n

* CHECK dout0_3 Vdout0_3ck165 = 0.9 time = 830
.meas tran vdout0_3ck165 FIND v(dout0_3) AT=830.025n

* CHECK dout0_4 Vdout0_4ck165 = 0.9 time = 830
.meas tran vdout0_4ck165 FIND v(dout0_4) AT=830.025n

* CHECK dout0_5 Vdout0_5ck165 = 0.9 time = 830
.meas tran vdout0_5ck165 FIND v(dout0_5) AT=830.025n

* CHECK dout0_6 Vdout0_6ck165 = 0.9 time = 830
.meas tran vdout0_6ck165 FIND v(dout0_6) AT=830.025n

* CHECK dout0_7 Vdout0_7ck165 = 0 time = 830
.meas tran vdout0_7ck165 FIND v(dout0_7) AT=830.025n

* CHECK dout0_8 Vdout0_8ck165 = 0.9 time = 830
.meas tran vdout0_8ck165 FIND v(dout0_8) AT=830.025n

* CHECK dout0_9 Vdout0_9ck165 = 0 time = 830
.meas tran vdout0_9ck165 FIND v(dout0_9) AT=830.025n

* CHECK dout0_10 Vdout0_10ck165 = 0 time = 830
.meas tran vdout0_10ck165 FIND v(dout0_10) AT=830.025n

* CHECK dout0_11 Vdout0_11ck165 = 0.9 time = 830
.meas tran vdout0_11ck165 FIND v(dout0_11) AT=830.025n

* CHECK dout0_12 Vdout0_12ck165 = 0.9 time = 830
.meas tran vdout0_12ck165 FIND v(dout0_12) AT=830.025n

* CHECK dout0_13 Vdout0_13ck165 = 0.9 time = 830
.meas tran vdout0_13ck165 FIND v(dout0_13) AT=830.025n

* CHECK dout0_14 Vdout0_14ck165 = 0.9 time = 830
.meas tran vdout0_14ck165 FIND v(dout0_14) AT=830.025n

* CHECK dout0_15 Vdout0_15ck165 = 0 time = 830
.meas tran vdout0_15ck165 FIND v(dout0_15) AT=830.025n

* CHECK dout0_16 Vdout0_16ck165 = 0 time = 830
.meas tran vdout0_16ck165 FIND v(dout0_16) AT=830.025n

* CHECK dout0_17 Vdout0_17ck165 = 0.9 time = 830
.meas tran vdout0_17ck165 FIND v(dout0_17) AT=830.025n

* CHECK dout0_18 Vdout0_18ck165 = 0 time = 830
.meas tran vdout0_18ck165 FIND v(dout0_18) AT=830.025n

* CHECK dout0_19 Vdout0_19ck165 = 0.9 time = 830
.meas tran vdout0_19ck165 FIND v(dout0_19) AT=830.025n

* CHECK dout0_20 Vdout0_20ck165 = 0 time = 830
.meas tran vdout0_20ck165 FIND v(dout0_20) AT=830.025n

* CHECK dout0_21 Vdout0_21ck165 = 0 time = 830
.meas tran vdout0_21ck165 FIND v(dout0_21) AT=830.025n

* CHECK dout0_22 Vdout0_22ck165 = 0.9 time = 830
.meas tran vdout0_22ck165 FIND v(dout0_22) AT=830.025n

* CHECK dout0_23 Vdout0_23ck165 = 0 time = 830
.meas tran vdout0_23ck165 FIND v(dout0_23) AT=830.025n

* CHECK dout0_24 Vdout0_24ck165 = 0.9 time = 830
.meas tran vdout0_24ck165 FIND v(dout0_24) AT=830.025n

* CHECK dout0_25 Vdout0_25ck165 = 0.9 time = 830
.meas tran vdout0_25ck165 FIND v(dout0_25) AT=830.025n

* CHECK dout0_26 Vdout0_26ck165 = 0.9 time = 830
.meas tran vdout0_26ck165 FIND v(dout0_26) AT=830.025n

* CHECK dout0_27 Vdout0_27ck165 = 0 time = 830
.meas tran vdout0_27ck165 FIND v(dout0_27) AT=830.025n

* CHECK dout0_28 Vdout0_28ck165 = 0 time = 830
.meas tran vdout0_28ck165 FIND v(dout0_28) AT=830.025n

* CHECK dout0_29 Vdout0_29ck165 = 0.9 time = 830
.meas tran vdout0_29ck165 FIND v(dout0_29) AT=830.025n

* CHECK dout0_30 Vdout0_30ck165 = 0.9 time = 830
.meas tran vdout0_30ck165 FIND v(dout0_30) AT=830.025n

* CHECK dout0_31 Vdout0_31ck165 = 0.9 time = 830
.meas tran vdout0_31ck165 FIND v(dout0_31) AT=830.025n

* CHECK dout0_32 Vdout0_32ck165 = 0 time = 830
.meas tran vdout0_32ck165 FIND v(dout0_32) AT=830.025n

* CHECK dout0_33 Vdout0_33ck165 = 0.9 time = 830
.meas tran vdout0_33ck165 FIND v(dout0_33) AT=830.025n

* CHECK dout0_34 Vdout0_34ck165 = 0 time = 830
.meas tran vdout0_34ck165 FIND v(dout0_34) AT=830.025n

* CHECK dout0_35 Vdout0_35ck165 = 0.9 time = 830
.meas tran vdout0_35ck165 FIND v(dout0_35) AT=830.025n

* CHECK dout0_36 Vdout0_36ck165 = 0 time = 830
.meas tran vdout0_36ck165 FIND v(dout0_36) AT=830.025n

* CHECK dout0_37 Vdout0_37ck165 = 0 time = 830
.meas tran vdout0_37ck165 FIND v(dout0_37) AT=830.025n

* CHECK dout0_38 Vdout0_38ck165 = 0 time = 830
.meas tran vdout0_38ck165 FIND v(dout0_38) AT=830.025n

* CHECK dout0_39 Vdout0_39ck165 = 0.9 time = 830
.meas tran vdout0_39ck165 FIND v(dout0_39) AT=830.025n

* CHECK dout0_40 Vdout0_40ck165 = 0 time = 830
.meas tran vdout0_40ck165 FIND v(dout0_40) AT=830.025n

* CHECK dout0_41 Vdout0_41ck165 = 0 time = 830
.meas tran vdout0_41ck165 FIND v(dout0_41) AT=830.025n

* CHECK dout0_42 Vdout0_42ck165 = 0 time = 830
.meas tran vdout0_42ck165 FIND v(dout0_42) AT=830.025n

* CHECK dout0_43 Vdout0_43ck165 = 0 time = 830
.meas tran vdout0_43ck165 FIND v(dout0_43) AT=830.025n

* CHECK dout0_44 Vdout0_44ck165 = 0.9 time = 830
.meas tran vdout0_44ck165 FIND v(dout0_44) AT=830.025n

* CHECK dout0_45 Vdout0_45ck165 = 0.9 time = 830
.meas tran vdout0_45ck165 FIND v(dout0_45) AT=830.025n

* CHECK dout0_46 Vdout0_46ck165 = 0 time = 830
.meas tran vdout0_46ck165 FIND v(dout0_46) AT=830.025n

* CHECK dout0_47 Vdout0_47ck165 = 0 time = 830
.meas tran vdout0_47ck165 FIND v(dout0_47) AT=830.025n

* CHECK dout0_48 Vdout0_48ck165 = 0 time = 830
.meas tran vdout0_48ck165 FIND v(dout0_48) AT=830.025n

* CHECK dout0_49 Vdout0_49ck165 = 0.9 time = 830
.meas tran vdout0_49ck165 FIND v(dout0_49) AT=830.025n

* CHECK dout0_50 Vdout0_50ck165 = 0.9 time = 830
.meas tran vdout0_50ck165 FIND v(dout0_50) AT=830.025n

* CHECK dout0_51 Vdout0_51ck165 = 0 time = 830
.meas tran vdout0_51ck165 FIND v(dout0_51) AT=830.025n

* CHECK dout0_52 Vdout0_52ck165 = 0.9 time = 830
.meas tran vdout0_52ck165 FIND v(dout0_52) AT=830.025n

* CHECK dout0_53 Vdout0_53ck165 = 0 time = 830
.meas tran vdout0_53ck165 FIND v(dout0_53) AT=830.025n

* CHECK dout0_54 Vdout0_54ck165 = 0 time = 830
.meas tran vdout0_54ck165 FIND v(dout0_54) AT=830.025n

* CHECK dout0_55 Vdout0_55ck165 = 0.9 time = 830
.meas tran vdout0_55ck165 FIND v(dout0_55) AT=830.025n

* CHECK dout0_56 Vdout0_56ck165 = 0.9 time = 830
.meas tran vdout0_56ck165 FIND v(dout0_56) AT=830.025n

* CHECK dout0_57 Vdout0_57ck165 = 0.9 time = 830
.meas tran vdout0_57ck165 FIND v(dout0_57) AT=830.025n

* CHECK dout0_58 Vdout0_58ck165 = 0.9 time = 830
.meas tran vdout0_58ck165 FIND v(dout0_58) AT=830.025n

* CHECK dout0_59 Vdout0_59ck165 = 0 time = 830
.meas tran vdout0_59ck165 FIND v(dout0_59) AT=830.025n

* CHECK dout0_60 Vdout0_60ck165 = 0.9 time = 830
.meas tran vdout0_60ck165 FIND v(dout0_60) AT=830.025n

* CHECK dout0_61 Vdout0_61ck165 = 0.9 time = 830
.meas tran vdout0_61ck165 FIND v(dout0_61) AT=830.025n

* CHECK dout0_62 Vdout0_62ck165 = 0.9 time = 830
.meas tran vdout0_62ck165 FIND v(dout0_62) AT=830.025n

* CHECK dout0_63 Vdout0_63ck165 = 0.9 time = 830
.meas tran vdout0_63ck165 FIND v(dout0_63) AT=830.025n

* CHECK dout0_0 Vdout0_0ck166 = 0 time = 835
.meas tran vdout0_0ck166 FIND v(dout0_0) AT=835.025n

* CHECK dout0_1 Vdout0_1ck166 = 0.9 time = 835
.meas tran vdout0_1ck166 FIND v(dout0_1) AT=835.025n

* CHECK dout0_2 Vdout0_2ck166 = 0 time = 835
.meas tran vdout0_2ck166 FIND v(dout0_2) AT=835.025n

* CHECK dout0_3 Vdout0_3ck166 = 0.9 time = 835
.meas tran vdout0_3ck166 FIND v(dout0_3) AT=835.025n

* CHECK dout0_4 Vdout0_4ck166 = 0.9 time = 835
.meas tran vdout0_4ck166 FIND v(dout0_4) AT=835.025n

* CHECK dout0_5 Vdout0_5ck166 = 0.9 time = 835
.meas tran vdout0_5ck166 FIND v(dout0_5) AT=835.025n

* CHECK dout0_6 Vdout0_6ck166 = 0.9 time = 835
.meas tran vdout0_6ck166 FIND v(dout0_6) AT=835.025n

* CHECK dout0_7 Vdout0_7ck166 = 0 time = 835
.meas tran vdout0_7ck166 FIND v(dout0_7) AT=835.025n

* CHECK dout0_8 Vdout0_8ck166 = 0.9 time = 835
.meas tran vdout0_8ck166 FIND v(dout0_8) AT=835.025n

* CHECK dout0_9 Vdout0_9ck166 = 0 time = 835
.meas tran vdout0_9ck166 FIND v(dout0_9) AT=835.025n

* CHECK dout0_10 Vdout0_10ck166 = 0 time = 835
.meas tran vdout0_10ck166 FIND v(dout0_10) AT=835.025n

* CHECK dout0_11 Vdout0_11ck166 = 0.9 time = 835
.meas tran vdout0_11ck166 FIND v(dout0_11) AT=835.025n

* CHECK dout0_12 Vdout0_12ck166 = 0.9 time = 835
.meas tran vdout0_12ck166 FIND v(dout0_12) AT=835.025n

* CHECK dout0_13 Vdout0_13ck166 = 0.9 time = 835
.meas tran vdout0_13ck166 FIND v(dout0_13) AT=835.025n

* CHECK dout0_14 Vdout0_14ck166 = 0.9 time = 835
.meas tran vdout0_14ck166 FIND v(dout0_14) AT=835.025n

* CHECK dout0_15 Vdout0_15ck166 = 0 time = 835
.meas tran vdout0_15ck166 FIND v(dout0_15) AT=835.025n

* CHECK dout0_16 Vdout0_16ck166 = 0 time = 835
.meas tran vdout0_16ck166 FIND v(dout0_16) AT=835.025n

* CHECK dout0_17 Vdout0_17ck166 = 0.9 time = 835
.meas tran vdout0_17ck166 FIND v(dout0_17) AT=835.025n

* CHECK dout0_18 Vdout0_18ck166 = 0 time = 835
.meas tran vdout0_18ck166 FIND v(dout0_18) AT=835.025n

* CHECK dout0_19 Vdout0_19ck166 = 0.9 time = 835
.meas tran vdout0_19ck166 FIND v(dout0_19) AT=835.025n

* CHECK dout0_20 Vdout0_20ck166 = 0 time = 835
.meas tran vdout0_20ck166 FIND v(dout0_20) AT=835.025n

* CHECK dout0_21 Vdout0_21ck166 = 0 time = 835
.meas tran vdout0_21ck166 FIND v(dout0_21) AT=835.025n

* CHECK dout0_22 Vdout0_22ck166 = 0.9 time = 835
.meas tran vdout0_22ck166 FIND v(dout0_22) AT=835.025n

* CHECK dout0_23 Vdout0_23ck166 = 0 time = 835
.meas tran vdout0_23ck166 FIND v(dout0_23) AT=835.025n

* CHECK dout0_24 Vdout0_24ck166 = 0.9 time = 835
.meas tran vdout0_24ck166 FIND v(dout0_24) AT=835.025n

* CHECK dout0_25 Vdout0_25ck166 = 0.9 time = 835
.meas tran vdout0_25ck166 FIND v(dout0_25) AT=835.025n

* CHECK dout0_26 Vdout0_26ck166 = 0.9 time = 835
.meas tran vdout0_26ck166 FIND v(dout0_26) AT=835.025n

* CHECK dout0_27 Vdout0_27ck166 = 0 time = 835
.meas tran vdout0_27ck166 FIND v(dout0_27) AT=835.025n

* CHECK dout0_28 Vdout0_28ck166 = 0 time = 835
.meas tran vdout0_28ck166 FIND v(dout0_28) AT=835.025n

* CHECK dout0_29 Vdout0_29ck166 = 0.9 time = 835
.meas tran vdout0_29ck166 FIND v(dout0_29) AT=835.025n

* CHECK dout0_30 Vdout0_30ck166 = 0.9 time = 835
.meas tran vdout0_30ck166 FIND v(dout0_30) AT=835.025n

* CHECK dout0_31 Vdout0_31ck166 = 0.9 time = 835
.meas tran vdout0_31ck166 FIND v(dout0_31) AT=835.025n

* CHECK dout0_32 Vdout0_32ck166 = 0 time = 835
.meas tran vdout0_32ck166 FIND v(dout0_32) AT=835.025n

* CHECK dout0_33 Vdout0_33ck166 = 0.9 time = 835
.meas tran vdout0_33ck166 FIND v(dout0_33) AT=835.025n

* CHECK dout0_34 Vdout0_34ck166 = 0 time = 835
.meas tran vdout0_34ck166 FIND v(dout0_34) AT=835.025n

* CHECK dout0_35 Vdout0_35ck166 = 0.9 time = 835
.meas tran vdout0_35ck166 FIND v(dout0_35) AT=835.025n

* CHECK dout0_36 Vdout0_36ck166 = 0 time = 835
.meas tran vdout0_36ck166 FIND v(dout0_36) AT=835.025n

* CHECK dout0_37 Vdout0_37ck166 = 0 time = 835
.meas tran vdout0_37ck166 FIND v(dout0_37) AT=835.025n

* CHECK dout0_38 Vdout0_38ck166 = 0 time = 835
.meas tran vdout0_38ck166 FIND v(dout0_38) AT=835.025n

* CHECK dout0_39 Vdout0_39ck166 = 0.9 time = 835
.meas tran vdout0_39ck166 FIND v(dout0_39) AT=835.025n

* CHECK dout0_40 Vdout0_40ck166 = 0 time = 835
.meas tran vdout0_40ck166 FIND v(dout0_40) AT=835.025n

* CHECK dout0_41 Vdout0_41ck166 = 0 time = 835
.meas tran vdout0_41ck166 FIND v(dout0_41) AT=835.025n

* CHECK dout0_42 Vdout0_42ck166 = 0 time = 835
.meas tran vdout0_42ck166 FIND v(dout0_42) AT=835.025n

* CHECK dout0_43 Vdout0_43ck166 = 0 time = 835
.meas tran vdout0_43ck166 FIND v(dout0_43) AT=835.025n

* CHECK dout0_44 Vdout0_44ck166 = 0.9 time = 835
.meas tran vdout0_44ck166 FIND v(dout0_44) AT=835.025n

* CHECK dout0_45 Vdout0_45ck166 = 0.9 time = 835
.meas tran vdout0_45ck166 FIND v(dout0_45) AT=835.025n

* CHECK dout0_46 Vdout0_46ck166 = 0 time = 835
.meas tran vdout0_46ck166 FIND v(dout0_46) AT=835.025n

* CHECK dout0_47 Vdout0_47ck166 = 0 time = 835
.meas tran vdout0_47ck166 FIND v(dout0_47) AT=835.025n

* CHECK dout0_48 Vdout0_48ck166 = 0 time = 835
.meas tran vdout0_48ck166 FIND v(dout0_48) AT=835.025n

* CHECK dout0_49 Vdout0_49ck166 = 0.9 time = 835
.meas tran vdout0_49ck166 FIND v(dout0_49) AT=835.025n

* CHECK dout0_50 Vdout0_50ck166 = 0.9 time = 835
.meas tran vdout0_50ck166 FIND v(dout0_50) AT=835.025n

* CHECK dout0_51 Vdout0_51ck166 = 0 time = 835
.meas tran vdout0_51ck166 FIND v(dout0_51) AT=835.025n

* CHECK dout0_52 Vdout0_52ck166 = 0.9 time = 835
.meas tran vdout0_52ck166 FIND v(dout0_52) AT=835.025n

* CHECK dout0_53 Vdout0_53ck166 = 0 time = 835
.meas tran vdout0_53ck166 FIND v(dout0_53) AT=835.025n

* CHECK dout0_54 Vdout0_54ck166 = 0 time = 835
.meas tran vdout0_54ck166 FIND v(dout0_54) AT=835.025n

* CHECK dout0_55 Vdout0_55ck166 = 0.9 time = 835
.meas tran vdout0_55ck166 FIND v(dout0_55) AT=835.025n

* CHECK dout0_56 Vdout0_56ck166 = 0.9 time = 835
.meas tran vdout0_56ck166 FIND v(dout0_56) AT=835.025n

* CHECK dout0_57 Vdout0_57ck166 = 0.9 time = 835
.meas tran vdout0_57ck166 FIND v(dout0_57) AT=835.025n

* CHECK dout0_58 Vdout0_58ck166 = 0.9 time = 835
.meas tran vdout0_58ck166 FIND v(dout0_58) AT=835.025n

* CHECK dout0_59 Vdout0_59ck166 = 0 time = 835
.meas tran vdout0_59ck166 FIND v(dout0_59) AT=835.025n

* CHECK dout0_60 Vdout0_60ck166 = 0.9 time = 835
.meas tran vdout0_60ck166 FIND v(dout0_60) AT=835.025n

* CHECK dout0_61 Vdout0_61ck166 = 0.9 time = 835
.meas tran vdout0_61ck166 FIND v(dout0_61) AT=835.025n

* CHECK dout0_62 Vdout0_62ck166 = 0.9 time = 835
.meas tran vdout0_62ck166 FIND v(dout0_62) AT=835.025n

* CHECK dout0_63 Vdout0_63ck166 = 0.9 time = 835
.meas tran vdout0_63ck166 FIND v(dout0_63) AT=835.025n

* CHECK dout0_0 Vdout0_0ck168 = 0 time = 845
.meas tran vdout0_0ck168 FIND v(dout0_0) AT=845.025n

* CHECK dout0_1 Vdout0_1ck168 = 0 time = 845
.meas tran vdout0_1ck168 FIND v(dout0_1) AT=845.025n

* CHECK dout0_2 Vdout0_2ck168 = 0 time = 845
.meas tran vdout0_2ck168 FIND v(dout0_2) AT=845.025n

* CHECK dout0_3 Vdout0_3ck168 = 0.9 time = 845
.meas tran vdout0_3ck168 FIND v(dout0_3) AT=845.025n

* CHECK dout0_4 Vdout0_4ck168 = 0.9 time = 845
.meas tran vdout0_4ck168 FIND v(dout0_4) AT=845.025n

* CHECK dout0_5 Vdout0_5ck168 = 0.9 time = 845
.meas tran vdout0_5ck168 FIND v(dout0_5) AT=845.025n

* CHECK dout0_6 Vdout0_6ck168 = 0.9 time = 845
.meas tran vdout0_6ck168 FIND v(dout0_6) AT=845.025n

* CHECK dout0_7 Vdout0_7ck168 = 0.9 time = 845
.meas tran vdout0_7ck168 FIND v(dout0_7) AT=845.025n

* CHECK dout0_8 Vdout0_8ck168 = 0 time = 845
.meas tran vdout0_8ck168 FIND v(dout0_8) AT=845.025n

* CHECK dout0_9 Vdout0_9ck168 = 0.9 time = 845
.meas tran vdout0_9ck168 FIND v(dout0_9) AT=845.025n

* CHECK dout0_10 Vdout0_10ck168 = 0 time = 845
.meas tran vdout0_10ck168 FIND v(dout0_10) AT=845.025n

* CHECK dout0_11 Vdout0_11ck168 = 0 time = 845
.meas tran vdout0_11ck168 FIND v(dout0_11) AT=845.025n

* CHECK dout0_12 Vdout0_12ck168 = 0 time = 845
.meas tran vdout0_12ck168 FIND v(dout0_12) AT=845.025n

* CHECK dout0_13 Vdout0_13ck168 = 0 time = 845
.meas tran vdout0_13ck168 FIND v(dout0_13) AT=845.025n

* CHECK dout0_14 Vdout0_14ck168 = 0.9 time = 845
.meas tran vdout0_14ck168 FIND v(dout0_14) AT=845.025n

* CHECK dout0_15 Vdout0_15ck168 = 0 time = 845
.meas tran vdout0_15ck168 FIND v(dout0_15) AT=845.025n

* CHECK dout0_16 Vdout0_16ck168 = 0 time = 845
.meas tran vdout0_16ck168 FIND v(dout0_16) AT=845.025n

* CHECK dout0_17 Vdout0_17ck168 = 0 time = 845
.meas tran vdout0_17ck168 FIND v(dout0_17) AT=845.025n

* CHECK dout0_18 Vdout0_18ck168 = 0.9 time = 845
.meas tran vdout0_18ck168 FIND v(dout0_18) AT=845.025n

* CHECK dout0_19 Vdout0_19ck168 = 0 time = 845
.meas tran vdout0_19ck168 FIND v(dout0_19) AT=845.025n

* CHECK dout0_20 Vdout0_20ck168 = 0.9 time = 845
.meas tran vdout0_20ck168 FIND v(dout0_20) AT=845.025n

* CHECK dout0_21 Vdout0_21ck168 = 0 time = 845
.meas tran vdout0_21ck168 FIND v(dout0_21) AT=845.025n

* CHECK dout0_22 Vdout0_22ck168 = 0.9 time = 845
.meas tran vdout0_22ck168 FIND v(dout0_22) AT=845.025n

* CHECK dout0_23 Vdout0_23ck168 = 0 time = 845
.meas tran vdout0_23ck168 FIND v(dout0_23) AT=845.025n

* CHECK dout0_24 Vdout0_24ck168 = 0.9 time = 845
.meas tran vdout0_24ck168 FIND v(dout0_24) AT=845.025n

* CHECK dout0_25 Vdout0_25ck168 = 0 time = 845
.meas tran vdout0_25ck168 FIND v(dout0_25) AT=845.025n

* CHECK dout0_26 Vdout0_26ck168 = 0.9 time = 845
.meas tran vdout0_26ck168 FIND v(dout0_26) AT=845.025n

* CHECK dout0_27 Vdout0_27ck168 = 0 time = 845
.meas tran vdout0_27ck168 FIND v(dout0_27) AT=845.025n

* CHECK dout0_28 Vdout0_28ck168 = 0 time = 845
.meas tran vdout0_28ck168 FIND v(dout0_28) AT=845.025n

* CHECK dout0_29 Vdout0_29ck168 = 0 time = 845
.meas tran vdout0_29ck168 FIND v(dout0_29) AT=845.025n

* CHECK dout0_30 Vdout0_30ck168 = 0.9 time = 845
.meas tran vdout0_30ck168 FIND v(dout0_30) AT=845.025n

* CHECK dout0_31 Vdout0_31ck168 = 0 time = 845
.meas tran vdout0_31ck168 FIND v(dout0_31) AT=845.025n

* CHECK dout0_32 Vdout0_32ck168 = 0.9 time = 845
.meas tran vdout0_32ck168 FIND v(dout0_32) AT=845.025n

* CHECK dout0_33 Vdout0_33ck168 = 0 time = 845
.meas tran vdout0_33ck168 FIND v(dout0_33) AT=845.025n

* CHECK dout0_34 Vdout0_34ck168 = 0.9 time = 845
.meas tran vdout0_34ck168 FIND v(dout0_34) AT=845.025n

* CHECK dout0_35 Vdout0_35ck168 = 0 time = 845
.meas tran vdout0_35ck168 FIND v(dout0_35) AT=845.025n

* CHECK dout0_36 Vdout0_36ck168 = 0.9 time = 845
.meas tran vdout0_36ck168 FIND v(dout0_36) AT=845.025n

* CHECK dout0_37 Vdout0_37ck168 = 0.9 time = 845
.meas tran vdout0_37ck168 FIND v(dout0_37) AT=845.025n

* CHECK dout0_38 Vdout0_38ck168 = 0.9 time = 845
.meas tran vdout0_38ck168 FIND v(dout0_38) AT=845.025n

* CHECK dout0_39 Vdout0_39ck168 = 0.9 time = 845
.meas tran vdout0_39ck168 FIND v(dout0_39) AT=845.025n

* CHECK dout0_40 Vdout0_40ck168 = 0 time = 845
.meas tran vdout0_40ck168 FIND v(dout0_40) AT=845.025n

* CHECK dout0_41 Vdout0_41ck168 = 0.9 time = 845
.meas tran vdout0_41ck168 FIND v(dout0_41) AT=845.025n

* CHECK dout0_42 Vdout0_42ck168 = 0.9 time = 845
.meas tran vdout0_42ck168 FIND v(dout0_42) AT=845.025n

* CHECK dout0_43 Vdout0_43ck168 = 0.9 time = 845
.meas tran vdout0_43ck168 FIND v(dout0_43) AT=845.025n

* CHECK dout0_44 Vdout0_44ck168 = 0 time = 845
.meas tran vdout0_44ck168 FIND v(dout0_44) AT=845.025n

* CHECK dout0_45 Vdout0_45ck168 = 0.9 time = 845
.meas tran vdout0_45ck168 FIND v(dout0_45) AT=845.025n

* CHECK dout0_46 Vdout0_46ck168 = 0 time = 845
.meas tran vdout0_46ck168 FIND v(dout0_46) AT=845.025n

* CHECK dout0_47 Vdout0_47ck168 = 0 time = 845
.meas tran vdout0_47ck168 FIND v(dout0_47) AT=845.025n

* CHECK dout0_48 Vdout0_48ck168 = 0 time = 845
.meas tran vdout0_48ck168 FIND v(dout0_48) AT=845.025n

* CHECK dout0_49 Vdout0_49ck168 = 0.9 time = 845
.meas tran vdout0_49ck168 FIND v(dout0_49) AT=845.025n

* CHECK dout0_50 Vdout0_50ck168 = 0.9 time = 845
.meas tran vdout0_50ck168 FIND v(dout0_50) AT=845.025n

* CHECK dout0_51 Vdout0_51ck168 = 0.9 time = 845
.meas tran vdout0_51ck168 FIND v(dout0_51) AT=845.025n

* CHECK dout0_52 Vdout0_52ck168 = 0.9 time = 845
.meas tran vdout0_52ck168 FIND v(dout0_52) AT=845.025n

* CHECK dout0_53 Vdout0_53ck168 = 0 time = 845
.meas tran vdout0_53ck168 FIND v(dout0_53) AT=845.025n

* CHECK dout0_54 Vdout0_54ck168 = 0 time = 845
.meas tran vdout0_54ck168 FIND v(dout0_54) AT=845.025n

* CHECK dout0_55 Vdout0_55ck168 = 0.9 time = 845
.meas tran vdout0_55ck168 FIND v(dout0_55) AT=845.025n

* CHECK dout0_56 Vdout0_56ck168 = 0.9 time = 845
.meas tran vdout0_56ck168 FIND v(dout0_56) AT=845.025n

* CHECK dout0_57 Vdout0_57ck168 = 0.9 time = 845
.meas tran vdout0_57ck168 FIND v(dout0_57) AT=845.025n

* CHECK dout0_58 Vdout0_58ck168 = 0 time = 845
.meas tran vdout0_58ck168 FIND v(dout0_58) AT=845.025n

* CHECK dout0_59 Vdout0_59ck168 = 0.9 time = 845
.meas tran vdout0_59ck168 FIND v(dout0_59) AT=845.025n

* CHECK dout0_60 Vdout0_60ck168 = 0.9 time = 845
.meas tran vdout0_60ck168 FIND v(dout0_60) AT=845.025n

* CHECK dout0_61 Vdout0_61ck168 = 0.9 time = 845
.meas tran vdout0_61ck168 FIND v(dout0_61) AT=845.025n

* CHECK dout0_62 Vdout0_62ck168 = 0.9 time = 845
.meas tran vdout0_62ck168 FIND v(dout0_62) AT=845.025n

* CHECK dout0_63 Vdout0_63ck168 = 0 time = 845
.meas tran vdout0_63ck168 FIND v(dout0_63) AT=845.025n

* CHECK dout0_0 Vdout0_0ck169 = 0 time = 850
.meas tran vdout0_0ck169 FIND v(dout0_0) AT=850.025n

* CHECK dout0_1 Vdout0_1ck169 = 0 time = 850
.meas tran vdout0_1ck169 FIND v(dout0_1) AT=850.025n

* CHECK dout0_2 Vdout0_2ck169 = 0 time = 850
.meas tran vdout0_2ck169 FIND v(dout0_2) AT=850.025n

* CHECK dout0_3 Vdout0_3ck169 = 0.9 time = 850
.meas tran vdout0_3ck169 FIND v(dout0_3) AT=850.025n

* CHECK dout0_4 Vdout0_4ck169 = 0 time = 850
.meas tran vdout0_4ck169 FIND v(dout0_4) AT=850.025n

* CHECK dout0_5 Vdout0_5ck169 = 0 time = 850
.meas tran vdout0_5ck169 FIND v(dout0_5) AT=850.025n

* CHECK dout0_6 Vdout0_6ck169 = 0 time = 850
.meas tran vdout0_6ck169 FIND v(dout0_6) AT=850.025n

* CHECK dout0_7 Vdout0_7ck169 = 0 time = 850
.meas tran vdout0_7ck169 FIND v(dout0_7) AT=850.025n

* CHECK dout0_8 Vdout0_8ck169 = 0.9 time = 850
.meas tran vdout0_8ck169 FIND v(dout0_8) AT=850.025n

* CHECK dout0_9 Vdout0_9ck169 = 0 time = 850
.meas tran vdout0_9ck169 FIND v(dout0_9) AT=850.025n

* CHECK dout0_10 Vdout0_10ck169 = 0.9 time = 850
.meas tran vdout0_10ck169 FIND v(dout0_10) AT=850.025n

* CHECK dout0_11 Vdout0_11ck169 = 0 time = 850
.meas tran vdout0_11ck169 FIND v(dout0_11) AT=850.025n

* CHECK dout0_12 Vdout0_12ck169 = 0 time = 850
.meas tran vdout0_12ck169 FIND v(dout0_12) AT=850.025n

* CHECK dout0_13 Vdout0_13ck169 = 0.9 time = 850
.meas tran vdout0_13ck169 FIND v(dout0_13) AT=850.025n

* CHECK dout0_14 Vdout0_14ck169 = 0.9 time = 850
.meas tran vdout0_14ck169 FIND v(dout0_14) AT=850.025n

* CHECK dout0_15 Vdout0_15ck169 = 0.9 time = 850
.meas tran vdout0_15ck169 FIND v(dout0_15) AT=850.025n

* CHECK dout0_16 Vdout0_16ck169 = 0 time = 850
.meas tran vdout0_16ck169 FIND v(dout0_16) AT=850.025n

* CHECK dout0_17 Vdout0_17ck169 = 0.9 time = 850
.meas tran vdout0_17ck169 FIND v(dout0_17) AT=850.025n

* CHECK dout0_18 Vdout0_18ck169 = 0 time = 850
.meas tran vdout0_18ck169 FIND v(dout0_18) AT=850.025n

* CHECK dout0_19 Vdout0_19ck169 = 0.9 time = 850
.meas tran vdout0_19ck169 FIND v(dout0_19) AT=850.025n

* CHECK dout0_20 Vdout0_20ck169 = 0 time = 850
.meas tran vdout0_20ck169 FIND v(dout0_20) AT=850.025n

* CHECK dout0_21 Vdout0_21ck169 = 0 time = 850
.meas tran vdout0_21ck169 FIND v(dout0_21) AT=850.025n

* CHECK dout0_22 Vdout0_22ck169 = 0.9 time = 850
.meas tran vdout0_22ck169 FIND v(dout0_22) AT=850.025n

* CHECK dout0_23 Vdout0_23ck169 = 0.9 time = 850
.meas tran vdout0_23ck169 FIND v(dout0_23) AT=850.025n

* CHECK dout0_24 Vdout0_24ck169 = 0 time = 850
.meas tran vdout0_24ck169 FIND v(dout0_24) AT=850.025n

* CHECK dout0_25 Vdout0_25ck169 = 0 time = 850
.meas tran vdout0_25ck169 FIND v(dout0_25) AT=850.025n

* CHECK dout0_26 Vdout0_26ck169 = 0.9 time = 850
.meas tran vdout0_26ck169 FIND v(dout0_26) AT=850.025n

* CHECK dout0_27 Vdout0_27ck169 = 0 time = 850
.meas tran vdout0_27ck169 FIND v(dout0_27) AT=850.025n

* CHECK dout0_28 Vdout0_28ck169 = 0 time = 850
.meas tran vdout0_28ck169 FIND v(dout0_28) AT=850.025n

* CHECK dout0_29 Vdout0_29ck169 = 0.9 time = 850
.meas tran vdout0_29ck169 FIND v(dout0_29) AT=850.025n

* CHECK dout0_30 Vdout0_30ck169 = 0 time = 850
.meas tran vdout0_30ck169 FIND v(dout0_30) AT=850.025n

* CHECK dout0_31 Vdout0_31ck169 = 0 time = 850
.meas tran vdout0_31ck169 FIND v(dout0_31) AT=850.025n

* CHECK dout0_32 Vdout0_32ck169 = 0.9 time = 850
.meas tran vdout0_32ck169 FIND v(dout0_32) AT=850.025n

* CHECK dout0_33 Vdout0_33ck169 = 0 time = 850
.meas tran vdout0_33ck169 FIND v(dout0_33) AT=850.025n

* CHECK dout0_34 Vdout0_34ck169 = 0.9 time = 850
.meas tran vdout0_34ck169 FIND v(dout0_34) AT=850.025n

* CHECK dout0_35 Vdout0_35ck169 = 0.9 time = 850
.meas tran vdout0_35ck169 FIND v(dout0_35) AT=850.025n

* CHECK dout0_36 Vdout0_36ck169 = 0.9 time = 850
.meas tran vdout0_36ck169 FIND v(dout0_36) AT=850.025n

* CHECK dout0_37 Vdout0_37ck169 = 0 time = 850
.meas tran vdout0_37ck169 FIND v(dout0_37) AT=850.025n

* CHECK dout0_38 Vdout0_38ck169 = 0.9 time = 850
.meas tran vdout0_38ck169 FIND v(dout0_38) AT=850.025n

* CHECK dout0_39 Vdout0_39ck169 = 0 time = 850
.meas tran vdout0_39ck169 FIND v(dout0_39) AT=850.025n

* CHECK dout0_40 Vdout0_40ck169 = 0.9 time = 850
.meas tran vdout0_40ck169 FIND v(dout0_40) AT=850.025n

* CHECK dout0_41 Vdout0_41ck169 = 0.9 time = 850
.meas tran vdout0_41ck169 FIND v(dout0_41) AT=850.025n

* CHECK dout0_42 Vdout0_42ck169 = 0 time = 850
.meas tran vdout0_42ck169 FIND v(dout0_42) AT=850.025n

* CHECK dout0_43 Vdout0_43ck169 = 0 time = 850
.meas tran vdout0_43ck169 FIND v(dout0_43) AT=850.025n

* CHECK dout0_44 Vdout0_44ck169 = 0.9 time = 850
.meas tran vdout0_44ck169 FIND v(dout0_44) AT=850.025n

* CHECK dout0_45 Vdout0_45ck169 = 0 time = 850
.meas tran vdout0_45ck169 FIND v(dout0_45) AT=850.025n

* CHECK dout0_46 Vdout0_46ck169 = 0 time = 850
.meas tran vdout0_46ck169 FIND v(dout0_46) AT=850.025n

* CHECK dout0_47 Vdout0_47ck169 = 0 time = 850
.meas tran vdout0_47ck169 FIND v(dout0_47) AT=850.025n

* CHECK dout0_48 Vdout0_48ck169 = 0 time = 850
.meas tran vdout0_48ck169 FIND v(dout0_48) AT=850.025n

* CHECK dout0_49 Vdout0_49ck169 = 0.9 time = 850
.meas tran vdout0_49ck169 FIND v(dout0_49) AT=850.025n

* CHECK dout0_50 Vdout0_50ck169 = 0.9 time = 850
.meas tran vdout0_50ck169 FIND v(dout0_50) AT=850.025n

* CHECK dout0_51 Vdout0_51ck169 = 0 time = 850
.meas tran vdout0_51ck169 FIND v(dout0_51) AT=850.025n

* CHECK dout0_52 Vdout0_52ck169 = 0 time = 850
.meas tran vdout0_52ck169 FIND v(dout0_52) AT=850.025n

* CHECK dout0_53 Vdout0_53ck169 = 0.9 time = 850
.meas tran vdout0_53ck169 FIND v(dout0_53) AT=850.025n

* CHECK dout0_54 Vdout0_54ck169 = 0 time = 850
.meas tran vdout0_54ck169 FIND v(dout0_54) AT=850.025n

* CHECK dout0_55 Vdout0_55ck169 = 0 time = 850
.meas tran vdout0_55ck169 FIND v(dout0_55) AT=850.025n

* CHECK dout0_56 Vdout0_56ck169 = 0.9 time = 850
.meas tran vdout0_56ck169 FIND v(dout0_56) AT=850.025n

* CHECK dout0_57 Vdout0_57ck169 = 0 time = 850
.meas tran vdout0_57ck169 FIND v(dout0_57) AT=850.025n

* CHECK dout0_58 Vdout0_58ck169 = 0 time = 850
.meas tran vdout0_58ck169 FIND v(dout0_58) AT=850.025n

* CHECK dout0_59 Vdout0_59ck169 = 0.9 time = 850
.meas tran vdout0_59ck169 FIND v(dout0_59) AT=850.025n

* CHECK dout0_60 Vdout0_60ck169 = 0 time = 850
.meas tran vdout0_60ck169 FIND v(dout0_60) AT=850.025n

* CHECK dout0_61 Vdout0_61ck169 = 0.9 time = 850
.meas tran vdout0_61ck169 FIND v(dout0_61) AT=850.025n

* CHECK dout0_62 Vdout0_62ck169 = 0.9 time = 850
.meas tran vdout0_62ck169 FIND v(dout0_62) AT=850.025n

* CHECK dout0_63 Vdout0_63ck169 = 0.9 time = 850
.meas tran vdout0_63ck169 FIND v(dout0_63) AT=850.025n

* CHECK dout0_0 Vdout0_0ck170 = 0.9 time = 855
.meas tran vdout0_0ck170 FIND v(dout0_0) AT=855.025n

* CHECK dout0_1 Vdout0_1ck170 = 0 time = 855
.meas tran vdout0_1ck170 FIND v(dout0_1) AT=855.025n

* CHECK dout0_2 Vdout0_2ck170 = 0.9 time = 855
.meas tran vdout0_2ck170 FIND v(dout0_2) AT=855.025n

* CHECK dout0_3 Vdout0_3ck170 = 0 time = 855
.meas tran vdout0_3ck170 FIND v(dout0_3) AT=855.025n

* CHECK dout0_4 Vdout0_4ck170 = 0 time = 855
.meas tran vdout0_4ck170 FIND v(dout0_4) AT=855.025n

* CHECK dout0_5 Vdout0_5ck170 = 0 time = 855
.meas tran vdout0_5ck170 FIND v(dout0_5) AT=855.025n

* CHECK dout0_6 Vdout0_6ck170 = 0.9 time = 855
.meas tran vdout0_6ck170 FIND v(dout0_6) AT=855.025n

* CHECK dout0_7 Vdout0_7ck170 = 0 time = 855
.meas tran vdout0_7ck170 FIND v(dout0_7) AT=855.025n

* CHECK dout0_8 Vdout0_8ck170 = 0 time = 855
.meas tran vdout0_8ck170 FIND v(dout0_8) AT=855.025n

* CHECK dout0_9 Vdout0_9ck170 = 0 time = 855
.meas tran vdout0_9ck170 FIND v(dout0_9) AT=855.025n

* CHECK dout0_10 Vdout0_10ck170 = 0 time = 855
.meas tran vdout0_10ck170 FIND v(dout0_10) AT=855.025n

* CHECK dout0_11 Vdout0_11ck170 = 0.9 time = 855
.meas tran vdout0_11ck170 FIND v(dout0_11) AT=855.025n

* CHECK dout0_12 Vdout0_12ck170 = 0 time = 855
.meas tran vdout0_12ck170 FIND v(dout0_12) AT=855.025n

* CHECK dout0_13 Vdout0_13ck170 = 0 time = 855
.meas tran vdout0_13ck170 FIND v(dout0_13) AT=855.025n

* CHECK dout0_14 Vdout0_14ck170 = 0 time = 855
.meas tran vdout0_14ck170 FIND v(dout0_14) AT=855.025n

* CHECK dout0_15 Vdout0_15ck170 = 0 time = 855
.meas tran vdout0_15ck170 FIND v(dout0_15) AT=855.025n

* CHECK dout0_16 Vdout0_16ck170 = 0.9 time = 855
.meas tran vdout0_16ck170 FIND v(dout0_16) AT=855.025n

* CHECK dout0_17 Vdout0_17ck170 = 0.9 time = 855
.meas tran vdout0_17ck170 FIND v(dout0_17) AT=855.025n

* CHECK dout0_18 Vdout0_18ck170 = 0 time = 855
.meas tran vdout0_18ck170 FIND v(dout0_18) AT=855.025n

* CHECK dout0_19 Vdout0_19ck170 = 0.9 time = 855
.meas tran vdout0_19ck170 FIND v(dout0_19) AT=855.025n

* CHECK dout0_20 Vdout0_20ck170 = 0.9 time = 855
.meas tran vdout0_20ck170 FIND v(dout0_20) AT=855.025n

* CHECK dout0_21 Vdout0_21ck170 = 0.9 time = 855
.meas tran vdout0_21ck170 FIND v(dout0_21) AT=855.025n

* CHECK dout0_22 Vdout0_22ck170 = 0.9 time = 855
.meas tran vdout0_22ck170 FIND v(dout0_22) AT=855.025n

* CHECK dout0_23 Vdout0_23ck170 = 0.9 time = 855
.meas tran vdout0_23ck170 FIND v(dout0_23) AT=855.025n

* CHECK dout0_24 Vdout0_24ck170 = 0 time = 855
.meas tran vdout0_24ck170 FIND v(dout0_24) AT=855.025n

* CHECK dout0_25 Vdout0_25ck170 = 0 time = 855
.meas tran vdout0_25ck170 FIND v(dout0_25) AT=855.025n

* CHECK dout0_26 Vdout0_26ck170 = 0.9 time = 855
.meas tran vdout0_26ck170 FIND v(dout0_26) AT=855.025n

* CHECK dout0_27 Vdout0_27ck170 = 0 time = 855
.meas tran vdout0_27ck170 FIND v(dout0_27) AT=855.025n

* CHECK dout0_28 Vdout0_28ck170 = 0 time = 855
.meas tran vdout0_28ck170 FIND v(dout0_28) AT=855.025n

* CHECK dout0_29 Vdout0_29ck170 = 0.9 time = 855
.meas tran vdout0_29ck170 FIND v(dout0_29) AT=855.025n

* CHECK dout0_30 Vdout0_30ck170 = 0 time = 855
.meas tran vdout0_30ck170 FIND v(dout0_30) AT=855.025n

* CHECK dout0_31 Vdout0_31ck170 = 0 time = 855
.meas tran vdout0_31ck170 FIND v(dout0_31) AT=855.025n

* CHECK dout0_32 Vdout0_32ck170 = 0 time = 855
.meas tran vdout0_32ck170 FIND v(dout0_32) AT=855.025n

* CHECK dout0_33 Vdout0_33ck170 = 0.9 time = 855
.meas tran vdout0_33ck170 FIND v(dout0_33) AT=855.025n

* CHECK dout0_34 Vdout0_34ck170 = 0 time = 855
.meas tran vdout0_34ck170 FIND v(dout0_34) AT=855.025n

* CHECK dout0_35 Vdout0_35ck170 = 0 time = 855
.meas tran vdout0_35ck170 FIND v(dout0_35) AT=855.025n

* CHECK dout0_36 Vdout0_36ck170 = 0.9 time = 855
.meas tran vdout0_36ck170 FIND v(dout0_36) AT=855.025n

* CHECK dout0_37 Vdout0_37ck170 = 0.9 time = 855
.meas tran vdout0_37ck170 FIND v(dout0_37) AT=855.025n

* CHECK dout0_38 Vdout0_38ck170 = 0 time = 855
.meas tran vdout0_38ck170 FIND v(dout0_38) AT=855.025n

* CHECK dout0_39 Vdout0_39ck170 = 0.9 time = 855
.meas tran vdout0_39ck170 FIND v(dout0_39) AT=855.025n

* CHECK dout0_40 Vdout0_40ck170 = 0.9 time = 855
.meas tran vdout0_40ck170 FIND v(dout0_40) AT=855.025n

* CHECK dout0_41 Vdout0_41ck170 = 0.9 time = 855
.meas tran vdout0_41ck170 FIND v(dout0_41) AT=855.025n

* CHECK dout0_42 Vdout0_42ck170 = 0.9 time = 855
.meas tran vdout0_42ck170 FIND v(dout0_42) AT=855.025n

* CHECK dout0_43 Vdout0_43ck170 = 0 time = 855
.meas tran vdout0_43ck170 FIND v(dout0_43) AT=855.025n

* CHECK dout0_44 Vdout0_44ck170 = 0 time = 855
.meas tran vdout0_44ck170 FIND v(dout0_44) AT=855.025n

* CHECK dout0_45 Vdout0_45ck170 = 0 time = 855
.meas tran vdout0_45ck170 FIND v(dout0_45) AT=855.025n

* CHECK dout0_46 Vdout0_46ck170 = 0 time = 855
.meas tran vdout0_46ck170 FIND v(dout0_46) AT=855.025n

* CHECK dout0_47 Vdout0_47ck170 = 0.9 time = 855
.meas tran vdout0_47ck170 FIND v(dout0_47) AT=855.025n

* CHECK dout0_48 Vdout0_48ck170 = 0 time = 855
.meas tran vdout0_48ck170 FIND v(dout0_48) AT=855.025n

* CHECK dout0_49 Vdout0_49ck170 = 0.9 time = 855
.meas tran vdout0_49ck170 FIND v(dout0_49) AT=855.025n

* CHECK dout0_50 Vdout0_50ck170 = 0.9 time = 855
.meas tran vdout0_50ck170 FIND v(dout0_50) AT=855.025n

* CHECK dout0_51 Vdout0_51ck170 = 0.9 time = 855
.meas tran vdout0_51ck170 FIND v(dout0_51) AT=855.025n

* CHECK dout0_52 Vdout0_52ck170 = 0 time = 855
.meas tran vdout0_52ck170 FIND v(dout0_52) AT=855.025n

* CHECK dout0_53 Vdout0_53ck170 = 0 time = 855
.meas tran vdout0_53ck170 FIND v(dout0_53) AT=855.025n

* CHECK dout0_54 Vdout0_54ck170 = 0 time = 855
.meas tran vdout0_54ck170 FIND v(dout0_54) AT=855.025n

* CHECK dout0_55 Vdout0_55ck170 = 0.9 time = 855
.meas tran vdout0_55ck170 FIND v(dout0_55) AT=855.025n

* CHECK dout0_56 Vdout0_56ck170 = 0 time = 855
.meas tran vdout0_56ck170 FIND v(dout0_56) AT=855.025n

* CHECK dout0_57 Vdout0_57ck170 = 0 time = 855
.meas tran vdout0_57ck170 FIND v(dout0_57) AT=855.025n

* CHECK dout0_58 Vdout0_58ck170 = 0 time = 855
.meas tran vdout0_58ck170 FIND v(dout0_58) AT=855.025n

* CHECK dout0_59 Vdout0_59ck170 = 0.9 time = 855
.meas tran vdout0_59ck170 FIND v(dout0_59) AT=855.025n

* CHECK dout0_60 Vdout0_60ck170 = 0 time = 855
.meas tran vdout0_60ck170 FIND v(dout0_60) AT=855.025n

* CHECK dout0_61 Vdout0_61ck170 = 0.9 time = 855
.meas tran vdout0_61ck170 FIND v(dout0_61) AT=855.025n

* CHECK dout0_62 Vdout0_62ck170 = 0 time = 855
.meas tran vdout0_62ck170 FIND v(dout0_62) AT=855.025n

* CHECK dout0_63 Vdout0_63ck170 = 0 time = 855
.meas tran vdout0_63ck170 FIND v(dout0_63) AT=855.025n

* CHECK dout0_0 Vdout0_0ck171 = 0 time = 860
.meas tran vdout0_0ck171 FIND v(dout0_0) AT=860.025n

* CHECK dout0_1 Vdout0_1ck171 = 0 time = 860
.meas tran vdout0_1ck171 FIND v(dout0_1) AT=860.025n

* CHECK dout0_2 Vdout0_2ck171 = 0 time = 860
.meas tran vdout0_2ck171 FIND v(dout0_2) AT=860.025n

* CHECK dout0_3 Vdout0_3ck171 = 0.9 time = 860
.meas tran vdout0_3ck171 FIND v(dout0_3) AT=860.025n

* CHECK dout0_4 Vdout0_4ck171 = 0.9 time = 860
.meas tran vdout0_4ck171 FIND v(dout0_4) AT=860.025n

* CHECK dout0_5 Vdout0_5ck171 = 0.9 time = 860
.meas tran vdout0_5ck171 FIND v(dout0_5) AT=860.025n

* CHECK dout0_6 Vdout0_6ck171 = 0.9 time = 860
.meas tran vdout0_6ck171 FIND v(dout0_6) AT=860.025n

* CHECK dout0_7 Vdout0_7ck171 = 0.9 time = 860
.meas tran vdout0_7ck171 FIND v(dout0_7) AT=860.025n

* CHECK dout0_8 Vdout0_8ck171 = 0 time = 860
.meas tran vdout0_8ck171 FIND v(dout0_8) AT=860.025n

* CHECK dout0_9 Vdout0_9ck171 = 0.9 time = 860
.meas tran vdout0_9ck171 FIND v(dout0_9) AT=860.025n

* CHECK dout0_10 Vdout0_10ck171 = 0 time = 860
.meas tran vdout0_10ck171 FIND v(dout0_10) AT=860.025n

* CHECK dout0_11 Vdout0_11ck171 = 0 time = 860
.meas tran vdout0_11ck171 FIND v(dout0_11) AT=860.025n

* CHECK dout0_12 Vdout0_12ck171 = 0 time = 860
.meas tran vdout0_12ck171 FIND v(dout0_12) AT=860.025n

* CHECK dout0_13 Vdout0_13ck171 = 0 time = 860
.meas tran vdout0_13ck171 FIND v(dout0_13) AT=860.025n

* CHECK dout0_14 Vdout0_14ck171 = 0.9 time = 860
.meas tran vdout0_14ck171 FIND v(dout0_14) AT=860.025n

* CHECK dout0_15 Vdout0_15ck171 = 0 time = 860
.meas tran vdout0_15ck171 FIND v(dout0_15) AT=860.025n

* CHECK dout0_16 Vdout0_16ck171 = 0 time = 860
.meas tran vdout0_16ck171 FIND v(dout0_16) AT=860.025n

* CHECK dout0_17 Vdout0_17ck171 = 0 time = 860
.meas tran vdout0_17ck171 FIND v(dout0_17) AT=860.025n

* CHECK dout0_18 Vdout0_18ck171 = 0.9 time = 860
.meas tran vdout0_18ck171 FIND v(dout0_18) AT=860.025n

* CHECK dout0_19 Vdout0_19ck171 = 0 time = 860
.meas tran vdout0_19ck171 FIND v(dout0_19) AT=860.025n

* CHECK dout0_20 Vdout0_20ck171 = 0.9 time = 860
.meas tran vdout0_20ck171 FIND v(dout0_20) AT=860.025n

* CHECK dout0_21 Vdout0_21ck171 = 0 time = 860
.meas tran vdout0_21ck171 FIND v(dout0_21) AT=860.025n

* CHECK dout0_22 Vdout0_22ck171 = 0.9 time = 860
.meas tran vdout0_22ck171 FIND v(dout0_22) AT=860.025n

* CHECK dout0_23 Vdout0_23ck171 = 0 time = 860
.meas tran vdout0_23ck171 FIND v(dout0_23) AT=860.025n

* CHECK dout0_24 Vdout0_24ck171 = 0.9 time = 860
.meas tran vdout0_24ck171 FIND v(dout0_24) AT=860.025n

* CHECK dout0_25 Vdout0_25ck171 = 0 time = 860
.meas tran vdout0_25ck171 FIND v(dout0_25) AT=860.025n

* CHECK dout0_26 Vdout0_26ck171 = 0.9 time = 860
.meas tran vdout0_26ck171 FIND v(dout0_26) AT=860.025n

* CHECK dout0_27 Vdout0_27ck171 = 0 time = 860
.meas tran vdout0_27ck171 FIND v(dout0_27) AT=860.025n

* CHECK dout0_28 Vdout0_28ck171 = 0 time = 860
.meas tran vdout0_28ck171 FIND v(dout0_28) AT=860.025n

* CHECK dout0_29 Vdout0_29ck171 = 0 time = 860
.meas tran vdout0_29ck171 FIND v(dout0_29) AT=860.025n

* CHECK dout0_30 Vdout0_30ck171 = 0.9 time = 860
.meas tran vdout0_30ck171 FIND v(dout0_30) AT=860.025n

* CHECK dout0_31 Vdout0_31ck171 = 0 time = 860
.meas tran vdout0_31ck171 FIND v(dout0_31) AT=860.025n

* CHECK dout0_32 Vdout0_32ck171 = 0.9 time = 860
.meas tran vdout0_32ck171 FIND v(dout0_32) AT=860.025n

* CHECK dout0_33 Vdout0_33ck171 = 0 time = 860
.meas tran vdout0_33ck171 FIND v(dout0_33) AT=860.025n

* CHECK dout0_34 Vdout0_34ck171 = 0.9 time = 860
.meas tran vdout0_34ck171 FIND v(dout0_34) AT=860.025n

* CHECK dout0_35 Vdout0_35ck171 = 0 time = 860
.meas tran vdout0_35ck171 FIND v(dout0_35) AT=860.025n

* CHECK dout0_36 Vdout0_36ck171 = 0.9 time = 860
.meas tran vdout0_36ck171 FIND v(dout0_36) AT=860.025n

* CHECK dout0_37 Vdout0_37ck171 = 0.9 time = 860
.meas tran vdout0_37ck171 FIND v(dout0_37) AT=860.025n

* CHECK dout0_38 Vdout0_38ck171 = 0.9 time = 860
.meas tran vdout0_38ck171 FIND v(dout0_38) AT=860.025n

* CHECK dout0_39 Vdout0_39ck171 = 0.9 time = 860
.meas tran vdout0_39ck171 FIND v(dout0_39) AT=860.025n

* CHECK dout0_40 Vdout0_40ck171 = 0 time = 860
.meas tran vdout0_40ck171 FIND v(dout0_40) AT=860.025n

* CHECK dout0_41 Vdout0_41ck171 = 0.9 time = 860
.meas tran vdout0_41ck171 FIND v(dout0_41) AT=860.025n

* CHECK dout0_42 Vdout0_42ck171 = 0.9 time = 860
.meas tran vdout0_42ck171 FIND v(dout0_42) AT=860.025n

* CHECK dout0_43 Vdout0_43ck171 = 0.9 time = 860
.meas tran vdout0_43ck171 FIND v(dout0_43) AT=860.025n

* CHECK dout0_44 Vdout0_44ck171 = 0 time = 860
.meas tran vdout0_44ck171 FIND v(dout0_44) AT=860.025n

* CHECK dout0_45 Vdout0_45ck171 = 0.9 time = 860
.meas tran vdout0_45ck171 FIND v(dout0_45) AT=860.025n

* CHECK dout0_46 Vdout0_46ck171 = 0 time = 860
.meas tran vdout0_46ck171 FIND v(dout0_46) AT=860.025n

* CHECK dout0_47 Vdout0_47ck171 = 0 time = 860
.meas tran vdout0_47ck171 FIND v(dout0_47) AT=860.025n

* CHECK dout0_48 Vdout0_48ck171 = 0 time = 860
.meas tran vdout0_48ck171 FIND v(dout0_48) AT=860.025n

* CHECK dout0_49 Vdout0_49ck171 = 0.9 time = 860
.meas tran vdout0_49ck171 FIND v(dout0_49) AT=860.025n

* CHECK dout0_50 Vdout0_50ck171 = 0.9 time = 860
.meas tran vdout0_50ck171 FIND v(dout0_50) AT=860.025n

* CHECK dout0_51 Vdout0_51ck171 = 0.9 time = 860
.meas tran vdout0_51ck171 FIND v(dout0_51) AT=860.025n

* CHECK dout0_52 Vdout0_52ck171 = 0.9 time = 860
.meas tran vdout0_52ck171 FIND v(dout0_52) AT=860.025n

* CHECK dout0_53 Vdout0_53ck171 = 0 time = 860
.meas tran vdout0_53ck171 FIND v(dout0_53) AT=860.025n

* CHECK dout0_54 Vdout0_54ck171 = 0 time = 860
.meas tran vdout0_54ck171 FIND v(dout0_54) AT=860.025n

* CHECK dout0_55 Vdout0_55ck171 = 0.9 time = 860
.meas tran vdout0_55ck171 FIND v(dout0_55) AT=860.025n

* CHECK dout0_56 Vdout0_56ck171 = 0.9 time = 860
.meas tran vdout0_56ck171 FIND v(dout0_56) AT=860.025n

* CHECK dout0_57 Vdout0_57ck171 = 0.9 time = 860
.meas tran vdout0_57ck171 FIND v(dout0_57) AT=860.025n

* CHECK dout0_58 Vdout0_58ck171 = 0 time = 860
.meas tran vdout0_58ck171 FIND v(dout0_58) AT=860.025n

* CHECK dout0_59 Vdout0_59ck171 = 0.9 time = 860
.meas tran vdout0_59ck171 FIND v(dout0_59) AT=860.025n

* CHECK dout0_60 Vdout0_60ck171 = 0.9 time = 860
.meas tran vdout0_60ck171 FIND v(dout0_60) AT=860.025n

* CHECK dout0_61 Vdout0_61ck171 = 0.9 time = 860
.meas tran vdout0_61ck171 FIND v(dout0_61) AT=860.025n

* CHECK dout0_62 Vdout0_62ck171 = 0.9 time = 860
.meas tran vdout0_62ck171 FIND v(dout0_62) AT=860.025n

* CHECK dout0_63 Vdout0_63ck171 = 0 time = 860
.meas tran vdout0_63ck171 FIND v(dout0_63) AT=860.025n

* CHECK dout0_0 Vdout0_0ck173 = 0 time = 870
.meas tran vdout0_0ck173 FIND v(dout0_0) AT=870.025n

* CHECK dout0_1 Vdout0_1ck173 = 0 time = 870
.meas tran vdout0_1ck173 FIND v(dout0_1) AT=870.025n

* CHECK dout0_2 Vdout0_2ck173 = 0 time = 870
.meas tran vdout0_2ck173 FIND v(dout0_2) AT=870.025n

* CHECK dout0_3 Vdout0_3ck173 = 0.9 time = 870
.meas tran vdout0_3ck173 FIND v(dout0_3) AT=870.025n

* CHECK dout0_4 Vdout0_4ck173 = 0 time = 870
.meas tran vdout0_4ck173 FIND v(dout0_4) AT=870.025n

* CHECK dout0_5 Vdout0_5ck173 = 0 time = 870
.meas tran vdout0_5ck173 FIND v(dout0_5) AT=870.025n

* CHECK dout0_6 Vdout0_6ck173 = 0 time = 870
.meas tran vdout0_6ck173 FIND v(dout0_6) AT=870.025n

* CHECK dout0_7 Vdout0_7ck173 = 0 time = 870
.meas tran vdout0_7ck173 FIND v(dout0_7) AT=870.025n

* CHECK dout0_8 Vdout0_8ck173 = 0.9 time = 870
.meas tran vdout0_8ck173 FIND v(dout0_8) AT=870.025n

* CHECK dout0_9 Vdout0_9ck173 = 0 time = 870
.meas tran vdout0_9ck173 FIND v(dout0_9) AT=870.025n

* CHECK dout0_10 Vdout0_10ck173 = 0.9 time = 870
.meas tran vdout0_10ck173 FIND v(dout0_10) AT=870.025n

* CHECK dout0_11 Vdout0_11ck173 = 0 time = 870
.meas tran vdout0_11ck173 FIND v(dout0_11) AT=870.025n

* CHECK dout0_12 Vdout0_12ck173 = 0 time = 870
.meas tran vdout0_12ck173 FIND v(dout0_12) AT=870.025n

* CHECK dout0_13 Vdout0_13ck173 = 0.9 time = 870
.meas tran vdout0_13ck173 FIND v(dout0_13) AT=870.025n

* CHECK dout0_14 Vdout0_14ck173 = 0.9 time = 870
.meas tran vdout0_14ck173 FIND v(dout0_14) AT=870.025n

* CHECK dout0_15 Vdout0_15ck173 = 0.9 time = 870
.meas tran vdout0_15ck173 FIND v(dout0_15) AT=870.025n

* CHECK dout0_16 Vdout0_16ck173 = 0 time = 870
.meas tran vdout0_16ck173 FIND v(dout0_16) AT=870.025n

* CHECK dout0_17 Vdout0_17ck173 = 0.9 time = 870
.meas tran vdout0_17ck173 FIND v(dout0_17) AT=870.025n

* CHECK dout0_18 Vdout0_18ck173 = 0 time = 870
.meas tran vdout0_18ck173 FIND v(dout0_18) AT=870.025n

* CHECK dout0_19 Vdout0_19ck173 = 0.9 time = 870
.meas tran vdout0_19ck173 FIND v(dout0_19) AT=870.025n

* CHECK dout0_20 Vdout0_20ck173 = 0 time = 870
.meas tran vdout0_20ck173 FIND v(dout0_20) AT=870.025n

* CHECK dout0_21 Vdout0_21ck173 = 0 time = 870
.meas tran vdout0_21ck173 FIND v(dout0_21) AT=870.025n

* CHECK dout0_22 Vdout0_22ck173 = 0.9 time = 870
.meas tran vdout0_22ck173 FIND v(dout0_22) AT=870.025n

* CHECK dout0_23 Vdout0_23ck173 = 0.9 time = 870
.meas tran vdout0_23ck173 FIND v(dout0_23) AT=870.025n

* CHECK dout0_24 Vdout0_24ck173 = 0 time = 870
.meas tran vdout0_24ck173 FIND v(dout0_24) AT=870.025n

* CHECK dout0_25 Vdout0_25ck173 = 0 time = 870
.meas tran vdout0_25ck173 FIND v(dout0_25) AT=870.025n

* CHECK dout0_26 Vdout0_26ck173 = 0.9 time = 870
.meas tran vdout0_26ck173 FIND v(dout0_26) AT=870.025n

* CHECK dout0_27 Vdout0_27ck173 = 0 time = 870
.meas tran vdout0_27ck173 FIND v(dout0_27) AT=870.025n

* CHECK dout0_28 Vdout0_28ck173 = 0 time = 870
.meas tran vdout0_28ck173 FIND v(dout0_28) AT=870.025n

* CHECK dout0_29 Vdout0_29ck173 = 0.9 time = 870
.meas tran vdout0_29ck173 FIND v(dout0_29) AT=870.025n

* CHECK dout0_30 Vdout0_30ck173 = 0 time = 870
.meas tran vdout0_30ck173 FIND v(dout0_30) AT=870.025n

* CHECK dout0_31 Vdout0_31ck173 = 0 time = 870
.meas tran vdout0_31ck173 FIND v(dout0_31) AT=870.025n

* CHECK dout0_32 Vdout0_32ck173 = 0.9 time = 870
.meas tran vdout0_32ck173 FIND v(dout0_32) AT=870.025n

* CHECK dout0_33 Vdout0_33ck173 = 0 time = 870
.meas tran vdout0_33ck173 FIND v(dout0_33) AT=870.025n

* CHECK dout0_34 Vdout0_34ck173 = 0.9 time = 870
.meas tran vdout0_34ck173 FIND v(dout0_34) AT=870.025n

* CHECK dout0_35 Vdout0_35ck173 = 0.9 time = 870
.meas tran vdout0_35ck173 FIND v(dout0_35) AT=870.025n

* CHECK dout0_36 Vdout0_36ck173 = 0.9 time = 870
.meas tran vdout0_36ck173 FIND v(dout0_36) AT=870.025n

* CHECK dout0_37 Vdout0_37ck173 = 0 time = 870
.meas tran vdout0_37ck173 FIND v(dout0_37) AT=870.025n

* CHECK dout0_38 Vdout0_38ck173 = 0.9 time = 870
.meas tran vdout0_38ck173 FIND v(dout0_38) AT=870.025n

* CHECK dout0_39 Vdout0_39ck173 = 0 time = 870
.meas tran vdout0_39ck173 FIND v(dout0_39) AT=870.025n

* CHECK dout0_40 Vdout0_40ck173 = 0.9 time = 870
.meas tran vdout0_40ck173 FIND v(dout0_40) AT=870.025n

* CHECK dout0_41 Vdout0_41ck173 = 0.9 time = 870
.meas tran vdout0_41ck173 FIND v(dout0_41) AT=870.025n

* CHECK dout0_42 Vdout0_42ck173 = 0 time = 870
.meas tran vdout0_42ck173 FIND v(dout0_42) AT=870.025n

* CHECK dout0_43 Vdout0_43ck173 = 0 time = 870
.meas tran vdout0_43ck173 FIND v(dout0_43) AT=870.025n

* CHECK dout0_44 Vdout0_44ck173 = 0.9 time = 870
.meas tran vdout0_44ck173 FIND v(dout0_44) AT=870.025n

* CHECK dout0_45 Vdout0_45ck173 = 0 time = 870
.meas tran vdout0_45ck173 FIND v(dout0_45) AT=870.025n

* CHECK dout0_46 Vdout0_46ck173 = 0 time = 870
.meas tran vdout0_46ck173 FIND v(dout0_46) AT=870.025n

* CHECK dout0_47 Vdout0_47ck173 = 0 time = 870
.meas tran vdout0_47ck173 FIND v(dout0_47) AT=870.025n

* CHECK dout0_48 Vdout0_48ck173 = 0 time = 870
.meas tran vdout0_48ck173 FIND v(dout0_48) AT=870.025n

* CHECK dout0_49 Vdout0_49ck173 = 0.9 time = 870
.meas tran vdout0_49ck173 FIND v(dout0_49) AT=870.025n

* CHECK dout0_50 Vdout0_50ck173 = 0.9 time = 870
.meas tran vdout0_50ck173 FIND v(dout0_50) AT=870.025n

* CHECK dout0_51 Vdout0_51ck173 = 0 time = 870
.meas tran vdout0_51ck173 FIND v(dout0_51) AT=870.025n

* CHECK dout0_52 Vdout0_52ck173 = 0 time = 870
.meas tran vdout0_52ck173 FIND v(dout0_52) AT=870.025n

* CHECK dout0_53 Vdout0_53ck173 = 0.9 time = 870
.meas tran vdout0_53ck173 FIND v(dout0_53) AT=870.025n

* CHECK dout0_54 Vdout0_54ck173 = 0 time = 870
.meas tran vdout0_54ck173 FIND v(dout0_54) AT=870.025n

* CHECK dout0_55 Vdout0_55ck173 = 0 time = 870
.meas tran vdout0_55ck173 FIND v(dout0_55) AT=870.025n

* CHECK dout0_56 Vdout0_56ck173 = 0.9 time = 870
.meas tran vdout0_56ck173 FIND v(dout0_56) AT=870.025n

* CHECK dout0_57 Vdout0_57ck173 = 0 time = 870
.meas tran vdout0_57ck173 FIND v(dout0_57) AT=870.025n

* CHECK dout0_58 Vdout0_58ck173 = 0 time = 870
.meas tran vdout0_58ck173 FIND v(dout0_58) AT=870.025n

* CHECK dout0_59 Vdout0_59ck173 = 0.9 time = 870
.meas tran vdout0_59ck173 FIND v(dout0_59) AT=870.025n

* CHECK dout0_60 Vdout0_60ck173 = 0 time = 870
.meas tran vdout0_60ck173 FIND v(dout0_60) AT=870.025n

* CHECK dout0_61 Vdout0_61ck173 = 0.9 time = 870
.meas tran vdout0_61ck173 FIND v(dout0_61) AT=870.025n

* CHECK dout0_62 Vdout0_62ck173 = 0.9 time = 870
.meas tran vdout0_62ck173 FIND v(dout0_62) AT=870.025n

* CHECK dout0_63 Vdout0_63ck173 = 0.9 time = 870
.meas tran vdout0_63ck173 FIND v(dout0_63) AT=870.025n

* CHECK dout0_0 Vdout0_0ck174 = 0 time = 875
.meas tran vdout0_0ck174 FIND v(dout0_0) AT=875.025n

* CHECK dout0_1 Vdout0_1ck174 = 0 time = 875
.meas tran vdout0_1ck174 FIND v(dout0_1) AT=875.025n

* CHECK dout0_2 Vdout0_2ck174 = 0 time = 875
.meas tran vdout0_2ck174 FIND v(dout0_2) AT=875.025n

* CHECK dout0_3 Vdout0_3ck174 = 0.9 time = 875
.meas tran vdout0_3ck174 FIND v(dout0_3) AT=875.025n

* CHECK dout0_4 Vdout0_4ck174 = 0 time = 875
.meas tran vdout0_4ck174 FIND v(dout0_4) AT=875.025n

* CHECK dout0_5 Vdout0_5ck174 = 0 time = 875
.meas tran vdout0_5ck174 FIND v(dout0_5) AT=875.025n

* CHECK dout0_6 Vdout0_6ck174 = 0 time = 875
.meas tran vdout0_6ck174 FIND v(dout0_6) AT=875.025n

* CHECK dout0_7 Vdout0_7ck174 = 0 time = 875
.meas tran vdout0_7ck174 FIND v(dout0_7) AT=875.025n

* CHECK dout0_8 Vdout0_8ck174 = 0.9 time = 875
.meas tran vdout0_8ck174 FIND v(dout0_8) AT=875.025n

* CHECK dout0_9 Vdout0_9ck174 = 0 time = 875
.meas tran vdout0_9ck174 FIND v(dout0_9) AT=875.025n

* CHECK dout0_10 Vdout0_10ck174 = 0.9 time = 875
.meas tran vdout0_10ck174 FIND v(dout0_10) AT=875.025n

* CHECK dout0_11 Vdout0_11ck174 = 0 time = 875
.meas tran vdout0_11ck174 FIND v(dout0_11) AT=875.025n

* CHECK dout0_12 Vdout0_12ck174 = 0 time = 875
.meas tran vdout0_12ck174 FIND v(dout0_12) AT=875.025n

* CHECK dout0_13 Vdout0_13ck174 = 0.9 time = 875
.meas tran vdout0_13ck174 FIND v(dout0_13) AT=875.025n

* CHECK dout0_14 Vdout0_14ck174 = 0.9 time = 875
.meas tran vdout0_14ck174 FIND v(dout0_14) AT=875.025n

* CHECK dout0_15 Vdout0_15ck174 = 0.9 time = 875
.meas tran vdout0_15ck174 FIND v(dout0_15) AT=875.025n

* CHECK dout0_16 Vdout0_16ck174 = 0 time = 875
.meas tran vdout0_16ck174 FIND v(dout0_16) AT=875.025n

* CHECK dout0_17 Vdout0_17ck174 = 0.9 time = 875
.meas tran vdout0_17ck174 FIND v(dout0_17) AT=875.025n

* CHECK dout0_18 Vdout0_18ck174 = 0 time = 875
.meas tran vdout0_18ck174 FIND v(dout0_18) AT=875.025n

* CHECK dout0_19 Vdout0_19ck174 = 0.9 time = 875
.meas tran vdout0_19ck174 FIND v(dout0_19) AT=875.025n

* CHECK dout0_20 Vdout0_20ck174 = 0 time = 875
.meas tran vdout0_20ck174 FIND v(dout0_20) AT=875.025n

* CHECK dout0_21 Vdout0_21ck174 = 0 time = 875
.meas tran vdout0_21ck174 FIND v(dout0_21) AT=875.025n

* CHECK dout0_22 Vdout0_22ck174 = 0.9 time = 875
.meas tran vdout0_22ck174 FIND v(dout0_22) AT=875.025n

* CHECK dout0_23 Vdout0_23ck174 = 0.9 time = 875
.meas tran vdout0_23ck174 FIND v(dout0_23) AT=875.025n

* CHECK dout0_24 Vdout0_24ck174 = 0 time = 875
.meas tran vdout0_24ck174 FIND v(dout0_24) AT=875.025n

* CHECK dout0_25 Vdout0_25ck174 = 0 time = 875
.meas tran vdout0_25ck174 FIND v(dout0_25) AT=875.025n

* CHECK dout0_26 Vdout0_26ck174 = 0.9 time = 875
.meas tran vdout0_26ck174 FIND v(dout0_26) AT=875.025n

* CHECK dout0_27 Vdout0_27ck174 = 0 time = 875
.meas tran vdout0_27ck174 FIND v(dout0_27) AT=875.025n

* CHECK dout0_28 Vdout0_28ck174 = 0 time = 875
.meas tran vdout0_28ck174 FIND v(dout0_28) AT=875.025n

* CHECK dout0_29 Vdout0_29ck174 = 0.9 time = 875
.meas tran vdout0_29ck174 FIND v(dout0_29) AT=875.025n

* CHECK dout0_30 Vdout0_30ck174 = 0 time = 875
.meas tran vdout0_30ck174 FIND v(dout0_30) AT=875.025n

* CHECK dout0_31 Vdout0_31ck174 = 0 time = 875
.meas tran vdout0_31ck174 FIND v(dout0_31) AT=875.025n

* CHECK dout0_32 Vdout0_32ck174 = 0.9 time = 875
.meas tran vdout0_32ck174 FIND v(dout0_32) AT=875.025n

* CHECK dout0_33 Vdout0_33ck174 = 0 time = 875
.meas tran vdout0_33ck174 FIND v(dout0_33) AT=875.025n

* CHECK dout0_34 Vdout0_34ck174 = 0.9 time = 875
.meas tran vdout0_34ck174 FIND v(dout0_34) AT=875.025n

* CHECK dout0_35 Vdout0_35ck174 = 0.9 time = 875
.meas tran vdout0_35ck174 FIND v(dout0_35) AT=875.025n

* CHECK dout0_36 Vdout0_36ck174 = 0.9 time = 875
.meas tran vdout0_36ck174 FIND v(dout0_36) AT=875.025n

* CHECK dout0_37 Vdout0_37ck174 = 0 time = 875
.meas tran vdout0_37ck174 FIND v(dout0_37) AT=875.025n

* CHECK dout0_38 Vdout0_38ck174 = 0.9 time = 875
.meas tran vdout0_38ck174 FIND v(dout0_38) AT=875.025n

* CHECK dout0_39 Vdout0_39ck174 = 0 time = 875
.meas tran vdout0_39ck174 FIND v(dout0_39) AT=875.025n

* CHECK dout0_40 Vdout0_40ck174 = 0.9 time = 875
.meas tran vdout0_40ck174 FIND v(dout0_40) AT=875.025n

* CHECK dout0_41 Vdout0_41ck174 = 0.9 time = 875
.meas tran vdout0_41ck174 FIND v(dout0_41) AT=875.025n

* CHECK dout0_42 Vdout0_42ck174 = 0 time = 875
.meas tran vdout0_42ck174 FIND v(dout0_42) AT=875.025n

* CHECK dout0_43 Vdout0_43ck174 = 0 time = 875
.meas tran vdout0_43ck174 FIND v(dout0_43) AT=875.025n

* CHECK dout0_44 Vdout0_44ck174 = 0.9 time = 875
.meas tran vdout0_44ck174 FIND v(dout0_44) AT=875.025n

* CHECK dout0_45 Vdout0_45ck174 = 0 time = 875
.meas tran vdout0_45ck174 FIND v(dout0_45) AT=875.025n

* CHECK dout0_46 Vdout0_46ck174 = 0 time = 875
.meas tran vdout0_46ck174 FIND v(dout0_46) AT=875.025n

* CHECK dout0_47 Vdout0_47ck174 = 0 time = 875
.meas tran vdout0_47ck174 FIND v(dout0_47) AT=875.025n

* CHECK dout0_48 Vdout0_48ck174 = 0 time = 875
.meas tran vdout0_48ck174 FIND v(dout0_48) AT=875.025n

* CHECK dout0_49 Vdout0_49ck174 = 0.9 time = 875
.meas tran vdout0_49ck174 FIND v(dout0_49) AT=875.025n

* CHECK dout0_50 Vdout0_50ck174 = 0.9 time = 875
.meas tran vdout0_50ck174 FIND v(dout0_50) AT=875.025n

* CHECK dout0_51 Vdout0_51ck174 = 0 time = 875
.meas tran vdout0_51ck174 FIND v(dout0_51) AT=875.025n

* CHECK dout0_52 Vdout0_52ck174 = 0 time = 875
.meas tran vdout0_52ck174 FIND v(dout0_52) AT=875.025n

* CHECK dout0_53 Vdout0_53ck174 = 0.9 time = 875
.meas tran vdout0_53ck174 FIND v(dout0_53) AT=875.025n

* CHECK dout0_54 Vdout0_54ck174 = 0 time = 875
.meas tran vdout0_54ck174 FIND v(dout0_54) AT=875.025n

* CHECK dout0_55 Vdout0_55ck174 = 0 time = 875
.meas tran vdout0_55ck174 FIND v(dout0_55) AT=875.025n

* CHECK dout0_56 Vdout0_56ck174 = 0.9 time = 875
.meas tran vdout0_56ck174 FIND v(dout0_56) AT=875.025n

* CHECK dout0_57 Vdout0_57ck174 = 0 time = 875
.meas tran vdout0_57ck174 FIND v(dout0_57) AT=875.025n

* CHECK dout0_58 Vdout0_58ck174 = 0 time = 875
.meas tran vdout0_58ck174 FIND v(dout0_58) AT=875.025n

* CHECK dout0_59 Vdout0_59ck174 = 0.9 time = 875
.meas tran vdout0_59ck174 FIND v(dout0_59) AT=875.025n

* CHECK dout0_60 Vdout0_60ck174 = 0 time = 875
.meas tran vdout0_60ck174 FIND v(dout0_60) AT=875.025n

* CHECK dout0_61 Vdout0_61ck174 = 0.9 time = 875
.meas tran vdout0_61ck174 FIND v(dout0_61) AT=875.025n

* CHECK dout0_62 Vdout0_62ck174 = 0.9 time = 875
.meas tran vdout0_62ck174 FIND v(dout0_62) AT=875.025n

* CHECK dout0_63 Vdout0_63ck174 = 0.9 time = 875
.meas tran vdout0_63ck174 FIND v(dout0_63) AT=875.025n

* CHECK dout0_0 Vdout0_0ck176 = 0 time = 885
.meas tran vdout0_0ck176 FIND v(dout0_0) AT=885.025n

* CHECK dout0_1 Vdout0_1ck176 = 0.9 time = 885
.meas tran vdout0_1ck176 FIND v(dout0_1) AT=885.025n

* CHECK dout0_2 Vdout0_2ck176 = 0 time = 885
.meas tran vdout0_2ck176 FIND v(dout0_2) AT=885.025n

* CHECK dout0_3 Vdout0_3ck176 = 0.9 time = 885
.meas tran vdout0_3ck176 FIND v(dout0_3) AT=885.025n

* CHECK dout0_4 Vdout0_4ck176 = 0.9 time = 885
.meas tran vdout0_4ck176 FIND v(dout0_4) AT=885.025n

* CHECK dout0_5 Vdout0_5ck176 = 0.9 time = 885
.meas tran vdout0_5ck176 FIND v(dout0_5) AT=885.025n

* CHECK dout0_6 Vdout0_6ck176 = 0.9 time = 885
.meas tran vdout0_6ck176 FIND v(dout0_6) AT=885.025n

* CHECK dout0_7 Vdout0_7ck176 = 0 time = 885
.meas tran vdout0_7ck176 FIND v(dout0_7) AT=885.025n

* CHECK dout0_8 Vdout0_8ck176 = 0.9 time = 885
.meas tran vdout0_8ck176 FIND v(dout0_8) AT=885.025n

* CHECK dout0_9 Vdout0_9ck176 = 0 time = 885
.meas tran vdout0_9ck176 FIND v(dout0_9) AT=885.025n

* CHECK dout0_10 Vdout0_10ck176 = 0 time = 885
.meas tran vdout0_10ck176 FIND v(dout0_10) AT=885.025n

* CHECK dout0_11 Vdout0_11ck176 = 0.9 time = 885
.meas tran vdout0_11ck176 FIND v(dout0_11) AT=885.025n

* CHECK dout0_12 Vdout0_12ck176 = 0.9 time = 885
.meas tran vdout0_12ck176 FIND v(dout0_12) AT=885.025n

* CHECK dout0_13 Vdout0_13ck176 = 0.9 time = 885
.meas tran vdout0_13ck176 FIND v(dout0_13) AT=885.025n

* CHECK dout0_14 Vdout0_14ck176 = 0.9 time = 885
.meas tran vdout0_14ck176 FIND v(dout0_14) AT=885.025n

* CHECK dout0_15 Vdout0_15ck176 = 0 time = 885
.meas tran vdout0_15ck176 FIND v(dout0_15) AT=885.025n

* CHECK dout0_16 Vdout0_16ck176 = 0 time = 885
.meas tran vdout0_16ck176 FIND v(dout0_16) AT=885.025n

* CHECK dout0_17 Vdout0_17ck176 = 0.9 time = 885
.meas tran vdout0_17ck176 FIND v(dout0_17) AT=885.025n

* CHECK dout0_18 Vdout0_18ck176 = 0 time = 885
.meas tran vdout0_18ck176 FIND v(dout0_18) AT=885.025n

* CHECK dout0_19 Vdout0_19ck176 = 0.9 time = 885
.meas tran vdout0_19ck176 FIND v(dout0_19) AT=885.025n

* CHECK dout0_20 Vdout0_20ck176 = 0 time = 885
.meas tran vdout0_20ck176 FIND v(dout0_20) AT=885.025n

* CHECK dout0_21 Vdout0_21ck176 = 0 time = 885
.meas tran vdout0_21ck176 FIND v(dout0_21) AT=885.025n

* CHECK dout0_22 Vdout0_22ck176 = 0.9 time = 885
.meas tran vdout0_22ck176 FIND v(dout0_22) AT=885.025n

* CHECK dout0_23 Vdout0_23ck176 = 0 time = 885
.meas tran vdout0_23ck176 FIND v(dout0_23) AT=885.025n

* CHECK dout0_24 Vdout0_24ck176 = 0.9 time = 885
.meas tran vdout0_24ck176 FIND v(dout0_24) AT=885.025n

* CHECK dout0_25 Vdout0_25ck176 = 0.9 time = 885
.meas tran vdout0_25ck176 FIND v(dout0_25) AT=885.025n

* CHECK dout0_26 Vdout0_26ck176 = 0.9 time = 885
.meas tran vdout0_26ck176 FIND v(dout0_26) AT=885.025n

* CHECK dout0_27 Vdout0_27ck176 = 0 time = 885
.meas tran vdout0_27ck176 FIND v(dout0_27) AT=885.025n

* CHECK dout0_28 Vdout0_28ck176 = 0 time = 885
.meas tran vdout0_28ck176 FIND v(dout0_28) AT=885.025n

* CHECK dout0_29 Vdout0_29ck176 = 0.9 time = 885
.meas tran vdout0_29ck176 FIND v(dout0_29) AT=885.025n

* CHECK dout0_30 Vdout0_30ck176 = 0.9 time = 885
.meas tran vdout0_30ck176 FIND v(dout0_30) AT=885.025n

* CHECK dout0_31 Vdout0_31ck176 = 0.9 time = 885
.meas tran vdout0_31ck176 FIND v(dout0_31) AT=885.025n

* CHECK dout0_32 Vdout0_32ck176 = 0 time = 885
.meas tran vdout0_32ck176 FIND v(dout0_32) AT=885.025n

* CHECK dout0_33 Vdout0_33ck176 = 0.9 time = 885
.meas tran vdout0_33ck176 FIND v(dout0_33) AT=885.025n

* CHECK dout0_34 Vdout0_34ck176 = 0 time = 885
.meas tran vdout0_34ck176 FIND v(dout0_34) AT=885.025n

* CHECK dout0_35 Vdout0_35ck176 = 0.9 time = 885
.meas tran vdout0_35ck176 FIND v(dout0_35) AT=885.025n

* CHECK dout0_36 Vdout0_36ck176 = 0 time = 885
.meas tran vdout0_36ck176 FIND v(dout0_36) AT=885.025n

* CHECK dout0_37 Vdout0_37ck176 = 0 time = 885
.meas tran vdout0_37ck176 FIND v(dout0_37) AT=885.025n

* CHECK dout0_38 Vdout0_38ck176 = 0 time = 885
.meas tran vdout0_38ck176 FIND v(dout0_38) AT=885.025n

* CHECK dout0_39 Vdout0_39ck176 = 0.9 time = 885
.meas tran vdout0_39ck176 FIND v(dout0_39) AT=885.025n

* CHECK dout0_40 Vdout0_40ck176 = 0 time = 885
.meas tran vdout0_40ck176 FIND v(dout0_40) AT=885.025n

* CHECK dout0_41 Vdout0_41ck176 = 0 time = 885
.meas tran vdout0_41ck176 FIND v(dout0_41) AT=885.025n

* CHECK dout0_42 Vdout0_42ck176 = 0 time = 885
.meas tran vdout0_42ck176 FIND v(dout0_42) AT=885.025n

* CHECK dout0_43 Vdout0_43ck176 = 0 time = 885
.meas tran vdout0_43ck176 FIND v(dout0_43) AT=885.025n

* CHECK dout0_44 Vdout0_44ck176 = 0.9 time = 885
.meas tran vdout0_44ck176 FIND v(dout0_44) AT=885.025n

* CHECK dout0_45 Vdout0_45ck176 = 0.9 time = 885
.meas tran vdout0_45ck176 FIND v(dout0_45) AT=885.025n

* CHECK dout0_46 Vdout0_46ck176 = 0 time = 885
.meas tran vdout0_46ck176 FIND v(dout0_46) AT=885.025n

* CHECK dout0_47 Vdout0_47ck176 = 0 time = 885
.meas tran vdout0_47ck176 FIND v(dout0_47) AT=885.025n

* CHECK dout0_48 Vdout0_48ck176 = 0 time = 885
.meas tran vdout0_48ck176 FIND v(dout0_48) AT=885.025n

* CHECK dout0_49 Vdout0_49ck176 = 0.9 time = 885
.meas tran vdout0_49ck176 FIND v(dout0_49) AT=885.025n

* CHECK dout0_50 Vdout0_50ck176 = 0.9 time = 885
.meas tran vdout0_50ck176 FIND v(dout0_50) AT=885.025n

* CHECK dout0_51 Vdout0_51ck176 = 0 time = 885
.meas tran vdout0_51ck176 FIND v(dout0_51) AT=885.025n

* CHECK dout0_52 Vdout0_52ck176 = 0.9 time = 885
.meas tran vdout0_52ck176 FIND v(dout0_52) AT=885.025n

* CHECK dout0_53 Vdout0_53ck176 = 0 time = 885
.meas tran vdout0_53ck176 FIND v(dout0_53) AT=885.025n

* CHECK dout0_54 Vdout0_54ck176 = 0 time = 885
.meas tran vdout0_54ck176 FIND v(dout0_54) AT=885.025n

* CHECK dout0_55 Vdout0_55ck176 = 0.9 time = 885
.meas tran vdout0_55ck176 FIND v(dout0_55) AT=885.025n

* CHECK dout0_56 Vdout0_56ck176 = 0.9 time = 885
.meas tran vdout0_56ck176 FIND v(dout0_56) AT=885.025n

* CHECK dout0_57 Vdout0_57ck176 = 0.9 time = 885
.meas tran vdout0_57ck176 FIND v(dout0_57) AT=885.025n

* CHECK dout0_58 Vdout0_58ck176 = 0.9 time = 885
.meas tran vdout0_58ck176 FIND v(dout0_58) AT=885.025n

* CHECK dout0_59 Vdout0_59ck176 = 0 time = 885
.meas tran vdout0_59ck176 FIND v(dout0_59) AT=885.025n

* CHECK dout0_60 Vdout0_60ck176 = 0.9 time = 885
.meas tran vdout0_60ck176 FIND v(dout0_60) AT=885.025n

* CHECK dout0_61 Vdout0_61ck176 = 0.9 time = 885
.meas tran vdout0_61ck176 FIND v(dout0_61) AT=885.025n

* CHECK dout0_62 Vdout0_62ck176 = 0.9 time = 885
.meas tran vdout0_62ck176 FIND v(dout0_62) AT=885.025n

* CHECK dout0_63 Vdout0_63ck176 = 0.9 time = 885
.meas tran vdout0_63ck176 FIND v(dout0_63) AT=885.025n

* CHECK dout0_0 Vdout0_0ck177 = 0 time = 890
.meas tran vdout0_0ck177 FIND v(dout0_0) AT=890.025n

* CHECK dout0_1 Vdout0_1ck177 = 0 time = 890
.meas tran vdout0_1ck177 FIND v(dout0_1) AT=890.025n

* CHECK dout0_2 Vdout0_2ck177 = 0 time = 890
.meas tran vdout0_2ck177 FIND v(dout0_2) AT=890.025n

* CHECK dout0_3 Vdout0_3ck177 = 0.9 time = 890
.meas tran vdout0_3ck177 FIND v(dout0_3) AT=890.025n

* CHECK dout0_4 Vdout0_4ck177 = 0 time = 890
.meas tran vdout0_4ck177 FIND v(dout0_4) AT=890.025n

* CHECK dout0_5 Vdout0_5ck177 = 0 time = 890
.meas tran vdout0_5ck177 FIND v(dout0_5) AT=890.025n

* CHECK dout0_6 Vdout0_6ck177 = 0 time = 890
.meas tran vdout0_6ck177 FIND v(dout0_6) AT=890.025n

* CHECK dout0_7 Vdout0_7ck177 = 0 time = 890
.meas tran vdout0_7ck177 FIND v(dout0_7) AT=890.025n

* CHECK dout0_8 Vdout0_8ck177 = 0.9 time = 890
.meas tran vdout0_8ck177 FIND v(dout0_8) AT=890.025n

* CHECK dout0_9 Vdout0_9ck177 = 0 time = 890
.meas tran vdout0_9ck177 FIND v(dout0_9) AT=890.025n

* CHECK dout0_10 Vdout0_10ck177 = 0.9 time = 890
.meas tran vdout0_10ck177 FIND v(dout0_10) AT=890.025n

* CHECK dout0_11 Vdout0_11ck177 = 0 time = 890
.meas tran vdout0_11ck177 FIND v(dout0_11) AT=890.025n

* CHECK dout0_12 Vdout0_12ck177 = 0 time = 890
.meas tran vdout0_12ck177 FIND v(dout0_12) AT=890.025n

* CHECK dout0_13 Vdout0_13ck177 = 0.9 time = 890
.meas tran vdout0_13ck177 FIND v(dout0_13) AT=890.025n

* CHECK dout0_14 Vdout0_14ck177 = 0.9 time = 890
.meas tran vdout0_14ck177 FIND v(dout0_14) AT=890.025n

* CHECK dout0_15 Vdout0_15ck177 = 0.9 time = 890
.meas tran vdout0_15ck177 FIND v(dout0_15) AT=890.025n

* CHECK dout0_16 Vdout0_16ck177 = 0 time = 890
.meas tran vdout0_16ck177 FIND v(dout0_16) AT=890.025n

* CHECK dout0_17 Vdout0_17ck177 = 0.9 time = 890
.meas tran vdout0_17ck177 FIND v(dout0_17) AT=890.025n

* CHECK dout0_18 Vdout0_18ck177 = 0 time = 890
.meas tran vdout0_18ck177 FIND v(dout0_18) AT=890.025n

* CHECK dout0_19 Vdout0_19ck177 = 0.9 time = 890
.meas tran vdout0_19ck177 FIND v(dout0_19) AT=890.025n

* CHECK dout0_20 Vdout0_20ck177 = 0 time = 890
.meas tran vdout0_20ck177 FIND v(dout0_20) AT=890.025n

* CHECK dout0_21 Vdout0_21ck177 = 0 time = 890
.meas tran vdout0_21ck177 FIND v(dout0_21) AT=890.025n

* CHECK dout0_22 Vdout0_22ck177 = 0.9 time = 890
.meas tran vdout0_22ck177 FIND v(dout0_22) AT=890.025n

* CHECK dout0_23 Vdout0_23ck177 = 0.9 time = 890
.meas tran vdout0_23ck177 FIND v(dout0_23) AT=890.025n

* CHECK dout0_24 Vdout0_24ck177 = 0 time = 890
.meas tran vdout0_24ck177 FIND v(dout0_24) AT=890.025n

* CHECK dout0_25 Vdout0_25ck177 = 0 time = 890
.meas tran vdout0_25ck177 FIND v(dout0_25) AT=890.025n

* CHECK dout0_26 Vdout0_26ck177 = 0.9 time = 890
.meas tran vdout0_26ck177 FIND v(dout0_26) AT=890.025n

* CHECK dout0_27 Vdout0_27ck177 = 0 time = 890
.meas tran vdout0_27ck177 FIND v(dout0_27) AT=890.025n

* CHECK dout0_28 Vdout0_28ck177 = 0 time = 890
.meas tran vdout0_28ck177 FIND v(dout0_28) AT=890.025n

* CHECK dout0_29 Vdout0_29ck177 = 0.9 time = 890
.meas tran vdout0_29ck177 FIND v(dout0_29) AT=890.025n

* CHECK dout0_30 Vdout0_30ck177 = 0 time = 890
.meas tran vdout0_30ck177 FIND v(dout0_30) AT=890.025n

* CHECK dout0_31 Vdout0_31ck177 = 0 time = 890
.meas tran vdout0_31ck177 FIND v(dout0_31) AT=890.025n

* CHECK dout0_32 Vdout0_32ck177 = 0.9 time = 890
.meas tran vdout0_32ck177 FIND v(dout0_32) AT=890.025n

* CHECK dout0_33 Vdout0_33ck177 = 0 time = 890
.meas tran vdout0_33ck177 FIND v(dout0_33) AT=890.025n

* CHECK dout0_34 Vdout0_34ck177 = 0.9 time = 890
.meas tran vdout0_34ck177 FIND v(dout0_34) AT=890.025n

* CHECK dout0_35 Vdout0_35ck177 = 0.9 time = 890
.meas tran vdout0_35ck177 FIND v(dout0_35) AT=890.025n

* CHECK dout0_36 Vdout0_36ck177 = 0.9 time = 890
.meas tran vdout0_36ck177 FIND v(dout0_36) AT=890.025n

* CHECK dout0_37 Vdout0_37ck177 = 0 time = 890
.meas tran vdout0_37ck177 FIND v(dout0_37) AT=890.025n

* CHECK dout0_38 Vdout0_38ck177 = 0.9 time = 890
.meas tran vdout0_38ck177 FIND v(dout0_38) AT=890.025n

* CHECK dout0_39 Vdout0_39ck177 = 0 time = 890
.meas tran vdout0_39ck177 FIND v(dout0_39) AT=890.025n

* CHECK dout0_40 Vdout0_40ck177 = 0.9 time = 890
.meas tran vdout0_40ck177 FIND v(dout0_40) AT=890.025n

* CHECK dout0_41 Vdout0_41ck177 = 0.9 time = 890
.meas tran vdout0_41ck177 FIND v(dout0_41) AT=890.025n

* CHECK dout0_42 Vdout0_42ck177 = 0 time = 890
.meas tran vdout0_42ck177 FIND v(dout0_42) AT=890.025n

* CHECK dout0_43 Vdout0_43ck177 = 0 time = 890
.meas tran vdout0_43ck177 FIND v(dout0_43) AT=890.025n

* CHECK dout0_44 Vdout0_44ck177 = 0.9 time = 890
.meas tran vdout0_44ck177 FIND v(dout0_44) AT=890.025n

* CHECK dout0_45 Vdout0_45ck177 = 0 time = 890
.meas tran vdout0_45ck177 FIND v(dout0_45) AT=890.025n

* CHECK dout0_46 Vdout0_46ck177 = 0 time = 890
.meas tran vdout0_46ck177 FIND v(dout0_46) AT=890.025n

* CHECK dout0_47 Vdout0_47ck177 = 0 time = 890
.meas tran vdout0_47ck177 FIND v(dout0_47) AT=890.025n

* CHECK dout0_48 Vdout0_48ck177 = 0 time = 890
.meas tran vdout0_48ck177 FIND v(dout0_48) AT=890.025n

* CHECK dout0_49 Vdout0_49ck177 = 0.9 time = 890
.meas tran vdout0_49ck177 FIND v(dout0_49) AT=890.025n

* CHECK dout0_50 Vdout0_50ck177 = 0.9 time = 890
.meas tran vdout0_50ck177 FIND v(dout0_50) AT=890.025n

* CHECK dout0_51 Vdout0_51ck177 = 0 time = 890
.meas tran vdout0_51ck177 FIND v(dout0_51) AT=890.025n

* CHECK dout0_52 Vdout0_52ck177 = 0 time = 890
.meas tran vdout0_52ck177 FIND v(dout0_52) AT=890.025n

* CHECK dout0_53 Vdout0_53ck177 = 0.9 time = 890
.meas tran vdout0_53ck177 FIND v(dout0_53) AT=890.025n

* CHECK dout0_54 Vdout0_54ck177 = 0 time = 890
.meas tran vdout0_54ck177 FIND v(dout0_54) AT=890.025n

* CHECK dout0_55 Vdout0_55ck177 = 0 time = 890
.meas tran vdout0_55ck177 FIND v(dout0_55) AT=890.025n

* CHECK dout0_56 Vdout0_56ck177 = 0.9 time = 890
.meas tran vdout0_56ck177 FIND v(dout0_56) AT=890.025n

* CHECK dout0_57 Vdout0_57ck177 = 0 time = 890
.meas tran vdout0_57ck177 FIND v(dout0_57) AT=890.025n

* CHECK dout0_58 Vdout0_58ck177 = 0 time = 890
.meas tran vdout0_58ck177 FIND v(dout0_58) AT=890.025n

* CHECK dout0_59 Vdout0_59ck177 = 0.9 time = 890
.meas tran vdout0_59ck177 FIND v(dout0_59) AT=890.025n

* CHECK dout0_60 Vdout0_60ck177 = 0 time = 890
.meas tran vdout0_60ck177 FIND v(dout0_60) AT=890.025n

* CHECK dout0_61 Vdout0_61ck177 = 0.9 time = 890
.meas tran vdout0_61ck177 FIND v(dout0_61) AT=890.025n

* CHECK dout0_62 Vdout0_62ck177 = 0.9 time = 890
.meas tran vdout0_62ck177 FIND v(dout0_62) AT=890.025n

* CHECK dout0_63 Vdout0_63ck177 = 0.9 time = 890
.meas tran vdout0_63ck177 FIND v(dout0_63) AT=890.025n

* CHECK dout0_0 Vdout0_0ck179 = 0.9 time = 900
.meas tran vdout0_0ck179 FIND v(dout0_0) AT=900.025n

* CHECK dout0_1 Vdout0_1ck179 = 0 time = 900
.meas tran vdout0_1ck179 FIND v(dout0_1) AT=900.025n

* CHECK dout0_2 Vdout0_2ck179 = 0 time = 900
.meas tran vdout0_2ck179 FIND v(dout0_2) AT=900.025n

* CHECK dout0_3 Vdout0_3ck179 = 0 time = 900
.meas tran vdout0_3ck179 FIND v(dout0_3) AT=900.025n

* CHECK dout0_4 Vdout0_4ck179 = 0.9 time = 900
.meas tran vdout0_4ck179 FIND v(dout0_4) AT=900.025n

* CHECK dout0_5 Vdout0_5ck179 = 0.9 time = 900
.meas tran vdout0_5ck179 FIND v(dout0_5) AT=900.025n

* CHECK dout0_6 Vdout0_6ck179 = 0.9 time = 900
.meas tran vdout0_6ck179 FIND v(dout0_6) AT=900.025n

* CHECK dout0_7 Vdout0_7ck179 = 0 time = 900
.meas tran vdout0_7ck179 FIND v(dout0_7) AT=900.025n

* CHECK dout0_8 Vdout0_8ck179 = 0.9 time = 900
.meas tran vdout0_8ck179 FIND v(dout0_8) AT=900.025n

* CHECK dout0_9 Vdout0_9ck179 = 0.9 time = 900
.meas tran vdout0_9ck179 FIND v(dout0_9) AT=900.025n

* CHECK dout0_10 Vdout0_10ck179 = 0.9 time = 900
.meas tran vdout0_10ck179 FIND v(dout0_10) AT=900.025n

* CHECK dout0_11 Vdout0_11ck179 = 0 time = 900
.meas tran vdout0_11ck179 FIND v(dout0_11) AT=900.025n

* CHECK dout0_12 Vdout0_12ck179 = 0 time = 900
.meas tran vdout0_12ck179 FIND v(dout0_12) AT=900.025n

* CHECK dout0_13 Vdout0_13ck179 = 0 time = 900
.meas tran vdout0_13ck179 FIND v(dout0_13) AT=900.025n

* CHECK dout0_14 Vdout0_14ck179 = 0.9 time = 900
.meas tran vdout0_14ck179 FIND v(dout0_14) AT=900.025n

* CHECK dout0_15 Vdout0_15ck179 = 0 time = 900
.meas tran vdout0_15ck179 FIND v(dout0_15) AT=900.025n

* CHECK dout0_16 Vdout0_16ck179 = 0.9 time = 900
.meas tran vdout0_16ck179 FIND v(dout0_16) AT=900.025n

* CHECK dout0_17 Vdout0_17ck179 = 0 time = 900
.meas tran vdout0_17ck179 FIND v(dout0_17) AT=900.025n

* CHECK dout0_18 Vdout0_18ck179 = 0 time = 900
.meas tran vdout0_18ck179 FIND v(dout0_18) AT=900.025n

* CHECK dout0_19 Vdout0_19ck179 = 0.9 time = 900
.meas tran vdout0_19ck179 FIND v(dout0_19) AT=900.025n

* CHECK dout0_20 Vdout0_20ck179 = 0.9 time = 900
.meas tran vdout0_20ck179 FIND v(dout0_20) AT=900.025n

* CHECK dout0_21 Vdout0_21ck179 = 0 time = 900
.meas tran vdout0_21ck179 FIND v(dout0_21) AT=900.025n

* CHECK dout0_22 Vdout0_22ck179 = 0 time = 900
.meas tran vdout0_22ck179 FIND v(dout0_22) AT=900.025n

* CHECK dout0_23 Vdout0_23ck179 = 0.9 time = 900
.meas tran vdout0_23ck179 FIND v(dout0_23) AT=900.025n

* CHECK dout0_24 Vdout0_24ck179 = 0 time = 900
.meas tran vdout0_24ck179 FIND v(dout0_24) AT=900.025n

* CHECK dout0_25 Vdout0_25ck179 = 0 time = 900
.meas tran vdout0_25ck179 FIND v(dout0_25) AT=900.025n

* CHECK dout0_26 Vdout0_26ck179 = 0.9 time = 900
.meas tran vdout0_26ck179 FIND v(dout0_26) AT=900.025n

* CHECK dout0_27 Vdout0_27ck179 = 0 time = 900
.meas tran vdout0_27ck179 FIND v(dout0_27) AT=900.025n

* CHECK dout0_28 Vdout0_28ck179 = 0.9 time = 900
.meas tran vdout0_28ck179 FIND v(dout0_28) AT=900.025n

* CHECK dout0_29 Vdout0_29ck179 = 0 time = 900
.meas tran vdout0_29ck179 FIND v(dout0_29) AT=900.025n

* CHECK dout0_30 Vdout0_30ck179 = 0 time = 900
.meas tran vdout0_30ck179 FIND v(dout0_30) AT=900.025n

* CHECK dout0_31 Vdout0_31ck179 = 0 time = 900
.meas tran vdout0_31ck179 FIND v(dout0_31) AT=900.025n

* CHECK dout0_32 Vdout0_32ck179 = 0 time = 900
.meas tran vdout0_32ck179 FIND v(dout0_32) AT=900.025n

* CHECK dout0_33 Vdout0_33ck179 = 0.9 time = 900
.meas tran vdout0_33ck179 FIND v(dout0_33) AT=900.025n

* CHECK dout0_34 Vdout0_34ck179 = 0 time = 900
.meas tran vdout0_34ck179 FIND v(dout0_34) AT=900.025n

* CHECK dout0_35 Vdout0_35ck179 = 0 time = 900
.meas tran vdout0_35ck179 FIND v(dout0_35) AT=900.025n

* CHECK dout0_36 Vdout0_36ck179 = 0 time = 900
.meas tran vdout0_36ck179 FIND v(dout0_36) AT=900.025n

* CHECK dout0_37 Vdout0_37ck179 = 0 time = 900
.meas tran vdout0_37ck179 FIND v(dout0_37) AT=900.025n

* CHECK dout0_38 Vdout0_38ck179 = 0.9 time = 900
.meas tran vdout0_38ck179 FIND v(dout0_38) AT=900.025n

* CHECK dout0_39 Vdout0_39ck179 = 0 time = 900
.meas tran vdout0_39ck179 FIND v(dout0_39) AT=900.025n

* CHECK dout0_40 Vdout0_40ck179 = 0 time = 900
.meas tran vdout0_40ck179 FIND v(dout0_40) AT=900.025n

* CHECK dout0_41 Vdout0_41ck179 = 0.9 time = 900
.meas tran vdout0_41ck179 FIND v(dout0_41) AT=900.025n

* CHECK dout0_42 Vdout0_42ck179 = 0.9 time = 900
.meas tran vdout0_42ck179 FIND v(dout0_42) AT=900.025n

* CHECK dout0_43 Vdout0_43ck179 = 0 time = 900
.meas tran vdout0_43ck179 FIND v(dout0_43) AT=900.025n

* CHECK dout0_44 Vdout0_44ck179 = 0 time = 900
.meas tran vdout0_44ck179 FIND v(dout0_44) AT=900.025n

* CHECK dout0_45 Vdout0_45ck179 = 0 time = 900
.meas tran vdout0_45ck179 FIND v(dout0_45) AT=900.025n

* CHECK dout0_46 Vdout0_46ck179 = 0 time = 900
.meas tran vdout0_46ck179 FIND v(dout0_46) AT=900.025n

* CHECK dout0_47 Vdout0_47ck179 = 0.9 time = 900
.meas tran vdout0_47ck179 FIND v(dout0_47) AT=900.025n

* CHECK dout0_48 Vdout0_48ck179 = 0.9 time = 900
.meas tran vdout0_48ck179 FIND v(dout0_48) AT=900.025n

* CHECK dout0_49 Vdout0_49ck179 = 0.9 time = 900
.meas tran vdout0_49ck179 FIND v(dout0_49) AT=900.025n

* CHECK dout0_50 Vdout0_50ck179 = 0.9 time = 900
.meas tran vdout0_50ck179 FIND v(dout0_50) AT=900.025n

* CHECK dout0_51 Vdout0_51ck179 = 0 time = 900
.meas tran vdout0_51ck179 FIND v(dout0_51) AT=900.025n

* CHECK dout0_52 Vdout0_52ck179 = 0 time = 900
.meas tran vdout0_52ck179 FIND v(dout0_52) AT=900.025n

* CHECK dout0_53 Vdout0_53ck179 = 0.9 time = 900
.meas tran vdout0_53ck179 FIND v(dout0_53) AT=900.025n

* CHECK dout0_54 Vdout0_54ck179 = 0 time = 900
.meas tran vdout0_54ck179 FIND v(dout0_54) AT=900.025n

* CHECK dout0_55 Vdout0_55ck179 = 0.9 time = 900
.meas tran vdout0_55ck179 FIND v(dout0_55) AT=900.025n

* CHECK dout0_56 Vdout0_56ck179 = 0 time = 900
.meas tran vdout0_56ck179 FIND v(dout0_56) AT=900.025n

* CHECK dout0_57 Vdout0_57ck179 = 0.9 time = 900
.meas tran vdout0_57ck179 FIND v(dout0_57) AT=900.025n

* CHECK dout0_58 Vdout0_58ck179 = 0.9 time = 900
.meas tran vdout0_58ck179 FIND v(dout0_58) AT=900.025n

* CHECK dout0_59 Vdout0_59ck179 = 0.9 time = 900
.meas tran vdout0_59ck179 FIND v(dout0_59) AT=900.025n

* CHECK dout0_60 Vdout0_60ck179 = 0.9 time = 900
.meas tran vdout0_60ck179 FIND v(dout0_60) AT=900.025n

* CHECK dout0_61 Vdout0_61ck179 = 0 time = 900
.meas tran vdout0_61ck179 FIND v(dout0_61) AT=900.025n

* CHECK dout0_62 Vdout0_62ck179 = 0.9 time = 900
.meas tran vdout0_62ck179 FIND v(dout0_62) AT=900.025n

* CHECK dout0_63 Vdout0_63ck179 = 0 time = 900
.meas tran vdout0_63ck179 FIND v(dout0_63) AT=900.025n

* CHECK dout0_0 Vdout0_0ck180 = 0.9 time = 905
.meas tran vdout0_0ck180 FIND v(dout0_0) AT=905.025n

* CHECK dout0_1 Vdout0_1ck180 = 0 time = 905
.meas tran vdout0_1ck180 FIND v(dout0_1) AT=905.025n

* CHECK dout0_2 Vdout0_2ck180 = 0 time = 905
.meas tran vdout0_2ck180 FIND v(dout0_2) AT=905.025n

* CHECK dout0_3 Vdout0_3ck180 = 0 time = 905
.meas tran vdout0_3ck180 FIND v(dout0_3) AT=905.025n

* CHECK dout0_4 Vdout0_4ck180 = 0.9 time = 905
.meas tran vdout0_4ck180 FIND v(dout0_4) AT=905.025n

* CHECK dout0_5 Vdout0_5ck180 = 0.9 time = 905
.meas tran vdout0_5ck180 FIND v(dout0_5) AT=905.025n

* CHECK dout0_6 Vdout0_6ck180 = 0.9 time = 905
.meas tran vdout0_6ck180 FIND v(dout0_6) AT=905.025n

* CHECK dout0_7 Vdout0_7ck180 = 0 time = 905
.meas tran vdout0_7ck180 FIND v(dout0_7) AT=905.025n

* CHECK dout0_8 Vdout0_8ck180 = 0.9 time = 905
.meas tran vdout0_8ck180 FIND v(dout0_8) AT=905.025n

* CHECK dout0_9 Vdout0_9ck180 = 0.9 time = 905
.meas tran vdout0_9ck180 FIND v(dout0_9) AT=905.025n

* CHECK dout0_10 Vdout0_10ck180 = 0.9 time = 905
.meas tran vdout0_10ck180 FIND v(dout0_10) AT=905.025n

* CHECK dout0_11 Vdout0_11ck180 = 0 time = 905
.meas tran vdout0_11ck180 FIND v(dout0_11) AT=905.025n

* CHECK dout0_12 Vdout0_12ck180 = 0 time = 905
.meas tran vdout0_12ck180 FIND v(dout0_12) AT=905.025n

* CHECK dout0_13 Vdout0_13ck180 = 0 time = 905
.meas tran vdout0_13ck180 FIND v(dout0_13) AT=905.025n

* CHECK dout0_14 Vdout0_14ck180 = 0.9 time = 905
.meas tran vdout0_14ck180 FIND v(dout0_14) AT=905.025n

* CHECK dout0_15 Vdout0_15ck180 = 0 time = 905
.meas tran vdout0_15ck180 FIND v(dout0_15) AT=905.025n

* CHECK dout0_16 Vdout0_16ck180 = 0.9 time = 905
.meas tran vdout0_16ck180 FIND v(dout0_16) AT=905.025n

* CHECK dout0_17 Vdout0_17ck180 = 0 time = 905
.meas tran vdout0_17ck180 FIND v(dout0_17) AT=905.025n

* CHECK dout0_18 Vdout0_18ck180 = 0 time = 905
.meas tran vdout0_18ck180 FIND v(dout0_18) AT=905.025n

* CHECK dout0_19 Vdout0_19ck180 = 0.9 time = 905
.meas tran vdout0_19ck180 FIND v(dout0_19) AT=905.025n

* CHECK dout0_20 Vdout0_20ck180 = 0.9 time = 905
.meas tran vdout0_20ck180 FIND v(dout0_20) AT=905.025n

* CHECK dout0_21 Vdout0_21ck180 = 0 time = 905
.meas tran vdout0_21ck180 FIND v(dout0_21) AT=905.025n

* CHECK dout0_22 Vdout0_22ck180 = 0 time = 905
.meas tran vdout0_22ck180 FIND v(dout0_22) AT=905.025n

* CHECK dout0_23 Vdout0_23ck180 = 0.9 time = 905
.meas tran vdout0_23ck180 FIND v(dout0_23) AT=905.025n

* CHECK dout0_24 Vdout0_24ck180 = 0 time = 905
.meas tran vdout0_24ck180 FIND v(dout0_24) AT=905.025n

* CHECK dout0_25 Vdout0_25ck180 = 0 time = 905
.meas tran vdout0_25ck180 FIND v(dout0_25) AT=905.025n

* CHECK dout0_26 Vdout0_26ck180 = 0.9 time = 905
.meas tran vdout0_26ck180 FIND v(dout0_26) AT=905.025n

* CHECK dout0_27 Vdout0_27ck180 = 0 time = 905
.meas tran vdout0_27ck180 FIND v(dout0_27) AT=905.025n

* CHECK dout0_28 Vdout0_28ck180 = 0.9 time = 905
.meas tran vdout0_28ck180 FIND v(dout0_28) AT=905.025n

* CHECK dout0_29 Vdout0_29ck180 = 0 time = 905
.meas tran vdout0_29ck180 FIND v(dout0_29) AT=905.025n

* CHECK dout0_30 Vdout0_30ck180 = 0 time = 905
.meas tran vdout0_30ck180 FIND v(dout0_30) AT=905.025n

* CHECK dout0_31 Vdout0_31ck180 = 0 time = 905
.meas tran vdout0_31ck180 FIND v(dout0_31) AT=905.025n

* CHECK dout0_32 Vdout0_32ck180 = 0 time = 905
.meas tran vdout0_32ck180 FIND v(dout0_32) AT=905.025n

* CHECK dout0_33 Vdout0_33ck180 = 0.9 time = 905
.meas tran vdout0_33ck180 FIND v(dout0_33) AT=905.025n

* CHECK dout0_34 Vdout0_34ck180 = 0 time = 905
.meas tran vdout0_34ck180 FIND v(dout0_34) AT=905.025n

* CHECK dout0_35 Vdout0_35ck180 = 0 time = 905
.meas tran vdout0_35ck180 FIND v(dout0_35) AT=905.025n

* CHECK dout0_36 Vdout0_36ck180 = 0 time = 905
.meas tran vdout0_36ck180 FIND v(dout0_36) AT=905.025n

* CHECK dout0_37 Vdout0_37ck180 = 0 time = 905
.meas tran vdout0_37ck180 FIND v(dout0_37) AT=905.025n

* CHECK dout0_38 Vdout0_38ck180 = 0.9 time = 905
.meas tran vdout0_38ck180 FIND v(dout0_38) AT=905.025n

* CHECK dout0_39 Vdout0_39ck180 = 0 time = 905
.meas tran vdout0_39ck180 FIND v(dout0_39) AT=905.025n

* CHECK dout0_40 Vdout0_40ck180 = 0 time = 905
.meas tran vdout0_40ck180 FIND v(dout0_40) AT=905.025n

* CHECK dout0_41 Vdout0_41ck180 = 0.9 time = 905
.meas tran vdout0_41ck180 FIND v(dout0_41) AT=905.025n

* CHECK dout0_42 Vdout0_42ck180 = 0.9 time = 905
.meas tran vdout0_42ck180 FIND v(dout0_42) AT=905.025n

* CHECK dout0_43 Vdout0_43ck180 = 0 time = 905
.meas tran vdout0_43ck180 FIND v(dout0_43) AT=905.025n

* CHECK dout0_44 Vdout0_44ck180 = 0 time = 905
.meas tran vdout0_44ck180 FIND v(dout0_44) AT=905.025n

* CHECK dout0_45 Vdout0_45ck180 = 0 time = 905
.meas tran vdout0_45ck180 FIND v(dout0_45) AT=905.025n

* CHECK dout0_46 Vdout0_46ck180 = 0 time = 905
.meas tran vdout0_46ck180 FIND v(dout0_46) AT=905.025n

* CHECK dout0_47 Vdout0_47ck180 = 0.9 time = 905
.meas tran vdout0_47ck180 FIND v(dout0_47) AT=905.025n

* CHECK dout0_48 Vdout0_48ck180 = 0.9 time = 905
.meas tran vdout0_48ck180 FIND v(dout0_48) AT=905.025n

* CHECK dout0_49 Vdout0_49ck180 = 0.9 time = 905
.meas tran vdout0_49ck180 FIND v(dout0_49) AT=905.025n

* CHECK dout0_50 Vdout0_50ck180 = 0.9 time = 905
.meas tran vdout0_50ck180 FIND v(dout0_50) AT=905.025n

* CHECK dout0_51 Vdout0_51ck180 = 0 time = 905
.meas tran vdout0_51ck180 FIND v(dout0_51) AT=905.025n

* CHECK dout0_52 Vdout0_52ck180 = 0 time = 905
.meas tran vdout0_52ck180 FIND v(dout0_52) AT=905.025n

* CHECK dout0_53 Vdout0_53ck180 = 0.9 time = 905
.meas tran vdout0_53ck180 FIND v(dout0_53) AT=905.025n

* CHECK dout0_54 Vdout0_54ck180 = 0 time = 905
.meas tran vdout0_54ck180 FIND v(dout0_54) AT=905.025n

* CHECK dout0_55 Vdout0_55ck180 = 0.9 time = 905
.meas tran vdout0_55ck180 FIND v(dout0_55) AT=905.025n

* CHECK dout0_56 Vdout0_56ck180 = 0 time = 905
.meas tran vdout0_56ck180 FIND v(dout0_56) AT=905.025n

* CHECK dout0_57 Vdout0_57ck180 = 0.9 time = 905
.meas tran vdout0_57ck180 FIND v(dout0_57) AT=905.025n

* CHECK dout0_58 Vdout0_58ck180 = 0.9 time = 905
.meas tran vdout0_58ck180 FIND v(dout0_58) AT=905.025n

* CHECK dout0_59 Vdout0_59ck180 = 0.9 time = 905
.meas tran vdout0_59ck180 FIND v(dout0_59) AT=905.025n

* CHECK dout0_60 Vdout0_60ck180 = 0.9 time = 905
.meas tran vdout0_60ck180 FIND v(dout0_60) AT=905.025n

* CHECK dout0_61 Vdout0_61ck180 = 0 time = 905
.meas tran vdout0_61ck180 FIND v(dout0_61) AT=905.025n

* CHECK dout0_62 Vdout0_62ck180 = 0.9 time = 905
.meas tran vdout0_62ck180 FIND v(dout0_62) AT=905.025n

* CHECK dout0_63 Vdout0_63ck180 = 0 time = 905
.meas tran vdout0_63ck180 FIND v(dout0_63) AT=905.025n

* CHECK dout0_0 Vdout0_0ck182 = 0 time = 915
.meas tran vdout0_0ck182 FIND v(dout0_0) AT=915.025n

* CHECK dout0_1 Vdout0_1ck182 = 0 time = 915
.meas tran vdout0_1ck182 FIND v(dout0_1) AT=915.025n

* CHECK dout0_2 Vdout0_2ck182 = 0 time = 915
.meas tran vdout0_2ck182 FIND v(dout0_2) AT=915.025n

* CHECK dout0_3 Vdout0_3ck182 = 0.9 time = 915
.meas tran vdout0_3ck182 FIND v(dout0_3) AT=915.025n

* CHECK dout0_4 Vdout0_4ck182 = 0 time = 915
.meas tran vdout0_4ck182 FIND v(dout0_4) AT=915.025n

* CHECK dout0_5 Vdout0_5ck182 = 0 time = 915
.meas tran vdout0_5ck182 FIND v(dout0_5) AT=915.025n

* CHECK dout0_6 Vdout0_6ck182 = 0 time = 915
.meas tran vdout0_6ck182 FIND v(dout0_6) AT=915.025n

* CHECK dout0_7 Vdout0_7ck182 = 0.9 time = 915
.meas tran vdout0_7ck182 FIND v(dout0_7) AT=915.025n

* CHECK dout0_8 Vdout0_8ck182 = 0 time = 915
.meas tran vdout0_8ck182 FIND v(dout0_8) AT=915.025n

* CHECK dout0_9 Vdout0_9ck182 = 0.9 time = 915
.meas tran vdout0_9ck182 FIND v(dout0_9) AT=915.025n

* CHECK dout0_10 Vdout0_10ck182 = 0 time = 915
.meas tran vdout0_10ck182 FIND v(dout0_10) AT=915.025n

* CHECK dout0_11 Vdout0_11ck182 = 0 time = 915
.meas tran vdout0_11ck182 FIND v(dout0_11) AT=915.025n

* CHECK dout0_12 Vdout0_12ck182 = 0.9 time = 915
.meas tran vdout0_12ck182 FIND v(dout0_12) AT=915.025n

* CHECK dout0_13 Vdout0_13ck182 = 0 time = 915
.meas tran vdout0_13ck182 FIND v(dout0_13) AT=915.025n

* CHECK dout0_14 Vdout0_14ck182 = 0 time = 915
.meas tran vdout0_14ck182 FIND v(dout0_14) AT=915.025n

* CHECK dout0_15 Vdout0_15ck182 = 0 time = 915
.meas tran vdout0_15ck182 FIND v(dout0_15) AT=915.025n

* CHECK dout0_16 Vdout0_16ck182 = 0 time = 915
.meas tran vdout0_16ck182 FIND v(dout0_16) AT=915.025n

* CHECK dout0_17 Vdout0_17ck182 = 0.9 time = 915
.meas tran vdout0_17ck182 FIND v(dout0_17) AT=915.025n

* CHECK dout0_18 Vdout0_18ck182 = 0 time = 915
.meas tran vdout0_18ck182 FIND v(dout0_18) AT=915.025n

* CHECK dout0_19 Vdout0_19ck182 = 0.9 time = 915
.meas tran vdout0_19ck182 FIND v(dout0_19) AT=915.025n

* CHECK dout0_20 Vdout0_20ck182 = 0 time = 915
.meas tran vdout0_20ck182 FIND v(dout0_20) AT=915.025n

* CHECK dout0_21 Vdout0_21ck182 = 0 time = 915
.meas tran vdout0_21ck182 FIND v(dout0_21) AT=915.025n

* CHECK dout0_22 Vdout0_22ck182 = 0.9 time = 915
.meas tran vdout0_22ck182 FIND v(dout0_22) AT=915.025n

* CHECK dout0_23 Vdout0_23ck182 = 0 time = 915
.meas tran vdout0_23ck182 FIND v(dout0_23) AT=915.025n

* CHECK dout0_24 Vdout0_24ck182 = 0.9 time = 915
.meas tran vdout0_24ck182 FIND v(dout0_24) AT=915.025n

* CHECK dout0_25 Vdout0_25ck182 = 0.9 time = 915
.meas tran vdout0_25ck182 FIND v(dout0_25) AT=915.025n

* CHECK dout0_26 Vdout0_26ck182 = 0 time = 915
.meas tran vdout0_26ck182 FIND v(dout0_26) AT=915.025n

* CHECK dout0_27 Vdout0_27ck182 = 0.9 time = 915
.meas tran vdout0_27ck182 FIND v(dout0_27) AT=915.025n

* CHECK dout0_28 Vdout0_28ck182 = 0.9 time = 915
.meas tran vdout0_28ck182 FIND v(dout0_28) AT=915.025n

* CHECK dout0_29 Vdout0_29ck182 = 0 time = 915
.meas tran vdout0_29ck182 FIND v(dout0_29) AT=915.025n

* CHECK dout0_30 Vdout0_30ck182 = 0.9 time = 915
.meas tran vdout0_30ck182 FIND v(dout0_30) AT=915.025n

* CHECK dout0_31 Vdout0_31ck182 = 0 time = 915
.meas tran vdout0_31ck182 FIND v(dout0_31) AT=915.025n

* CHECK dout0_32 Vdout0_32ck182 = 0 time = 915
.meas tran vdout0_32ck182 FIND v(dout0_32) AT=915.025n

* CHECK dout0_33 Vdout0_33ck182 = 0 time = 915
.meas tran vdout0_33ck182 FIND v(dout0_33) AT=915.025n

* CHECK dout0_34 Vdout0_34ck182 = 0 time = 915
.meas tran vdout0_34ck182 FIND v(dout0_34) AT=915.025n

* CHECK dout0_35 Vdout0_35ck182 = 0.9 time = 915
.meas tran vdout0_35ck182 FIND v(dout0_35) AT=915.025n

* CHECK dout0_36 Vdout0_36ck182 = 0 time = 915
.meas tran vdout0_36ck182 FIND v(dout0_36) AT=915.025n

* CHECK dout0_37 Vdout0_37ck182 = 0 time = 915
.meas tran vdout0_37ck182 FIND v(dout0_37) AT=915.025n

* CHECK dout0_38 Vdout0_38ck182 = 0 time = 915
.meas tran vdout0_38ck182 FIND v(dout0_38) AT=915.025n

* CHECK dout0_39 Vdout0_39ck182 = 0.9 time = 915
.meas tran vdout0_39ck182 FIND v(dout0_39) AT=915.025n

* CHECK dout0_40 Vdout0_40ck182 = 0.9 time = 915
.meas tran vdout0_40ck182 FIND v(dout0_40) AT=915.025n

* CHECK dout0_41 Vdout0_41ck182 = 0 time = 915
.meas tran vdout0_41ck182 FIND v(dout0_41) AT=915.025n

* CHECK dout0_42 Vdout0_42ck182 = 0.9 time = 915
.meas tran vdout0_42ck182 FIND v(dout0_42) AT=915.025n

* CHECK dout0_43 Vdout0_43ck182 = 0 time = 915
.meas tran vdout0_43ck182 FIND v(dout0_43) AT=915.025n

* CHECK dout0_44 Vdout0_44ck182 = 0.9 time = 915
.meas tran vdout0_44ck182 FIND v(dout0_44) AT=915.025n

* CHECK dout0_45 Vdout0_45ck182 = 0 time = 915
.meas tran vdout0_45ck182 FIND v(dout0_45) AT=915.025n

* CHECK dout0_46 Vdout0_46ck182 = 0 time = 915
.meas tran vdout0_46ck182 FIND v(dout0_46) AT=915.025n

* CHECK dout0_47 Vdout0_47ck182 = 0.9 time = 915
.meas tran vdout0_47ck182 FIND v(dout0_47) AT=915.025n

* CHECK dout0_48 Vdout0_48ck182 = 0 time = 915
.meas tran vdout0_48ck182 FIND v(dout0_48) AT=915.025n

* CHECK dout0_49 Vdout0_49ck182 = 0.9 time = 915
.meas tran vdout0_49ck182 FIND v(dout0_49) AT=915.025n

* CHECK dout0_50 Vdout0_50ck182 = 0 time = 915
.meas tran vdout0_50ck182 FIND v(dout0_50) AT=915.025n

* CHECK dout0_51 Vdout0_51ck182 = 0 time = 915
.meas tran vdout0_51ck182 FIND v(dout0_51) AT=915.025n

* CHECK dout0_52 Vdout0_52ck182 = 0 time = 915
.meas tran vdout0_52ck182 FIND v(dout0_52) AT=915.025n

* CHECK dout0_53 Vdout0_53ck182 = 0 time = 915
.meas tran vdout0_53ck182 FIND v(dout0_53) AT=915.025n

* CHECK dout0_54 Vdout0_54ck182 = 0 time = 915
.meas tran vdout0_54ck182 FIND v(dout0_54) AT=915.025n

* CHECK dout0_55 Vdout0_55ck182 = 0.9 time = 915
.meas tran vdout0_55ck182 FIND v(dout0_55) AT=915.025n

* CHECK dout0_56 Vdout0_56ck182 = 0.9 time = 915
.meas tran vdout0_56ck182 FIND v(dout0_56) AT=915.025n

* CHECK dout0_57 Vdout0_57ck182 = 0 time = 915
.meas tran vdout0_57ck182 FIND v(dout0_57) AT=915.025n

* CHECK dout0_58 Vdout0_58ck182 = 0.9 time = 915
.meas tran vdout0_58ck182 FIND v(dout0_58) AT=915.025n

* CHECK dout0_59 Vdout0_59ck182 = 0.9 time = 915
.meas tran vdout0_59ck182 FIND v(dout0_59) AT=915.025n

* CHECK dout0_60 Vdout0_60ck182 = 0 time = 915
.meas tran vdout0_60ck182 FIND v(dout0_60) AT=915.025n

* CHECK dout0_61 Vdout0_61ck182 = 0 time = 915
.meas tran vdout0_61ck182 FIND v(dout0_61) AT=915.025n

* CHECK dout0_62 Vdout0_62ck182 = 0 time = 915
.meas tran vdout0_62ck182 FIND v(dout0_62) AT=915.025n

* CHECK dout0_63 Vdout0_63ck182 = 0 time = 915
.meas tran vdout0_63ck182 FIND v(dout0_63) AT=915.025n

* CHECK dout0_0 Vdout0_0ck186 = 0.9 time = 935
.meas tran vdout0_0ck186 FIND v(dout0_0) AT=935.025n

* CHECK dout0_1 Vdout0_1ck186 = 0 time = 935
.meas tran vdout0_1ck186 FIND v(dout0_1) AT=935.025n

* CHECK dout0_2 Vdout0_2ck186 = 0 time = 935
.meas tran vdout0_2ck186 FIND v(dout0_2) AT=935.025n

* CHECK dout0_3 Vdout0_3ck186 = 0 time = 935
.meas tran vdout0_3ck186 FIND v(dout0_3) AT=935.025n

* CHECK dout0_4 Vdout0_4ck186 = 0.9 time = 935
.meas tran vdout0_4ck186 FIND v(dout0_4) AT=935.025n

* CHECK dout0_5 Vdout0_5ck186 = 0.9 time = 935
.meas tran vdout0_5ck186 FIND v(dout0_5) AT=935.025n

* CHECK dout0_6 Vdout0_6ck186 = 0.9 time = 935
.meas tran vdout0_6ck186 FIND v(dout0_6) AT=935.025n

* CHECK dout0_7 Vdout0_7ck186 = 0 time = 935
.meas tran vdout0_7ck186 FIND v(dout0_7) AT=935.025n

* CHECK dout0_8 Vdout0_8ck186 = 0.9 time = 935
.meas tran vdout0_8ck186 FIND v(dout0_8) AT=935.025n

* CHECK dout0_9 Vdout0_9ck186 = 0.9 time = 935
.meas tran vdout0_9ck186 FIND v(dout0_9) AT=935.025n

* CHECK dout0_10 Vdout0_10ck186 = 0.9 time = 935
.meas tran vdout0_10ck186 FIND v(dout0_10) AT=935.025n

* CHECK dout0_11 Vdout0_11ck186 = 0 time = 935
.meas tran vdout0_11ck186 FIND v(dout0_11) AT=935.025n

* CHECK dout0_12 Vdout0_12ck186 = 0 time = 935
.meas tran vdout0_12ck186 FIND v(dout0_12) AT=935.025n

* CHECK dout0_13 Vdout0_13ck186 = 0 time = 935
.meas tran vdout0_13ck186 FIND v(dout0_13) AT=935.025n

* CHECK dout0_14 Vdout0_14ck186 = 0.9 time = 935
.meas tran vdout0_14ck186 FIND v(dout0_14) AT=935.025n

* CHECK dout0_15 Vdout0_15ck186 = 0 time = 935
.meas tran vdout0_15ck186 FIND v(dout0_15) AT=935.025n

* CHECK dout0_16 Vdout0_16ck186 = 0.9 time = 935
.meas tran vdout0_16ck186 FIND v(dout0_16) AT=935.025n

* CHECK dout0_17 Vdout0_17ck186 = 0 time = 935
.meas tran vdout0_17ck186 FIND v(dout0_17) AT=935.025n

* CHECK dout0_18 Vdout0_18ck186 = 0 time = 935
.meas tran vdout0_18ck186 FIND v(dout0_18) AT=935.025n

* CHECK dout0_19 Vdout0_19ck186 = 0.9 time = 935
.meas tran vdout0_19ck186 FIND v(dout0_19) AT=935.025n

* CHECK dout0_20 Vdout0_20ck186 = 0.9 time = 935
.meas tran vdout0_20ck186 FIND v(dout0_20) AT=935.025n

* CHECK dout0_21 Vdout0_21ck186 = 0 time = 935
.meas tran vdout0_21ck186 FIND v(dout0_21) AT=935.025n

* CHECK dout0_22 Vdout0_22ck186 = 0 time = 935
.meas tran vdout0_22ck186 FIND v(dout0_22) AT=935.025n

* CHECK dout0_23 Vdout0_23ck186 = 0.9 time = 935
.meas tran vdout0_23ck186 FIND v(dout0_23) AT=935.025n

* CHECK dout0_24 Vdout0_24ck186 = 0 time = 935
.meas tran vdout0_24ck186 FIND v(dout0_24) AT=935.025n

* CHECK dout0_25 Vdout0_25ck186 = 0 time = 935
.meas tran vdout0_25ck186 FIND v(dout0_25) AT=935.025n

* CHECK dout0_26 Vdout0_26ck186 = 0.9 time = 935
.meas tran vdout0_26ck186 FIND v(dout0_26) AT=935.025n

* CHECK dout0_27 Vdout0_27ck186 = 0 time = 935
.meas tran vdout0_27ck186 FIND v(dout0_27) AT=935.025n

* CHECK dout0_28 Vdout0_28ck186 = 0.9 time = 935
.meas tran vdout0_28ck186 FIND v(dout0_28) AT=935.025n

* CHECK dout0_29 Vdout0_29ck186 = 0 time = 935
.meas tran vdout0_29ck186 FIND v(dout0_29) AT=935.025n

* CHECK dout0_30 Vdout0_30ck186 = 0 time = 935
.meas tran vdout0_30ck186 FIND v(dout0_30) AT=935.025n

* CHECK dout0_31 Vdout0_31ck186 = 0 time = 935
.meas tran vdout0_31ck186 FIND v(dout0_31) AT=935.025n

* CHECK dout0_32 Vdout0_32ck186 = 0 time = 935
.meas tran vdout0_32ck186 FIND v(dout0_32) AT=935.025n

* CHECK dout0_33 Vdout0_33ck186 = 0.9 time = 935
.meas tran vdout0_33ck186 FIND v(dout0_33) AT=935.025n

* CHECK dout0_34 Vdout0_34ck186 = 0 time = 935
.meas tran vdout0_34ck186 FIND v(dout0_34) AT=935.025n

* CHECK dout0_35 Vdout0_35ck186 = 0 time = 935
.meas tran vdout0_35ck186 FIND v(dout0_35) AT=935.025n

* CHECK dout0_36 Vdout0_36ck186 = 0 time = 935
.meas tran vdout0_36ck186 FIND v(dout0_36) AT=935.025n

* CHECK dout0_37 Vdout0_37ck186 = 0 time = 935
.meas tran vdout0_37ck186 FIND v(dout0_37) AT=935.025n

* CHECK dout0_38 Vdout0_38ck186 = 0.9 time = 935
.meas tran vdout0_38ck186 FIND v(dout0_38) AT=935.025n

* CHECK dout0_39 Vdout0_39ck186 = 0 time = 935
.meas tran vdout0_39ck186 FIND v(dout0_39) AT=935.025n

* CHECK dout0_40 Vdout0_40ck186 = 0 time = 935
.meas tran vdout0_40ck186 FIND v(dout0_40) AT=935.025n

* CHECK dout0_41 Vdout0_41ck186 = 0.9 time = 935
.meas tran vdout0_41ck186 FIND v(dout0_41) AT=935.025n

* CHECK dout0_42 Vdout0_42ck186 = 0.9 time = 935
.meas tran vdout0_42ck186 FIND v(dout0_42) AT=935.025n

* CHECK dout0_43 Vdout0_43ck186 = 0 time = 935
.meas tran vdout0_43ck186 FIND v(dout0_43) AT=935.025n

* CHECK dout0_44 Vdout0_44ck186 = 0 time = 935
.meas tran vdout0_44ck186 FIND v(dout0_44) AT=935.025n

* CHECK dout0_45 Vdout0_45ck186 = 0 time = 935
.meas tran vdout0_45ck186 FIND v(dout0_45) AT=935.025n

* CHECK dout0_46 Vdout0_46ck186 = 0 time = 935
.meas tran vdout0_46ck186 FIND v(dout0_46) AT=935.025n

* CHECK dout0_47 Vdout0_47ck186 = 0.9 time = 935
.meas tran vdout0_47ck186 FIND v(dout0_47) AT=935.025n

* CHECK dout0_48 Vdout0_48ck186 = 0.9 time = 935
.meas tran vdout0_48ck186 FIND v(dout0_48) AT=935.025n

* CHECK dout0_49 Vdout0_49ck186 = 0.9 time = 935
.meas tran vdout0_49ck186 FIND v(dout0_49) AT=935.025n

* CHECK dout0_50 Vdout0_50ck186 = 0.9 time = 935
.meas tran vdout0_50ck186 FIND v(dout0_50) AT=935.025n

* CHECK dout0_51 Vdout0_51ck186 = 0 time = 935
.meas tran vdout0_51ck186 FIND v(dout0_51) AT=935.025n

* CHECK dout0_52 Vdout0_52ck186 = 0 time = 935
.meas tran vdout0_52ck186 FIND v(dout0_52) AT=935.025n

* CHECK dout0_53 Vdout0_53ck186 = 0.9 time = 935
.meas tran vdout0_53ck186 FIND v(dout0_53) AT=935.025n

* CHECK dout0_54 Vdout0_54ck186 = 0 time = 935
.meas tran vdout0_54ck186 FIND v(dout0_54) AT=935.025n

* CHECK dout0_55 Vdout0_55ck186 = 0.9 time = 935
.meas tran vdout0_55ck186 FIND v(dout0_55) AT=935.025n

* CHECK dout0_56 Vdout0_56ck186 = 0 time = 935
.meas tran vdout0_56ck186 FIND v(dout0_56) AT=935.025n

* CHECK dout0_57 Vdout0_57ck186 = 0.9 time = 935
.meas tran vdout0_57ck186 FIND v(dout0_57) AT=935.025n

* CHECK dout0_58 Vdout0_58ck186 = 0.9 time = 935
.meas tran vdout0_58ck186 FIND v(dout0_58) AT=935.025n

* CHECK dout0_59 Vdout0_59ck186 = 0.9 time = 935
.meas tran vdout0_59ck186 FIND v(dout0_59) AT=935.025n

* CHECK dout0_60 Vdout0_60ck186 = 0.9 time = 935
.meas tran vdout0_60ck186 FIND v(dout0_60) AT=935.025n

* CHECK dout0_61 Vdout0_61ck186 = 0 time = 935
.meas tran vdout0_61ck186 FIND v(dout0_61) AT=935.025n

* CHECK dout0_62 Vdout0_62ck186 = 0.9 time = 935
.meas tran vdout0_62ck186 FIND v(dout0_62) AT=935.025n

* CHECK dout0_63 Vdout0_63ck186 = 0 time = 935
.meas tran vdout0_63ck186 FIND v(dout0_63) AT=935.025n

* CHECK dout0_0 Vdout0_0ck187 = 0 time = 940
.meas tran vdout0_0ck187 FIND v(dout0_0) AT=940.025n

* CHECK dout0_1 Vdout0_1ck187 = 0.9 time = 940
.meas tran vdout0_1ck187 FIND v(dout0_1) AT=940.025n

* CHECK dout0_2 Vdout0_2ck187 = 0 time = 940
.meas tran vdout0_2ck187 FIND v(dout0_2) AT=940.025n

* CHECK dout0_3 Vdout0_3ck187 = 0.9 time = 940
.meas tran vdout0_3ck187 FIND v(dout0_3) AT=940.025n

* CHECK dout0_4 Vdout0_4ck187 = 0 time = 940
.meas tran vdout0_4ck187 FIND v(dout0_4) AT=940.025n

* CHECK dout0_5 Vdout0_5ck187 = 0.9 time = 940
.meas tran vdout0_5ck187 FIND v(dout0_5) AT=940.025n

* CHECK dout0_6 Vdout0_6ck187 = 0.9 time = 940
.meas tran vdout0_6ck187 FIND v(dout0_6) AT=940.025n

* CHECK dout0_7 Vdout0_7ck187 = 0 time = 940
.meas tran vdout0_7ck187 FIND v(dout0_7) AT=940.025n

* CHECK dout0_8 Vdout0_8ck187 = 0 time = 940
.meas tran vdout0_8ck187 FIND v(dout0_8) AT=940.025n

* CHECK dout0_9 Vdout0_9ck187 = 0.9 time = 940
.meas tran vdout0_9ck187 FIND v(dout0_9) AT=940.025n

* CHECK dout0_10 Vdout0_10ck187 = 0 time = 940
.meas tran vdout0_10ck187 FIND v(dout0_10) AT=940.025n

* CHECK dout0_11 Vdout0_11ck187 = 0.9 time = 940
.meas tran vdout0_11ck187 FIND v(dout0_11) AT=940.025n

* CHECK dout0_12 Vdout0_12ck187 = 0 time = 940
.meas tran vdout0_12ck187 FIND v(dout0_12) AT=940.025n

* CHECK dout0_13 Vdout0_13ck187 = 0.9 time = 940
.meas tran vdout0_13ck187 FIND v(dout0_13) AT=940.025n

* CHECK dout0_14 Vdout0_14ck187 = 0.9 time = 940
.meas tran vdout0_14ck187 FIND v(dout0_14) AT=940.025n

* CHECK dout0_15 Vdout0_15ck187 = 0.9 time = 940
.meas tran vdout0_15ck187 FIND v(dout0_15) AT=940.025n

* CHECK dout0_16 Vdout0_16ck187 = 0 time = 940
.meas tran vdout0_16ck187 FIND v(dout0_16) AT=940.025n

* CHECK dout0_17 Vdout0_17ck187 = 0.9 time = 940
.meas tran vdout0_17ck187 FIND v(dout0_17) AT=940.025n

* CHECK dout0_18 Vdout0_18ck187 = 0 time = 940
.meas tran vdout0_18ck187 FIND v(dout0_18) AT=940.025n

* CHECK dout0_19 Vdout0_19ck187 = 0.9 time = 940
.meas tran vdout0_19ck187 FIND v(dout0_19) AT=940.025n

* CHECK dout0_20 Vdout0_20ck187 = 0 time = 940
.meas tran vdout0_20ck187 FIND v(dout0_20) AT=940.025n

* CHECK dout0_21 Vdout0_21ck187 = 0.9 time = 940
.meas tran vdout0_21ck187 FIND v(dout0_21) AT=940.025n

* CHECK dout0_22 Vdout0_22ck187 = 0 time = 940
.meas tran vdout0_22ck187 FIND v(dout0_22) AT=940.025n

* CHECK dout0_23 Vdout0_23ck187 = 0 time = 940
.meas tran vdout0_23ck187 FIND v(dout0_23) AT=940.025n

* CHECK dout0_24 Vdout0_24ck187 = 0 time = 940
.meas tran vdout0_24ck187 FIND v(dout0_24) AT=940.025n

* CHECK dout0_25 Vdout0_25ck187 = 0 time = 940
.meas tran vdout0_25ck187 FIND v(dout0_25) AT=940.025n

* CHECK dout0_26 Vdout0_26ck187 = 0.9 time = 940
.meas tran vdout0_26ck187 FIND v(dout0_26) AT=940.025n

* CHECK dout0_27 Vdout0_27ck187 = 0 time = 940
.meas tran vdout0_27ck187 FIND v(dout0_27) AT=940.025n

* CHECK dout0_28 Vdout0_28ck187 = 0 time = 940
.meas tran vdout0_28ck187 FIND v(dout0_28) AT=940.025n

* CHECK dout0_29 Vdout0_29ck187 = 0.9 time = 940
.meas tran vdout0_29ck187 FIND v(dout0_29) AT=940.025n

* CHECK dout0_30 Vdout0_30ck187 = 0.9 time = 940
.meas tran vdout0_30ck187 FIND v(dout0_30) AT=940.025n

* CHECK dout0_31 Vdout0_31ck187 = 0.9 time = 940
.meas tran vdout0_31ck187 FIND v(dout0_31) AT=940.025n

* CHECK dout0_32 Vdout0_32ck187 = 0.9 time = 940
.meas tran vdout0_32ck187 FIND v(dout0_32) AT=940.025n

* CHECK dout0_33 Vdout0_33ck187 = 0.9 time = 940
.meas tran vdout0_33ck187 FIND v(dout0_33) AT=940.025n

* CHECK dout0_34 Vdout0_34ck187 = 0 time = 940
.meas tran vdout0_34ck187 FIND v(dout0_34) AT=940.025n

* CHECK dout0_35 Vdout0_35ck187 = 0 time = 940
.meas tran vdout0_35ck187 FIND v(dout0_35) AT=940.025n

* CHECK dout0_36 Vdout0_36ck187 = 0.9 time = 940
.meas tran vdout0_36ck187 FIND v(dout0_36) AT=940.025n

* CHECK dout0_37 Vdout0_37ck187 = 0 time = 940
.meas tran vdout0_37ck187 FIND v(dout0_37) AT=940.025n

* CHECK dout0_38 Vdout0_38ck187 = 0 time = 940
.meas tran vdout0_38ck187 FIND v(dout0_38) AT=940.025n

* CHECK dout0_39 Vdout0_39ck187 = 0.9 time = 940
.meas tran vdout0_39ck187 FIND v(dout0_39) AT=940.025n

* CHECK dout0_40 Vdout0_40ck187 = 0 time = 940
.meas tran vdout0_40ck187 FIND v(dout0_40) AT=940.025n

* CHECK dout0_41 Vdout0_41ck187 = 0.9 time = 940
.meas tran vdout0_41ck187 FIND v(dout0_41) AT=940.025n

* CHECK dout0_42 Vdout0_42ck187 = 0.9 time = 940
.meas tran vdout0_42ck187 FIND v(dout0_42) AT=940.025n

* CHECK dout0_43 Vdout0_43ck187 = 0 time = 940
.meas tran vdout0_43ck187 FIND v(dout0_43) AT=940.025n

* CHECK dout0_44 Vdout0_44ck187 = 0.9 time = 940
.meas tran vdout0_44ck187 FIND v(dout0_44) AT=940.025n

* CHECK dout0_45 Vdout0_45ck187 = 0.9 time = 940
.meas tran vdout0_45ck187 FIND v(dout0_45) AT=940.025n

* CHECK dout0_46 Vdout0_46ck187 = 0.9 time = 940
.meas tran vdout0_46ck187 FIND v(dout0_46) AT=940.025n

* CHECK dout0_47 Vdout0_47ck187 = 0 time = 940
.meas tran vdout0_47ck187 FIND v(dout0_47) AT=940.025n

* CHECK dout0_48 Vdout0_48ck187 = 0.9 time = 940
.meas tran vdout0_48ck187 FIND v(dout0_48) AT=940.025n

* CHECK dout0_49 Vdout0_49ck187 = 0 time = 940
.meas tran vdout0_49ck187 FIND v(dout0_49) AT=940.025n

* CHECK dout0_50 Vdout0_50ck187 = 0 time = 940
.meas tran vdout0_50ck187 FIND v(dout0_50) AT=940.025n

* CHECK dout0_51 Vdout0_51ck187 = 0.9 time = 940
.meas tran vdout0_51ck187 FIND v(dout0_51) AT=940.025n

* CHECK dout0_52 Vdout0_52ck187 = 0 time = 940
.meas tran vdout0_52ck187 FIND v(dout0_52) AT=940.025n

* CHECK dout0_53 Vdout0_53ck187 = 0.9 time = 940
.meas tran vdout0_53ck187 FIND v(dout0_53) AT=940.025n

* CHECK dout0_54 Vdout0_54ck187 = 0.9 time = 940
.meas tran vdout0_54ck187 FIND v(dout0_54) AT=940.025n

* CHECK dout0_55 Vdout0_55ck187 = 0.9 time = 940
.meas tran vdout0_55ck187 FIND v(dout0_55) AT=940.025n

* CHECK dout0_56 Vdout0_56ck187 = 0 time = 940
.meas tran vdout0_56ck187 FIND v(dout0_56) AT=940.025n

* CHECK dout0_57 Vdout0_57ck187 = 0.9 time = 940
.meas tran vdout0_57ck187 FIND v(dout0_57) AT=940.025n

* CHECK dout0_58 Vdout0_58ck187 = 0 time = 940
.meas tran vdout0_58ck187 FIND v(dout0_58) AT=940.025n

* CHECK dout0_59 Vdout0_59ck187 = 0.9 time = 940
.meas tran vdout0_59ck187 FIND v(dout0_59) AT=940.025n

* CHECK dout0_60 Vdout0_60ck187 = 0.9 time = 940
.meas tran vdout0_60ck187 FIND v(dout0_60) AT=940.025n

* CHECK dout0_61 Vdout0_61ck187 = 0.9 time = 940
.meas tran vdout0_61ck187 FIND v(dout0_61) AT=940.025n

* CHECK dout0_62 Vdout0_62ck187 = 0 time = 940
.meas tran vdout0_62ck187 FIND v(dout0_62) AT=940.025n

* CHECK dout0_63 Vdout0_63ck187 = 0 time = 940
.meas tran vdout0_63ck187 FIND v(dout0_63) AT=940.025n

* CHECK dout0_0 Vdout0_0ck190 = 0 time = 955
.meas tran vdout0_0ck190 FIND v(dout0_0) AT=955.025n

* CHECK dout0_1 Vdout0_1ck190 = 0.9 time = 955
.meas tran vdout0_1ck190 FIND v(dout0_1) AT=955.025n

* CHECK dout0_2 Vdout0_2ck190 = 0 time = 955
.meas tran vdout0_2ck190 FIND v(dout0_2) AT=955.025n

* CHECK dout0_3 Vdout0_3ck190 = 0.9 time = 955
.meas tran vdout0_3ck190 FIND v(dout0_3) AT=955.025n

* CHECK dout0_4 Vdout0_4ck190 = 0.9 time = 955
.meas tran vdout0_4ck190 FIND v(dout0_4) AT=955.025n

* CHECK dout0_5 Vdout0_5ck190 = 0.9 time = 955
.meas tran vdout0_5ck190 FIND v(dout0_5) AT=955.025n

* CHECK dout0_6 Vdout0_6ck190 = 0.9 time = 955
.meas tran vdout0_6ck190 FIND v(dout0_6) AT=955.025n

* CHECK dout0_7 Vdout0_7ck190 = 0 time = 955
.meas tran vdout0_7ck190 FIND v(dout0_7) AT=955.025n

* CHECK dout0_8 Vdout0_8ck190 = 0.9 time = 955
.meas tran vdout0_8ck190 FIND v(dout0_8) AT=955.025n

* CHECK dout0_9 Vdout0_9ck190 = 0 time = 955
.meas tran vdout0_9ck190 FIND v(dout0_9) AT=955.025n

* CHECK dout0_10 Vdout0_10ck190 = 0 time = 955
.meas tran vdout0_10ck190 FIND v(dout0_10) AT=955.025n

* CHECK dout0_11 Vdout0_11ck190 = 0.9 time = 955
.meas tran vdout0_11ck190 FIND v(dout0_11) AT=955.025n

* CHECK dout0_12 Vdout0_12ck190 = 0.9 time = 955
.meas tran vdout0_12ck190 FIND v(dout0_12) AT=955.025n

* CHECK dout0_13 Vdout0_13ck190 = 0.9 time = 955
.meas tran vdout0_13ck190 FIND v(dout0_13) AT=955.025n

* CHECK dout0_14 Vdout0_14ck190 = 0.9 time = 955
.meas tran vdout0_14ck190 FIND v(dout0_14) AT=955.025n

* CHECK dout0_15 Vdout0_15ck190 = 0 time = 955
.meas tran vdout0_15ck190 FIND v(dout0_15) AT=955.025n

* CHECK dout0_16 Vdout0_16ck190 = 0 time = 955
.meas tran vdout0_16ck190 FIND v(dout0_16) AT=955.025n

* CHECK dout0_17 Vdout0_17ck190 = 0.9 time = 955
.meas tran vdout0_17ck190 FIND v(dout0_17) AT=955.025n

* CHECK dout0_18 Vdout0_18ck190 = 0 time = 955
.meas tran vdout0_18ck190 FIND v(dout0_18) AT=955.025n

* CHECK dout0_19 Vdout0_19ck190 = 0.9 time = 955
.meas tran vdout0_19ck190 FIND v(dout0_19) AT=955.025n

* CHECK dout0_20 Vdout0_20ck190 = 0 time = 955
.meas tran vdout0_20ck190 FIND v(dout0_20) AT=955.025n

* CHECK dout0_21 Vdout0_21ck190 = 0 time = 955
.meas tran vdout0_21ck190 FIND v(dout0_21) AT=955.025n

* CHECK dout0_22 Vdout0_22ck190 = 0.9 time = 955
.meas tran vdout0_22ck190 FIND v(dout0_22) AT=955.025n

* CHECK dout0_23 Vdout0_23ck190 = 0 time = 955
.meas tran vdout0_23ck190 FIND v(dout0_23) AT=955.025n

* CHECK dout0_24 Vdout0_24ck190 = 0.9 time = 955
.meas tran vdout0_24ck190 FIND v(dout0_24) AT=955.025n

* CHECK dout0_25 Vdout0_25ck190 = 0.9 time = 955
.meas tran vdout0_25ck190 FIND v(dout0_25) AT=955.025n

* CHECK dout0_26 Vdout0_26ck190 = 0.9 time = 955
.meas tran vdout0_26ck190 FIND v(dout0_26) AT=955.025n

* CHECK dout0_27 Vdout0_27ck190 = 0 time = 955
.meas tran vdout0_27ck190 FIND v(dout0_27) AT=955.025n

* CHECK dout0_28 Vdout0_28ck190 = 0 time = 955
.meas tran vdout0_28ck190 FIND v(dout0_28) AT=955.025n

* CHECK dout0_29 Vdout0_29ck190 = 0.9 time = 955
.meas tran vdout0_29ck190 FIND v(dout0_29) AT=955.025n

* CHECK dout0_30 Vdout0_30ck190 = 0.9 time = 955
.meas tran vdout0_30ck190 FIND v(dout0_30) AT=955.025n

* CHECK dout0_31 Vdout0_31ck190 = 0.9 time = 955
.meas tran vdout0_31ck190 FIND v(dout0_31) AT=955.025n

* CHECK dout0_32 Vdout0_32ck190 = 0 time = 955
.meas tran vdout0_32ck190 FIND v(dout0_32) AT=955.025n

* CHECK dout0_33 Vdout0_33ck190 = 0.9 time = 955
.meas tran vdout0_33ck190 FIND v(dout0_33) AT=955.025n

* CHECK dout0_34 Vdout0_34ck190 = 0 time = 955
.meas tran vdout0_34ck190 FIND v(dout0_34) AT=955.025n

* CHECK dout0_35 Vdout0_35ck190 = 0.9 time = 955
.meas tran vdout0_35ck190 FIND v(dout0_35) AT=955.025n

* CHECK dout0_36 Vdout0_36ck190 = 0 time = 955
.meas tran vdout0_36ck190 FIND v(dout0_36) AT=955.025n

* CHECK dout0_37 Vdout0_37ck190 = 0 time = 955
.meas tran vdout0_37ck190 FIND v(dout0_37) AT=955.025n

* CHECK dout0_38 Vdout0_38ck190 = 0 time = 955
.meas tran vdout0_38ck190 FIND v(dout0_38) AT=955.025n

* CHECK dout0_39 Vdout0_39ck190 = 0.9 time = 955
.meas tran vdout0_39ck190 FIND v(dout0_39) AT=955.025n

* CHECK dout0_40 Vdout0_40ck190 = 0 time = 955
.meas tran vdout0_40ck190 FIND v(dout0_40) AT=955.025n

* CHECK dout0_41 Vdout0_41ck190 = 0 time = 955
.meas tran vdout0_41ck190 FIND v(dout0_41) AT=955.025n

* CHECK dout0_42 Vdout0_42ck190 = 0 time = 955
.meas tran vdout0_42ck190 FIND v(dout0_42) AT=955.025n

* CHECK dout0_43 Vdout0_43ck190 = 0 time = 955
.meas tran vdout0_43ck190 FIND v(dout0_43) AT=955.025n

* CHECK dout0_44 Vdout0_44ck190 = 0.9 time = 955
.meas tran vdout0_44ck190 FIND v(dout0_44) AT=955.025n

* CHECK dout0_45 Vdout0_45ck190 = 0.9 time = 955
.meas tran vdout0_45ck190 FIND v(dout0_45) AT=955.025n

* CHECK dout0_46 Vdout0_46ck190 = 0 time = 955
.meas tran vdout0_46ck190 FIND v(dout0_46) AT=955.025n

* CHECK dout0_47 Vdout0_47ck190 = 0 time = 955
.meas tran vdout0_47ck190 FIND v(dout0_47) AT=955.025n

* CHECK dout0_48 Vdout0_48ck190 = 0 time = 955
.meas tran vdout0_48ck190 FIND v(dout0_48) AT=955.025n

* CHECK dout0_49 Vdout0_49ck190 = 0.9 time = 955
.meas tran vdout0_49ck190 FIND v(dout0_49) AT=955.025n

* CHECK dout0_50 Vdout0_50ck190 = 0.9 time = 955
.meas tran vdout0_50ck190 FIND v(dout0_50) AT=955.025n

* CHECK dout0_51 Vdout0_51ck190 = 0 time = 955
.meas tran vdout0_51ck190 FIND v(dout0_51) AT=955.025n

* CHECK dout0_52 Vdout0_52ck190 = 0.9 time = 955
.meas tran vdout0_52ck190 FIND v(dout0_52) AT=955.025n

* CHECK dout0_53 Vdout0_53ck190 = 0 time = 955
.meas tran vdout0_53ck190 FIND v(dout0_53) AT=955.025n

* CHECK dout0_54 Vdout0_54ck190 = 0 time = 955
.meas tran vdout0_54ck190 FIND v(dout0_54) AT=955.025n

* CHECK dout0_55 Vdout0_55ck190 = 0.9 time = 955
.meas tran vdout0_55ck190 FIND v(dout0_55) AT=955.025n

* CHECK dout0_56 Vdout0_56ck190 = 0.9 time = 955
.meas tran vdout0_56ck190 FIND v(dout0_56) AT=955.025n

* CHECK dout0_57 Vdout0_57ck190 = 0.9 time = 955
.meas tran vdout0_57ck190 FIND v(dout0_57) AT=955.025n

* CHECK dout0_58 Vdout0_58ck190 = 0.9 time = 955
.meas tran vdout0_58ck190 FIND v(dout0_58) AT=955.025n

* CHECK dout0_59 Vdout0_59ck190 = 0 time = 955
.meas tran vdout0_59ck190 FIND v(dout0_59) AT=955.025n

* CHECK dout0_60 Vdout0_60ck190 = 0.9 time = 955
.meas tran vdout0_60ck190 FIND v(dout0_60) AT=955.025n

* CHECK dout0_61 Vdout0_61ck190 = 0.9 time = 955
.meas tran vdout0_61ck190 FIND v(dout0_61) AT=955.025n

* CHECK dout0_62 Vdout0_62ck190 = 0.9 time = 955
.meas tran vdout0_62ck190 FIND v(dout0_62) AT=955.025n

* CHECK dout0_63 Vdout0_63ck190 = 0.9 time = 955
.meas tran vdout0_63ck190 FIND v(dout0_63) AT=955.025n

* CHECK dout0_0 Vdout0_0ck193 = 0 time = 970
.meas tran vdout0_0ck193 FIND v(dout0_0) AT=970.025n

* CHECK dout0_1 Vdout0_1ck193 = 0 time = 970
.meas tran vdout0_1ck193 FIND v(dout0_1) AT=970.025n

* CHECK dout0_2 Vdout0_2ck193 = 0.9 time = 970
.meas tran vdout0_2ck193 FIND v(dout0_2) AT=970.025n

* CHECK dout0_3 Vdout0_3ck193 = 0.9 time = 970
.meas tran vdout0_3ck193 FIND v(dout0_3) AT=970.025n

* CHECK dout0_4 Vdout0_4ck193 = 0 time = 970
.meas tran vdout0_4ck193 FIND v(dout0_4) AT=970.025n

* CHECK dout0_5 Vdout0_5ck193 = 0.9 time = 970
.meas tran vdout0_5ck193 FIND v(dout0_5) AT=970.025n

* CHECK dout0_6 Vdout0_6ck193 = 0 time = 970
.meas tran vdout0_6ck193 FIND v(dout0_6) AT=970.025n

* CHECK dout0_7 Vdout0_7ck193 = 0 time = 970
.meas tran vdout0_7ck193 FIND v(dout0_7) AT=970.025n

* CHECK dout0_8 Vdout0_8ck193 = 0 time = 970
.meas tran vdout0_8ck193 FIND v(dout0_8) AT=970.025n

* CHECK dout0_9 Vdout0_9ck193 = 0 time = 970
.meas tran vdout0_9ck193 FIND v(dout0_9) AT=970.025n

* CHECK dout0_10 Vdout0_10ck193 = 0.9 time = 970
.meas tran vdout0_10ck193 FIND v(dout0_10) AT=970.025n

* CHECK dout0_11 Vdout0_11ck193 = 0.9 time = 970
.meas tran vdout0_11ck193 FIND v(dout0_11) AT=970.025n

* CHECK dout0_12 Vdout0_12ck193 = 0 time = 970
.meas tran vdout0_12ck193 FIND v(dout0_12) AT=970.025n

* CHECK dout0_13 Vdout0_13ck193 = 0 time = 970
.meas tran vdout0_13ck193 FIND v(dout0_13) AT=970.025n

* CHECK dout0_14 Vdout0_14ck193 = 0 time = 970
.meas tran vdout0_14ck193 FIND v(dout0_14) AT=970.025n

* CHECK dout0_15 Vdout0_15ck193 = 0.9 time = 970
.meas tran vdout0_15ck193 FIND v(dout0_15) AT=970.025n

* CHECK dout0_16 Vdout0_16ck193 = 0 time = 970
.meas tran vdout0_16ck193 FIND v(dout0_16) AT=970.025n

* CHECK dout0_17 Vdout0_17ck193 = 0.9 time = 970
.meas tran vdout0_17ck193 FIND v(dout0_17) AT=970.025n

* CHECK dout0_18 Vdout0_18ck193 = 0 time = 970
.meas tran vdout0_18ck193 FIND v(dout0_18) AT=970.025n

* CHECK dout0_19 Vdout0_19ck193 = 0 time = 970
.meas tran vdout0_19ck193 FIND v(dout0_19) AT=970.025n

* CHECK dout0_20 Vdout0_20ck193 = 0.9 time = 970
.meas tran vdout0_20ck193 FIND v(dout0_20) AT=970.025n

* CHECK dout0_21 Vdout0_21ck193 = 0 time = 970
.meas tran vdout0_21ck193 FIND v(dout0_21) AT=970.025n

* CHECK dout0_22 Vdout0_22ck193 = 0 time = 970
.meas tran vdout0_22ck193 FIND v(dout0_22) AT=970.025n

* CHECK dout0_23 Vdout0_23ck193 = 0.9 time = 970
.meas tran vdout0_23ck193 FIND v(dout0_23) AT=970.025n

* CHECK dout0_24 Vdout0_24ck193 = 0 time = 970
.meas tran vdout0_24ck193 FIND v(dout0_24) AT=970.025n

* CHECK dout0_25 Vdout0_25ck193 = 0 time = 970
.meas tran vdout0_25ck193 FIND v(dout0_25) AT=970.025n

* CHECK dout0_26 Vdout0_26ck193 = 0.9 time = 970
.meas tran vdout0_26ck193 FIND v(dout0_26) AT=970.025n

* CHECK dout0_27 Vdout0_27ck193 = 0.9 time = 970
.meas tran vdout0_27ck193 FIND v(dout0_27) AT=970.025n

* CHECK dout0_28 Vdout0_28ck193 = 0 time = 970
.meas tran vdout0_28ck193 FIND v(dout0_28) AT=970.025n

* CHECK dout0_29 Vdout0_29ck193 = 0 time = 970
.meas tran vdout0_29ck193 FIND v(dout0_29) AT=970.025n

* CHECK dout0_30 Vdout0_30ck193 = 0 time = 970
.meas tran vdout0_30ck193 FIND v(dout0_30) AT=970.025n

* CHECK dout0_31 Vdout0_31ck193 = 0 time = 970
.meas tran vdout0_31ck193 FIND v(dout0_31) AT=970.025n

* CHECK dout0_32 Vdout0_32ck193 = 0 time = 970
.meas tran vdout0_32ck193 FIND v(dout0_32) AT=970.025n

* CHECK dout0_33 Vdout0_33ck193 = 0 time = 970
.meas tran vdout0_33ck193 FIND v(dout0_33) AT=970.025n

* CHECK dout0_34 Vdout0_34ck193 = 0.9 time = 970
.meas tran vdout0_34ck193 FIND v(dout0_34) AT=970.025n

* CHECK dout0_35 Vdout0_35ck193 = 0.9 time = 970
.meas tran vdout0_35ck193 FIND v(dout0_35) AT=970.025n

* CHECK dout0_36 Vdout0_36ck193 = 0 time = 970
.meas tran vdout0_36ck193 FIND v(dout0_36) AT=970.025n

* CHECK dout0_37 Vdout0_37ck193 = 0.9 time = 970
.meas tran vdout0_37ck193 FIND v(dout0_37) AT=970.025n

* CHECK dout0_38 Vdout0_38ck193 = 0.9 time = 970
.meas tran vdout0_38ck193 FIND v(dout0_38) AT=970.025n

* CHECK dout0_39 Vdout0_39ck193 = 0.9 time = 970
.meas tran vdout0_39ck193 FIND v(dout0_39) AT=970.025n

* CHECK dout0_40 Vdout0_40ck193 = 0.9 time = 970
.meas tran vdout0_40ck193 FIND v(dout0_40) AT=970.025n

* CHECK dout0_41 Vdout0_41ck193 = 0.9 time = 970
.meas tran vdout0_41ck193 FIND v(dout0_41) AT=970.025n

* CHECK dout0_42 Vdout0_42ck193 = 0 time = 970
.meas tran vdout0_42ck193 FIND v(dout0_42) AT=970.025n

* CHECK dout0_43 Vdout0_43ck193 = 0 time = 970
.meas tran vdout0_43ck193 FIND v(dout0_43) AT=970.025n

* CHECK dout0_44 Vdout0_44ck193 = 0.9 time = 970
.meas tran vdout0_44ck193 FIND v(dout0_44) AT=970.025n

* CHECK dout0_45 Vdout0_45ck193 = 0 time = 970
.meas tran vdout0_45ck193 FIND v(dout0_45) AT=970.025n

* CHECK dout0_46 Vdout0_46ck193 = 0 time = 970
.meas tran vdout0_46ck193 FIND v(dout0_46) AT=970.025n

* CHECK dout0_47 Vdout0_47ck193 = 0.9 time = 970
.meas tran vdout0_47ck193 FIND v(dout0_47) AT=970.025n

* CHECK dout0_48 Vdout0_48ck193 = 0 time = 970
.meas tran vdout0_48ck193 FIND v(dout0_48) AT=970.025n

* CHECK dout0_49 Vdout0_49ck193 = 0 time = 970
.meas tran vdout0_49ck193 FIND v(dout0_49) AT=970.025n

* CHECK dout0_50 Vdout0_50ck193 = 0 time = 970
.meas tran vdout0_50ck193 FIND v(dout0_50) AT=970.025n

* CHECK dout0_51 Vdout0_51ck193 = 0.9 time = 970
.meas tran vdout0_51ck193 FIND v(dout0_51) AT=970.025n

* CHECK dout0_52 Vdout0_52ck193 = 0 time = 970
.meas tran vdout0_52ck193 FIND v(dout0_52) AT=970.025n

* CHECK dout0_53 Vdout0_53ck193 = 0 time = 970
.meas tran vdout0_53ck193 FIND v(dout0_53) AT=970.025n

* CHECK dout0_54 Vdout0_54ck193 = 0 time = 970
.meas tran vdout0_54ck193 FIND v(dout0_54) AT=970.025n

* CHECK dout0_55 Vdout0_55ck193 = 0.9 time = 970
.meas tran vdout0_55ck193 FIND v(dout0_55) AT=970.025n

* CHECK dout0_56 Vdout0_56ck193 = 0 time = 970
.meas tran vdout0_56ck193 FIND v(dout0_56) AT=970.025n

* CHECK dout0_57 Vdout0_57ck193 = 0 time = 970
.meas tran vdout0_57ck193 FIND v(dout0_57) AT=970.025n

* CHECK dout0_58 Vdout0_58ck193 = 0.9 time = 970
.meas tran vdout0_58ck193 FIND v(dout0_58) AT=970.025n

* CHECK dout0_59 Vdout0_59ck193 = 0 time = 970
.meas tran vdout0_59ck193 FIND v(dout0_59) AT=970.025n

* CHECK dout0_60 Vdout0_60ck193 = 0.9 time = 970
.meas tran vdout0_60ck193 FIND v(dout0_60) AT=970.025n

* CHECK dout0_61 Vdout0_61ck193 = 0 time = 970
.meas tran vdout0_61ck193 FIND v(dout0_61) AT=970.025n

* CHECK dout0_62 Vdout0_62ck193 = 0.9 time = 970
.meas tran vdout0_62ck193 FIND v(dout0_62) AT=970.025n

* CHECK dout0_63 Vdout0_63ck193 = 0.9 time = 970
.meas tran vdout0_63ck193 FIND v(dout0_63) AT=970.025n

* CHECK dout0_0 Vdout0_0ck195 = 0.9 time = 980
.meas tran vdout0_0ck195 FIND v(dout0_0) AT=980.025n

* CHECK dout0_1 Vdout0_1ck195 = 0.9 time = 980
.meas tran vdout0_1ck195 FIND v(dout0_1) AT=980.025n

* CHECK dout0_2 Vdout0_2ck195 = 0 time = 980
.meas tran vdout0_2ck195 FIND v(dout0_2) AT=980.025n

* CHECK dout0_3 Vdout0_3ck195 = 0.9 time = 980
.meas tran vdout0_3ck195 FIND v(dout0_3) AT=980.025n

* CHECK dout0_4 Vdout0_4ck195 = 0 time = 980
.meas tran vdout0_4ck195 FIND v(dout0_4) AT=980.025n

* CHECK dout0_5 Vdout0_5ck195 = 0 time = 980
.meas tran vdout0_5ck195 FIND v(dout0_5) AT=980.025n

* CHECK dout0_6 Vdout0_6ck195 = 0 time = 980
.meas tran vdout0_6ck195 FIND v(dout0_6) AT=980.025n

* CHECK dout0_7 Vdout0_7ck195 = 0.9 time = 980
.meas tran vdout0_7ck195 FIND v(dout0_7) AT=980.025n

* CHECK dout0_8 Vdout0_8ck195 = 0.9 time = 980
.meas tran vdout0_8ck195 FIND v(dout0_8) AT=980.025n

* CHECK dout0_9 Vdout0_9ck195 = 0 time = 980
.meas tran vdout0_9ck195 FIND v(dout0_9) AT=980.025n

* CHECK dout0_10 Vdout0_10ck195 = 0.9 time = 980
.meas tran vdout0_10ck195 FIND v(dout0_10) AT=980.025n

* CHECK dout0_11 Vdout0_11ck195 = 0.9 time = 980
.meas tran vdout0_11ck195 FIND v(dout0_11) AT=980.025n

* CHECK dout0_12 Vdout0_12ck195 = 0.9 time = 980
.meas tran vdout0_12ck195 FIND v(dout0_12) AT=980.025n

* CHECK dout0_13 Vdout0_13ck195 = 0 time = 980
.meas tran vdout0_13ck195 FIND v(dout0_13) AT=980.025n

* CHECK dout0_14 Vdout0_14ck195 = 0.9 time = 980
.meas tran vdout0_14ck195 FIND v(dout0_14) AT=980.025n

* CHECK dout0_15 Vdout0_15ck195 = 0.9 time = 980
.meas tran vdout0_15ck195 FIND v(dout0_15) AT=980.025n

* CHECK dout0_16 Vdout0_16ck195 = 0.9 time = 980
.meas tran vdout0_16ck195 FIND v(dout0_16) AT=980.025n

* CHECK dout0_17 Vdout0_17ck195 = 0 time = 980
.meas tran vdout0_17ck195 FIND v(dout0_17) AT=980.025n

* CHECK dout0_18 Vdout0_18ck195 = 0.9 time = 980
.meas tran vdout0_18ck195 FIND v(dout0_18) AT=980.025n

* CHECK dout0_19 Vdout0_19ck195 = 0.9 time = 980
.meas tran vdout0_19ck195 FIND v(dout0_19) AT=980.025n

* CHECK dout0_20 Vdout0_20ck195 = 0 time = 980
.meas tran vdout0_20ck195 FIND v(dout0_20) AT=980.025n

* CHECK dout0_21 Vdout0_21ck195 = 0 time = 980
.meas tran vdout0_21ck195 FIND v(dout0_21) AT=980.025n

* CHECK dout0_22 Vdout0_22ck195 = 0 time = 980
.meas tran vdout0_22ck195 FIND v(dout0_22) AT=980.025n

* CHECK dout0_23 Vdout0_23ck195 = 0.9 time = 980
.meas tran vdout0_23ck195 FIND v(dout0_23) AT=980.025n

* CHECK dout0_24 Vdout0_24ck195 = 0.9 time = 980
.meas tran vdout0_24ck195 FIND v(dout0_24) AT=980.025n

* CHECK dout0_25 Vdout0_25ck195 = 0 time = 980
.meas tran vdout0_25ck195 FIND v(dout0_25) AT=980.025n

* CHECK dout0_26 Vdout0_26ck195 = 0 time = 980
.meas tran vdout0_26ck195 FIND v(dout0_26) AT=980.025n

* CHECK dout0_27 Vdout0_27ck195 = 0 time = 980
.meas tran vdout0_27ck195 FIND v(dout0_27) AT=980.025n

* CHECK dout0_28 Vdout0_28ck195 = 0.9 time = 980
.meas tran vdout0_28ck195 FIND v(dout0_28) AT=980.025n

* CHECK dout0_29 Vdout0_29ck195 = 0 time = 980
.meas tran vdout0_29ck195 FIND v(dout0_29) AT=980.025n

* CHECK dout0_30 Vdout0_30ck195 = 0 time = 980
.meas tran vdout0_30ck195 FIND v(dout0_30) AT=980.025n

* CHECK dout0_31 Vdout0_31ck195 = 0 time = 980
.meas tran vdout0_31ck195 FIND v(dout0_31) AT=980.025n

* CHECK dout0_32 Vdout0_32ck195 = 0 time = 980
.meas tran vdout0_32ck195 FIND v(dout0_32) AT=980.025n

* CHECK dout0_33 Vdout0_33ck195 = 0 time = 980
.meas tran vdout0_33ck195 FIND v(dout0_33) AT=980.025n

* CHECK dout0_34 Vdout0_34ck195 = 0 time = 980
.meas tran vdout0_34ck195 FIND v(dout0_34) AT=980.025n

* CHECK dout0_35 Vdout0_35ck195 = 0.9 time = 980
.meas tran vdout0_35ck195 FIND v(dout0_35) AT=980.025n

* CHECK dout0_36 Vdout0_36ck195 = 0.9 time = 980
.meas tran vdout0_36ck195 FIND v(dout0_36) AT=980.025n

* CHECK dout0_37 Vdout0_37ck195 = 0 time = 980
.meas tran vdout0_37ck195 FIND v(dout0_37) AT=980.025n

* CHECK dout0_38 Vdout0_38ck195 = 0.9 time = 980
.meas tran vdout0_38ck195 FIND v(dout0_38) AT=980.025n

* CHECK dout0_39 Vdout0_39ck195 = 0.9 time = 980
.meas tran vdout0_39ck195 FIND v(dout0_39) AT=980.025n

* CHECK dout0_40 Vdout0_40ck195 = 0 time = 980
.meas tran vdout0_40ck195 FIND v(dout0_40) AT=980.025n

* CHECK dout0_41 Vdout0_41ck195 = 0.9 time = 980
.meas tran vdout0_41ck195 FIND v(dout0_41) AT=980.025n

* CHECK dout0_42 Vdout0_42ck195 = 0.9 time = 980
.meas tran vdout0_42ck195 FIND v(dout0_42) AT=980.025n

* CHECK dout0_43 Vdout0_43ck195 = 0 time = 980
.meas tran vdout0_43ck195 FIND v(dout0_43) AT=980.025n

* CHECK dout0_44 Vdout0_44ck195 = 0 time = 980
.meas tran vdout0_44ck195 FIND v(dout0_44) AT=980.025n

* CHECK dout0_45 Vdout0_45ck195 = 0 time = 980
.meas tran vdout0_45ck195 FIND v(dout0_45) AT=980.025n

* CHECK dout0_46 Vdout0_46ck195 = 0.9 time = 980
.meas tran vdout0_46ck195 FIND v(dout0_46) AT=980.025n

* CHECK dout0_47 Vdout0_47ck195 = 0 time = 980
.meas tran vdout0_47ck195 FIND v(dout0_47) AT=980.025n

* CHECK dout0_48 Vdout0_48ck195 = 0.9 time = 980
.meas tran vdout0_48ck195 FIND v(dout0_48) AT=980.025n

* CHECK dout0_49 Vdout0_49ck195 = 0 time = 980
.meas tran vdout0_49ck195 FIND v(dout0_49) AT=980.025n

* CHECK dout0_50 Vdout0_50ck195 = 0.9 time = 980
.meas tran vdout0_50ck195 FIND v(dout0_50) AT=980.025n

* CHECK dout0_51 Vdout0_51ck195 = 0 time = 980
.meas tran vdout0_51ck195 FIND v(dout0_51) AT=980.025n

* CHECK dout0_52 Vdout0_52ck195 = 0.9 time = 980
.meas tran vdout0_52ck195 FIND v(dout0_52) AT=980.025n

* CHECK dout0_53 Vdout0_53ck195 = 0.9 time = 980
.meas tran vdout0_53ck195 FIND v(dout0_53) AT=980.025n

* CHECK dout0_54 Vdout0_54ck195 = 0.9 time = 980
.meas tran vdout0_54ck195 FIND v(dout0_54) AT=980.025n

* CHECK dout0_55 Vdout0_55ck195 = 0.9 time = 980
.meas tran vdout0_55ck195 FIND v(dout0_55) AT=980.025n

* CHECK dout0_56 Vdout0_56ck195 = 0 time = 980
.meas tran vdout0_56ck195 FIND v(dout0_56) AT=980.025n

* CHECK dout0_57 Vdout0_57ck195 = 0 time = 980
.meas tran vdout0_57ck195 FIND v(dout0_57) AT=980.025n

* CHECK dout0_58 Vdout0_58ck195 = 0 time = 980
.meas tran vdout0_58ck195 FIND v(dout0_58) AT=980.025n

* CHECK dout0_59 Vdout0_59ck195 = 0.9 time = 980
.meas tran vdout0_59ck195 FIND v(dout0_59) AT=980.025n

* CHECK dout0_60 Vdout0_60ck195 = 0.9 time = 980
.meas tran vdout0_60ck195 FIND v(dout0_60) AT=980.025n

* CHECK dout0_61 Vdout0_61ck195 = 0.9 time = 980
.meas tran vdout0_61ck195 FIND v(dout0_61) AT=980.025n

* CHECK dout0_62 Vdout0_62ck195 = 0 time = 980
.meas tran vdout0_62ck195 FIND v(dout0_62) AT=980.025n

* CHECK dout0_63 Vdout0_63ck195 = 0.9 time = 980
.meas tran vdout0_63ck195 FIND v(dout0_63) AT=980.025n

* CHECK dout0_0 Vdout0_0ck196 = 0 time = 985
.meas tran vdout0_0ck196 FIND v(dout0_0) AT=985.025n

* CHECK dout0_1 Vdout0_1ck196 = 0.9 time = 985
.meas tran vdout0_1ck196 FIND v(dout0_1) AT=985.025n

* CHECK dout0_2 Vdout0_2ck196 = 0 time = 985
.meas tran vdout0_2ck196 FIND v(dout0_2) AT=985.025n

* CHECK dout0_3 Vdout0_3ck196 = 0.9 time = 985
.meas tran vdout0_3ck196 FIND v(dout0_3) AT=985.025n

* CHECK dout0_4 Vdout0_4ck196 = 0.9 time = 985
.meas tran vdout0_4ck196 FIND v(dout0_4) AT=985.025n

* CHECK dout0_5 Vdout0_5ck196 = 0.9 time = 985
.meas tran vdout0_5ck196 FIND v(dout0_5) AT=985.025n

* CHECK dout0_6 Vdout0_6ck196 = 0.9 time = 985
.meas tran vdout0_6ck196 FIND v(dout0_6) AT=985.025n

* CHECK dout0_7 Vdout0_7ck196 = 0 time = 985
.meas tran vdout0_7ck196 FIND v(dout0_7) AT=985.025n

* CHECK dout0_8 Vdout0_8ck196 = 0.9 time = 985
.meas tran vdout0_8ck196 FIND v(dout0_8) AT=985.025n

* CHECK dout0_9 Vdout0_9ck196 = 0 time = 985
.meas tran vdout0_9ck196 FIND v(dout0_9) AT=985.025n

* CHECK dout0_10 Vdout0_10ck196 = 0 time = 985
.meas tran vdout0_10ck196 FIND v(dout0_10) AT=985.025n

* CHECK dout0_11 Vdout0_11ck196 = 0.9 time = 985
.meas tran vdout0_11ck196 FIND v(dout0_11) AT=985.025n

* CHECK dout0_12 Vdout0_12ck196 = 0.9 time = 985
.meas tran vdout0_12ck196 FIND v(dout0_12) AT=985.025n

* CHECK dout0_13 Vdout0_13ck196 = 0.9 time = 985
.meas tran vdout0_13ck196 FIND v(dout0_13) AT=985.025n

* CHECK dout0_14 Vdout0_14ck196 = 0.9 time = 985
.meas tran vdout0_14ck196 FIND v(dout0_14) AT=985.025n

* CHECK dout0_15 Vdout0_15ck196 = 0 time = 985
.meas tran vdout0_15ck196 FIND v(dout0_15) AT=985.025n

* CHECK dout0_16 Vdout0_16ck196 = 0 time = 985
.meas tran vdout0_16ck196 FIND v(dout0_16) AT=985.025n

* CHECK dout0_17 Vdout0_17ck196 = 0.9 time = 985
.meas tran vdout0_17ck196 FIND v(dout0_17) AT=985.025n

* CHECK dout0_18 Vdout0_18ck196 = 0 time = 985
.meas tran vdout0_18ck196 FIND v(dout0_18) AT=985.025n

* CHECK dout0_19 Vdout0_19ck196 = 0.9 time = 985
.meas tran vdout0_19ck196 FIND v(dout0_19) AT=985.025n

* CHECK dout0_20 Vdout0_20ck196 = 0 time = 985
.meas tran vdout0_20ck196 FIND v(dout0_20) AT=985.025n

* CHECK dout0_21 Vdout0_21ck196 = 0 time = 985
.meas tran vdout0_21ck196 FIND v(dout0_21) AT=985.025n

* CHECK dout0_22 Vdout0_22ck196 = 0.9 time = 985
.meas tran vdout0_22ck196 FIND v(dout0_22) AT=985.025n

* CHECK dout0_23 Vdout0_23ck196 = 0 time = 985
.meas tran vdout0_23ck196 FIND v(dout0_23) AT=985.025n

* CHECK dout0_24 Vdout0_24ck196 = 0.9 time = 985
.meas tran vdout0_24ck196 FIND v(dout0_24) AT=985.025n

* CHECK dout0_25 Vdout0_25ck196 = 0.9 time = 985
.meas tran vdout0_25ck196 FIND v(dout0_25) AT=985.025n

* CHECK dout0_26 Vdout0_26ck196 = 0.9 time = 985
.meas tran vdout0_26ck196 FIND v(dout0_26) AT=985.025n

* CHECK dout0_27 Vdout0_27ck196 = 0 time = 985
.meas tran vdout0_27ck196 FIND v(dout0_27) AT=985.025n

* CHECK dout0_28 Vdout0_28ck196 = 0 time = 985
.meas tran vdout0_28ck196 FIND v(dout0_28) AT=985.025n

* CHECK dout0_29 Vdout0_29ck196 = 0.9 time = 985
.meas tran vdout0_29ck196 FIND v(dout0_29) AT=985.025n

* CHECK dout0_30 Vdout0_30ck196 = 0.9 time = 985
.meas tran vdout0_30ck196 FIND v(dout0_30) AT=985.025n

* CHECK dout0_31 Vdout0_31ck196 = 0.9 time = 985
.meas tran vdout0_31ck196 FIND v(dout0_31) AT=985.025n

* CHECK dout0_32 Vdout0_32ck196 = 0 time = 985
.meas tran vdout0_32ck196 FIND v(dout0_32) AT=985.025n

* CHECK dout0_33 Vdout0_33ck196 = 0.9 time = 985
.meas tran vdout0_33ck196 FIND v(dout0_33) AT=985.025n

* CHECK dout0_34 Vdout0_34ck196 = 0 time = 985
.meas tran vdout0_34ck196 FIND v(dout0_34) AT=985.025n

* CHECK dout0_35 Vdout0_35ck196 = 0.9 time = 985
.meas tran vdout0_35ck196 FIND v(dout0_35) AT=985.025n

* CHECK dout0_36 Vdout0_36ck196 = 0 time = 985
.meas tran vdout0_36ck196 FIND v(dout0_36) AT=985.025n

* CHECK dout0_37 Vdout0_37ck196 = 0 time = 985
.meas tran vdout0_37ck196 FIND v(dout0_37) AT=985.025n

* CHECK dout0_38 Vdout0_38ck196 = 0 time = 985
.meas tran vdout0_38ck196 FIND v(dout0_38) AT=985.025n

* CHECK dout0_39 Vdout0_39ck196 = 0.9 time = 985
.meas tran vdout0_39ck196 FIND v(dout0_39) AT=985.025n

* CHECK dout0_40 Vdout0_40ck196 = 0 time = 985
.meas tran vdout0_40ck196 FIND v(dout0_40) AT=985.025n

* CHECK dout0_41 Vdout0_41ck196 = 0 time = 985
.meas tran vdout0_41ck196 FIND v(dout0_41) AT=985.025n

* CHECK dout0_42 Vdout0_42ck196 = 0 time = 985
.meas tran vdout0_42ck196 FIND v(dout0_42) AT=985.025n

* CHECK dout0_43 Vdout0_43ck196 = 0 time = 985
.meas tran vdout0_43ck196 FIND v(dout0_43) AT=985.025n

* CHECK dout0_44 Vdout0_44ck196 = 0.9 time = 985
.meas tran vdout0_44ck196 FIND v(dout0_44) AT=985.025n

* CHECK dout0_45 Vdout0_45ck196 = 0.9 time = 985
.meas tran vdout0_45ck196 FIND v(dout0_45) AT=985.025n

* CHECK dout0_46 Vdout0_46ck196 = 0 time = 985
.meas tran vdout0_46ck196 FIND v(dout0_46) AT=985.025n

* CHECK dout0_47 Vdout0_47ck196 = 0 time = 985
.meas tran vdout0_47ck196 FIND v(dout0_47) AT=985.025n

* CHECK dout0_48 Vdout0_48ck196 = 0 time = 985
.meas tran vdout0_48ck196 FIND v(dout0_48) AT=985.025n

* CHECK dout0_49 Vdout0_49ck196 = 0.9 time = 985
.meas tran vdout0_49ck196 FIND v(dout0_49) AT=985.025n

* CHECK dout0_50 Vdout0_50ck196 = 0.9 time = 985
.meas tran vdout0_50ck196 FIND v(dout0_50) AT=985.025n

* CHECK dout0_51 Vdout0_51ck196 = 0 time = 985
.meas tran vdout0_51ck196 FIND v(dout0_51) AT=985.025n

* CHECK dout0_52 Vdout0_52ck196 = 0.9 time = 985
.meas tran vdout0_52ck196 FIND v(dout0_52) AT=985.025n

* CHECK dout0_53 Vdout0_53ck196 = 0 time = 985
.meas tran vdout0_53ck196 FIND v(dout0_53) AT=985.025n

* CHECK dout0_54 Vdout0_54ck196 = 0 time = 985
.meas tran vdout0_54ck196 FIND v(dout0_54) AT=985.025n

* CHECK dout0_55 Vdout0_55ck196 = 0.9 time = 985
.meas tran vdout0_55ck196 FIND v(dout0_55) AT=985.025n

* CHECK dout0_56 Vdout0_56ck196 = 0.9 time = 985
.meas tran vdout0_56ck196 FIND v(dout0_56) AT=985.025n

* CHECK dout0_57 Vdout0_57ck196 = 0.9 time = 985
.meas tran vdout0_57ck196 FIND v(dout0_57) AT=985.025n

* CHECK dout0_58 Vdout0_58ck196 = 0.9 time = 985
.meas tran vdout0_58ck196 FIND v(dout0_58) AT=985.025n

* CHECK dout0_59 Vdout0_59ck196 = 0 time = 985
.meas tran vdout0_59ck196 FIND v(dout0_59) AT=985.025n

* CHECK dout0_60 Vdout0_60ck196 = 0.9 time = 985
.meas tran vdout0_60ck196 FIND v(dout0_60) AT=985.025n

* CHECK dout0_61 Vdout0_61ck196 = 0.9 time = 985
.meas tran vdout0_61ck196 FIND v(dout0_61) AT=985.025n

* CHECK dout0_62 Vdout0_62ck196 = 0.9 time = 985
.meas tran vdout0_62ck196 FIND v(dout0_62) AT=985.025n

* CHECK dout0_63 Vdout0_63ck196 = 0.9 time = 985
.meas tran vdout0_63ck196 FIND v(dout0_63) AT=985.025n

* CHECK dout0_0 Vdout0_0ck197 = 0.9 time = 990
.meas tran vdout0_0ck197 FIND v(dout0_0) AT=990.025n

* CHECK dout0_1 Vdout0_1ck197 = 0.9 time = 990
.meas tran vdout0_1ck197 FIND v(dout0_1) AT=990.025n

* CHECK dout0_2 Vdout0_2ck197 = 0 time = 990
.meas tran vdout0_2ck197 FIND v(dout0_2) AT=990.025n

* CHECK dout0_3 Vdout0_3ck197 = 0.9 time = 990
.meas tran vdout0_3ck197 FIND v(dout0_3) AT=990.025n

* CHECK dout0_4 Vdout0_4ck197 = 0 time = 990
.meas tran vdout0_4ck197 FIND v(dout0_4) AT=990.025n

* CHECK dout0_5 Vdout0_5ck197 = 0 time = 990
.meas tran vdout0_5ck197 FIND v(dout0_5) AT=990.025n

* CHECK dout0_6 Vdout0_6ck197 = 0 time = 990
.meas tran vdout0_6ck197 FIND v(dout0_6) AT=990.025n

* CHECK dout0_7 Vdout0_7ck197 = 0.9 time = 990
.meas tran vdout0_7ck197 FIND v(dout0_7) AT=990.025n

* CHECK dout0_8 Vdout0_8ck197 = 0.9 time = 990
.meas tran vdout0_8ck197 FIND v(dout0_8) AT=990.025n

* CHECK dout0_9 Vdout0_9ck197 = 0 time = 990
.meas tran vdout0_9ck197 FIND v(dout0_9) AT=990.025n

* CHECK dout0_10 Vdout0_10ck197 = 0.9 time = 990
.meas tran vdout0_10ck197 FIND v(dout0_10) AT=990.025n

* CHECK dout0_11 Vdout0_11ck197 = 0.9 time = 990
.meas tran vdout0_11ck197 FIND v(dout0_11) AT=990.025n

* CHECK dout0_12 Vdout0_12ck197 = 0.9 time = 990
.meas tran vdout0_12ck197 FIND v(dout0_12) AT=990.025n

* CHECK dout0_13 Vdout0_13ck197 = 0 time = 990
.meas tran vdout0_13ck197 FIND v(dout0_13) AT=990.025n

* CHECK dout0_14 Vdout0_14ck197 = 0.9 time = 990
.meas tran vdout0_14ck197 FIND v(dout0_14) AT=990.025n

* CHECK dout0_15 Vdout0_15ck197 = 0.9 time = 990
.meas tran vdout0_15ck197 FIND v(dout0_15) AT=990.025n

* CHECK dout0_16 Vdout0_16ck197 = 0.9 time = 990
.meas tran vdout0_16ck197 FIND v(dout0_16) AT=990.025n

* CHECK dout0_17 Vdout0_17ck197 = 0 time = 990
.meas tran vdout0_17ck197 FIND v(dout0_17) AT=990.025n

* CHECK dout0_18 Vdout0_18ck197 = 0.9 time = 990
.meas tran vdout0_18ck197 FIND v(dout0_18) AT=990.025n

* CHECK dout0_19 Vdout0_19ck197 = 0.9 time = 990
.meas tran vdout0_19ck197 FIND v(dout0_19) AT=990.025n

* CHECK dout0_20 Vdout0_20ck197 = 0 time = 990
.meas tran vdout0_20ck197 FIND v(dout0_20) AT=990.025n

* CHECK dout0_21 Vdout0_21ck197 = 0 time = 990
.meas tran vdout0_21ck197 FIND v(dout0_21) AT=990.025n

* CHECK dout0_22 Vdout0_22ck197 = 0 time = 990
.meas tran vdout0_22ck197 FIND v(dout0_22) AT=990.025n

* CHECK dout0_23 Vdout0_23ck197 = 0.9 time = 990
.meas tran vdout0_23ck197 FIND v(dout0_23) AT=990.025n

* CHECK dout0_24 Vdout0_24ck197 = 0.9 time = 990
.meas tran vdout0_24ck197 FIND v(dout0_24) AT=990.025n

* CHECK dout0_25 Vdout0_25ck197 = 0 time = 990
.meas tran vdout0_25ck197 FIND v(dout0_25) AT=990.025n

* CHECK dout0_26 Vdout0_26ck197 = 0 time = 990
.meas tran vdout0_26ck197 FIND v(dout0_26) AT=990.025n

* CHECK dout0_27 Vdout0_27ck197 = 0 time = 990
.meas tran vdout0_27ck197 FIND v(dout0_27) AT=990.025n

* CHECK dout0_28 Vdout0_28ck197 = 0.9 time = 990
.meas tran vdout0_28ck197 FIND v(dout0_28) AT=990.025n

* CHECK dout0_29 Vdout0_29ck197 = 0 time = 990
.meas tran vdout0_29ck197 FIND v(dout0_29) AT=990.025n

* CHECK dout0_30 Vdout0_30ck197 = 0 time = 990
.meas tran vdout0_30ck197 FIND v(dout0_30) AT=990.025n

* CHECK dout0_31 Vdout0_31ck197 = 0 time = 990
.meas tran vdout0_31ck197 FIND v(dout0_31) AT=990.025n

* CHECK dout0_32 Vdout0_32ck197 = 0 time = 990
.meas tran vdout0_32ck197 FIND v(dout0_32) AT=990.025n

* CHECK dout0_33 Vdout0_33ck197 = 0 time = 990
.meas tran vdout0_33ck197 FIND v(dout0_33) AT=990.025n

* CHECK dout0_34 Vdout0_34ck197 = 0 time = 990
.meas tran vdout0_34ck197 FIND v(dout0_34) AT=990.025n

* CHECK dout0_35 Vdout0_35ck197 = 0.9 time = 990
.meas tran vdout0_35ck197 FIND v(dout0_35) AT=990.025n

* CHECK dout0_36 Vdout0_36ck197 = 0.9 time = 990
.meas tran vdout0_36ck197 FIND v(dout0_36) AT=990.025n

* CHECK dout0_37 Vdout0_37ck197 = 0 time = 990
.meas tran vdout0_37ck197 FIND v(dout0_37) AT=990.025n

* CHECK dout0_38 Vdout0_38ck197 = 0.9 time = 990
.meas tran vdout0_38ck197 FIND v(dout0_38) AT=990.025n

* CHECK dout0_39 Vdout0_39ck197 = 0.9 time = 990
.meas tran vdout0_39ck197 FIND v(dout0_39) AT=990.025n

* CHECK dout0_40 Vdout0_40ck197 = 0 time = 990
.meas tran vdout0_40ck197 FIND v(dout0_40) AT=990.025n

* CHECK dout0_41 Vdout0_41ck197 = 0.9 time = 990
.meas tran vdout0_41ck197 FIND v(dout0_41) AT=990.025n

* CHECK dout0_42 Vdout0_42ck197 = 0.9 time = 990
.meas tran vdout0_42ck197 FIND v(dout0_42) AT=990.025n

* CHECK dout0_43 Vdout0_43ck197 = 0 time = 990
.meas tran vdout0_43ck197 FIND v(dout0_43) AT=990.025n

* CHECK dout0_44 Vdout0_44ck197 = 0 time = 990
.meas tran vdout0_44ck197 FIND v(dout0_44) AT=990.025n

* CHECK dout0_45 Vdout0_45ck197 = 0 time = 990
.meas tran vdout0_45ck197 FIND v(dout0_45) AT=990.025n

* CHECK dout0_46 Vdout0_46ck197 = 0.9 time = 990
.meas tran vdout0_46ck197 FIND v(dout0_46) AT=990.025n

* CHECK dout0_47 Vdout0_47ck197 = 0 time = 990
.meas tran vdout0_47ck197 FIND v(dout0_47) AT=990.025n

* CHECK dout0_48 Vdout0_48ck197 = 0.9 time = 990
.meas tran vdout0_48ck197 FIND v(dout0_48) AT=990.025n

* CHECK dout0_49 Vdout0_49ck197 = 0 time = 990
.meas tran vdout0_49ck197 FIND v(dout0_49) AT=990.025n

* CHECK dout0_50 Vdout0_50ck197 = 0.9 time = 990
.meas tran vdout0_50ck197 FIND v(dout0_50) AT=990.025n

* CHECK dout0_51 Vdout0_51ck197 = 0 time = 990
.meas tran vdout0_51ck197 FIND v(dout0_51) AT=990.025n

* CHECK dout0_52 Vdout0_52ck197 = 0.9 time = 990
.meas tran vdout0_52ck197 FIND v(dout0_52) AT=990.025n

* CHECK dout0_53 Vdout0_53ck197 = 0.9 time = 990
.meas tran vdout0_53ck197 FIND v(dout0_53) AT=990.025n

* CHECK dout0_54 Vdout0_54ck197 = 0.9 time = 990
.meas tran vdout0_54ck197 FIND v(dout0_54) AT=990.025n

* CHECK dout0_55 Vdout0_55ck197 = 0.9 time = 990
.meas tran vdout0_55ck197 FIND v(dout0_55) AT=990.025n

* CHECK dout0_56 Vdout0_56ck197 = 0 time = 990
.meas tran vdout0_56ck197 FIND v(dout0_56) AT=990.025n

* CHECK dout0_57 Vdout0_57ck197 = 0 time = 990
.meas tran vdout0_57ck197 FIND v(dout0_57) AT=990.025n

* CHECK dout0_58 Vdout0_58ck197 = 0 time = 990
.meas tran vdout0_58ck197 FIND v(dout0_58) AT=990.025n

* CHECK dout0_59 Vdout0_59ck197 = 0.9 time = 990
.meas tran vdout0_59ck197 FIND v(dout0_59) AT=990.025n

* CHECK dout0_60 Vdout0_60ck197 = 0.9 time = 990
.meas tran vdout0_60ck197 FIND v(dout0_60) AT=990.025n

* CHECK dout0_61 Vdout0_61ck197 = 0.9 time = 990
.meas tran vdout0_61ck197 FIND v(dout0_61) AT=990.025n

* CHECK dout0_62 Vdout0_62ck197 = 0 time = 990
.meas tran vdout0_62ck197 FIND v(dout0_62) AT=990.025n

* CHECK dout0_63 Vdout0_63ck197 = 0.9 time = 990
.meas tran vdout0_63ck197 FIND v(dout0_63) AT=990.025n

* CHECK dout0_0 Vdout0_0ck198 = 0.9 time = 995
.meas tran vdout0_0ck198 FIND v(dout0_0) AT=995.025n

* CHECK dout0_1 Vdout0_1ck198 = 0.9 time = 995
.meas tran vdout0_1ck198 FIND v(dout0_1) AT=995.025n

* CHECK dout0_2 Vdout0_2ck198 = 0 time = 995
.meas tran vdout0_2ck198 FIND v(dout0_2) AT=995.025n

* CHECK dout0_3 Vdout0_3ck198 = 0.9 time = 995
.meas tran vdout0_3ck198 FIND v(dout0_3) AT=995.025n

* CHECK dout0_4 Vdout0_4ck198 = 0 time = 995
.meas tran vdout0_4ck198 FIND v(dout0_4) AT=995.025n

* CHECK dout0_5 Vdout0_5ck198 = 0 time = 995
.meas tran vdout0_5ck198 FIND v(dout0_5) AT=995.025n

* CHECK dout0_6 Vdout0_6ck198 = 0 time = 995
.meas tran vdout0_6ck198 FIND v(dout0_6) AT=995.025n

* CHECK dout0_7 Vdout0_7ck198 = 0.9 time = 995
.meas tran vdout0_7ck198 FIND v(dout0_7) AT=995.025n

* CHECK dout0_8 Vdout0_8ck198 = 0.9 time = 995
.meas tran vdout0_8ck198 FIND v(dout0_8) AT=995.025n

* CHECK dout0_9 Vdout0_9ck198 = 0 time = 995
.meas tran vdout0_9ck198 FIND v(dout0_9) AT=995.025n

* CHECK dout0_10 Vdout0_10ck198 = 0.9 time = 995
.meas tran vdout0_10ck198 FIND v(dout0_10) AT=995.025n

* CHECK dout0_11 Vdout0_11ck198 = 0.9 time = 995
.meas tran vdout0_11ck198 FIND v(dout0_11) AT=995.025n

* CHECK dout0_12 Vdout0_12ck198 = 0.9 time = 995
.meas tran vdout0_12ck198 FIND v(dout0_12) AT=995.025n

* CHECK dout0_13 Vdout0_13ck198 = 0 time = 995
.meas tran vdout0_13ck198 FIND v(dout0_13) AT=995.025n

* CHECK dout0_14 Vdout0_14ck198 = 0.9 time = 995
.meas tran vdout0_14ck198 FIND v(dout0_14) AT=995.025n

* CHECK dout0_15 Vdout0_15ck198 = 0.9 time = 995
.meas tran vdout0_15ck198 FIND v(dout0_15) AT=995.025n

* CHECK dout0_16 Vdout0_16ck198 = 0.9 time = 995
.meas tran vdout0_16ck198 FIND v(dout0_16) AT=995.025n

* CHECK dout0_17 Vdout0_17ck198 = 0 time = 995
.meas tran vdout0_17ck198 FIND v(dout0_17) AT=995.025n

* CHECK dout0_18 Vdout0_18ck198 = 0.9 time = 995
.meas tran vdout0_18ck198 FIND v(dout0_18) AT=995.025n

* CHECK dout0_19 Vdout0_19ck198 = 0.9 time = 995
.meas tran vdout0_19ck198 FIND v(dout0_19) AT=995.025n

* CHECK dout0_20 Vdout0_20ck198 = 0 time = 995
.meas tran vdout0_20ck198 FIND v(dout0_20) AT=995.025n

* CHECK dout0_21 Vdout0_21ck198 = 0 time = 995
.meas tran vdout0_21ck198 FIND v(dout0_21) AT=995.025n

* CHECK dout0_22 Vdout0_22ck198 = 0 time = 995
.meas tran vdout0_22ck198 FIND v(dout0_22) AT=995.025n

* CHECK dout0_23 Vdout0_23ck198 = 0.9 time = 995
.meas tran vdout0_23ck198 FIND v(dout0_23) AT=995.025n

* CHECK dout0_24 Vdout0_24ck198 = 0.9 time = 995
.meas tran vdout0_24ck198 FIND v(dout0_24) AT=995.025n

* CHECK dout0_25 Vdout0_25ck198 = 0 time = 995
.meas tran vdout0_25ck198 FIND v(dout0_25) AT=995.025n

* CHECK dout0_26 Vdout0_26ck198 = 0 time = 995
.meas tran vdout0_26ck198 FIND v(dout0_26) AT=995.025n

* CHECK dout0_27 Vdout0_27ck198 = 0 time = 995
.meas tran vdout0_27ck198 FIND v(dout0_27) AT=995.025n

* CHECK dout0_28 Vdout0_28ck198 = 0.9 time = 995
.meas tran vdout0_28ck198 FIND v(dout0_28) AT=995.025n

* CHECK dout0_29 Vdout0_29ck198 = 0 time = 995
.meas tran vdout0_29ck198 FIND v(dout0_29) AT=995.025n

* CHECK dout0_30 Vdout0_30ck198 = 0 time = 995
.meas tran vdout0_30ck198 FIND v(dout0_30) AT=995.025n

* CHECK dout0_31 Vdout0_31ck198 = 0 time = 995
.meas tran vdout0_31ck198 FIND v(dout0_31) AT=995.025n

* CHECK dout0_32 Vdout0_32ck198 = 0 time = 995
.meas tran vdout0_32ck198 FIND v(dout0_32) AT=995.025n

* CHECK dout0_33 Vdout0_33ck198 = 0 time = 995
.meas tran vdout0_33ck198 FIND v(dout0_33) AT=995.025n

* CHECK dout0_34 Vdout0_34ck198 = 0 time = 995
.meas tran vdout0_34ck198 FIND v(dout0_34) AT=995.025n

* CHECK dout0_35 Vdout0_35ck198 = 0.9 time = 995
.meas tran vdout0_35ck198 FIND v(dout0_35) AT=995.025n

* CHECK dout0_36 Vdout0_36ck198 = 0.9 time = 995
.meas tran vdout0_36ck198 FIND v(dout0_36) AT=995.025n

* CHECK dout0_37 Vdout0_37ck198 = 0 time = 995
.meas tran vdout0_37ck198 FIND v(dout0_37) AT=995.025n

* CHECK dout0_38 Vdout0_38ck198 = 0.9 time = 995
.meas tran vdout0_38ck198 FIND v(dout0_38) AT=995.025n

* CHECK dout0_39 Vdout0_39ck198 = 0.9 time = 995
.meas tran vdout0_39ck198 FIND v(dout0_39) AT=995.025n

* CHECK dout0_40 Vdout0_40ck198 = 0 time = 995
.meas tran vdout0_40ck198 FIND v(dout0_40) AT=995.025n

* CHECK dout0_41 Vdout0_41ck198 = 0.9 time = 995
.meas tran vdout0_41ck198 FIND v(dout0_41) AT=995.025n

* CHECK dout0_42 Vdout0_42ck198 = 0.9 time = 995
.meas tran vdout0_42ck198 FIND v(dout0_42) AT=995.025n

* CHECK dout0_43 Vdout0_43ck198 = 0 time = 995
.meas tran vdout0_43ck198 FIND v(dout0_43) AT=995.025n

* CHECK dout0_44 Vdout0_44ck198 = 0 time = 995
.meas tran vdout0_44ck198 FIND v(dout0_44) AT=995.025n

* CHECK dout0_45 Vdout0_45ck198 = 0 time = 995
.meas tran vdout0_45ck198 FIND v(dout0_45) AT=995.025n

* CHECK dout0_46 Vdout0_46ck198 = 0.9 time = 995
.meas tran vdout0_46ck198 FIND v(dout0_46) AT=995.025n

* CHECK dout0_47 Vdout0_47ck198 = 0 time = 995
.meas tran vdout0_47ck198 FIND v(dout0_47) AT=995.025n

* CHECK dout0_48 Vdout0_48ck198 = 0.9 time = 995
.meas tran vdout0_48ck198 FIND v(dout0_48) AT=995.025n

* CHECK dout0_49 Vdout0_49ck198 = 0 time = 995
.meas tran vdout0_49ck198 FIND v(dout0_49) AT=995.025n

* CHECK dout0_50 Vdout0_50ck198 = 0.9 time = 995
.meas tran vdout0_50ck198 FIND v(dout0_50) AT=995.025n

* CHECK dout0_51 Vdout0_51ck198 = 0 time = 995
.meas tran vdout0_51ck198 FIND v(dout0_51) AT=995.025n

* CHECK dout0_52 Vdout0_52ck198 = 0.9 time = 995
.meas tran vdout0_52ck198 FIND v(dout0_52) AT=995.025n

* CHECK dout0_53 Vdout0_53ck198 = 0.9 time = 995
.meas tran vdout0_53ck198 FIND v(dout0_53) AT=995.025n

* CHECK dout0_54 Vdout0_54ck198 = 0.9 time = 995
.meas tran vdout0_54ck198 FIND v(dout0_54) AT=995.025n

* CHECK dout0_55 Vdout0_55ck198 = 0.9 time = 995
.meas tran vdout0_55ck198 FIND v(dout0_55) AT=995.025n

* CHECK dout0_56 Vdout0_56ck198 = 0 time = 995
.meas tran vdout0_56ck198 FIND v(dout0_56) AT=995.025n

* CHECK dout0_57 Vdout0_57ck198 = 0 time = 995
.meas tran vdout0_57ck198 FIND v(dout0_57) AT=995.025n

* CHECK dout0_58 Vdout0_58ck198 = 0 time = 995
.meas tran vdout0_58ck198 FIND v(dout0_58) AT=995.025n

* CHECK dout0_59 Vdout0_59ck198 = 0.9 time = 995
.meas tran vdout0_59ck198 FIND v(dout0_59) AT=995.025n

* CHECK dout0_60 Vdout0_60ck198 = 0.9 time = 995
.meas tran vdout0_60ck198 FIND v(dout0_60) AT=995.025n

* CHECK dout0_61 Vdout0_61ck198 = 0.9 time = 995
.meas tran vdout0_61ck198 FIND v(dout0_61) AT=995.025n

* CHECK dout0_62 Vdout0_62ck198 = 0 time = 995
.meas tran vdout0_62ck198 FIND v(dout0_62) AT=995.025n

* CHECK dout0_63 Vdout0_63ck198 = 0.9 time = 995
.meas tran vdout0_63ck198 FIND v(dout0_63) AT=995.025n

* CHECK dout0_0 Vdout0_0ck199 = 0.9 time = 1000
.meas tran vdout0_0ck199 FIND v(dout0_0) AT=1000.025n

* CHECK dout0_1 Vdout0_1ck199 = 0.9 time = 1000
.meas tran vdout0_1ck199 FIND v(dout0_1) AT=1000.025n

* CHECK dout0_2 Vdout0_2ck199 = 0 time = 1000
.meas tran vdout0_2ck199 FIND v(dout0_2) AT=1000.025n

* CHECK dout0_3 Vdout0_3ck199 = 0.9 time = 1000
.meas tran vdout0_3ck199 FIND v(dout0_3) AT=1000.025n

* CHECK dout0_4 Vdout0_4ck199 = 0 time = 1000
.meas tran vdout0_4ck199 FIND v(dout0_4) AT=1000.025n

* CHECK dout0_5 Vdout0_5ck199 = 0 time = 1000
.meas tran vdout0_5ck199 FIND v(dout0_5) AT=1000.025n

* CHECK dout0_6 Vdout0_6ck199 = 0 time = 1000
.meas tran vdout0_6ck199 FIND v(dout0_6) AT=1000.025n

* CHECK dout0_7 Vdout0_7ck199 = 0.9 time = 1000
.meas tran vdout0_7ck199 FIND v(dout0_7) AT=1000.025n

* CHECK dout0_8 Vdout0_8ck199 = 0.9 time = 1000
.meas tran vdout0_8ck199 FIND v(dout0_8) AT=1000.025n

* CHECK dout0_9 Vdout0_9ck199 = 0 time = 1000
.meas tran vdout0_9ck199 FIND v(dout0_9) AT=1000.025n

* CHECK dout0_10 Vdout0_10ck199 = 0.9 time = 1000
.meas tran vdout0_10ck199 FIND v(dout0_10) AT=1000.025n

* CHECK dout0_11 Vdout0_11ck199 = 0.9 time = 1000
.meas tran vdout0_11ck199 FIND v(dout0_11) AT=1000.025n

* CHECK dout0_12 Vdout0_12ck199 = 0.9 time = 1000
.meas tran vdout0_12ck199 FIND v(dout0_12) AT=1000.025n

* CHECK dout0_13 Vdout0_13ck199 = 0 time = 1000
.meas tran vdout0_13ck199 FIND v(dout0_13) AT=1000.025n

* CHECK dout0_14 Vdout0_14ck199 = 0.9 time = 1000
.meas tran vdout0_14ck199 FIND v(dout0_14) AT=1000.025n

* CHECK dout0_15 Vdout0_15ck199 = 0.9 time = 1000
.meas tran vdout0_15ck199 FIND v(dout0_15) AT=1000.025n

* CHECK dout0_16 Vdout0_16ck199 = 0.9 time = 1000
.meas tran vdout0_16ck199 FIND v(dout0_16) AT=1000.025n

* CHECK dout0_17 Vdout0_17ck199 = 0 time = 1000
.meas tran vdout0_17ck199 FIND v(dout0_17) AT=1000.025n

* CHECK dout0_18 Vdout0_18ck199 = 0.9 time = 1000
.meas tran vdout0_18ck199 FIND v(dout0_18) AT=1000.025n

* CHECK dout0_19 Vdout0_19ck199 = 0.9 time = 1000
.meas tran vdout0_19ck199 FIND v(dout0_19) AT=1000.025n

* CHECK dout0_20 Vdout0_20ck199 = 0 time = 1000
.meas tran vdout0_20ck199 FIND v(dout0_20) AT=1000.025n

* CHECK dout0_21 Vdout0_21ck199 = 0 time = 1000
.meas tran vdout0_21ck199 FIND v(dout0_21) AT=1000.025n

* CHECK dout0_22 Vdout0_22ck199 = 0 time = 1000
.meas tran vdout0_22ck199 FIND v(dout0_22) AT=1000.025n

* CHECK dout0_23 Vdout0_23ck199 = 0.9 time = 1000
.meas tran vdout0_23ck199 FIND v(dout0_23) AT=1000.025n

* CHECK dout0_24 Vdout0_24ck199 = 0.9 time = 1000
.meas tran vdout0_24ck199 FIND v(dout0_24) AT=1000.025n

* CHECK dout0_25 Vdout0_25ck199 = 0 time = 1000
.meas tran vdout0_25ck199 FIND v(dout0_25) AT=1000.025n

* CHECK dout0_26 Vdout0_26ck199 = 0 time = 1000
.meas tran vdout0_26ck199 FIND v(dout0_26) AT=1000.025n

* CHECK dout0_27 Vdout0_27ck199 = 0 time = 1000
.meas tran vdout0_27ck199 FIND v(dout0_27) AT=1000.025n

* CHECK dout0_28 Vdout0_28ck199 = 0.9 time = 1000
.meas tran vdout0_28ck199 FIND v(dout0_28) AT=1000.025n

* CHECK dout0_29 Vdout0_29ck199 = 0 time = 1000
.meas tran vdout0_29ck199 FIND v(dout0_29) AT=1000.025n

* CHECK dout0_30 Vdout0_30ck199 = 0 time = 1000
.meas tran vdout0_30ck199 FIND v(dout0_30) AT=1000.025n

* CHECK dout0_31 Vdout0_31ck199 = 0 time = 1000
.meas tran vdout0_31ck199 FIND v(dout0_31) AT=1000.025n

* CHECK dout0_32 Vdout0_32ck199 = 0 time = 1000
.meas tran vdout0_32ck199 FIND v(dout0_32) AT=1000.025n

* CHECK dout0_33 Vdout0_33ck199 = 0 time = 1000
.meas tran vdout0_33ck199 FIND v(dout0_33) AT=1000.025n

* CHECK dout0_34 Vdout0_34ck199 = 0 time = 1000
.meas tran vdout0_34ck199 FIND v(dout0_34) AT=1000.025n

* CHECK dout0_35 Vdout0_35ck199 = 0.9 time = 1000
.meas tran vdout0_35ck199 FIND v(dout0_35) AT=1000.025n

* CHECK dout0_36 Vdout0_36ck199 = 0.9 time = 1000
.meas tran vdout0_36ck199 FIND v(dout0_36) AT=1000.025n

* CHECK dout0_37 Vdout0_37ck199 = 0 time = 1000
.meas tran vdout0_37ck199 FIND v(dout0_37) AT=1000.025n

* CHECK dout0_38 Vdout0_38ck199 = 0.9 time = 1000
.meas tran vdout0_38ck199 FIND v(dout0_38) AT=1000.025n

* CHECK dout0_39 Vdout0_39ck199 = 0.9 time = 1000
.meas tran vdout0_39ck199 FIND v(dout0_39) AT=1000.025n

* CHECK dout0_40 Vdout0_40ck199 = 0 time = 1000
.meas tran vdout0_40ck199 FIND v(dout0_40) AT=1000.025n

* CHECK dout0_41 Vdout0_41ck199 = 0.9 time = 1000
.meas tran vdout0_41ck199 FIND v(dout0_41) AT=1000.025n

* CHECK dout0_42 Vdout0_42ck199 = 0.9 time = 1000
.meas tran vdout0_42ck199 FIND v(dout0_42) AT=1000.025n

* CHECK dout0_43 Vdout0_43ck199 = 0 time = 1000
.meas tran vdout0_43ck199 FIND v(dout0_43) AT=1000.025n

* CHECK dout0_44 Vdout0_44ck199 = 0 time = 1000
.meas tran vdout0_44ck199 FIND v(dout0_44) AT=1000.025n

* CHECK dout0_45 Vdout0_45ck199 = 0 time = 1000
.meas tran vdout0_45ck199 FIND v(dout0_45) AT=1000.025n

* CHECK dout0_46 Vdout0_46ck199 = 0.9 time = 1000
.meas tran vdout0_46ck199 FIND v(dout0_46) AT=1000.025n

* CHECK dout0_47 Vdout0_47ck199 = 0 time = 1000
.meas tran vdout0_47ck199 FIND v(dout0_47) AT=1000.025n

* CHECK dout0_48 Vdout0_48ck199 = 0.9 time = 1000
.meas tran vdout0_48ck199 FIND v(dout0_48) AT=1000.025n

* CHECK dout0_49 Vdout0_49ck199 = 0 time = 1000
.meas tran vdout0_49ck199 FIND v(dout0_49) AT=1000.025n

* CHECK dout0_50 Vdout0_50ck199 = 0.9 time = 1000
.meas tran vdout0_50ck199 FIND v(dout0_50) AT=1000.025n

* CHECK dout0_51 Vdout0_51ck199 = 0 time = 1000
.meas tran vdout0_51ck199 FIND v(dout0_51) AT=1000.025n

* CHECK dout0_52 Vdout0_52ck199 = 0.9 time = 1000
.meas tran vdout0_52ck199 FIND v(dout0_52) AT=1000.025n

* CHECK dout0_53 Vdout0_53ck199 = 0.9 time = 1000
.meas tran vdout0_53ck199 FIND v(dout0_53) AT=1000.025n

* CHECK dout0_54 Vdout0_54ck199 = 0.9 time = 1000
.meas tran vdout0_54ck199 FIND v(dout0_54) AT=1000.025n

* CHECK dout0_55 Vdout0_55ck199 = 0.9 time = 1000
.meas tran vdout0_55ck199 FIND v(dout0_55) AT=1000.025n

* CHECK dout0_56 Vdout0_56ck199 = 0 time = 1000
.meas tran vdout0_56ck199 FIND v(dout0_56) AT=1000.025n

* CHECK dout0_57 Vdout0_57ck199 = 0 time = 1000
.meas tran vdout0_57ck199 FIND v(dout0_57) AT=1000.025n

* CHECK dout0_58 Vdout0_58ck199 = 0 time = 1000
.meas tran vdout0_58ck199 FIND v(dout0_58) AT=1000.025n

* CHECK dout0_59 Vdout0_59ck199 = 0.9 time = 1000
.meas tran vdout0_59ck199 FIND v(dout0_59) AT=1000.025n

* CHECK dout0_60 Vdout0_60ck199 = 0.9 time = 1000
.meas tran vdout0_60ck199 FIND v(dout0_60) AT=1000.025n

* CHECK dout0_61 Vdout0_61ck199 = 0.9 time = 1000
.meas tran vdout0_61ck199 FIND v(dout0_61) AT=1000.025n

* CHECK dout0_62 Vdout0_62ck199 = 0 time = 1000
.meas tran vdout0_62ck199 FIND v(dout0_62) AT=1000.025n

* CHECK dout0_63 Vdout0_63ck199 = 0.9 time = 1000
.meas tran vdout0_63ck199 FIND v(dout0_63) AT=1000.025n

* CHECK dout0_0 Vdout0_0ck200 = 0 time = 1005
.meas tran vdout0_0ck200 FIND v(dout0_0) AT=1005.025n

* CHECK dout0_1 Vdout0_1ck200 = 0 time = 1005
.meas tran vdout0_1ck200 FIND v(dout0_1) AT=1005.025n

* CHECK dout0_2 Vdout0_2ck200 = 0.9 time = 1005
.meas tran vdout0_2ck200 FIND v(dout0_2) AT=1005.025n

* CHECK dout0_3 Vdout0_3ck200 = 0.9 time = 1005
.meas tran vdout0_3ck200 FIND v(dout0_3) AT=1005.025n

* CHECK dout0_4 Vdout0_4ck200 = 0 time = 1005
.meas tran vdout0_4ck200 FIND v(dout0_4) AT=1005.025n

* CHECK dout0_5 Vdout0_5ck200 = 0.9 time = 1005
.meas tran vdout0_5ck200 FIND v(dout0_5) AT=1005.025n

* CHECK dout0_6 Vdout0_6ck200 = 0 time = 1005
.meas tran vdout0_6ck200 FIND v(dout0_6) AT=1005.025n

* CHECK dout0_7 Vdout0_7ck200 = 0 time = 1005
.meas tran vdout0_7ck200 FIND v(dout0_7) AT=1005.025n

* CHECK dout0_8 Vdout0_8ck200 = 0 time = 1005
.meas tran vdout0_8ck200 FIND v(dout0_8) AT=1005.025n

* CHECK dout0_9 Vdout0_9ck200 = 0 time = 1005
.meas tran vdout0_9ck200 FIND v(dout0_9) AT=1005.025n

* CHECK dout0_10 Vdout0_10ck200 = 0.9 time = 1005
.meas tran vdout0_10ck200 FIND v(dout0_10) AT=1005.025n

* CHECK dout0_11 Vdout0_11ck200 = 0.9 time = 1005
.meas tran vdout0_11ck200 FIND v(dout0_11) AT=1005.025n

* CHECK dout0_12 Vdout0_12ck200 = 0 time = 1005
.meas tran vdout0_12ck200 FIND v(dout0_12) AT=1005.025n

* CHECK dout0_13 Vdout0_13ck200 = 0 time = 1005
.meas tran vdout0_13ck200 FIND v(dout0_13) AT=1005.025n

* CHECK dout0_14 Vdout0_14ck200 = 0 time = 1005
.meas tran vdout0_14ck200 FIND v(dout0_14) AT=1005.025n

* CHECK dout0_15 Vdout0_15ck200 = 0.9 time = 1005
.meas tran vdout0_15ck200 FIND v(dout0_15) AT=1005.025n

* CHECK dout0_16 Vdout0_16ck200 = 0 time = 1005
.meas tran vdout0_16ck200 FIND v(dout0_16) AT=1005.025n

* CHECK dout0_17 Vdout0_17ck200 = 0.9 time = 1005
.meas tran vdout0_17ck200 FIND v(dout0_17) AT=1005.025n

* CHECK dout0_18 Vdout0_18ck200 = 0 time = 1005
.meas tran vdout0_18ck200 FIND v(dout0_18) AT=1005.025n

* CHECK dout0_19 Vdout0_19ck200 = 0 time = 1005
.meas tran vdout0_19ck200 FIND v(dout0_19) AT=1005.025n

* CHECK dout0_20 Vdout0_20ck200 = 0.9 time = 1005
.meas tran vdout0_20ck200 FIND v(dout0_20) AT=1005.025n

* CHECK dout0_21 Vdout0_21ck200 = 0 time = 1005
.meas tran vdout0_21ck200 FIND v(dout0_21) AT=1005.025n

* CHECK dout0_22 Vdout0_22ck200 = 0 time = 1005
.meas tran vdout0_22ck200 FIND v(dout0_22) AT=1005.025n

* CHECK dout0_23 Vdout0_23ck200 = 0.9 time = 1005
.meas tran vdout0_23ck200 FIND v(dout0_23) AT=1005.025n

* CHECK dout0_24 Vdout0_24ck200 = 0 time = 1005
.meas tran vdout0_24ck200 FIND v(dout0_24) AT=1005.025n

* CHECK dout0_25 Vdout0_25ck200 = 0 time = 1005
.meas tran vdout0_25ck200 FIND v(dout0_25) AT=1005.025n

* CHECK dout0_26 Vdout0_26ck200 = 0.9 time = 1005
.meas tran vdout0_26ck200 FIND v(dout0_26) AT=1005.025n

* CHECK dout0_27 Vdout0_27ck200 = 0.9 time = 1005
.meas tran vdout0_27ck200 FIND v(dout0_27) AT=1005.025n

* CHECK dout0_28 Vdout0_28ck200 = 0 time = 1005
.meas tran vdout0_28ck200 FIND v(dout0_28) AT=1005.025n

* CHECK dout0_29 Vdout0_29ck200 = 0 time = 1005
.meas tran vdout0_29ck200 FIND v(dout0_29) AT=1005.025n

* CHECK dout0_30 Vdout0_30ck200 = 0 time = 1005
.meas tran vdout0_30ck200 FIND v(dout0_30) AT=1005.025n

* CHECK dout0_31 Vdout0_31ck200 = 0 time = 1005
.meas tran vdout0_31ck200 FIND v(dout0_31) AT=1005.025n

* CHECK dout0_32 Vdout0_32ck200 = 0 time = 1005
.meas tran vdout0_32ck200 FIND v(dout0_32) AT=1005.025n

* CHECK dout0_33 Vdout0_33ck200 = 0 time = 1005
.meas tran vdout0_33ck200 FIND v(dout0_33) AT=1005.025n

* CHECK dout0_34 Vdout0_34ck200 = 0.9 time = 1005
.meas tran vdout0_34ck200 FIND v(dout0_34) AT=1005.025n

* CHECK dout0_35 Vdout0_35ck200 = 0.9 time = 1005
.meas tran vdout0_35ck200 FIND v(dout0_35) AT=1005.025n

* CHECK dout0_36 Vdout0_36ck200 = 0 time = 1005
.meas tran vdout0_36ck200 FIND v(dout0_36) AT=1005.025n

* CHECK dout0_37 Vdout0_37ck200 = 0.9 time = 1005
.meas tran vdout0_37ck200 FIND v(dout0_37) AT=1005.025n

* CHECK dout0_38 Vdout0_38ck200 = 0.9 time = 1005
.meas tran vdout0_38ck200 FIND v(dout0_38) AT=1005.025n

* CHECK dout0_39 Vdout0_39ck200 = 0.9 time = 1005
.meas tran vdout0_39ck200 FIND v(dout0_39) AT=1005.025n

* CHECK dout0_40 Vdout0_40ck200 = 0.9 time = 1005
.meas tran vdout0_40ck200 FIND v(dout0_40) AT=1005.025n

* CHECK dout0_41 Vdout0_41ck200 = 0.9 time = 1005
.meas tran vdout0_41ck200 FIND v(dout0_41) AT=1005.025n

* CHECK dout0_42 Vdout0_42ck200 = 0 time = 1005
.meas tran vdout0_42ck200 FIND v(dout0_42) AT=1005.025n

* CHECK dout0_43 Vdout0_43ck200 = 0 time = 1005
.meas tran vdout0_43ck200 FIND v(dout0_43) AT=1005.025n

* CHECK dout0_44 Vdout0_44ck200 = 0.9 time = 1005
.meas tran vdout0_44ck200 FIND v(dout0_44) AT=1005.025n

* CHECK dout0_45 Vdout0_45ck200 = 0 time = 1005
.meas tran vdout0_45ck200 FIND v(dout0_45) AT=1005.025n

* CHECK dout0_46 Vdout0_46ck200 = 0 time = 1005
.meas tran vdout0_46ck200 FIND v(dout0_46) AT=1005.025n

* CHECK dout0_47 Vdout0_47ck200 = 0.9 time = 1005
.meas tran vdout0_47ck200 FIND v(dout0_47) AT=1005.025n

* CHECK dout0_48 Vdout0_48ck200 = 0 time = 1005
.meas tran vdout0_48ck200 FIND v(dout0_48) AT=1005.025n

* CHECK dout0_49 Vdout0_49ck200 = 0 time = 1005
.meas tran vdout0_49ck200 FIND v(dout0_49) AT=1005.025n

* CHECK dout0_50 Vdout0_50ck200 = 0 time = 1005
.meas tran vdout0_50ck200 FIND v(dout0_50) AT=1005.025n

* CHECK dout0_51 Vdout0_51ck200 = 0.9 time = 1005
.meas tran vdout0_51ck200 FIND v(dout0_51) AT=1005.025n

* CHECK dout0_52 Vdout0_52ck200 = 0 time = 1005
.meas tran vdout0_52ck200 FIND v(dout0_52) AT=1005.025n

* CHECK dout0_53 Vdout0_53ck200 = 0 time = 1005
.meas tran vdout0_53ck200 FIND v(dout0_53) AT=1005.025n

* CHECK dout0_54 Vdout0_54ck200 = 0 time = 1005
.meas tran vdout0_54ck200 FIND v(dout0_54) AT=1005.025n

* CHECK dout0_55 Vdout0_55ck200 = 0.9 time = 1005
.meas tran vdout0_55ck200 FIND v(dout0_55) AT=1005.025n

* CHECK dout0_56 Vdout0_56ck200 = 0 time = 1005
.meas tran vdout0_56ck200 FIND v(dout0_56) AT=1005.025n

* CHECK dout0_57 Vdout0_57ck200 = 0 time = 1005
.meas tran vdout0_57ck200 FIND v(dout0_57) AT=1005.025n

* CHECK dout0_58 Vdout0_58ck200 = 0.9 time = 1005
.meas tran vdout0_58ck200 FIND v(dout0_58) AT=1005.025n

* CHECK dout0_59 Vdout0_59ck200 = 0 time = 1005
.meas tran vdout0_59ck200 FIND v(dout0_59) AT=1005.025n

* CHECK dout0_60 Vdout0_60ck200 = 0.9 time = 1005
.meas tran vdout0_60ck200 FIND v(dout0_60) AT=1005.025n

* CHECK dout0_61 Vdout0_61ck200 = 0 time = 1005
.meas tran vdout0_61ck200 FIND v(dout0_61) AT=1005.025n

* CHECK dout0_62 Vdout0_62ck200 = 0.9 time = 1005
.meas tran vdout0_62ck200 FIND v(dout0_62) AT=1005.025n

* CHECK dout0_63 Vdout0_63ck200 = 0.9 time = 1005
.meas tran vdout0_63ck200 FIND v(dout0_63) AT=1005.025n

* CHECK dout0_0 Vdout0_0ck202 = 0.9 time = 1015
.meas tran vdout0_0ck202 FIND v(dout0_0) AT=1015.025n

* CHECK dout0_1 Vdout0_1ck202 = 0.9 time = 1015
.meas tran vdout0_1ck202 FIND v(dout0_1) AT=1015.025n

* CHECK dout0_2 Vdout0_2ck202 = 0.9 time = 1015
.meas tran vdout0_2ck202 FIND v(dout0_2) AT=1015.025n

* CHECK dout0_3 Vdout0_3ck202 = 0 time = 1015
.meas tran vdout0_3ck202 FIND v(dout0_3) AT=1015.025n

* CHECK dout0_4 Vdout0_4ck202 = 0.9 time = 1015
.meas tran vdout0_4ck202 FIND v(dout0_4) AT=1015.025n

* CHECK dout0_5 Vdout0_5ck202 = 0 time = 1015
.meas tran vdout0_5ck202 FIND v(dout0_5) AT=1015.025n

* CHECK dout0_6 Vdout0_6ck202 = 0 time = 1015
.meas tran vdout0_6ck202 FIND v(dout0_6) AT=1015.025n

* CHECK dout0_7 Vdout0_7ck202 = 0 time = 1015
.meas tran vdout0_7ck202 FIND v(dout0_7) AT=1015.025n

* CHECK dout0_8 Vdout0_8ck202 = 0.9 time = 1015
.meas tran vdout0_8ck202 FIND v(dout0_8) AT=1015.025n

* CHECK dout0_9 Vdout0_9ck202 = 0 time = 1015
.meas tran vdout0_9ck202 FIND v(dout0_9) AT=1015.025n

* CHECK dout0_10 Vdout0_10ck202 = 0.9 time = 1015
.meas tran vdout0_10ck202 FIND v(dout0_10) AT=1015.025n

* CHECK dout0_11 Vdout0_11ck202 = 0.9 time = 1015
.meas tran vdout0_11ck202 FIND v(dout0_11) AT=1015.025n

* CHECK dout0_12 Vdout0_12ck202 = 0.9 time = 1015
.meas tran vdout0_12ck202 FIND v(dout0_12) AT=1015.025n

* CHECK dout0_13 Vdout0_13ck202 = 0 time = 1015
.meas tran vdout0_13ck202 FIND v(dout0_13) AT=1015.025n

* CHECK dout0_14 Vdout0_14ck202 = 0.9 time = 1015
.meas tran vdout0_14ck202 FIND v(dout0_14) AT=1015.025n

* CHECK dout0_15 Vdout0_15ck202 = 0.9 time = 1015
.meas tran vdout0_15ck202 FIND v(dout0_15) AT=1015.025n

* CHECK dout0_16 Vdout0_16ck202 = 0.9 time = 1015
.meas tran vdout0_16ck202 FIND v(dout0_16) AT=1015.025n

* CHECK dout0_17 Vdout0_17ck202 = 0.9 time = 1015
.meas tran vdout0_17ck202 FIND v(dout0_17) AT=1015.025n

* CHECK dout0_18 Vdout0_18ck202 = 0 time = 1015
.meas tran vdout0_18ck202 FIND v(dout0_18) AT=1015.025n

* CHECK dout0_19 Vdout0_19ck202 = 0.9 time = 1015
.meas tran vdout0_19ck202 FIND v(dout0_19) AT=1015.025n

* CHECK dout0_20 Vdout0_20ck202 = 0.9 time = 1015
.meas tran vdout0_20ck202 FIND v(dout0_20) AT=1015.025n

* CHECK dout0_21 Vdout0_21ck202 = 0.9 time = 1015
.meas tran vdout0_21ck202 FIND v(dout0_21) AT=1015.025n

* CHECK dout0_22 Vdout0_22ck202 = 0.9 time = 1015
.meas tran vdout0_22ck202 FIND v(dout0_22) AT=1015.025n

* CHECK dout0_23 Vdout0_23ck202 = 0 time = 1015
.meas tran vdout0_23ck202 FIND v(dout0_23) AT=1015.025n

* CHECK dout0_24 Vdout0_24ck202 = 0.9 time = 1015
.meas tran vdout0_24ck202 FIND v(dout0_24) AT=1015.025n

* CHECK dout0_25 Vdout0_25ck202 = 0 time = 1015
.meas tran vdout0_25ck202 FIND v(dout0_25) AT=1015.025n

* CHECK dout0_26 Vdout0_26ck202 = 0 time = 1015
.meas tran vdout0_26ck202 FIND v(dout0_26) AT=1015.025n

* CHECK dout0_27 Vdout0_27ck202 = 0.9 time = 1015
.meas tran vdout0_27ck202 FIND v(dout0_27) AT=1015.025n

* CHECK dout0_28 Vdout0_28ck202 = 0.9 time = 1015
.meas tran vdout0_28ck202 FIND v(dout0_28) AT=1015.025n

* CHECK dout0_29 Vdout0_29ck202 = 0.9 time = 1015
.meas tran vdout0_29ck202 FIND v(dout0_29) AT=1015.025n

* CHECK dout0_30 Vdout0_30ck202 = 0 time = 1015
.meas tran vdout0_30ck202 FIND v(dout0_30) AT=1015.025n

* CHECK dout0_31 Vdout0_31ck202 = 0 time = 1015
.meas tran vdout0_31ck202 FIND v(dout0_31) AT=1015.025n

* CHECK dout0_32 Vdout0_32ck202 = 0 time = 1015
.meas tran vdout0_32ck202 FIND v(dout0_32) AT=1015.025n

* CHECK dout0_33 Vdout0_33ck202 = 0 time = 1015
.meas tran vdout0_33ck202 FIND v(dout0_33) AT=1015.025n

* CHECK dout0_34 Vdout0_34ck202 = 0 time = 1015
.meas tran vdout0_34ck202 FIND v(dout0_34) AT=1015.025n

* CHECK dout0_35 Vdout0_35ck202 = 0.9 time = 1015
.meas tran vdout0_35ck202 FIND v(dout0_35) AT=1015.025n

* CHECK dout0_36 Vdout0_36ck202 = 0.9 time = 1015
.meas tran vdout0_36ck202 FIND v(dout0_36) AT=1015.025n

* CHECK dout0_37 Vdout0_37ck202 = 0 time = 1015
.meas tran vdout0_37ck202 FIND v(dout0_37) AT=1015.025n

* CHECK dout0_38 Vdout0_38ck202 = 0 time = 1015
.meas tran vdout0_38ck202 FIND v(dout0_38) AT=1015.025n

* CHECK dout0_39 Vdout0_39ck202 = 0.9 time = 1015
.meas tran vdout0_39ck202 FIND v(dout0_39) AT=1015.025n

* CHECK dout0_40 Vdout0_40ck202 = 0 time = 1015
.meas tran vdout0_40ck202 FIND v(dout0_40) AT=1015.025n

* CHECK dout0_41 Vdout0_41ck202 = 0.9 time = 1015
.meas tran vdout0_41ck202 FIND v(dout0_41) AT=1015.025n

* CHECK dout0_42 Vdout0_42ck202 = 0 time = 1015
.meas tran vdout0_42ck202 FIND v(dout0_42) AT=1015.025n

* CHECK dout0_43 Vdout0_43ck202 = 0.9 time = 1015
.meas tran vdout0_43ck202 FIND v(dout0_43) AT=1015.025n

* CHECK dout0_44 Vdout0_44ck202 = 0.9 time = 1015
.meas tran vdout0_44ck202 FIND v(dout0_44) AT=1015.025n

* CHECK dout0_45 Vdout0_45ck202 = 0.9 time = 1015
.meas tran vdout0_45ck202 FIND v(dout0_45) AT=1015.025n

* CHECK dout0_46 Vdout0_46ck202 = 0.9 time = 1015
.meas tran vdout0_46ck202 FIND v(dout0_46) AT=1015.025n

* CHECK dout0_47 Vdout0_47ck202 = 0 time = 1015
.meas tran vdout0_47ck202 FIND v(dout0_47) AT=1015.025n

* CHECK dout0_48 Vdout0_48ck202 = 0.9 time = 1015
.meas tran vdout0_48ck202 FIND v(dout0_48) AT=1015.025n

* CHECK dout0_49 Vdout0_49ck202 = 0 time = 1015
.meas tran vdout0_49ck202 FIND v(dout0_49) AT=1015.025n

* CHECK dout0_50 Vdout0_50ck202 = 0.9 time = 1015
.meas tran vdout0_50ck202 FIND v(dout0_50) AT=1015.025n

* CHECK dout0_51 Vdout0_51ck202 = 0.9 time = 1015
.meas tran vdout0_51ck202 FIND v(dout0_51) AT=1015.025n

* CHECK dout0_52 Vdout0_52ck202 = 0.9 time = 1015
.meas tran vdout0_52ck202 FIND v(dout0_52) AT=1015.025n

* CHECK dout0_53 Vdout0_53ck202 = 0.9 time = 1015
.meas tran vdout0_53ck202 FIND v(dout0_53) AT=1015.025n

* CHECK dout0_54 Vdout0_54ck202 = 0.9 time = 1015
.meas tran vdout0_54ck202 FIND v(dout0_54) AT=1015.025n

* CHECK dout0_55 Vdout0_55ck202 = 0 time = 1015
.meas tran vdout0_55ck202 FIND v(dout0_55) AT=1015.025n

* CHECK dout0_56 Vdout0_56ck202 = 0 time = 1015
.meas tran vdout0_56ck202 FIND v(dout0_56) AT=1015.025n

* CHECK dout0_57 Vdout0_57ck202 = 0 time = 1015
.meas tran vdout0_57ck202 FIND v(dout0_57) AT=1015.025n

* CHECK dout0_58 Vdout0_58ck202 = 0.9 time = 1015
.meas tran vdout0_58ck202 FIND v(dout0_58) AT=1015.025n

* CHECK dout0_59 Vdout0_59ck202 = 0 time = 1015
.meas tran vdout0_59ck202 FIND v(dout0_59) AT=1015.025n

* CHECK dout0_60 Vdout0_60ck202 = 0.9 time = 1015
.meas tran vdout0_60ck202 FIND v(dout0_60) AT=1015.025n

* CHECK dout0_61 Vdout0_61ck202 = 0.9 time = 1015
.meas tran vdout0_61ck202 FIND v(dout0_61) AT=1015.025n

* CHECK dout0_62 Vdout0_62ck202 = 0 time = 1015
.meas tran vdout0_62ck202 FIND v(dout0_62) AT=1015.025n

* CHECK dout0_63 Vdout0_63ck202 = 0.9 time = 1015
.meas tran vdout0_63ck202 FIND v(dout0_63) AT=1015.025n

* CHECK dout0_0 Vdout0_0ck203 = 0 time = 1020
.meas tran vdout0_0ck203 FIND v(dout0_0) AT=1020.025n

* CHECK dout0_1 Vdout0_1ck203 = 0 time = 1020
.meas tran vdout0_1ck203 FIND v(dout0_1) AT=1020.025n

* CHECK dout0_2 Vdout0_2ck203 = 0.9 time = 1020
.meas tran vdout0_2ck203 FIND v(dout0_2) AT=1020.025n

* CHECK dout0_3 Vdout0_3ck203 = 0.9 time = 1020
.meas tran vdout0_3ck203 FIND v(dout0_3) AT=1020.025n

* CHECK dout0_4 Vdout0_4ck203 = 0 time = 1020
.meas tran vdout0_4ck203 FIND v(dout0_4) AT=1020.025n

* CHECK dout0_5 Vdout0_5ck203 = 0.9 time = 1020
.meas tran vdout0_5ck203 FIND v(dout0_5) AT=1020.025n

* CHECK dout0_6 Vdout0_6ck203 = 0 time = 1020
.meas tran vdout0_6ck203 FIND v(dout0_6) AT=1020.025n

* CHECK dout0_7 Vdout0_7ck203 = 0 time = 1020
.meas tran vdout0_7ck203 FIND v(dout0_7) AT=1020.025n

* CHECK dout0_8 Vdout0_8ck203 = 0 time = 1020
.meas tran vdout0_8ck203 FIND v(dout0_8) AT=1020.025n

* CHECK dout0_9 Vdout0_9ck203 = 0 time = 1020
.meas tran vdout0_9ck203 FIND v(dout0_9) AT=1020.025n

* CHECK dout0_10 Vdout0_10ck203 = 0.9 time = 1020
.meas tran vdout0_10ck203 FIND v(dout0_10) AT=1020.025n

* CHECK dout0_11 Vdout0_11ck203 = 0.9 time = 1020
.meas tran vdout0_11ck203 FIND v(dout0_11) AT=1020.025n

* CHECK dout0_12 Vdout0_12ck203 = 0 time = 1020
.meas tran vdout0_12ck203 FIND v(dout0_12) AT=1020.025n

* CHECK dout0_13 Vdout0_13ck203 = 0 time = 1020
.meas tran vdout0_13ck203 FIND v(dout0_13) AT=1020.025n

* CHECK dout0_14 Vdout0_14ck203 = 0 time = 1020
.meas tran vdout0_14ck203 FIND v(dout0_14) AT=1020.025n

* CHECK dout0_15 Vdout0_15ck203 = 0.9 time = 1020
.meas tran vdout0_15ck203 FIND v(dout0_15) AT=1020.025n

* CHECK dout0_16 Vdout0_16ck203 = 0 time = 1020
.meas tran vdout0_16ck203 FIND v(dout0_16) AT=1020.025n

* CHECK dout0_17 Vdout0_17ck203 = 0.9 time = 1020
.meas tran vdout0_17ck203 FIND v(dout0_17) AT=1020.025n

* CHECK dout0_18 Vdout0_18ck203 = 0 time = 1020
.meas tran vdout0_18ck203 FIND v(dout0_18) AT=1020.025n

* CHECK dout0_19 Vdout0_19ck203 = 0 time = 1020
.meas tran vdout0_19ck203 FIND v(dout0_19) AT=1020.025n

* CHECK dout0_20 Vdout0_20ck203 = 0.9 time = 1020
.meas tran vdout0_20ck203 FIND v(dout0_20) AT=1020.025n

* CHECK dout0_21 Vdout0_21ck203 = 0 time = 1020
.meas tran vdout0_21ck203 FIND v(dout0_21) AT=1020.025n

* CHECK dout0_22 Vdout0_22ck203 = 0 time = 1020
.meas tran vdout0_22ck203 FIND v(dout0_22) AT=1020.025n

* CHECK dout0_23 Vdout0_23ck203 = 0.9 time = 1020
.meas tran vdout0_23ck203 FIND v(dout0_23) AT=1020.025n

* CHECK dout0_24 Vdout0_24ck203 = 0 time = 1020
.meas tran vdout0_24ck203 FIND v(dout0_24) AT=1020.025n

* CHECK dout0_25 Vdout0_25ck203 = 0 time = 1020
.meas tran vdout0_25ck203 FIND v(dout0_25) AT=1020.025n

* CHECK dout0_26 Vdout0_26ck203 = 0.9 time = 1020
.meas tran vdout0_26ck203 FIND v(dout0_26) AT=1020.025n

* CHECK dout0_27 Vdout0_27ck203 = 0.9 time = 1020
.meas tran vdout0_27ck203 FIND v(dout0_27) AT=1020.025n

* CHECK dout0_28 Vdout0_28ck203 = 0 time = 1020
.meas tran vdout0_28ck203 FIND v(dout0_28) AT=1020.025n

* CHECK dout0_29 Vdout0_29ck203 = 0 time = 1020
.meas tran vdout0_29ck203 FIND v(dout0_29) AT=1020.025n

* CHECK dout0_30 Vdout0_30ck203 = 0 time = 1020
.meas tran vdout0_30ck203 FIND v(dout0_30) AT=1020.025n

* CHECK dout0_31 Vdout0_31ck203 = 0 time = 1020
.meas tran vdout0_31ck203 FIND v(dout0_31) AT=1020.025n

* CHECK dout0_32 Vdout0_32ck203 = 0 time = 1020
.meas tran vdout0_32ck203 FIND v(dout0_32) AT=1020.025n

* CHECK dout0_33 Vdout0_33ck203 = 0 time = 1020
.meas tran vdout0_33ck203 FIND v(dout0_33) AT=1020.025n

* CHECK dout0_34 Vdout0_34ck203 = 0.9 time = 1020
.meas tran vdout0_34ck203 FIND v(dout0_34) AT=1020.025n

* CHECK dout0_35 Vdout0_35ck203 = 0.9 time = 1020
.meas tran vdout0_35ck203 FIND v(dout0_35) AT=1020.025n

* CHECK dout0_36 Vdout0_36ck203 = 0 time = 1020
.meas tran vdout0_36ck203 FIND v(dout0_36) AT=1020.025n

* CHECK dout0_37 Vdout0_37ck203 = 0.9 time = 1020
.meas tran vdout0_37ck203 FIND v(dout0_37) AT=1020.025n

* CHECK dout0_38 Vdout0_38ck203 = 0.9 time = 1020
.meas tran vdout0_38ck203 FIND v(dout0_38) AT=1020.025n

* CHECK dout0_39 Vdout0_39ck203 = 0.9 time = 1020
.meas tran vdout0_39ck203 FIND v(dout0_39) AT=1020.025n

* CHECK dout0_40 Vdout0_40ck203 = 0.9 time = 1020
.meas tran vdout0_40ck203 FIND v(dout0_40) AT=1020.025n

* CHECK dout0_41 Vdout0_41ck203 = 0.9 time = 1020
.meas tran vdout0_41ck203 FIND v(dout0_41) AT=1020.025n

* CHECK dout0_42 Vdout0_42ck203 = 0 time = 1020
.meas tran vdout0_42ck203 FIND v(dout0_42) AT=1020.025n

* CHECK dout0_43 Vdout0_43ck203 = 0 time = 1020
.meas tran vdout0_43ck203 FIND v(dout0_43) AT=1020.025n

* CHECK dout0_44 Vdout0_44ck203 = 0.9 time = 1020
.meas tran vdout0_44ck203 FIND v(dout0_44) AT=1020.025n

* CHECK dout0_45 Vdout0_45ck203 = 0 time = 1020
.meas tran vdout0_45ck203 FIND v(dout0_45) AT=1020.025n

* CHECK dout0_46 Vdout0_46ck203 = 0 time = 1020
.meas tran vdout0_46ck203 FIND v(dout0_46) AT=1020.025n

* CHECK dout0_47 Vdout0_47ck203 = 0.9 time = 1020
.meas tran vdout0_47ck203 FIND v(dout0_47) AT=1020.025n

* CHECK dout0_48 Vdout0_48ck203 = 0 time = 1020
.meas tran vdout0_48ck203 FIND v(dout0_48) AT=1020.025n

* CHECK dout0_49 Vdout0_49ck203 = 0 time = 1020
.meas tran vdout0_49ck203 FIND v(dout0_49) AT=1020.025n

* CHECK dout0_50 Vdout0_50ck203 = 0 time = 1020
.meas tran vdout0_50ck203 FIND v(dout0_50) AT=1020.025n

* CHECK dout0_51 Vdout0_51ck203 = 0.9 time = 1020
.meas tran vdout0_51ck203 FIND v(dout0_51) AT=1020.025n

* CHECK dout0_52 Vdout0_52ck203 = 0 time = 1020
.meas tran vdout0_52ck203 FIND v(dout0_52) AT=1020.025n

* CHECK dout0_53 Vdout0_53ck203 = 0 time = 1020
.meas tran vdout0_53ck203 FIND v(dout0_53) AT=1020.025n

* CHECK dout0_54 Vdout0_54ck203 = 0 time = 1020
.meas tran vdout0_54ck203 FIND v(dout0_54) AT=1020.025n

* CHECK dout0_55 Vdout0_55ck203 = 0.9 time = 1020
.meas tran vdout0_55ck203 FIND v(dout0_55) AT=1020.025n

* CHECK dout0_56 Vdout0_56ck203 = 0 time = 1020
.meas tran vdout0_56ck203 FIND v(dout0_56) AT=1020.025n

* CHECK dout0_57 Vdout0_57ck203 = 0 time = 1020
.meas tran vdout0_57ck203 FIND v(dout0_57) AT=1020.025n

* CHECK dout0_58 Vdout0_58ck203 = 0.9 time = 1020
.meas tran vdout0_58ck203 FIND v(dout0_58) AT=1020.025n

* CHECK dout0_59 Vdout0_59ck203 = 0 time = 1020
.meas tran vdout0_59ck203 FIND v(dout0_59) AT=1020.025n

* CHECK dout0_60 Vdout0_60ck203 = 0.9 time = 1020
.meas tran vdout0_60ck203 FIND v(dout0_60) AT=1020.025n

* CHECK dout0_61 Vdout0_61ck203 = 0 time = 1020
.meas tran vdout0_61ck203 FIND v(dout0_61) AT=1020.025n

* CHECK dout0_62 Vdout0_62ck203 = 0.9 time = 1020
.meas tran vdout0_62ck203 FIND v(dout0_62) AT=1020.025n

* CHECK dout0_63 Vdout0_63ck203 = 0.9 time = 1020
.meas tran vdout0_63ck203 FIND v(dout0_63) AT=1020.025n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
