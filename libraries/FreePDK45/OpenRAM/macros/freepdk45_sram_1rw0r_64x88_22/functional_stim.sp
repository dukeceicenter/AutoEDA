* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "freepdk45_sram_1rw0r_64x88_22.sp"

* Global Power Supplies
Vvdd vdd 0 0.9

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xfreepdk45_sram_1rw0r_64x88_22 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 din0_40 din0_41 din0_42 din0_43 din0_44 din0_45 din0_46 din0_47 din0_48 din0_49 din0_50 din0_51 din0_52 din0_53 din0_54 din0_55 din0_56 din0_57 din0_58 din0_59 din0_60 din0_61 din0_62 din0_63 din0_64 din0_65 din0_66 din0_67 din0_68 din0_69 din0_70 din0_71 din0_72 din0_73 din0_74 din0_75 din0_76 din0_77 din0_78 din0_79 din0_80 din0_81 din0_82 din0_83 din0_84 din0_85 din0_86 din0_87 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 CSB0 WEB0 clk0 WMASK0_0 WMASK0_1 WMASK0_2 WMASK0_3 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout0_32 dout0_33 dout0_34 dout0_35 dout0_36 dout0_37 dout0_38 dout0_39 dout0_40 dout0_41 dout0_42 dout0_43 dout0_44 dout0_45 dout0_46 dout0_47 dout0_48 dout0_49 dout0_50 dout0_51 dout0_52 dout0_53 dout0_54 dout0_55 dout0_56 dout0_57 dout0_58 dout0_59 dout0_60 dout0_61 dout0_62 dout0_63 dout0_64 dout0_65 dout0_66 dout0_67 dout0_68 dout0_69 dout0_70 dout0_71 dout0_72 dout0_73 dout0_74 dout0_75 dout0_76 dout0_77 dout0_78 dout0_79 dout0_80 dout0_81 dout0_82 dout0_83 dout0_84 dout0_85 dout0_86 dout0_87 vdd gnd freepdk45_sram_1rw0r_64x88_22

* SRAM output loads
CD00 dout0_0  0 0.8364f
CD01 dout0_1  0 0.8364f
CD02 dout0_2  0 0.8364f
CD03 dout0_3  0 0.8364f
CD04 dout0_4  0 0.8364f
CD05 dout0_5  0 0.8364f
CD06 dout0_6  0 0.8364f
CD07 dout0_7  0 0.8364f
CD08 dout0_8  0 0.8364f
CD09 dout0_9  0 0.8364f
CD010 dout0_10  0 0.8364f
CD011 dout0_11  0 0.8364f
CD012 dout0_12  0 0.8364f
CD013 dout0_13  0 0.8364f
CD014 dout0_14  0 0.8364f
CD015 dout0_15  0 0.8364f
CD016 dout0_16  0 0.8364f
CD017 dout0_17  0 0.8364f
CD018 dout0_18  0 0.8364f
CD019 dout0_19  0 0.8364f
CD020 dout0_20  0 0.8364f
CD021 dout0_21  0 0.8364f
CD022 dout0_22  0 0.8364f
CD023 dout0_23  0 0.8364f
CD024 dout0_24  0 0.8364f
CD025 dout0_25  0 0.8364f
CD026 dout0_26  0 0.8364f
CD027 dout0_27  0 0.8364f
CD028 dout0_28  0 0.8364f
CD029 dout0_29  0 0.8364f
CD030 dout0_30  0 0.8364f
CD031 dout0_31  0 0.8364f
CD032 dout0_32  0 0.8364f
CD033 dout0_33  0 0.8364f
CD034 dout0_34  0 0.8364f
CD035 dout0_35  0 0.8364f
CD036 dout0_36  0 0.8364f
CD037 dout0_37  0 0.8364f
CD038 dout0_38  0 0.8364f
CD039 dout0_39  0 0.8364f
CD040 dout0_40  0 0.8364f
CD041 dout0_41  0 0.8364f
CD042 dout0_42  0 0.8364f
CD043 dout0_43  0 0.8364f
CD044 dout0_44  0 0.8364f
CD045 dout0_45  0 0.8364f
CD046 dout0_46  0 0.8364f
CD047 dout0_47  0 0.8364f
CD048 dout0_48  0 0.8364f
CD049 dout0_49  0 0.8364f
CD050 dout0_50  0 0.8364f
CD051 dout0_51  0 0.8364f
CD052 dout0_52  0 0.8364f
CD053 dout0_53  0 0.8364f
CD054 dout0_54  0 0.8364f
CD055 dout0_55  0 0.8364f
CD056 dout0_56  0 0.8364f
CD057 dout0_57  0 0.8364f
CD058 dout0_58  0 0.8364f
CD059 dout0_59  0 0.8364f
CD060 dout0_60  0 0.8364f
CD061 dout0_61  0 0.8364f
CD062 dout0_62  0 0.8364f
CD063 dout0_63  0 0.8364f
CD064 dout0_64  0 0.8364f
CD065 dout0_65  0 0.8364f
CD066 dout0_66  0 0.8364f
CD067 dout0_67  0 0.8364f
CD068 dout0_68  0 0.8364f
CD069 dout0_69  0 0.8364f
CD070 dout0_70  0 0.8364f
CD071 dout0_71  0 0.8364f
CD072 dout0_72  0 0.8364f
CD073 dout0_73  0 0.8364f
CD074 dout0_74  0 0.8364f
CD075 dout0_75  0 0.8364f
CD076 dout0_76  0 0.8364f
CD077 dout0_77  0 0.8364f
CD078 dout0_78  0 0.8364f
CD079 dout0_79  0 0.8364f
CD080 dout0_80  0 0.8364f
CD081 dout0_81  0 0.8364f
CD082 dout0_82  0 0.8364f
CD083 dout0_83  0 0.8364f
CD084 dout0_84  0 0.8364f
CD085 dout0_85  0 0.8364f
CD086 dout0_86  0 0.8364f
CD087 dout0_87  0 0.8364f

* Important signals for debug
* bl:	xfreepdk45_sram_1rw0r_64x88_22.xbank0.bl_0_0
* br:	xfreepdk45_sram_1rw0r_64x88_22.xbank0.br_0_0
* s_en:	xfreepdk45_sram_1rw0r_64x88_22.s_en
* q:	xfreepdk45_sram_1rw0r_64x88_22.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xfreepdk45_sram_1rw0r_64x88_22.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 1000101110010001000000100101011100011110001010110000010001110111001001011001111110000001  to  address 000000 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 1100000101001110101000000101001111011000101000011110100110001010011101000010011010110111  to  address 000000 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 0001101011111010111111010011001111011110101110000001100010010100100100111111011001111000  to  address 000000 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 0001101011111010111111010011001111011110101110000001100010010100100100111111011001111000 from address 000000 (from port 0) during cycle 4 (20ns - 25ns)
*	Reading 0001101011111010111111010011001111011110101110000001100010010100100100111111011001111000 from address 000000 (from port 0) during cycle 5 (25ns - 30ns)
*	Writing (partial) 0000100011110101110001101111111001011011110000111010111001111100000100101001010001101001  to  address 000000 with mask bit 0111 (from port 0) during cycle 6 (30ns - 35ns)
*	Writing (partial) 0111010000011011011110010001101001011111111111011111100110111101010110000000000010010011  to  address 000000 with mask bit 0011 (from port 0) during cycle 7 (35ns - 40ns)
*	Writing (partial) 0001111110000101111100111000101000001001001110111111000000001101110011011001000101011010  to  address 000000 with mask bit 0111 (from port 0) during cycle 8 (40ns - 45ns)
*	Reading 0001101011111010111111111000101000001001001110111111000000001101110011011001000101011010 from address 000000 (from port 0) during cycle 9 (45ns - 50ns)
*	Writing 0001001110000110110111101000001111110101001111101010001001111000001010100101100110001000  to  address 000000 (from port 0) during cycle 10 (50ns - 55ns)
*	Writing 0101111011001111110000111111100001001101000010011010100100101001010000011001000011001111  to  address 111110 (from port 0) during cycle 11 (55ns - 60ns)
*	Writing (partial) 1000101111111011110111010100110101100111111001000001010111111001110100001011001101100101  to  address 111110 with mask bit 1000 (from port 0) during cycle 12 (60ns - 65ns)
*	Reading 0001001110000110110111101000001111110101001111101010001001111000001010100101100110001000 from address 000000 (from port 0) during cycle 13 (65ns - 70ns)
*	Writing (partial) 1011110101011001100001001011000010111111100100111110000110011011111100000111000000100011  to  address 111110 with mask bit 1101 (from port 0) during cycle 14 (70ns - 75ns)
*	Reading 0001001110000110110111101000001111110101001111101010001001111000001010100101100110001000 from address 000000 (from port 0) during cycle 15 (75ns - 80ns)
*	Writing (partial) 0000001100101101101101100001011000010100011100001111100000100110001011011010000011010110  to  address 000000 with mask bit 0101 (from port 0) during cycle 16 (80ns - 85ns)
*	Writing 0100110101101000110001111111101000010101000010111011101001111010111001001111000110111110  to  address 111110 (from port 0) during cycle 17 (85ns - 90ns)
*	Reading 0100110101101000110001111111101000010101000010111011101001111010111001001111000110111110 from address 111110 (from port 0) during cycle 18 (90ns - 95ns)
*	Reading 0001001110000110110111100001011000010100011111101010001001111000001011011010000011010110 from address 000000 (from port 0) during cycle 19 (95ns - 100ns)
*	Reading 0001001110000110110111100001011000010100011111101010001001111000001011011010000011010110 from address 000000 (from port 0) during cycle 20 (100ns - 105ns)
*	Reading 0001001110000110110111100001011000010100011111101010001001111000001011011010000011010110 from address 000000 (from port 0) during cycle 21 (105ns - 110ns)
*	Writing 1000000101111000110001100100110110010011100101010001111111110111010110111110000100010101  to  address 111110 (from port 0) during cycle 22 (110ns - 115ns)
*	Reading 1000000101111000110001100100110110010011100101010001111111110111010110111110000100010101 from address 111110 (from port 0) during cycle 24 (120ns - 125ns)
*	Reading 1000000101111000110001100100110110010011100101010001111111110111010110111110000100010101 from address 111110 (from port 0) during cycle 25 (125ns - 130ns)
*	Reading 1000000101111000110001100100110110010011100101010001111111110111010110111110000100010101 from address 111110 (from port 0) during cycle 26 (130ns - 135ns)
*	Reading 0001001110000110110111100001011000010100011111101010001001111000001011011010000011010110 from address 000000 (from port 0) during cycle 27 (135ns - 140ns)
*	Writing 0101000001101110001000111010101000000111100000101010001001000100101001100111001001101011  to  address 111110 (from port 0) during cycle 28 (140ns - 145ns)
*	Reading 0101000001101110001000111010101000000111100000101010001001000100101001100111001001101011 from address 111110 (from port 0) during cycle 30 (150ns - 155ns)
*	Reading 0001001110000110110111100001011000010100011111101010001001111000001011011010000011010110 from address 000000 (from port 0) during cycle 31 (155ns - 160ns)
*	Reading 0001001110000110110111100001011000010100011111101010001001111000001011011010000011010110 from address 000000 (from port 0) during cycle 32 (160ns - 165ns)
*	Reading 0001001110000110110111100001011000010100011111101010001001111000001011011010000011010110 from address 000000 (from port 0) during cycle 33 (165ns - 170ns)
*	Writing 1101110000101010110110001010001100110011011100110101000100110110000011111011110101010001  to  address 000000 (from port 0) during cycle 34 (170ns - 175ns)
*	Writing 1011111011100001101011111011001011010011000001000010100100001110001111001111010101110010  to  address 111110 (from port 0) during cycle 35 (175ns - 180ns)
*	Writing (partial) 1100010010111010111001010110110011010110010100011011011101110111100100101111111011101101  to  address 111110 with mask bit 1011 (from port 0) during cycle 36 (180ns - 185ns)
*	Writing (partial) 0010010000010110110000101010000000010111000110001111010100010100000110001100101011011001  to  address 000000 with mask bit 0101 (from port 0) during cycle 37 (185ns - 190ns)
*	Reading 1101110000101010110110101010000000010111000100110101000100110110000110001100101011011001 from address 000000 (from port 0) during cycle 38 (190ns - 195ns)
*	Reading 1101110000101010110110101010000000010111000100110101000100110110000110001100101011011001 from address 000000 (from port 0) during cycle 39 (195ns - 200ns)
*	Reading 1101110000101010110110101010000000010111000100110101000100110110000110001100101011011001 from address 000000 (from port 0) during cycle 40 (200ns - 205ns)
*	Writing (partial) 0101001100111101101101011110010110100010111010100010100111011101100111100101100011100010  to  address 000000 with mask bit 1011 (from port 0) during cycle 42 (210ns - 215ns)
*	Writing 0011110011111101010001110100010001100001100110011010100110011001011111000101101111101110  to  address 000000 (from port 0) during cycle 43 (215ns - 220ns)
*	Writing (partial) 1011000001110101010011000110111000000001110001110110001111101001110101000010100000100100  to  address 111110 with mask bit 1101 (from port 0) during cycle 44 (220ns - 225ns)
*	Reading 1011000001110101010011000110111000000001110000011011011101110111100101000010100000100100 from address 111110 (from port 0) during cycle 45 (225ns - 230ns)
*	Writing 0001001111100100110001111110101001110000110001111100000010010101011111011011011110001110  to  address 111110 (from port 0) during cycle 46 (230ns - 235ns)
*	Writing (partial) 0011000111010011111110110101101110101100000100101000000110100000000010111101000010000110  to  address 000000 with mask bit 0100 (from port 0) during cycle 47 (235ns - 240ns)
*	Writing (partial) 0001111011000000100100000101101111101001100011001111111111101001001111010001100010100101  to  address 000000 with mask bit 1010 (from port 0) during cycle 49 (245ns - 250ns)
*	Reading 0001001111100100110001111110101001110000110001111100000010010101011111011011011110001110 from address 111110 (from port 0) during cycle 50 (250ns - 255ns)
*	Reading 0001111011000000100100110101101110101100000111001111111111101001001111000101101111101110 from address 000000 (from port 0) during cycle 51 (255ns - 260ns)
*	Writing (partial) 0111110101011111101001101100011100111000111110010001110101101010010011101110110010001110  to  address 111110 with mask bit 1101 (from port 0) during cycle 52 (260ns - 265ns)
*	Reading 0111110101011111101001101100011100111000111101111100000010010101010011101110110010001110 from address 111110 (from port 0) during cycle 54 (270ns - 275ns)
*	Reading 0111110101011111101001101100011100111000111101111100000010010101010011101110110010001110 from address 111110 (from port 0) during cycle 55 (275ns - 280ns)
*	Writing (partial) 0100111110100100011001100111100101011100010100010111010010010000110101111100111110110010  to  address 111110 with mask bit 1000 (from port 0) during cycle 56 (280ns - 285ns)
*	Writing (partial) 0110010101000111100000101000101111011001111010001101111010000110010101001100111110111011  to  address 111110 with mask bit 1000 (from port 0) during cycle 57 (285ns - 290ns)
*	Reading 0110010101000111100000101100011100111000111101111100000010010101010011101110110010001110 from address 111110 (from port 0) during cycle 58 (290ns - 295ns)
*	Reading 0110010101000111100000101100011100111000111101111100000010010101010011101110110010001110 from address 111110 (from port 0) during cycle 59 (295ns - 300ns)
*	Writing (partial) 0001011101001100010010111100110100001101111111100101010010100100100111101010011101001011  to  address 000000 with mask bit 1010 (from port 0) during cycle 60 (300ns - 305ns)
*	Writing (partial) 1011110101000000000011001001110011100010101100010011001000100101110010111110011111101110  to  address 000000 with mask bit 1110 (from port 0) during cycle 62 (310ns - 315ns)
*	Reading 1011110101000000000011001001110011100010101100010011001000100101111111000101101111101110 from address 000000 (from port 0) during cycle 63 (315ns - 320ns)
*	Reading 1011110101000000000011001001110011100010101100010011001000100101111111000101101111101110 from address 000000 (from port 0) during cycle 64 (320ns - 325ns)
*	Reading 0110010101000111100000101100011100111000111101111100000010010101010011101110110010001110 from address 111110 (from port 0) during cycle 66 (330ns - 335ns)
*	Writing 1000000100100101000100010010100110110100100111111010100100101111011110010110010010001000  to  address 111110 (from port 0) during cycle 67 (335ns - 340ns)
*	Writing (partial) 1111100100011010000111100001011000111110110011111111011111001001000011100111011010011001  to  address 000000 with mask bit 1101 (from port 0) during cycle 68 (340ns - 345ns)
*	Reading 1000000100100101000100010010100110110100100111111010100100101111011110010110010010001000 from address 111110 (from port 0) during cycle 72 (360ns - 365ns)
*	Writing 1111001101111010111100000001001011100010100010000111000001010110000111011100001011100111  to  address 111110 (from port 0) during cycle 73 (365ns - 370ns)
*	Writing 1001111110010011011010000110100101111111100011111100110000010001101000101100110011101001  to  address 111110 (from port 0) during cycle 74 (370ns - 375ns)
*	Writing 1000000101011100110000010001110111001011010100011101111101011101100000001111000001000110  to  address 111110 (from port 0) during cycle 75 (375ns - 380ns)
*	Reading 1000000101011100110000010001110111001011010100011101111101011101100000001111000001000110 from address 111110 (from port 0) during cycle 77 (385ns - 390ns)
*	Writing (partial) 1010010100011000100010111011001001111010001001111110010011000100101111000100101001001011  to  address 000000 with mask bit 0001 (from port 0) during cycle 78 (390ns - 395ns)
*	Reading 1000000101011100110000010001110111001011010100011101111101011101100000001111000001000110 from address 111110 (from port 0) during cycle 79 (395ns - 400ns)
*	Reading 1000000101011100110000010001110111001011010100011101111101011101100000001111000001000110 from address 111110 (from port 0) during cycle 83 (415ns - 420ns)
*	Reading 1111100100011010000111100001011000111110110000010011001000100101111111000100101001001011 from address 000000 (from port 0) during cycle 84 (420ns - 425ns)
*	Reading 1000000101011100110000010001110111001011010100011101111101011101100000001111000001000110 from address 111110 (from port 0) during cycle 86 (430ns - 435ns)
*	Reading 1000000101011100110000010001110111001011010100011101111101011101100000001111000001000110 from address 111110 (from port 0) during cycle 88 (440ns - 445ns)
*	Reading 1111100100011010000111100001011000111110110000010011001000100101111111000100101001001011 from address 000000 (from port 0) during cycle 89 (445ns - 450ns)
*	Writing 1101100101001101001110110110010010101101010010101110100100111001001100000110111010011101  to  address 000000 (from port 0) during cycle 90 (450ns - 455ns)
*	Writing (partial) 0001101000000101110001001111101100010100111000000010101011010111000010010100111010010111  to  address 111110 with mask bit 1101 (from port 0) during cycle 92 (460ns - 465ns)
*	Reading 1101100101001101001110110110010010101101010010101110100100111001001100000110111010011101 from address 000000 (from port 0) during cycle 94 (470ns - 475ns)
*	Reading 0001101000000101110001001111101100010100111000011101111101011101100010010100111010010111 from address 111110 (from port 0) during cycle 96 (480ns - 485ns)
*	Writing (partial) 0111000011100011100000010111011111000111100001011110110000110000001010101000101110010100  to  address 000000 with mask bit 0111 (from port 0) during cycle 97 (485ns - 490ns)
*	Writing 1110100011111001000001001110011101110010101110101011000101100011111010110000010010010001  to  address 111110 (from port 0) during cycle 98 (490ns - 495ns)
*	Reading 1110100011111001000001001110011101110010101110101011000101100011111010110000010010010001 from address 111110 (from port 0) during cycle 100 (500ns - 505ns)
*	Writing (partial) 1100010110111110101000001100000010101011000110001110110100110001111011111100011101010011  to  address 111110 with mask bit 1011 (from port 0) during cycle 101 (505ns - 510ns)
*	Reading 1101100101001101001110010111011111000111100001011110110000110000001010101000101110010100 from address 000000 (from port 0) during cycle 102 (510ns - 515ns)
*	Reading 1101100101001101001110010111011111000111100001011110110000110000001010101000101110010100 from address 000000 (from port 0) during cycle 103 (515ns - 520ns)
*	Writing 1100010110001100101000100101000100010100001110110111111000110100001011111100001101001101  to  address 000000 (from port 0) during cycle 104 (520ns - 525ns)
*	Reading 1100010110001100101000100101000100010100001110110111111000110100001011111100001101001101 from address 000000 (from port 0) during cycle 105 (525ns - 530ns)
*	Reading 1100010110001100101000100101000100010100001110110111111000110100001011111100001101001101 from address 000000 (from port 0) during cycle 106 (530ns - 535ns)
*	Writing 0011100010001011110100110001111100110001100001100001001001100100111110101000001101111100  to  address 111110 (from port 0) during cycle 107 (535ns - 540ns)
*	Writing (partial) 1100010000001001001011000101101011000110110100111101110100010001011000010010111110010011  to  address 111110 with mask bit 1101 (from port 0) during cycle 108 (540ns - 545ns)
*	Writing 0101000011101001111011111110101100001000001001001001000010100001110111001100011001100101  to  address 111110 (from port 0) during cycle 109 (545ns - 550ns)
*	Writing (partial) 0110000100001101010101010011011011000100110010100101001000101111001101010101100011110010  to  address 111110 with mask bit 0010 (from port 0) during cycle 110 (550ns - 555ns)
*	Writing (partial) 1101001011010011101101010110001000010011000001110000011001110100001110010111011111001111  to  address 000000 with mask bit 1100 (from port 0) during cycle 111 (555ns - 560ns)
*	Reading 0101000011101001111011111110101100001000001010100101001000101111000111001100011001100101 from address 111110 (from port 0) during cycle 112 (560ns - 565ns)
*	Reading 0101000011101001111011111110101100001000001010100101001000101111000111001100011001100101 from address 111110 (from port 0) during cycle 113 (565ns - 570ns)
*	Reading 0101000011101001111011111110101100001000001010100101001000101111000111001100011001100101 from address 111110 (from port 0) during cycle 114 (570ns - 575ns)
*	Writing (partial) 1101011010110001010100101011100111101101110000100010001011111011011010011010110111011110  to  address 111110 with mask bit 1100 (from port 0) during cycle 115 (575ns - 580ns)
*	Writing 0010111100000100111001011011000010010101011010001101100101011101001010111101111110010001  to  address 111110 (from port 0) during cycle 116 (580ns - 585ns)
*	Writing (partial) 1010101110011101011001101111000100001010110110011101101111110101111010001011011100000110  to  address 111110 with mask bit 0011 (from port 0) during cycle 117 (585ns - 590ns)
*	Reading 0010111100000100111001011011000010010101011010011101101111110101111010001011011100000110 from address 111110 (from port 0) during cycle 118 (590ns - 595ns)
*	Reading 1101001011010011101101010110001000010011000010110111111000110100001011111100001101001101 from address 000000 (from port 0) during cycle 119 (595ns - 600ns)
*	Writing (partial) 1011011001011101011100111010001010111110001100110010100101110100110010011011001101010110  to  address 000000 with mask bit 1110 (from port 0) during cycle 121 (605ns - 610ns)
*	Reading 0010111100000100111001011011000010010101011010011101101111110101111010001011011100000110 from address 111110 (from port 0) during cycle 122 (610ns - 615ns)
*	Writing 1000110000101111100100011010100111110011100001111100011010001000111110001010010110111100  to  address 111110 (from port 0) during cycle 124 (620ns - 625ns)
*	Reading 1011011001011101011100111010001010111110001100110010100101110100111011111100001101001101 from address 000000 (from port 0) during cycle 126 (630ns - 635ns)
*	Reading 1000110000101111100100011010100111110011100001111100011010001000111110001010010110111100 from address 111110 (from port 0) during cycle 127 (635ns - 640ns)
*	Writing (partial) 0101111110011110101000101111110111010111110011111010001111110010111111000001010000011010  to  address 111110 with mask bit 0101 (from port 0) during cycle 128 (640ns - 645ns)
*	Reading 1011011001011101011100111010001010111110001100110010100101110100111011111100001101001101 from address 000000 (from port 0) during cycle 129 (645ns - 650ns)
*	Writing (partial) 1111001000010011001000111100010011111001000101111001001111001000110111111111011110110001  to  address 111110 with mask bit 1100 (from port 0) during cycle 133 (665ns - 670ns)
*	Reading 1111001000010011001000111100010011111001000101111100011010001000111111000001010000011010 from address 111110 (from port 0) during cycle 134 (670ns - 675ns)
*	Reading 1111001000010011001000111100010011111001000101111100011010001000111111000001010000011010 from address 111110 (from port 0) during cycle 136 (680ns - 685ns)
*	Reading 1111001000010011001000111100010011111001000101111100011010001000111111000001010000011010 from address 111110 (from port 0) during cycle 137 (685ns - 690ns)
*	Reading 1011011001011101011100111010001010111110001100110010100101110100111011111100001101001101 from address 000000 (from port 0) during cycle 138 (690ns - 695ns)
*	Reading 1011011001011101011100111010001010111110001100110010100101110100111011111100001101001101 from address 000000 (from port 0) during cycle 139 (695ns - 700ns)
*	Writing 0101100001101010001010111110001001001111101010011010010001001110110000010100101100110111  to  address 000000 (from port 0) during cycle 140 (700ns - 705ns)
*	Reading 0101100001101010001010111110001001001111101010011010010001001110110000010100101100110111 from address 000000 (from port 0) during cycle 141 (705ns - 710ns)
*	Writing 1101100001010100110100010010110010101000000001010010111001001011100000001011000111000001  to  address 111110 (from port 0) during cycle 142 (710ns - 715ns)
*	Reading 1101100001010100110100010010110010101000000001010010111001001011100000001011000111000001 from address 111110 (from port 0) during cycle 143 (715ns - 720ns)
*	Reading 1101100001010100110100010010110010101000000001010010111001001011100000001011000111000001 from address 111110 (from port 0) during cycle 144 (720ns - 725ns)
*	Writing 1001010101111001100000111100000011000111101110110100010101010001101100110100100000100111  to  address 111110 (from port 0) during cycle 145 (725ns - 730ns)
*	Writing (partial) 1001011010010000000011100100110100011100101010100010011001101011111001000100011011001011  to  address 000000 with mask bit 0110 (from port 0) during cycle 146 (730ns - 735ns)
*	Writing 1111101011000010011110111110111101011110100001011001110101011100100011010101011011010010  to  address 111110 (from port 0) during cycle 147 (735ns - 740ns)
*	Writing 1000000010111001011001000001010001110001011101001100100111111000011011000100010101011001  to  address 111110 (from port 0) during cycle 150 (750ns - 755ns)
*	Reading 1000000010111001011001000001010001110001011101001100100111111000011011000100010101011001 from address 111110 (from port 0) during cycle 153 (765ns - 770ns)
*	Writing (partial) 0011100101100100111101001101100000011100011100110111110110001000110111110111100001001001  to  address 111110 with mask bit 1101 (from port 0) during cycle 154 (770ns - 775ns)
*	Writing 0111010111011011000000111001010000101000110101111000100010110011010111111000111100010111  to  address 000000 (from port 0) during cycle 155 (775ns - 780ns)
*	Writing 1000111001001011110111010111100111011010011111101110110111111111001001101100010001001101  to  address 111110 (from port 0) during cycle 157 (785ns - 790ns)
*	Reading 1000111001001011110111010111100111011010011111101110110111111111001001101100010001001101 from address 111110 (from port 0) during cycle 158 (790ns - 795ns)
*	Writing 1010111011110010110100010000110001110101011101011010111111100011001001000110001011110010  to  address 000000 (from port 0) during cycle 159 (795ns - 800ns)
*	Reading 1010111011110010110100010000110001110101011101011010111111100011001001000110001011110010 from address 000000 (from port 0) during cycle 162 (810ns - 815ns)
*	Reading 1000111001001011110111010111100111011010011111101110110111111111001001101100010001001101 from address 111110 (from port 0) during cycle 163 (815ns - 820ns)
*	Writing (partial) 1111000100010100111000010111010001110100011101000101100101001110110000011100100110001111  to  address 111110 with mask bit 0111 (from port 0) during cycle 164 (820ns - 825ns)
*	Writing 1111100100111001111110000010111111101100100101101000011000100000001011001110000101110011  to  address 111110 (from port 0) during cycle 165 (825ns - 830ns)
*	Writing 1111111010100110110101111101000100111001010011100110011010011010110110011101010010101010  to  address 111110 (from port 0) during cycle 166 (830ns - 835ns)
*	Reading 1111111010100110110101111101000100111001010011100110011010011010110110011101010010101010 from address 111110 (from port 0) during cycle 167 (835ns - 840ns)
*	Writing (partial) 0011000011101111000101110111111111100001111010111000010010010101100100110000100111110001  to  address 111110 with mask bit 0101 (from port 0) during cycle 169 (845ns - 850ns)
*	Writing 0001000011010001100111100011110111011111001100001011100000100110011110011000101000010101  to  address 000000 (from port 0) during cycle 170 (850ns - 855ns)
*	Writing 1010101011101101100001100010010100011011010101110101011011101110010101011001100010101011  to  address 111110 (from port 0) during cycle 172 (860ns - 865ns)
*	Writing (partial) 1101011010001100001101111011010000001001100111000000000100101011111000101100110000011010  to  address 111110 with mask bit 0111 (from port 0) during cycle 173 (865ns - 870ns)
*	Reading 1010101011101101100001111011010000001001100111000000000100101011111000101100110000011010 from address 111110 (from port 0) during cycle 174 (870ns - 875ns)
*	Writing 0011100011100001011111110111111010111001010011001010111110101111111001010011000000111010  to  address 000000 (from port 0) during cycle 175 (875ns - 880ns)
*	Reading 1010101011101101100001111011010000001001100111000000000100101011111000101100110000011010 from address 111110 (from port 0) during cycle 177 (885ns - 890ns)
*	Reading 1010101011101101100001111011010000001001100111000000000100101011111000101100110000011010 from address 111110 (from port 0) during cycle 178 (890ns - 895ns)
*	Reading 1010101011101101100001111011010000001001100111000000000100101011111000101100110000011010 from address 111110 (from port 0) during cycle 179 (895ns - 900ns)
*	Writing (partial) 1101110000000000010100011110001011100001000101110100110000111111111011001000100111101011  to  address 000000 with mask bit 0111 (from port 0) during cycle 180 (900ns - 905ns)
*	Reading 1010101011101101100001111011010000001001100111000000000100101011111000101100110000011010 from address 111110 (from port 0) during cycle 181 (905ns - 910ns)
*	Writing 0110111010011110101011001010011100000100110101011110101011111111110011011010110000100011  to  address 111110 (from port 0) during cycle 182 (910ns - 915ns)
*	Writing 0110001010010111001000001111101000001100100000111001100101001111010111011111010111010100  to  address 111110 (from port 0) during cycle 183 (915ns - 920ns)
*	Writing 1110001010110000011001000100110110010111011011000100010000111110110101011001110010110111  to  address 111110 (from port 0) during cycle 184 (920ns - 925ns)
*	Reading 1110001010110000011001000100110110010111011011000100010000111110110101011001110010110111 from address 111110 (from port 0) during cycle 185 (925ns - 930ns)
*	Writing 0011110010001010110100000010011101100101111001100101110100001010011011000010100011111100  to  address 000000 (from port 0) during cycle 186 (930ns - 935ns)
*	Writing 1110100111110111011111000100110111001011010011001111010110000011001010010000000110110110  to  address 111110 (from port 0) during cycle 187 (935ns - 940ns)
*	Reading 0011110010001010110100000010011101100101111001100101110100001010011011000010100011111100 from address 000000 (from port 0) during cycle 188 (940ns - 945ns)
*	Writing 0111100011010010100110000010010111111010110111111111001111000001010101101111100001100010  to  address 000000 (from port 0) during cycle 190 (950ns - 955ns)
*	Writing (partial) 0001100001100100101010101110100100000010101000000011101001100110000110000000000010100000  to  address 111110 with mask bit 0100 (from port 0) during cycle 191 (955ns - 960ns)
*	Reading 1110100111110111011111101110100100000010101011001111010110000011001010010000000110110110 from address 111110 (from port 0) during cycle 192 (960ns - 965ns)
*	Reading 1110100111110111011111101110100100000010101011001111010110000011001010010000000110110110 from address 111110 (from port 0) during cycle 193 (965ns - 970ns)
*	Writing 0001011111001110010010101101001100011110000101101111001110110010001001001000010000100111  to  address 111110 (from port 0) during cycle 194 (970ns - 975ns)
*	Reading 0001011111001110010010101101001100011110000101101111001110110010001001001000010000100111 from address 111110 (from port 0) during cycle 196 (980ns - 985ns)
*	Reading 0111100011010010100110000010010111111010110111111111001111000001010101101111100001100010 from address 000000 (from port 0) during cycle 197 (985ns - 990ns)
*	Writing (partial) 0001011100111110000100001001111000111010001111100001111000111011110001110111001101011110  to  address 000000 with mask bit 1001 (from port 0) during cycle 198 (990ns - 995ns)
*	Writing 0110011101111010001100101110010111010111110110000000111100011001111011010110100010110100  to  address 111110 (from port 0) during cycle 199 (995ns - 1000ns)
*	Writing 0010001000100100010011001100110100101100101110001111101001001011011110011000001001000110  to  address 000000 (from port 0) during cycle 200 (1000ns - 1005ns)
*	Reading 0010001000100100010011001100110100101100101110001111101001001011011110011000001001000110 from address 000000 (from port 0) during cycle 201 (1005ns - 1010ns)
*	Writing 0000111001011011110000011111111111010101010101001001011011111011010100111001010001010111  to  address 000000 (from port 0) during cycle 202 (1010ns - 1015ns)
*	Writing (partial) 1111100000011010100101101100001011001100101111101000111111111000000010011111110010010111  to  address 000000 with mask bit 1000 (from port 0) during cycle 203 (1015ns - 1020ns)
*	Reading 1111100000011010100101011111111111010101010101001001011011111011010100111001010001010111 from address 000000 (from port 0) during cycle 204 (1020ns - 1025ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_40  din0_40  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 1), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_41  din0_41  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 1), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_42  din0_42  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_43  din0_43  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_44  din0_44  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_45  din0_45  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_46  din0_46  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_47  din0_47  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_48  din0_48  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_49  din0_49  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_50  din0_50  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_51  din0_51  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_52  din0_52  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_53  din0_53  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_54  din0_54  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_55  din0_55  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_56  din0_56  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_57  din0_57  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_58  din0_58  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_59  din0_59  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 1), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_60  din0_60  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_61  din0_61  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_62  din0_62  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_63  din0_63  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_64  din0_64  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_65  din0_65  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_66  din0_66  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 0), (45, 0), (50, 1), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_67  din0_67  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_68  din0_68  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_69  din0_69  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_70  din0_70  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_71  din0_71  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_72  din0_72  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_73  din0_73  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_74  din0_74  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_75  din0_75  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_76  din0_76  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_77  din0_77  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_78  din0_78  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_79  din0_79  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_80  din0_80  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_81  din0_81  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 0), (55, 1), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_82  din0_82  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_83  din0_83  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_84  din0_84  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_85  din0_85  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_86  din0_86  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_87  din0_87  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 0), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 0), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 0), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 0), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 0), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 1), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 1), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 1), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 1), (605, 0), (610, 0), (615, 1), (620, 0), (625, 1), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 0), (75, 1), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 1), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 0), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 0), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 1), (785, 0), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 1), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
VWEB0 WEB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.9v 874.745n 0.9v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )

* Generation of wmask signals
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
VWMASK0_0  WMASK0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 0), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
VWMASK0_1  WMASK0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.0v 544.745n 0.0v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
VWMASK0_2  WMASK0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWMASK0_3  WMASK0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 0 time = 25
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=25.025n

* CHECK dout0_1 Vdout0_1ck4 = 0 time = 25
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=25.025n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 25
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=25.025n

* CHECK dout0_3 Vdout0_3ck4 = 0.9 time = 25
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=25.025n

* CHECK dout0_4 Vdout0_4ck4 = 0.9 time = 25
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=25.025n

* CHECK dout0_5 Vdout0_5ck4 = 0.9 time = 25
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=25.025n

* CHECK dout0_6 Vdout0_6ck4 = 0.9 time = 25
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=25.025n

* CHECK dout0_7 Vdout0_7ck4 = 0 time = 25
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=25.025n

* CHECK dout0_8 Vdout0_8ck4 = 0 time = 25
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=25.025n

* CHECK dout0_9 Vdout0_9ck4 = 0.9 time = 25
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=25.025n

* CHECK dout0_10 Vdout0_10ck4 = 0.9 time = 25
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=25.025n

* CHECK dout0_11 Vdout0_11ck4 = 0 time = 25
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=25.025n

* CHECK dout0_12 Vdout0_12ck4 = 0.9 time = 25
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=25.025n

* CHECK dout0_13 Vdout0_13ck4 = 0.9 time = 25
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=25.025n

* CHECK dout0_14 Vdout0_14ck4 = 0.9 time = 25
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=25.025n

* CHECK dout0_15 Vdout0_15ck4 = 0.9 time = 25
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=25.025n

* CHECK dout0_16 Vdout0_16ck4 = 0.9 time = 25
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=25.025n

* CHECK dout0_17 Vdout0_17ck4 = 0.9 time = 25
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=25.025n

* CHECK dout0_18 Vdout0_18ck4 = 0 time = 25
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=25.025n

* CHECK dout0_19 Vdout0_19ck4 = 0 time = 25
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=25.025n

* CHECK dout0_20 Vdout0_20ck4 = 0.9 time = 25
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=25.025n

* CHECK dout0_21 Vdout0_21ck4 = 0 time = 25
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=25.025n

* CHECK dout0_22 Vdout0_22ck4 = 0 time = 25
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=25.025n

* CHECK dout0_23 Vdout0_23ck4 = 0.9 time = 25
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=25.025n

* CHECK dout0_24 Vdout0_24ck4 = 0 time = 25
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=25.025n

* CHECK dout0_25 Vdout0_25ck4 = 0 time = 25
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=25.025n

* CHECK dout0_26 Vdout0_26ck4 = 0.9 time = 25
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=25.025n

* CHECK dout0_27 Vdout0_27ck4 = 0 time = 25
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=25.025n

* CHECK dout0_28 Vdout0_28ck4 = 0.9 time = 25
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=25.025n

* CHECK dout0_29 Vdout0_29ck4 = 0 time = 25
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=25.025n

* CHECK dout0_30 Vdout0_30ck4 = 0 time = 25
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=25.025n

* CHECK dout0_31 Vdout0_31ck4 = 0.9 time = 25
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=25.025n

* CHECK dout0_32 Vdout0_32ck4 = 0 time = 25
.meas tran vdout0_32ck4 FIND v(dout0_32) AT=25.025n

* CHECK dout0_33 Vdout0_33ck4 = 0 time = 25
.meas tran vdout0_33ck4 FIND v(dout0_33) AT=25.025n

* CHECK dout0_34 Vdout0_34ck4 = 0 time = 25
.meas tran vdout0_34ck4 FIND v(dout0_34) AT=25.025n

* CHECK dout0_35 Vdout0_35ck4 = 0.9 time = 25
.meas tran vdout0_35ck4 FIND v(dout0_35) AT=25.025n

* CHECK dout0_36 Vdout0_36ck4 = 0.9 time = 25
.meas tran vdout0_36ck4 FIND v(dout0_36) AT=25.025n

* CHECK dout0_37 Vdout0_37ck4 = 0 time = 25
.meas tran vdout0_37ck4 FIND v(dout0_37) AT=25.025n

* CHECK dout0_38 Vdout0_38ck4 = 0 time = 25
.meas tran vdout0_38ck4 FIND v(dout0_38) AT=25.025n

* CHECK dout0_39 Vdout0_39ck4 = 0 time = 25
.meas tran vdout0_39ck4 FIND v(dout0_39) AT=25.025n

* CHECK dout0_40 Vdout0_40ck4 = 0 time = 25
.meas tran vdout0_40ck4 FIND v(dout0_40) AT=25.025n

* CHECK dout0_41 Vdout0_41ck4 = 0 time = 25
.meas tran vdout0_41ck4 FIND v(dout0_41) AT=25.025n

* CHECK dout0_42 Vdout0_42ck4 = 0 time = 25
.meas tran vdout0_42ck4 FIND v(dout0_42) AT=25.025n

* CHECK dout0_43 Vdout0_43ck4 = 0.9 time = 25
.meas tran vdout0_43ck4 FIND v(dout0_43) AT=25.025n

* CHECK dout0_44 Vdout0_44ck4 = 0.9 time = 25
.meas tran vdout0_44ck4 FIND v(dout0_44) AT=25.025n

* CHECK dout0_45 Vdout0_45ck4 = 0.9 time = 25
.meas tran vdout0_45ck4 FIND v(dout0_45) AT=25.025n

* CHECK dout0_46 Vdout0_46ck4 = 0 time = 25
.meas tran vdout0_46ck4 FIND v(dout0_46) AT=25.025n

* CHECK dout0_47 Vdout0_47ck4 = 0.9 time = 25
.meas tran vdout0_47ck4 FIND v(dout0_47) AT=25.025n

* CHECK dout0_48 Vdout0_48ck4 = 0 time = 25
.meas tran vdout0_48ck4 FIND v(dout0_48) AT=25.025n

* CHECK dout0_49 Vdout0_49ck4 = 0.9 time = 25
.meas tran vdout0_49ck4 FIND v(dout0_49) AT=25.025n

* CHECK dout0_50 Vdout0_50ck4 = 0.9 time = 25
.meas tran vdout0_50ck4 FIND v(dout0_50) AT=25.025n

* CHECK dout0_51 Vdout0_51ck4 = 0.9 time = 25
.meas tran vdout0_51ck4 FIND v(dout0_51) AT=25.025n

* CHECK dout0_52 Vdout0_52ck4 = 0.9 time = 25
.meas tran vdout0_52ck4 FIND v(dout0_52) AT=25.025n

* CHECK dout0_53 Vdout0_53ck4 = 0 time = 25
.meas tran vdout0_53ck4 FIND v(dout0_53) AT=25.025n

* CHECK dout0_54 Vdout0_54ck4 = 0.9 time = 25
.meas tran vdout0_54ck4 FIND v(dout0_54) AT=25.025n

* CHECK dout0_55 Vdout0_55ck4 = 0.9 time = 25
.meas tran vdout0_55ck4 FIND v(dout0_55) AT=25.025n

* CHECK dout0_56 Vdout0_56ck4 = 0.9 time = 25
.meas tran vdout0_56ck4 FIND v(dout0_56) AT=25.025n

* CHECK dout0_57 Vdout0_57ck4 = 0.9 time = 25
.meas tran vdout0_57ck4 FIND v(dout0_57) AT=25.025n

* CHECK dout0_58 Vdout0_58ck4 = 0 time = 25
.meas tran vdout0_58ck4 FIND v(dout0_58) AT=25.025n

* CHECK dout0_59 Vdout0_59ck4 = 0 time = 25
.meas tran vdout0_59ck4 FIND v(dout0_59) AT=25.025n

* CHECK dout0_60 Vdout0_60ck4 = 0.9 time = 25
.meas tran vdout0_60ck4 FIND v(dout0_60) AT=25.025n

* CHECK dout0_61 Vdout0_61ck4 = 0.9 time = 25
.meas tran vdout0_61ck4 FIND v(dout0_61) AT=25.025n

* CHECK dout0_62 Vdout0_62ck4 = 0 time = 25
.meas tran vdout0_62ck4 FIND v(dout0_62) AT=25.025n

* CHECK dout0_63 Vdout0_63ck4 = 0 time = 25
.meas tran vdout0_63ck4 FIND v(dout0_63) AT=25.025n

* CHECK dout0_64 Vdout0_64ck4 = 0.9 time = 25
.meas tran vdout0_64ck4 FIND v(dout0_64) AT=25.025n

* CHECK dout0_65 Vdout0_65ck4 = 0 time = 25
.meas tran vdout0_65ck4 FIND v(dout0_65) AT=25.025n

* CHECK dout0_66 Vdout0_66ck4 = 0.9 time = 25
.meas tran vdout0_66ck4 FIND v(dout0_66) AT=25.025n

* CHECK dout0_67 Vdout0_67ck4 = 0.9 time = 25
.meas tran vdout0_67ck4 FIND v(dout0_67) AT=25.025n

* CHECK dout0_68 Vdout0_68ck4 = 0.9 time = 25
.meas tran vdout0_68ck4 FIND v(dout0_68) AT=25.025n

* CHECK dout0_69 Vdout0_69ck4 = 0.9 time = 25
.meas tran vdout0_69ck4 FIND v(dout0_69) AT=25.025n

* CHECK dout0_70 Vdout0_70ck4 = 0.9 time = 25
.meas tran vdout0_70ck4 FIND v(dout0_70) AT=25.025n

* CHECK dout0_71 Vdout0_71ck4 = 0.9 time = 25
.meas tran vdout0_71ck4 FIND v(dout0_71) AT=25.025n

* CHECK dout0_72 Vdout0_72ck4 = 0 time = 25
.meas tran vdout0_72ck4 FIND v(dout0_72) AT=25.025n

* CHECK dout0_73 Vdout0_73ck4 = 0.9 time = 25
.meas tran vdout0_73ck4 FIND v(dout0_73) AT=25.025n

* CHECK dout0_74 Vdout0_74ck4 = 0 time = 25
.meas tran vdout0_74ck4 FIND v(dout0_74) AT=25.025n

* CHECK dout0_75 Vdout0_75ck4 = 0.9 time = 25
.meas tran vdout0_75ck4 FIND v(dout0_75) AT=25.025n

* CHECK dout0_76 Vdout0_76ck4 = 0.9 time = 25
.meas tran vdout0_76ck4 FIND v(dout0_76) AT=25.025n

* CHECK dout0_77 Vdout0_77ck4 = 0.9 time = 25
.meas tran vdout0_77ck4 FIND v(dout0_77) AT=25.025n

* CHECK dout0_78 Vdout0_78ck4 = 0.9 time = 25
.meas tran vdout0_78ck4 FIND v(dout0_78) AT=25.025n

* CHECK dout0_79 Vdout0_79ck4 = 0.9 time = 25
.meas tran vdout0_79ck4 FIND v(dout0_79) AT=25.025n

* CHECK dout0_80 Vdout0_80ck4 = 0 time = 25
.meas tran vdout0_80ck4 FIND v(dout0_80) AT=25.025n

* CHECK dout0_81 Vdout0_81ck4 = 0.9 time = 25
.meas tran vdout0_81ck4 FIND v(dout0_81) AT=25.025n

* CHECK dout0_82 Vdout0_82ck4 = 0 time = 25
.meas tran vdout0_82ck4 FIND v(dout0_82) AT=25.025n

* CHECK dout0_83 Vdout0_83ck4 = 0.9 time = 25
.meas tran vdout0_83ck4 FIND v(dout0_83) AT=25.025n

* CHECK dout0_84 Vdout0_84ck4 = 0.9 time = 25
.meas tran vdout0_84ck4 FIND v(dout0_84) AT=25.025n

* CHECK dout0_85 Vdout0_85ck4 = 0 time = 25
.meas tran vdout0_85ck4 FIND v(dout0_85) AT=25.025n

* CHECK dout0_86 Vdout0_86ck4 = 0 time = 25
.meas tran vdout0_86ck4 FIND v(dout0_86) AT=25.025n

* CHECK dout0_87 Vdout0_87ck4 = 0 time = 25
.meas tran vdout0_87ck4 FIND v(dout0_87) AT=25.025n

* CHECK dout0_0 Vdout0_0ck5 = 0 time = 30
.meas tran vdout0_0ck5 FIND v(dout0_0) AT=30.025n

* CHECK dout0_1 Vdout0_1ck5 = 0 time = 30
.meas tran vdout0_1ck5 FIND v(dout0_1) AT=30.025n

* CHECK dout0_2 Vdout0_2ck5 = 0 time = 30
.meas tran vdout0_2ck5 FIND v(dout0_2) AT=30.025n

* CHECK dout0_3 Vdout0_3ck5 = 0.9 time = 30
.meas tran vdout0_3ck5 FIND v(dout0_3) AT=30.025n

* CHECK dout0_4 Vdout0_4ck5 = 0.9 time = 30
.meas tran vdout0_4ck5 FIND v(dout0_4) AT=30.025n

* CHECK dout0_5 Vdout0_5ck5 = 0.9 time = 30
.meas tran vdout0_5ck5 FIND v(dout0_5) AT=30.025n

* CHECK dout0_6 Vdout0_6ck5 = 0.9 time = 30
.meas tran vdout0_6ck5 FIND v(dout0_6) AT=30.025n

* CHECK dout0_7 Vdout0_7ck5 = 0 time = 30
.meas tran vdout0_7ck5 FIND v(dout0_7) AT=30.025n

* CHECK dout0_8 Vdout0_8ck5 = 0 time = 30
.meas tran vdout0_8ck5 FIND v(dout0_8) AT=30.025n

* CHECK dout0_9 Vdout0_9ck5 = 0.9 time = 30
.meas tran vdout0_9ck5 FIND v(dout0_9) AT=30.025n

* CHECK dout0_10 Vdout0_10ck5 = 0.9 time = 30
.meas tran vdout0_10ck5 FIND v(dout0_10) AT=30.025n

* CHECK dout0_11 Vdout0_11ck5 = 0 time = 30
.meas tran vdout0_11ck5 FIND v(dout0_11) AT=30.025n

* CHECK dout0_12 Vdout0_12ck5 = 0.9 time = 30
.meas tran vdout0_12ck5 FIND v(dout0_12) AT=30.025n

* CHECK dout0_13 Vdout0_13ck5 = 0.9 time = 30
.meas tran vdout0_13ck5 FIND v(dout0_13) AT=30.025n

* CHECK dout0_14 Vdout0_14ck5 = 0.9 time = 30
.meas tran vdout0_14ck5 FIND v(dout0_14) AT=30.025n

* CHECK dout0_15 Vdout0_15ck5 = 0.9 time = 30
.meas tran vdout0_15ck5 FIND v(dout0_15) AT=30.025n

* CHECK dout0_16 Vdout0_16ck5 = 0.9 time = 30
.meas tran vdout0_16ck5 FIND v(dout0_16) AT=30.025n

* CHECK dout0_17 Vdout0_17ck5 = 0.9 time = 30
.meas tran vdout0_17ck5 FIND v(dout0_17) AT=30.025n

* CHECK dout0_18 Vdout0_18ck5 = 0 time = 30
.meas tran vdout0_18ck5 FIND v(dout0_18) AT=30.025n

* CHECK dout0_19 Vdout0_19ck5 = 0 time = 30
.meas tran vdout0_19ck5 FIND v(dout0_19) AT=30.025n

* CHECK dout0_20 Vdout0_20ck5 = 0.9 time = 30
.meas tran vdout0_20ck5 FIND v(dout0_20) AT=30.025n

* CHECK dout0_21 Vdout0_21ck5 = 0 time = 30
.meas tran vdout0_21ck5 FIND v(dout0_21) AT=30.025n

* CHECK dout0_22 Vdout0_22ck5 = 0 time = 30
.meas tran vdout0_22ck5 FIND v(dout0_22) AT=30.025n

* CHECK dout0_23 Vdout0_23ck5 = 0.9 time = 30
.meas tran vdout0_23ck5 FIND v(dout0_23) AT=30.025n

* CHECK dout0_24 Vdout0_24ck5 = 0 time = 30
.meas tran vdout0_24ck5 FIND v(dout0_24) AT=30.025n

* CHECK dout0_25 Vdout0_25ck5 = 0 time = 30
.meas tran vdout0_25ck5 FIND v(dout0_25) AT=30.025n

* CHECK dout0_26 Vdout0_26ck5 = 0.9 time = 30
.meas tran vdout0_26ck5 FIND v(dout0_26) AT=30.025n

* CHECK dout0_27 Vdout0_27ck5 = 0 time = 30
.meas tran vdout0_27ck5 FIND v(dout0_27) AT=30.025n

* CHECK dout0_28 Vdout0_28ck5 = 0.9 time = 30
.meas tran vdout0_28ck5 FIND v(dout0_28) AT=30.025n

* CHECK dout0_29 Vdout0_29ck5 = 0 time = 30
.meas tran vdout0_29ck5 FIND v(dout0_29) AT=30.025n

* CHECK dout0_30 Vdout0_30ck5 = 0 time = 30
.meas tran vdout0_30ck5 FIND v(dout0_30) AT=30.025n

* CHECK dout0_31 Vdout0_31ck5 = 0.9 time = 30
.meas tran vdout0_31ck5 FIND v(dout0_31) AT=30.025n

* CHECK dout0_32 Vdout0_32ck5 = 0 time = 30
.meas tran vdout0_32ck5 FIND v(dout0_32) AT=30.025n

* CHECK dout0_33 Vdout0_33ck5 = 0 time = 30
.meas tran vdout0_33ck5 FIND v(dout0_33) AT=30.025n

* CHECK dout0_34 Vdout0_34ck5 = 0 time = 30
.meas tran vdout0_34ck5 FIND v(dout0_34) AT=30.025n

* CHECK dout0_35 Vdout0_35ck5 = 0.9 time = 30
.meas tran vdout0_35ck5 FIND v(dout0_35) AT=30.025n

* CHECK dout0_36 Vdout0_36ck5 = 0.9 time = 30
.meas tran vdout0_36ck5 FIND v(dout0_36) AT=30.025n

* CHECK dout0_37 Vdout0_37ck5 = 0 time = 30
.meas tran vdout0_37ck5 FIND v(dout0_37) AT=30.025n

* CHECK dout0_38 Vdout0_38ck5 = 0 time = 30
.meas tran vdout0_38ck5 FIND v(dout0_38) AT=30.025n

* CHECK dout0_39 Vdout0_39ck5 = 0 time = 30
.meas tran vdout0_39ck5 FIND v(dout0_39) AT=30.025n

* CHECK dout0_40 Vdout0_40ck5 = 0 time = 30
.meas tran vdout0_40ck5 FIND v(dout0_40) AT=30.025n

* CHECK dout0_41 Vdout0_41ck5 = 0 time = 30
.meas tran vdout0_41ck5 FIND v(dout0_41) AT=30.025n

* CHECK dout0_42 Vdout0_42ck5 = 0 time = 30
.meas tran vdout0_42ck5 FIND v(dout0_42) AT=30.025n

* CHECK dout0_43 Vdout0_43ck5 = 0.9 time = 30
.meas tran vdout0_43ck5 FIND v(dout0_43) AT=30.025n

* CHECK dout0_44 Vdout0_44ck5 = 0.9 time = 30
.meas tran vdout0_44ck5 FIND v(dout0_44) AT=30.025n

* CHECK dout0_45 Vdout0_45ck5 = 0.9 time = 30
.meas tran vdout0_45ck5 FIND v(dout0_45) AT=30.025n

* CHECK dout0_46 Vdout0_46ck5 = 0 time = 30
.meas tran vdout0_46ck5 FIND v(dout0_46) AT=30.025n

* CHECK dout0_47 Vdout0_47ck5 = 0.9 time = 30
.meas tran vdout0_47ck5 FIND v(dout0_47) AT=30.025n

* CHECK dout0_48 Vdout0_48ck5 = 0 time = 30
.meas tran vdout0_48ck5 FIND v(dout0_48) AT=30.025n

* CHECK dout0_49 Vdout0_49ck5 = 0.9 time = 30
.meas tran vdout0_49ck5 FIND v(dout0_49) AT=30.025n

* CHECK dout0_50 Vdout0_50ck5 = 0.9 time = 30
.meas tran vdout0_50ck5 FIND v(dout0_50) AT=30.025n

* CHECK dout0_51 Vdout0_51ck5 = 0.9 time = 30
.meas tran vdout0_51ck5 FIND v(dout0_51) AT=30.025n

* CHECK dout0_52 Vdout0_52ck5 = 0.9 time = 30
.meas tran vdout0_52ck5 FIND v(dout0_52) AT=30.025n

* CHECK dout0_53 Vdout0_53ck5 = 0 time = 30
.meas tran vdout0_53ck5 FIND v(dout0_53) AT=30.025n

* CHECK dout0_54 Vdout0_54ck5 = 0.9 time = 30
.meas tran vdout0_54ck5 FIND v(dout0_54) AT=30.025n

* CHECK dout0_55 Vdout0_55ck5 = 0.9 time = 30
.meas tran vdout0_55ck5 FIND v(dout0_55) AT=30.025n

* CHECK dout0_56 Vdout0_56ck5 = 0.9 time = 30
.meas tran vdout0_56ck5 FIND v(dout0_56) AT=30.025n

* CHECK dout0_57 Vdout0_57ck5 = 0.9 time = 30
.meas tran vdout0_57ck5 FIND v(dout0_57) AT=30.025n

* CHECK dout0_58 Vdout0_58ck5 = 0 time = 30
.meas tran vdout0_58ck5 FIND v(dout0_58) AT=30.025n

* CHECK dout0_59 Vdout0_59ck5 = 0 time = 30
.meas tran vdout0_59ck5 FIND v(dout0_59) AT=30.025n

* CHECK dout0_60 Vdout0_60ck5 = 0.9 time = 30
.meas tran vdout0_60ck5 FIND v(dout0_60) AT=30.025n

* CHECK dout0_61 Vdout0_61ck5 = 0.9 time = 30
.meas tran vdout0_61ck5 FIND v(dout0_61) AT=30.025n

* CHECK dout0_62 Vdout0_62ck5 = 0 time = 30
.meas tran vdout0_62ck5 FIND v(dout0_62) AT=30.025n

* CHECK dout0_63 Vdout0_63ck5 = 0 time = 30
.meas tran vdout0_63ck5 FIND v(dout0_63) AT=30.025n

* CHECK dout0_64 Vdout0_64ck5 = 0.9 time = 30
.meas tran vdout0_64ck5 FIND v(dout0_64) AT=30.025n

* CHECK dout0_65 Vdout0_65ck5 = 0 time = 30
.meas tran vdout0_65ck5 FIND v(dout0_65) AT=30.025n

* CHECK dout0_66 Vdout0_66ck5 = 0.9 time = 30
.meas tran vdout0_66ck5 FIND v(dout0_66) AT=30.025n

* CHECK dout0_67 Vdout0_67ck5 = 0.9 time = 30
.meas tran vdout0_67ck5 FIND v(dout0_67) AT=30.025n

* CHECK dout0_68 Vdout0_68ck5 = 0.9 time = 30
.meas tran vdout0_68ck5 FIND v(dout0_68) AT=30.025n

* CHECK dout0_69 Vdout0_69ck5 = 0.9 time = 30
.meas tran vdout0_69ck5 FIND v(dout0_69) AT=30.025n

* CHECK dout0_70 Vdout0_70ck5 = 0.9 time = 30
.meas tran vdout0_70ck5 FIND v(dout0_70) AT=30.025n

* CHECK dout0_71 Vdout0_71ck5 = 0.9 time = 30
.meas tran vdout0_71ck5 FIND v(dout0_71) AT=30.025n

* CHECK dout0_72 Vdout0_72ck5 = 0 time = 30
.meas tran vdout0_72ck5 FIND v(dout0_72) AT=30.025n

* CHECK dout0_73 Vdout0_73ck5 = 0.9 time = 30
.meas tran vdout0_73ck5 FIND v(dout0_73) AT=30.025n

* CHECK dout0_74 Vdout0_74ck5 = 0 time = 30
.meas tran vdout0_74ck5 FIND v(dout0_74) AT=30.025n

* CHECK dout0_75 Vdout0_75ck5 = 0.9 time = 30
.meas tran vdout0_75ck5 FIND v(dout0_75) AT=30.025n

* CHECK dout0_76 Vdout0_76ck5 = 0.9 time = 30
.meas tran vdout0_76ck5 FIND v(dout0_76) AT=30.025n

* CHECK dout0_77 Vdout0_77ck5 = 0.9 time = 30
.meas tran vdout0_77ck5 FIND v(dout0_77) AT=30.025n

* CHECK dout0_78 Vdout0_78ck5 = 0.9 time = 30
.meas tran vdout0_78ck5 FIND v(dout0_78) AT=30.025n

* CHECK dout0_79 Vdout0_79ck5 = 0.9 time = 30
.meas tran vdout0_79ck5 FIND v(dout0_79) AT=30.025n

* CHECK dout0_80 Vdout0_80ck5 = 0 time = 30
.meas tran vdout0_80ck5 FIND v(dout0_80) AT=30.025n

* CHECK dout0_81 Vdout0_81ck5 = 0.9 time = 30
.meas tran vdout0_81ck5 FIND v(dout0_81) AT=30.025n

* CHECK dout0_82 Vdout0_82ck5 = 0 time = 30
.meas tran vdout0_82ck5 FIND v(dout0_82) AT=30.025n

* CHECK dout0_83 Vdout0_83ck5 = 0.9 time = 30
.meas tran vdout0_83ck5 FIND v(dout0_83) AT=30.025n

* CHECK dout0_84 Vdout0_84ck5 = 0.9 time = 30
.meas tran vdout0_84ck5 FIND v(dout0_84) AT=30.025n

* CHECK dout0_85 Vdout0_85ck5 = 0 time = 30
.meas tran vdout0_85ck5 FIND v(dout0_85) AT=30.025n

* CHECK dout0_86 Vdout0_86ck5 = 0 time = 30
.meas tran vdout0_86ck5 FIND v(dout0_86) AT=30.025n

* CHECK dout0_87 Vdout0_87ck5 = 0 time = 30
.meas tran vdout0_87ck5 FIND v(dout0_87) AT=30.025n

* CHECK dout0_0 Vdout0_0ck9 = 0 time = 50
.meas tran vdout0_0ck9 FIND v(dout0_0) AT=50.025n

* CHECK dout0_1 Vdout0_1ck9 = 0.9 time = 50
.meas tran vdout0_1ck9 FIND v(dout0_1) AT=50.025n

* CHECK dout0_2 Vdout0_2ck9 = 0 time = 50
.meas tran vdout0_2ck9 FIND v(dout0_2) AT=50.025n

* CHECK dout0_3 Vdout0_3ck9 = 0.9 time = 50
.meas tran vdout0_3ck9 FIND v(dout0_3) AT=50.025n

* CHECK dout0_4 Vdout0_4ck9 = 0.9 time = 50
.meas tran vdout0_4ck9 FIND v(dout0_4) AT=50.025n

* CHECK dout0_5 Vdout0_5ck9 = 0 time = 50
.meas tran vdout0_5ck9 FIND v(dout0_5) AT=50.025n

* CHECK dout0_6 Vdout0_6ck9 = 0.9 time = 50
.meas tran vdout0_6ck9 FIND v(dout0_6) AT=50.025n

* CHECK dout0_7 Vdout0_7ck9 = 0 time = 50
.meas tran vdout0_7ck9 FIND v(dout0_7) AT=50.025n

* CHECK dout0_8 Vdout0_8ck9 = 0.9 time = 50
.meas tran vdout0_8ck9 FIND v(dout0_8) AT=50.025n

* CHECK dout0_9 Vdout0_9ck9 = 0 time = 50
.meas tran vdout0_9ck9 FIND v(dout0_9) AT=50.025n

* CHECK dout0_10 Vdout0_10ck9 = 0 time = 50
.meas tran vdout0_10ck9 FIND v(dout0_10) AT=50.025n

* CHECK dout0_11 Vdout0_11ck9 = 0 time = 50
.meas tran vdout0_11ck9 FIND v(dout0_11) AT=50.025n

* CHECK dout0_12 Vdout0_12ck9 = 0.9 time = 50
.meas tran vdout0_12ck9 FIND v(dout0_12) AT=50.025n

* CHECK dout0_13 Vdout0_13ck9 = 0 time = 50
.meas tran vdout0_13ck9 FIND v(dout0_13) AT=50.025n

* CHECK dout0_14 Vdout0_14ck9 = 0 time = 50
.meas tran vdout0_14ck9 FIND v(dout0_14) AT=50.025n

* CHECK dout0_15 Vdout0_15ck9 = 0.9 time = 50
.meas tran vdout0_15ck9 FIND v(dout0_15) AT=50.025n

* CHECK dout0_16 Vdout0_16ck9 = 0.9 time = 50
.meas tran vdout0_16ck9 FIND v(dout0_16) AT=50.025n

* CHECK dout0_17 Vdout0_17ck9 = 0 time = 50
.meas tran vdout0_17ck9 FIND v(dout0_17) AT=50.025n

* CHECK dout0_18 Vdout0_18ck9 = 0.9 time = 50
.meas tran vdout0_18ck9 FIND v(dout0_18) AT=50.025n

* CHECK dout0_19 Vdout0_19ck9 = 0.9 time = 50
.meas tran vdout0_19ck9 FIND v(dout0_19) AT=50.025n

* CHECK dout0_20 Vdout0_20ck9 = 0 time = 50
.meas tran vdout0_20ck9 FIND v(dout0_20) AT=50.025n

* CHECK dout0_21 Vdout0_21ck9 = 0 time = 50
.meas tran vdout0_21ck9 FIND v(dout0_21) AT=50.025n

* CHECK dout0_22 Vdout0_22ck9 = 0.9 time = 50
.meas tran vdout0_22ck9 FIND v(dout0_22) AT=50.025n

* CHECK dout0_23 Vdout0_23ck9 = 0.9 time = 50
.meas tran vdout0_23ck9 FIND v(dout0_23) AT=50.025n

* CHECK dout0_24 Vdout0_24ck9 = 0.9 time = 50
.meas tran vdout0_24ck9 FIND v(dout0_24) AT=50.025n

* CHECK dout0_25 Vdout0_25ck9 = 0 time = 50
.meas tran vdout0_25ck9 FIND v(dout0_25) AT=50.025n

* CHECK dout0_26 Vdout0_26ck9 = 0.9 time = 50
.meas tran vdout0_26ck9 FIND v(dout0_26) AT=50.025n

* CHECK dout0_27 Vdout0_27ck9 = 0.9 time = 50
.meas tran vdout0_27ck9 FIND v(dout0_27) AT=50.025n

* CHECK dout0_28 Vdout0_28ck9 = 0 time = 50
.meas tran vdout0_28ck9 FIND v(dout0_28) AT=50.025n

* CHECK dout0_29 Vdout0_29ck9 = 0 time = 50
.meas tran vdout0_29ck9 FIND v(dout0_29) AT=50.025n

* CHECK dout0_30 Vdout0_30ck9 = 0 time = 50
.meas tran vdout0_30ck9 FIND v(dout0_30) AT=50.025n

* CHECK dout0_31 Vdout0_31ck9 = 0 time = 50
.meas tran vdout0_31ck9 FIND v(dout0_31) AT=50.025n

* CHECK dout0_32 Vdout0_32ck9 = 0 time = 50
.meas tran vdout0_32ck9 FIND v(dout0_32) AT=50.025n

* CHECK dout0_33 Vdout0_33ck9 = 0 time = 50
.meas tran vdout0_33ck9 FIND v(dout0_33) AT=50.025n

* CHECK dout0_34 Vdout0_34ck9 = 0 time = 50
.meas tran vdout0_34ck9 FIND v(dout0_34) AT=50.025n

* CHECK dout0_35 Vdout0_35ck9 = 0 time = 50
.meas tran vdout0_35ck9 FIND v(dout0_35) AT=50.025n

* CHECK dout0_36 Vdout0_36ck9 = 0.9 time = 50
.meas tran vdout0_36ck9 FIND v(dout0_36) AT=50.025n

* CHECK dout0_37 Vdout0_37ck9 = 0.9 time = 50
.meas tran vdout0_37ck9 FIND v(dout0_37) AT=50.025n

* CHECK dout0_38 Vdout0_38ck9 = 0.9 time = 50
.meas tran vdout0_38ck9 FIND v(dout0_38) AT=50.025n

* CHECK dout0_39 Vdout0_39ck9 = 0.9 time = 50
.meas tran vdout0_39ck9 FIND v(dout0_39) AT=50.025n

* CHECK dout0_40 Vdout0_40ck9 = 0.9 time = 50
.meas tran vdout0_40ck9 FIND v(dout0_40) AT=50.025n

* CHECK dout0_41 Vdout0_41ck9 = 0.9 time = 50
.meas tran vdout0_41ck9 FIND v(dout0_41) AT=50.025n

* CHECK dout0_42 Vdout0_42ck9 = 0 time = 50
.meas tran vdout0_42ck9 FIND v(dout0_42) AT=50.025n

* CHECK dout0_43 Vdout0_43ck9 = 0.9 time = 50
.meas tran vdout0_43ck9 FIND v(dout0_43) AT=50.025n

* CHECK dout0_44 Vdout0_44ck9 = 0.9 time = 50
.meas tran vdout0_44ck9 FIND v(dout0_44) AT=50.025n

* CHECK dout0_45 Vdout0_45ck9 = 0.9 time = 50
.meas tran vdout0_45ck9 FIND v(dout0_45) AT=50.025n

* CHECK dout0_46 Vdout0_46ck9 = 0 time = 50
.meas tran vdout0_46ck9 FIND v(dout0_46) AT=50.025n

* CHECK dout0_47 Vdout0_47ck9 = 0 time = 50
.meas tran vdout0_47ck9 FIND v(dout0_47) AT=50.025n

* CHECK dout0_48 Vdout0_48ck9 = 0.9 time = 50
.meas tran vdout0_48ck9 FIND v(dout0_48) AT=50.025n

* CHECK dout0_49 Vdout0_49ck9 = 0 time = 50
.meas tran vdout0_49ck9 FIND v(dout0_49) AT=50.025n

* CHECK dout0_50 Vdout0_50ck9 = 0 time = 50
.meas tran vdout0_50ck9 FIND v(dout0_50) AT=50.025n

* CHECK dout0_51 Vdout0_51ck9 = 0.9 time = 50
.meas tran vdout0_51ck9 FIND v(dout0_51) AT=50.025n

* CHECK dout0_52 Vdout0_52ck9 = 0 time = 50
.meas tran vdout0_52ck9 FIND v(dout0_52) AT=50.025n

* CHECK dout0_53 Vdout0_53ck9 = 0 time = 50
.meas tran vdout0_53ck9 FIND v(dout0_53) AT=50.025n

* CHECK dout0_54 Vdout0_54ck9 = 0 time = 50
.meas tran vdout0_54ck9 FIND v(dout0_54) AT=50.025n

* CHECK dout0_55 Vdout0_55ck9 = 0 time = 50
.meas tran vdout0_55ck9 FIND v(dout0_55) AT=50.025n

* CHECK dout0_56 Vdout0_56ck9 = 0 time = 50
.meas tran vdout0_56ck9 FIND v(dout0_56) AT=50.025n

* CHECK dout0_57 Vdout0_57ck9 = 0.9 time = 50
.meas tran vdout0_57ck9 FIND v(dout0_57) AT=50.025n

* CHECK dout0_58 Vdout0_58ck9 = 0 time = 50
.meas tran vdout0_58ck9 FIND v(dout0_58) AT=50.025n

* CHECK dout0_59 Vdout0_59ck9 = 0.9 time = 50
.meas tran vdout0_59ck9 FIND v(dout0_59) AT=50.025n

* CHECK dout0_60 Vdout0_60ck9 = 0 time = 50
.meas tran vdout0_60ck9 FIND v(dout0_60) AT=50.025n

* CHECK dout0_61 Vdout0_61ck9 = 0 time = 50
.meas tran vdout0_61ck9 FIND v(dout0_61) AT=50.025n

* CHECK dout0_62 Vdout0_62ck9 = 0 time = 50
.meas tran vdout0_62ck9 FIND v(dout0_62) AT=50.025n

* CHECK dout0_63 Vdout0_63ck9 = 0.9 time = 50
.meas tran vdout0_63ck9 FIND v(dout0_63) AT=50.025n

* CHECK dout0_64 Vdout0_64ck9 = 0.9 time = 50
.meas tran vdout0_64ck9 FIND v(dout0_64) AT=50.025n

* CHECK dout0_65 Vdout0_65ck9 = 0.9 time = 50
.meas tran vdout0_65ck9 FIND v(dout0_65) AT=50.025n

* CHECK dout0_66 Vdout0_66ck9 = 0.9 time = 50
.meas tran vdout0_66ck9 FIND v(dout0_66) AT=50.025n

* CHECK dout0_67 Vdout0_67ck9 = 0.9 time = 50
.meas tran vdout0_67ck9 FIND v(dout0_67) AT=50.025n

* CHECK dout0_68 Vdout0_68ck9 = 0.9 time = 50
.meas tran vdout0_68ck9 FIND v(dout0_68) AT=50.025n

* CHECK dout0_69 Vdout0_69ck9 = 0.9 time = 50
.meas tran vdout0_69ck9 FIND v(dout0_69) AT=50.025n

* CHECK dout0_70 Vdout0_70ck9 = 0.9 time = 50
.meas tran vdout0_70ck9 FIND v(dout0_70) AT=50.025n

* CHECK dout0_71 Vdout0_71ck9 = 0.9 time = 50
.meas tran vdout0_71ck9 FIND v(dout0_71) AT=50.025n

* CHECK dout0_72 Vdout0_72ck9 = 0 time = 50
.meas tran vdout0_72ck9 FIND v(dout0_72) AT=50.025n

* CHECK dout0_73 Vdout0_73ck9 = 0.9 time = 50
.meas tran vdout0_73ck9 FIND v(dout0_73) AT=50.025n

* CHECK dout0_74 Vdout0_74ck9 = 0 time = 50
.meas tran vdout0_74ck9 FIND v(dout0_74) AT=50.025n

* CHECK dout0_75 Vdout0_75ck9 = 0.9 time = 50
.meas tran vdout0_75ck9 FIND v(dout0_75) AT=50.025n

* CHECK dout0_76 Vdout0_76ck9 = 0.9 time = 50
.meas tran vdout0_76ck9 FIND v(dout0_76) AT=50.025n

* CHECK dout0_77 Vdout0_77ck9 = 0.9 time = 50
.meas tran vdout0_77ck9 FIND v(dout0_77) AT=50.025n

* CHECK dout0_78 Vdout0_78ck9 = 0.9 time = 50
.meas tran vdout0_78ck9 FIND v(dout0_78) AT=50.025n

* CHECK dout0_79 Vdout0_79ck9 = 0.9 time = 50
.meas tran vdout0_79ck9 FIND v(dout0_79) AT=50.025n

* CHECK dout0_80 Vdout0_80ck9 = 0 time = 50
.meas tran vdout0_80ck9 FIND v(dout0_80) AT=50.025n

* CHECK dout0_81 Vdout0_81ck9 = 0.9 time = 50
.meas tran vdout0_81ck9 FIND v(dout0_81) AT=50.025n

* CHECK dout0_82 Vdout0_82ck9 = 0 time = 50
.meas tran vdout0_82ck9 FIND v(dout0_82) AT=50.025n

* CHECK dout0_83 Vdout0_83ck9 = 0.9 time = 50
.meas tran vdout0_83ck9 FIND v(dout0_83) AT=50.025n

* CHECK dout0_84 Vdout0_84ck9 = 0.9 time = 50
.meas tran vdout0_84ck9 FIND v(dout0_84) AT=50.025n

* CHECK dout0_85 Vdout0_85ck9 = 0 time = 50
.meas tran vdout0_85ck9 FIND v(dout0_85) AT=50.025n

* CHECK dout0_86 Vdout0_86ck9 = 0 time = 50
.meas tran vdout0_86ck9 FIND v(dout0_86) AT=50.025n

* CHECK dout0_87 Vdout0_87ck9 = 0 time = 50
.meas tran vdout0_87ck9 FIND v(dout0_87) AT=50.025n

* CHECK dout0_0 Vdout0_0ck13 = 0 time = 70
.meas tran vdout0_0ck13 FIND v(dout0_0) AT=70.025n

* CHECK dout0_1 Vdout0_1ck13 = 0 time = 70
.meas tran vdout0_1ck13 FIND v(dout0_1) AT=70.025n

* CHECK dout0_2 Vdout0_2ck13 = 0 time = 70
.meas tran vdout0_2ck13 FIND v(dout0_2) AT=70.025n

* CHECK dout0_3 Vdout0_3ck13 = 0.9 time = 70
.meas tran vdout0_3ck13 FIND v(dout0_3) AT=70.025n

* CHECK dout0_4 Vdout0_4ck13 = 0 time = 70
.meas tran vdout0_4ck13 FIND v(dout0_4) AT=70.025n

* CHECK dout0_5 Vdout0_5ck13 = 0 time = 70
.meas tran vdout0_5ck13 FIND v(dout0_5) AT=70.025n

* CHECK dout0_6 Vdout0_6ck13 = 0 time = 70
.meas tran vdout0_6ck13 FIND v(dout0_6) AT=70.025n

* CHECK dout0_7 Vdout0_7ck13 = 0.9 time = 70
.meas tran vdout0_7ck13 FIND v(dout0_7) AT=70.025n

* CHECK dout0_8 Vdout0_8ck13 = 0.9 time = 70
.meas tran vdout0_8ck13 FIND v(dout0_8) AT=70.025n

* CHECK dout0_9 Vdout0_9ck13 = 0 time = 70
.meas tran vdout0_9ck13 FIND v(dout0_9) AT=70.025n

* CHECK dout0_10 Vdout0_10ck13 = 0 time = 70
.meas tran vdout0_10ck13 FIND v(dout0_10) AT=70.025n

* CHECK dout0_11 Vdout0_11ck13 = 0.9 time = 70
.meas tran vdout0_11ck13 FIND v(dout0_11) AT=70.025n

* CHECK dout0_12 Vdout0_12ck13 = 0.9 time = 70
.meas tran vdout0_12ck13 FIND v(dout0_12) AT=70.025n

* CHECK dout0_13 Vdout0_13ck13 = 0 time = 70
.meas tran vdout0_13ck13 FIND v(dout0_13) AT=70.025n

* CHECK dout0_14 Vdout0_14ck13 = 0.9 time = 70
.meas tran vdout0_14ck13 FIND v(dout0_14) AT=70.025n

* CHECK dout0_15 Vdout0_15ck13 = 0 time = 70
.meas tran vdout0_15ck13 FIND v(dout0_15) AT=70.025n

* CHECK dout0_16 Vdout0_16ck13 = 0 time = 70
.meas tran vdout0_16ck13 FIND v(dout0_16) AT=70.025n

* CHECK dout0_17 Vdout0_17ck13 = 0.9 time = 70
.meas tran vdout0_17ck13 FIND v(dout0_17) AT=70.025n

* CHECK dout0_18 Vdout0_18ck13 = 0 time = 70
.meas tran vdout0_18ck13 FIND v(dout0_18) AT=70.025n

* CHECK dout0_19 Vdout0_19ck13 = 0.9 time = 70
.meas tran vdout0_19ck13 FIND v(dout0_19) AT=70.025n

* CHECK dout0_20 Vdout0_20ck13 = 0 time = 70
.meas tran vdout0_20ck13 FIND v(dout0_20) AT=70.025n

* CHECK dout0_21 Vdout0_21ck13 = 0.9 time = 70
.meas tran vdout0_21ck13 FIND v(dout0_21) AT=70.025n

* CHECK dout0_22 Vdout0_22ck13 = 0 time = 70
.meas tran vdout0_22ck13 FIND v(dout0_22) AT=70.025n

* CHECK dout0_23 Vdout0_23ck13 = 0 time = 70
.meas tran vdout0_23ck13 FIND v(dout0_23) AT=70.025n

* CHECK dout0_24 Vdout0_24ck13 = 0 time = 70
.meas tran vdout0_24ck13 FIND v(dout0_24) AT=70.025n

* CHECK dout0_25 Vdout0_25ck13 = 0 time = 70
.meas tran vdout0_25ck13 FIND v(dout0_25) AT=70.025n

* CHECK dout0_26 Vdout0_26ck13 = 0 time = 70
.meas tran vdout0_26ck13 FIND v(dout0_26) AT=70.025n

* CHECK dout0_27 Vdout0_27ck13 = 0.9 time = 70
.meas tran vdout0_27ck13 FIND v(dout0_27) AT=70.025n

* CHECK dout0_28 Vdout0_28ck13 = 0.9 time = 70
.meas tran vdout0_28ck13 FIND v(dout0_28) AT=70.025n

* CHECK dout0_29 Vdout0_29ck13 = 0.9 time = 70
.meas tran vdout0_29ck13 FIND v(dout0_29) AT=70.025n

* CHECK dout0_30 Vdout0_30ck13 = 0.9 time = 70
.meas tran vdout0_30ck13 FIND v(dout0_30) AT=70.025n

* CHECK dout0_31 Vdout0_31ck13 = 0 time = 70
.meas tran vdout0_31ck13 FIND v(dout0_31) AT=70.025n

* CHECK dout0_32 Vdout0_32ck13 = 0 time = 70
.meas tran vdout0_32ck13 FIND v(dout0_32) AT=70.025n

* CHECK dout0_33 Vdout0_33ck13 = 0.9 time = 70
.meas tran vdout0_33ck13 FIND v(dout0_33) AT=70.025n

* CHECK dout0_34 Vdout0_34ck13 = 0 time = 70
.meas tran vdout0_34ck13 FIND v(dout0_34) AT=70.025n

* CHECK dout0_35 Vdout0_35ck13 = 0 time = 70
.meas tran vdout0_35ck13 FIND v(dout0_35) AT=70.025n

* CHECK dout0_36 Vdout0_36ck13 = 0 time = 70
.meas tran vdout0_36ck13 FIND v(dout0_36) AT=70.025n

* CHECK dout0_37 Vdout0_37ck13 = 0.9 time = 70
.meas tran vdout0_37ck13 FIND v(dout0_37) AT=70.025n

* CHECK dout0_38 Vdout0_38ck13 = 0 time = 70
.meas tran vdout0_38ck13 FIND v(dout0_38) AT=70.025n

* CHECK dout0_39 Vdout0_39ck13 = 0.9 time = 70
.meas tran vdout0_39ck13 FIND v(dout0_39) AT=70.025n

* CHECK dout0_40 Vdout0_40ck13 = 0 time = 70
.meas tran vdout0_40ck13 FIND v(dout0_40) AT=70.025n

* CHECK dout0_41 Vdout0_41ck13 = 0.9 time = 70
.meas tran vdout0_41ck13 FIND v(dout0_41) AT=70.025n

* CHECK dout0_42 Vdout0_42ck13 = 0.9 time = 70
.meas tran vdout0_42ck13 FIND v(dout0_42) AT=70.025n

* CHECK dout0_43 Vdout0_43ck13 = 0.9 time = 70
.meas tran vdout0_43ck13 FIND v(dout0_43) AT=70.025n

* CHECK dout0_44 Vdout0_44ck13 = 0.9 time = 70
.meas tran vdout0_44ck13 FIND v(dout0_44) AT=70.025n

* CHECK dout0_45 Vdout0_45ck13 = 0.9 time = 70
.meas tran vdout0_45ck13 FIND v(dout0_45) AT=70.025n

* CHECK dout0_46 Vdout0_46ck13 = 0 time = 70
.meas tran vdout0_46ck13 FIND v(dout0_46) AT=70.025n

* CHECK dout0_47 Vdout0_47ck13 = 0 time = 70
.meas tran vdout0_47ck13 FIND v(dout0_47) AT=70.025n

* CHECK dout0_48 Vdout0_48ck13 = 0.9 time = 70
.meas tran vdout0_48ck13 FIND v(dout0_48) AT=70.025n

* CHECK dout0_49 Vdout0_49ck13 = 0 time = 70
.meas tran vdout0_49ck13 FIND v(dout0_49) AT=70.025n

* CHECK dout0_50 Vdout0_50ck13 = 0.9 time = 70
.meas tran vdout0_50ck13 FIND v(dout0_50) AT=70.025n

* CHECK dout0_51 Vdout0_51ck13 = 0 time = 70
.meas tran vdout0_51ck13 FIND v(dout0_51) AT=70.025n

* CHECK dout0_52 Vdout0_52ck13 = 0.9 time = 70
.meas tran vdout0_52ck13 FIND v(dout0_52) AT=70.025n

* CHECK dout0_53 Vdout0_53ck13 = 0.9 time = 70
.meas tran vdout0_53ck13 FIND v(dout0_53) AT=70.025n

* CHECK dout0_54 Vdout0_54ck13 = 0.9 time = 70
.meas tran vdout0_54ck13 FIND v(dout0_54) AT=70.025n

* CHECK dout0_55 Vdout0_55ck13 = 0.9 time = 70
.meas tran vdout0_55ck13 FIND v(dout0_55) AT=70.025n

* CHECK dout0_56 Vdout0_56ck13 = 0.9 time = 70
.meas tran vdout0_56ck13 FIND v(dout0_56) AT=70.025n

* CHECK dout0_57 Vdout0_57ck13 = 0.9 time = 70
.meas tran vdout0_57ck13 FIND v(dout0_57) AT=70.025n

* CHECK dout0_58 Vdout0_58ck13 = 0 time = 70
.meas tran vdout0_58ck13 FIND v(dout0_58) AT=70.025n

* CHECK dout0_59 Vdout0_59ck13 = 0 time = 70
.meas tran vdout0_59ck13 FIND v(dout0_59) AT=70.025n

* CHECK dout0_60 Vdout0_60ck13 = 0 time = 70
.meas tran vdout0_60ck13 FIND v(dout0_60) AT=70.025n

* CHECK dout0_61 Vdout0_61ck13 = 0 time = 70
.meas tran vdout0_61ck13 FIND v(dout0_61) AT=70.025n

* CHECK dout0_62 Vdout0_62ck13 = 0 time = 70
.meas tran vdout0_62ck13 FIND v(dout0_62) AT=70.025n

* CHECK dout0_63 Vdout0_63ck13 = 0.9 time = 70
.meas tran vdout0_63ck13 FIND v(dout0_63) AT=70.025n

* CHECK dout0_64 Vdout0_64ck13 = 0 time = 70
.meas tran vdout0_64ck13 FIND v(dout0_64) AT=70.025n

* CHECK dout0_65 Vdout0_65ck13 = 0.9 time = 70
.meas tran vdout0_65ck13 FIND v(dout0_65) AT=70.025n

* CHECK dout0_66 Vdout0_66ck13 = 0.9 time = 70
.meas tran vdout0_66ck13 FIND v(dout0_66) AT=70.025n

* CHECK dout0_67 Vdout0_67ck13 = 0.9 time = 70
.meas tran vdout0_67ck13 FIND v(dout0_67) AT=70.025n

* CHECK dout0_68 Vdout0_68ck13 = 0.9 time = 70
.meas tran vdout0_68ck13 FIND v(dout0_68) AT=70.025n

* CHECK dout0_69 Vdout0_69ck13 = 0 time = 70
.meas tran vdout0_69ck13 FIND v(dout0_69) AT=70.025n

* CHECK dout0_70 Vdout0_70ck13 = 0.9 time = 70
.meas tran vdout0_70ck13 FIND v(dout0_70) AT=70.025n

* CHECK dout0_71 Vdout0_71ck13 = 0.9 time = 70
.meas tran vdout0_71ck13 FIND v(dout0_71) AT=70.025n

* CHECK dout0_72 Vdout0_72ck13 = 0 time = 70
.meas tran vdout0_72ck13 FIND v(dout0_72) AT=70.025n

* CHECK dout0_73 Vdout0_73ck13 = 0.9 time = 70
.meas tran vdout0_73ck13 FIND v(dout0_73) AT=70.025n

* CHECK dout0_74 Vdout0_74ck13 = 0.9 time = 70
.meas tran vdout0_74ck13 FIND v(dout0_74) AT=70.025n

* CHECK dout0_75 Vdout0_75ck13 = 0 time = 70
.meas tran vdout0_75ck13 FIND v(dout0_75) AT=70.025n

* CHECK dout0_76 Vdout0_76ck13 = 0 time = 70
.meas tran vdout0_76ck13 FIND v(dout0_76) AT=70.025n

* CHECK dout0_77 Vdout0_77ck13 = 0 time = 70
.meas tran vdout0_77ck13 FIND v(dout0_77) AT=70.025n

* CHECK dout0_78 Vdout0_78ck13 = 0 time = 70
.meas tran vdout0_78ck13 FIND v(dout0_78) AT=70.025n

* CHECK dout0_79 Vdout0_79ck13 = 0.9 time = 70
.meas tran vdout0_79ck13 FIND v(dout0_79) AT=70.025n

* CHECK dout0_80 Vdout0_80ck13 = 0.9 time = 70
.meas tran vdout0_80ck13 FIND v(dout0_80) AT=70.025n

* CHECK dout0_81 Vdout0_81ck13 = 0.9 time = 70
.meas tran vdout0_81ck13 FIND v(dout0_81) AT=70.025n

* CHECK dout0_82 Vdout0_82ck13 = 0 time = 70
.meas tran vdout0_82ck13 FIND v(dout0_82) AT=70.025n

* CHECK dout0_83 Vdout0_83ck13 = 0 time = 70
.meas tran vdout0_83ck13 FIND v(dout0_83) AT=70.025n

* CHECK dout0_84 Vdout0_84ck13 = 0.9 time = 70
.meas tran vdout0_84ck13 FIND v(dout0_84) AT=70.025n

* CHECK dout0_85 Vdout0_85ck13 = 0 time = 70
.meas tran vdout0_85ck13 FIND v(dout0_85) AT=70.025n

* CHECK dout0_86 Vdout0_86ck13 = 0 time = 70
.meas tran vdout0_86ck13 FIND v(dout0_86) AT=70.025n

* CHECK dout0_87 Vdout0_87ck13 = 0 time = 70
.meas tran vdout0_87ck13 FIND v(dout0_87) AT=70.025n

* CHECK dout0_0 Vdout0_0ck15 = 0 time = 80
.meas tran vdout0_0ck15 FIND v(dout0_0) AT=80.025n

* CHECK dout0_1 Vdout0_1ck15 = 0 time = 80
.meas tran vdout0_1ck15 FIND v(dout0_1) AT=80.025n

* CHECK dout0_2 Vdout0_2ck15 = 0 time = 80
.meas tran vdout0_2ck15 FIND v(dout0_2) AT=80.025n

* CHECK dout0_3 Vdout0_3ck15 = 0.9 time = 80
.meas tran vdout0_3ck15 FIND v(dout0_3) AT=80.025n

* CHECK dout0_4 Vdout0_4ck15 = 0 time = 80
.meas tran vdout0_4ck15 FIND v(dout0_4) AT=80.025n

* CHECK dout0_5 Vdout0_5ck15 = 0 time = 80
.meas tran vdout0_5ck15 FIND v(dout0_5) AT=80.025n

* CHECK dout0_6 Vdout0_6ck15 = 0 time = 80
.meas tran vdout0_6ck15 FIND v(dout0_6) AT=80.025n

* CHECK dout0_7 Vdout0_7ck15 = 0.9 time = 80
.meas tran vdout0_7ck15 FIND v(dout0_7) AT=80.025n

* CHECK dout0_8 Vdout0_8ck15 = 0.9 time = 80
.meas tran vdout0_8ck15 FIND v(dout0_8) AT=80.025n

* CHECK dout0_9 Vdout0_9ck15 = 0 time = 80
.meas tran vdout0_9ck15 FIND v(dout0_9) AT=80.025n

* CHECK dout0_10 Vdout0_10ck15 = 0 time = 80
.meas tran vdout0_10ck15 FIND v(dout0_10) AT=80.025n

* CHECK dout0_11 Vdout0_11ck15 = 0.9 time = 80
.meas tran vdout0_11ck15 FIND v(dout0_11) AT=80.025n

* CHECK dout0_12 Vdout0_12ck15 = 0.9 time = 80
.meas tran vdout0_12ck15 FIND v(dout0_12) AT=80.025n

* CHECK dout0_13 Vdout0_13ck15 = 0 time = 80
.meas tran vdout0_13ck15 FIND v(dout0_13) AT=80.025n

* CHECK dout0_14 Vdout0_14ck15 = 0.9 time = 80
.meas tran vdout0_14ck15 FIND v(dout0_14) AT=80.025n

* CHECK dout0_15 Vdout0_15ck15 = 0 time = 80
.meas tran vdout0_15ck15 FIND v(dout0_15) AT=80.025n

* CHECK dout0_16 Vdout0_16ck15 = 0 time = 80
.meas tran vdout0_16ck15 FIND v(dout0_16) AT=80.025n

* CHECK dout0_17 Vdout0_17ck15 = 0.9 time = 80
.meas tran vdout0_17ck15 FIND v(dout0_17) AT=80.025n

* CHECK dout0_18 Vdout0_18ck15 = 0 time = 80
.meas tran vdout0_18ck15 FIND v(dout0_18) AT=80.025n

* CHECK dout0_19 Vdout0_19ck15 = 0.9 time = 80
.meas tran vdout0_19ck15 FIND v(dout0_19) AT=80.025n

* CHECK dout0_20 Vdout0_20ck15 = 0 time = 80
.meas tran vdout0_20ck15 FIND v(dout0_20) AT=80.025n

* CHECK dout0_21 Vdout0_21ck15 = 0.9 time = 80
.meas tran vdout0_21ck15 FIND v(dout0_21) AT=80.025n

* CHECK dout0_22 Vdout0_22ck15 = 0 time = 80
.meas tran vdout0_22ck15 FIND v(dout0_22) AT=80.025n

* CHECK dout0_23 Vdout0_23ck15 = 0 time = 80
.meas tran vdout0_23ck15 FIND v(dout0_23) AT=80.025n

* CHECK dout0_24 Vdout0_24ck15 = 0 time = 80
.meas tran vdout0_24ck15 FIND v(dout0_24) AT=80.025n

* CHECK dout0_25 Vdout0_25ck15 = 0 time = 80
.meas tran vdout0_25ck15 FIND v(dout0_25) AT=80.025n

* CHECK dout0_26 Vdout0_26ck15 = 0 time = 80
.meas tran vdout0_26ck15 FIND v(dout0_26) AT=80.025n

* CHECK dout0_27 Vdout0_27ck15 = 0.9 time = 80
.meas tran vdout0_27ck15 FIND v(dout0_27) AT=80.025n

* CHECK dout0_28 Vdout0_28ck15 = 0.9 time = 80
.meas tran vdout0_28ck15 FIND v(dout0_28) AT=80.025n

* CHECK dout0_29 Vdout0_29ck15 = 0.9 time = 80
.meas tran vdout0_29ck15 FIND v(dout0_29) AT=80.025n

* CHECK dout0_30 Vdout0_30ck15 = 0.9 time = 80
.meas tran vdout0_30ck15 FIND v(dout0_30) AT=80.025n

* CHECK dout0_31 Vdout0_31ck15 = 0 time = 80
.meas tran vdout0_31ck15 FIND v(dout0_31) AT=80.025n

* CHECK dout0_32 Vdout0_32ck15 = 0 time = 80
.meas tran vdout0_32ck15 FIND v(dout0_32) AT=80.025n

* CHECK dout0_33 Vdout0_33ck15 = 0.9 time = 80
.meas tran vdout0_33ck15 FIND v(dout0_33) AT=80.025n

* CHECK dout0_34 Vdout0_34ck15 = 0 time = 80
.meas tran vdout0_34ck15 FIND v(dout0_34) AT=80.025n

* CHECK dout0_35 Vdout0_35ck15 = 0 time = 80
.meas tran vdout0_35ck15 FIND v(dout0_35) AT=80.025n

* CHECK dout0_36 Vdout0_36ck15 = 0 time = 80
.meas tran vdout0_36ck15 FIND v(dout0_36) AT=80.025n

* CHECK dout0_37 Vdout0_37ck15 = 0.9 time = 80
.meas tran vdout0_37ck15 FIND v(dout0_37) AT=80.025n

* CHECK dout0_38 Vdout0_38ck15 = 0 time = 80
.meas tran vdout0_38ck15 FIND v(dout0_38) AT=80.025n

* CHECK dout0_39 Vdout0_39ck15 = 0.9 time = 80
.meas tran vdout0_39ck15 FIND v(dout0_39) AT=80.025n

* CHECK dout0_40 Vdout0_40ck15 = 0 time = 80
.meas tran vdout0_40ck15 FIND v(dout0_40) AT=80.025n

* CHECK dout0_41 Vdout0_41ck15 = 0.9 time = 80
.meas tran vdout0_41ck15 FIND v(dout0_41) AT=80.025n

* CHECK dout0_42 Vdout0_42ck15 = 0.9 time = 80
.meas tran vdout0_42ck15 FIND v(dout0_42) AT=80.025n

* CHECK dout0_43 Vdout0_43ck15 = 0.9 time = 80
.meas tran vdout0_43ck15 FIND v(dout0_43) AT=80.025n

* CHECK dout0_44 Vdout0_44ck15 = 0.9 time = 80
.meas tran vdout0_44ck15 FIND v(dout0_44) AT=80.025n

* CHECK dout0_45 Vdout0_45ck15 = 0.9 time = 80
.meas tran vdout0_45ck15 FIND v(dout0_45) AT=80.025n

* CHECK dout0_46 Vdout0_46ck15 = 0 time = 80
.meas tran vdout0_46ck15 FIND v(dout0_46) AT=80.025n

* CHECK dout0_47 Vdout0_47ck15 = 0 time = 80
.meas tran vdout0_47ck15 FIND v(dout0_47) AT=80.025n

* CHECK dout0_48 Vdout0_48ck15 = 0.9 time = 80
.meas tran vdout0_48ck15 FIND v(dout0_48) AT=80.025n

* CHECK dout0_49 Vdout0_49ck15 = 0 time = 80
.meas tran vdout0_49ck15 FIND v(dout0_49) AT=80.025n

* CHECK dout0_50 Vdout0_50ck15 = 0.9 time = 80
.meas tran vdout0_50ck15 FIND v(dout0_50) AT=80.025n

* CHECK dout0_51 Vdout0_51ck15 = 0 time = 80
.meas tran vdout0_51ck15 FIND v(dout0_51) AT=80.025n

* CHECK dout0_52 Vdout0_52ck15 = 0.9 time = 80
.meas tran vdout0_52ck15 FIND v(dout0_52) AT=80.025n

* CHECK dout0_53 Vdout0_53ck15 = 0.9 time = 80
.meas tran vdout0_53ck15 FIND v(dout0_53) AT=80.025n

* CHECK dout0_54 Vdout0_54ck15 = 0.9 time = 80
.meas tran vdout0_54ck15 FIND v(dout0_54) AT=80.025n

* CHECK dout0_55 Vdout0_55ck15 = 0.9 time = 80
.meas tran vdout0_55ck15 FIND v(dout0_55) AT=80.025n

* CHECK dout0_56 Vdout0_56ck15 = 0.9 time = 80
.meas tran vdout0_56ck15 FIND v(dout0_56) AT=80.025n

* CHECK dout0_57 Vdout0_57ck15 = 0.9 time = 80
.meas tran vdout0_57ck15 FIND v(dout0_57) AT=80.025n

* CHECK dout0_58 Vdout0_58ck15 = 0 time = 80
.meas tran vdout0_58ck15 FIND v(dout0_58) AT=80.025n

* CHECK dout0_59 Vdout0_59ck15 = 0 time = 80
.meas tran vdout0_59ck15 FIND v(dout0_59) AT=80.025n

* CHECK dout0_60 Vdout0_60ck15 = 0 time = 80
.meas tran vdout0_60ck15 FIND v(dout0_60) AT=80.025n

* CHECK dout0_61 Vdout0_61ck15 = 0 time = 80
.meas tran vdout0_61ck15 FIND v(dout0_61) AT=80.025n

* CHECK dout0_62 Vdout0_62ck15 = 0 time = 80
.meas tran vdout0_62ck15 FIND v(dout0_62) AT=80.025n

* CHECK dout0_63 Vdout0_63ck15 = 0.9 time = 80
.meas tran vdout0_63ck15 FIND v(dout0_63) AT=80.025n

* CHECK dout0_64 Vdout0_64ck15 = 0 time = 80
.meas tran vdout0_64ck15 FIND v(dout0_64) AT=80.025n

* CHECK dout0_65 Vdout0_65ck15 = 0.9 time = 80
.meas tran vdout0_65ck15 FIND v(dout0_65) AT=80.025n

* CHECK dout0_66 Vdout0_66ck15 = 0.9 time = 80
.meas tran vdout0_66ck15 FIND v(dout0_66) AT=80.025n

* CHECK dout0_67 Vdout0_67ck15 = 0.9 time = 80
.meas tran vdout0_67ck15 FIND v(dout0_67) AT=80.025n

* CHECK dout0_68 Vdout0_68ck15 = 0.9 time = 80
.meas tran vdout0_68ck15 FIND v(dout0_68) AT=80.025n

* CHECK dout0_69 Vdout0_69ck15 = 0 time = 80
.meas tran vdout0_69ck15 FIND v(dout0_69) AT=80.025n

* CHECK dout0_70 Vdout0_70ck15 = 0.9 time = 80
.meas tran vdout0_70ck15 FIND v(dout0_70) AT=80.025n

* CHECK dout0_71 Vdout0_71ck15 = 0.9 time = 80
.meas tran vdout0_71ck15 FIND v(dout0_71) AT=80.025n

* CHECK dout0_72 Vdout0_72ck15 = 0 time = 80
.meas tran vdout0_72ck15 FIND v(dout0_72) AT=80.025n

* CHECK dout0_73 Vdout0_73ck15 = 0.9 time = 80
.meas tran vdout0_73ck15 FIND v(dout0_73) AT=80.025n

* CHECK dout0_74 Vdout0_74ck15 = 0.9 time = 80
.meas tran vdout0_74ck15 FIND v(dout0_74) AT=80.025n

* CHECK dout0_75 Vdout0_75ck15 = 0 time = 80
.meas tran vdout0_75ck15 FIND v(dout0_75) AT=80.025n

* CHECK dout0_76 Vdout0_76ck15 = 0 time = 80
.meas tran vdout0_76ck15 FIND v(dout0_76) AT=80.025n

* CHECK dout0_77 Vdout0_77ck15 = 0 time = 80
.meas tran vdout0_77ck15 FIND v(dout0_77) AT=80.025n

* CHECK dout0_78 Vdout0_78ck15 = 0 time = 80
.meas tran vdout0_78ck15 FIND v(dout0_78) AT=80.025n

* CHECK dout0_79 Vdout0_79ck15 = 0.9 time = 80
.meas tran vdout0_79ck15 FIND v(dout0_79) AT=80.025n

* CHECK dout0_80 Vdout0_80ck15 = 0.9 time = 80
.meas tran vdout0_80ck15 FIND v(dout0_80) AT=80.025n

* CHECK dout0_81 Vdout0_81ck15 = 0.9 time = 80
.meas tran vdout0_81ck15 FIND v(dout0_81) AT=80.025n

* CHECK dout0_82 Vdout0_82ck15 = 0 time = 80
.meas tran vdout0_82ck15 FIND v(dout0_82) AT=80.025n

* CHECK dout0_83 Vdout0_83ck15 = 0 time = 80
.meas tran vdout0_83ck15 FIND v(dout0_83) AT=80.025n

* CHECK dout0_84 Vdout0_84ck15 = 0.9 time = 80
.meas tran vdout0_84ck15 FIND v(dout0_84) AT=80.025n

* CHECK dout0_85 Vdout0_85ck15 = 0 time = 80
.meas tran vdout0_85ck15 FIND v(dout0_85) AT=80.025n

* CHECK dout0_86 Vdout0_86ck15 = 0 time = 80
.meas tran vdout0_86ck15 FIND v(dout0_86) AT=80.025n

* CHECK dout0_87 Vdout0_87ck15 = 0 time = 80
.meas tran vdout0_87ck15 FIND v(dout0_87) AT=80.025n

* CHECK dout0_0 Vdout0_0ck18 = 0 time = 95
.meas tran vdout0_0ck18 FIND v(dout0_0) AT=95.025n

* CHECK dout0_1 Vdout0_1ck18 = 0.9 time = 95
.meas tran vdout0_1ck18 FIND v(dout0_1) AT=95.025n

* CHECK dout0_2 Vdout0_2ck18 = 0.9 time = 95
.meas tran vdout0_2ck18 FIND v(dout0_2) AT=95.025n

* CHECK dout0_3 Vdout0_3ck18 = 0.9 time = 95
.meas tran vdout0_3ck18 FIND v(dout0_3) AT=95.025n

* CHECK dout0_4 Vdout0_4ck18 = 0.9 time = 95
.meas tran vdout0_4ck18 FIND v(dout0_4) AT=95.025n

* CHECK dout0_5 Vdout0_5ck18 = 0.9 time = 95
.meas tran vdout0_5ck18 FIND v(dout0_5) AT=95.025n

* CHECK dout0_6 Vdout0_6ck18 = 0 time = 95
.meas tran vdout0_6ck18 FIND v(dout0_6) AT=95.025n

* CHECK dout0_7 Vdout0_7ck18 = 0.9 time = 95
.meas tran vdout0_7ck18 FIND v(dout0_7) AT=95.025n

* CHECK dout0_8 Vdout0_8ck18 = 0.9 time = 95
.meas tran vdout0_8ck18 FIND v(dout0_8) AT=95.025n

* CHECK dout0_9 Vdout0_9ck18 = 0 time = 95
.meas tran vdout0_9ck18 FIND v(dout0_9) AT=95.025n

* CHECK dout0_10 Vdout0_10ck18 = 0 time = 95
.meas tran vdout0_10ck18 FIND v(dout0_10) AT=95.025n

* CHECK dout0_11 Vdout0_11ck18 = 0 time = 95
.meas tran vdout0_11ck18 FIND v(dout0_11) AT=95.025n

* CHECK dout0_12 Vdout0_12ck18 = 0.9 time = 95
.meas tran vdout0_12ck18 FIND v(dout0_12) AT=95.025n

* CHECK dout0_13 Vdout0_13ck18 = 0.9 time = 95
.meas tran vdout0_13ck18 FIND v(dout0_13) AT=95.025n

* CHECK dout0_14 Vdout0_14ck18 = 0.9 time = 95
.meas tran vdout0_14ck18 FIND v(dout0_14) AT=95.025n

* CHECK dout0_15 Vdout0_15ck18 = 0.9 time = 95
.meas tran vdout0_15ck18 FIND v(dout0_15) AT=95.025n

* CHECK dout0_16 Vdout0_16ck18 = 0 time = 95
.meas tran vdout0_16ck18 FIND v(dout0_16) AT=95.025n

* CHECK dout0_17 Vdout0_17ck18 = 0 time = 95
.meas tran vdout0_17ck18 FIND v(dout0_17) AT=95.025n

* CHECK dout0_18 Vdout0_18ck18 = 0.9 time = 95
.meas tran vdout0_18ck18 FIND v(dout0_18) AT=95.025n

* CHECK dout0_19 Vdout0_19ck18 = 0 time = 95
.meas tran vdout0_19ck18 FIND v(dout0_19) AT=95.025n

* CHECK dout0_20 Vdout0_20ck18 = 0 time = 95
.meas tran vdout0_20ck18 FIND v(dout0_20) AT=95.025n

* CHECK dout0_21 Vdout0_21ck18 = 0.9 time = 95
.meas tran vdout0_21ck18 FIND v(dout0_21) AT=95.025n

* CHECK dout0_22 Vdout0_22ck18 = 0.9 time = 95
.meas tran vdout0_22ck18 FIND v(dout0_22) AT=95.025n

* CHECK dout0_23 Vdout0_23ck18 = 0.9 time = 95
.meas tran vdout0_23ck18 FIND v(dout0_23) AT=95.025n

* CHECK dout0_24 Vdout0_24ck18 = 0 time = 95
.meas tran vdout0_24ck18 FIND v(dout0_24) AT=95.025n

* CHECK dout0_25 Vdout0_25ck18 = 0.9 time = 95
.meas tran vdout0_25ck18 FIND v(dout0_25) AT=95.025n

* CHECK dout0_26 Vdout0_26ck18 = 0 time = 95
.meas tran vdout0_26ck18 FIND v(dout0_26) AT=95.025n

* CHECK dout0_27 Vdout0_27ck18 = 0.9 time = 95
.meas tran vdout0_27ck18 FIND v(dout0_27) AT=95.025n

* CHECK dout0_28 Vdout0_28ck18 = 0.9 time = 95
.meas tran vdout0_28ck18 FIND v(dout0_28) AT=95.025n

* CHECK dout0_29 Vdout0_29ck18 = 0.9 time = 95
.meas tran vdout0_29ck18 FIND v(dout0_29) AT=95.025n

* CHECK dout0_30 Vdout0_30ck18 = 0.9 time = 95
.meas tran vdout0_30ck18 FIND v(dout0_30) AT=95.025n

* CHECK dout0_31 Vdout0_31ck18 = 0 time = 95
.meas tran vdout0_31ck18 FIND v(dout0_31) AT=95.025n

* CHECK dout0_32 Vdout0_32ck18 = 0 time = 95
.meas tran vdout0_32ck18 FIND v(dout0_32) AT=95.025n

* CHECK dout0_33 Vdout0_33ck18 = 0.9 time = 95
.meas tran vdout0_33ck18 FIND v(dout0_33) AT=95.025n

* CHECK dout0_34 Vdout0_34ck18 = 0 time = 95
.meas tran vdout0_34ck18 FIND v(dout0_34) AT=95.025n

* CHECK dout0_35 Vdout0_35ck18 = 0.9 time = 95
.meas tran vdout0_35ck18 FIND v(dout0_35) AT=95.025n

* CHECK dout0_36 Vdout0_36ck18 = 0.9 time = 95
.meas tran vdout0_36ck18 FIND v(dout0_36) AT=95.025n

* CHECK dout0_37 Vdout0_37ck18 = 0.9 time = 95
.meas tran vdout0_37ck18 FIND v(dout0_37) AT=95.025n

* CHECK dout0_38 Vdout0_38ck18 = 0 time = 95
.meas tran vdout0_38ck18 FIND v(dout0_38) AT=95.025n

* CHECK dout0_39 Vdout0_39ck18 = 0.9 time = 95
.meas tran vdout0_39ck18 FIND v(dout0_39) AT=95.025n

* CHECK dout0_40 Vdout0_40ck18 = 0.9 time = 95
.meas tran vdout0_40ck18 FIND v(dout0_40) AT=95.025n

* CHECK dout0_41 Vdout0_41ck18 = 0.9 time = 95
.meas tran vdout0_41ck18 FIND v(dout0_41) AT=95.025n

* CHECK dout0_42 Vdout0_42ck18 = 0 time = 95
.meas tran vdout0_42ck18 FIND v(dout0_42) AT=95.025n

* CHECK dout0_43 Vdout0_43ck18 = 0.9 time = 95
.meas tran vdout0_43ck18 FIND v(dout0_43) AT=95.025n

* CHECK dout0_44 Vdout0_44ck18 = 0 time = 95
.meas tran vdout0_44ck18 FIND v(dout0_44) AT=95.025n

* CHECK dout0_45 Vdout0_45ck18 = 0 time = 95
.meas tran vdout0_45ck18 FIND v(dout0_45) AT=95.025n

* CHECK dout0_46 Vdout0_46ck18 = 0 time = 95
.meas tran vdout0_46ck18 FIND v(dout0_46) AT=95.025n

* CHECK dout0_47 Vdout0_47ck18 = 0 time = 95
.meas tran vdout0_47ck18 FIND v(dout0_47) AT=95.025n

* CHECK dout0_48 Vdout0_48ck18 = 0.9 time = 95
.meas tran vdout0_48ck18 FIND v(dout0_48) AT=95.025n

* CHECK dout0_49 Vdout0_49ck18 = 0 time = 95
.meas tran vdout0_49ck18 FIND v(dout0_49) AT=95.025n

* CHECK dout0_50 Vdout0_50ck18 = 0.9 time = 95
.meas tran vdout0_50ck18 FIND v(dout0_50) AT=95.025n

* CHECK dout0_51 Vdout0_51ck18 = 0 time = 95
.meas tran vdout0_51ck18 FIND v(dout0_51) AT=95.025n

* CHECK dout0_52 Vdout0_52ck18 = 0.9 time = 95
.meas tran vdout0_52ck18 FIND v(dout0_52) AT=95.025n

* CHECK dout0_53 Vdout0_53ck18 = 0 time = 95
.meas tran vdout0_53ck18 FIND v(dout0_53) AT=95.025n

* CHECK dout0_54 Vdout0_54ck18 = 0 time = 95
.meas tran vdout0_54ck18 FIND v(dout0_54) AT=95.025n

* CHECK dout0_55 Vdout0_55ck18 = 0 time = 95
.meas tran vdout0_55ck18 FIND v(dout0_55) AT=95.025n

* CHECK dout0_56 Vdout0_56ck18 = 0 time = 95
.meas tran vdout0_56ck18 FIND v(dout0_56) AT=95.025n

* CHECK dout0_57 Vdout0_57ck18 = 0.9 time = 95
.meas tran vdout0_57ck18 FIND v(dout0_57) AT=95.025n

* CHECK dout0_58 Vdout0_58ck18 = 0 time = 95
.meas tran vdout0_58ck18 FIND v(dout0_58) AT=95.025n

* CHECK dout0_59 Vdout0_59ck18 = 0.9 time = 95
.meas tran vdout0_59ck18 FIND v(dout0_59) AT=95.025n

* CHECK dout0_60 Vdout0_60ck18 = 0.9 time = 95
.meas tran vdout0_60ck18 FIND v(dout0_60) AT=95.025n

* CHECK dout0_61 Vdout0_61ck18 = 0.9 time = 95
.meas tran vdout0_61ck18 FIND v(dout0_61) AT=95.025n

* CHECK dout0_62 Vdout0_62ck18 = 0.9 time = 95
.meas tran vdout0_62ck18 FIND v(dout0_62) AT=95.025n

* CHECK dout0_63 Vdout0_63ck18 = 0.9 time = 95
.meas tran vdout0_63ck18 FIND v(dout0_63) AT=95.025n

* CHECK dout0_64 Vdout0_64ck18 = 0.9 time = 95
.meas tran vdout0_64ck18 FIND v(dout0_64) AT=95.025n

* CHECK dout0_65 Vdout0_65ck18 = 0.9 time = 95
.meas tran vdout0_65ck18 FIND v(dout0_65) AT=95.025n

* CHECK dout0_66 Vdout0_66ck18 = 0.9 time = 95
.meas tran vdout0_66ck18 FIND v(dout0_66) AT=95.025n

* CHECK dout0_67 Vdout0_67ck18 = 0 time = 95
.meas tran vdout0_67ck18 FIND v(dout0_67) AT=95.025n

* CHECK dout0_68 Vdout0_68ck18 = 0 time = 95
.meas tran vdout0_68ck18 FIND v(dout0_68) AT=95.025n

* CHECK dout0_69 Vdout0_69ck18 = 0 time = 95
.meas tran vdout0_69ck18 FIND v(dout0_69) AT=95.025n

* CHECK dout0_70 Vdout0_70ck18 = 0.9 time = 95
.meas tran vdout0_70ck18 FIND v(dout0_70) AT=95.025n

* CHECK dout0_71 Vdout0_71ck18 = 0.9 time = 95
.meas tran vdout0_71ck18 FIND v(dout0_71) AT=95.025n

* CHECK dout0_72 Vdout0_72ck18 = 0 time = 95
.meas tran vdout0_72ck18 FIND v(dout0_72) AT=95.025n

* CHECK dout0_73 Vdout0_73ck18 = 0 time = 95
.meas tran vdout0_73ck18 FIND v(dout0_73) AT=95.025n

* CHECK dout0_74 Vdout0_74ck18 = 0 time = 95
.meas tran vdout0_74ck18 FIND v(dout0_74) AT=95.025n

* CHECK dout0_75 Vdout0_75ck18 = 0.9 time = 95
.meas tran vdout0_75ck18 FIND v(dout0_75) AT=95.025n

* CHECK dout0_76 Vdout0_76ck18 = 0 time = 95
.meas tran vdout0_76ck18 FIND v(dout0_76) AT=95.025n

* CHECK dout0_77 Vdout0_77ck18 = 0.9 time = 95
.meas tran vdout0_77ck18 FIND v(dout0_77) AT=95.025n

* CHECK dout0_78 Vdout0_78ck18 = 0.9 time = 95
.meas tran vdout0_78ck18 FIND v(dout0_78) AT=95.025n

* CHECK dout0_79 Vdout0_79ck18 = 0 time = 95
.meas tran vdout0_79ck18 FIND v(dout0_79) AT=95.025n

* CHECK dout0_80 Vdout0_80ck18 = 0.9 time = 95
.meas tran vdout0_80ck18 FIND v(dout0_80) AT=95.025n

* CHECK dout0_81 Vdout0_81ck18 = 0 time = 95
.meas tran vdout0_81ck18 FIND v(dout0_81) AT=95.025n

* CHECK dout0_82 Vdout0_82ck18 = 0.9 time = 95
.meas tran vdout0_82ck18 FIND v(dout0_82) AT=95.025n

* CHECK dout0_83 Vdout0_83ck18 = 0.9 time = 95
.meas tran vdout0_83ck18 FIND v(dout0_83) AT=95.025n

* CHECK dout0_84 Vdout0_84ck18 = 0 time = 95
.meas tran vdout0_84ck18 FIND v(dout0_84) AT=95.025n

* CHECK dout0_85 Vdout0_85ck18 = 0 time = 95
.meas tran vdout0_85ck18 FIND v(dout0_85) AT=95.025n

* CHECK dout0_86 Vdout0_86ck18 = 0.9 time = 95
.meas tran vdout0_86ck18 FIND v(dout0_86) AT=95.025n

* CHECK dout0_87 Vdout0_87ck18 = 0 time = 95
.meas tran vdout0_87ck18 FIND v(dout0_87) AT=95.025n

* CHECK dout0_0 Vdout0_0ck19 = 0 time = 100
.meas tran vdout0_0ck19 FIND v(dout0_0) AT=100.025n

* CHECK dout0_1 Vdout0_1ck19 = 0.9 time = 100
.meas tran vdout0_1ck19 FIND v(dout0_1) AT=100.025n

* CHECK dout0_2 Vdout0_2ck19 = 0.9 time = 100
.meas tran vdout0_2ck19 FIND v(dout0_2) AT=100.025n

* CHECK dout0_3 Vdout0_3ck19 = 0 time = 100
.meas tran vdout0_3ck19 FIND v(dout0_3) AT=100.025n

* CHECK dout0_4 Vdout0_4ck19 = 0.9 time = 100
.meas tran vdout0_4ck19 FIND v(dout0_4) AT=100.025n

* CHECK dout0_5 Vdout0_5ck19 = 0 time = 100
.meas tran vdout0_5ck19 FIND v(dout0_5) AT=100.025n

* CHECK dout0_6 Vdout0_6ck19 = 0.9 time = 100
.meas tran vdout0_6ck19 FIND v(dout0_6) AT=100.025n

* CHECK dout0_7 Vdout0_7ck19 = 0.9 time = 100
.meas tran vdout0_7ck19 FIND v(dout0_7) AT=100.025n

* CHECK dout0_8 Vdout0_8ck19 = 0 time = 100
.meas tran vdout0_8ck19 FIND v(dout0_8) AT=100.025n

* CHECK dout0_9 Vdout0_9ck19 = 0 time = 100
.meas tran vdout0_9ck19 FIND v(dout0_9) AT=100.025n

* CHECK dout0_10 Vdout0_10ck19 = 0 time = 100
.meas tran vdout0_10ck19 FIND v(dout0_10) AT=100.025n

* CHECK dout0_11 Vdout0_11ck19 = 0 time = 100
.meas tran vdout0_11ck19 FIND v(dout0_11) AT=100.025n

* CHECK dout0_12 Vdout0_12ck19 = 0 time = 100
.meas tran vdout0_12ck19 FIND v(dout0_12) AT=100.025n

* CHECK dout0_13 Vdout0_13ck19 = 0.9 time = 100
.meas tran vdout0_13ck19 FIND v(dout0_13) AT=100.025n

* CHECK dout0_14 Vdout0_14ck19 = 0 time = 100
.meas tran vdout0_14ck19 FIND v(dout0_14) AT=100.025n

* CHECK dout0_15 Vdout0_15ck19 = 0.9 time = 100
.meas tran vdout0_15ck19 FIND v(dout0_15) AT=100.025n

* CHECK dout0_16 Vdout0_16ck19 = 0.9 time = 100
.meas tran vdout0_16ck19 FIND v(dout0_16) AT=100.025n

* CHECK dout0_17 Vdout0_17ck19 = 0 time = 100
.meas tran vdout0_17ck19 FIND v(dout0_17) AT=100.025n

* CHECK dout0_18 Vdout0_18ck19 = 0.9 time = 100
.meas tran vdout0_18ck19 FIND v(dout0_18) AT=100.025n

* CHECK dout0_19 Vdout0_19ck19 = 0.9 time = 100
.meas tran vdout0_19ck19 FIND v(dout0_19) AT=100.025n

* CHECK dout0_20 Vdout0_20ck19 = 0 time = 100
.meas tran vdout0_20ck19 FIND v(dout0_20) AT=100.025n

* CHECK dout0_21 Vdout0_21ck19 = 0.9 time = 100
.meas tran vdout0_21ck19 FIND v(dout0_21) AT=100.025n

* CHECK dout0_22 Vdout0_22ck19 = 0 time = 100
.meas tran vdout0_22ck19 FIND v(dout0_22) AT=100.025n

* CHECK dout0_23 Vdout0_23ck19 = 0 time = 100
.meas tran vdout0_23ck19 FIND v(dout0_23) AT=100.025n

* CHECK dout0_24 Vdout0_24ck19 = 0 time = 100
.meas tran vdout0_24ck19 FIND v(dout0_24) AT=100.025n

* CHECK dout0_25 Vdout0_25ck19 = 0 time = 100
.meas tran vdout0_25ck19 FIND v(dout0_25) AT=100.025n

* CHECK dout0_26 Vdout0_26ck19 = 0 time = 100
.meas tran vdout0_26ck19 FIND v(dout0_26) AT=100.025n

* CHECK dout0_27 Vdout0_27ck19 = 0.9 time = 100
.meas tran vdout0_27ck19 FIND v(dout0_27) AT=100.025n

* CHECK dout0_28 Vdout0_28ck19 = 0.9 time = 100
.meas tran vdout0_28ck19 FIND v(dout0_28) AT=100.025n

* CHECK dout0_29 Vdout0_29ck19 = 0.9 time = 100
.meas tran vdout0_29ck19 FIND v(dout0_29) AT=100.025n

* CHECK dout0_30 Vdout0_30ck19 = 0.9 time = 100
.meas tran vdout0_30ck19 FIND v(dout0_30) AT=100.025n

* CHECK dout0_31 Vdout0_31ck19 = 0 time = 100
.meas tran vdout0_31ck19 FIND v(dout0_31) AT=100.025n

* CHECK dout0_32 Vdout0_32ck19 = 0 time = 100
.meas tran vdout0_32ck19 FIND v(dout0_32) AT=100.025n

* CHECK dout0_33 Vdout0_33ck19 = 0.9 time = 100
.meas tran vdout0_33ck19 FIND v(dout0_33) AT=100.025n

* CHECK dout0_34 Vdout0_34ck19 = 0 time = 100
.meas tran vdout0_34ck19 FIND v(dout0_34) AT=100.025n

* CHECK dout0_35 Vdout0_35ck19 = 0 time = 100
.meas tran vdout0_35ck19 FIND v(dout0_35) AT=100.025n

* CHECK dout0_36 Vdout0_36ck19 = 0 time = 100
.meas tran vdout0_36ck19 FIND v(dout0_36) AT=100.025n

* CHECK dout0_37 Vdout0_37ck19 = 0.9 time = 100
.meas tran vdout0_37ck19 FIND v(dout0_37) AT=100.025n

* CHECK dout0_38 Vdout0_38ck19 = 0 time = 100
.meas tran vdout0_38ck19 FIND v(dout0_38) AT=100.025n

* CHECK dout0_39 Vdout0_39ck19 = 0.9 time = 100
.meas tran vdout0_39ck19 FIND v(dout0_39) AT=100.025n

* CHECK dout0_40 Vdout0_40ck19 = 0 time = 100
.meas tran vdout0_40ck19 FIND v(dout0_40) AT=100.025n

* CHECK dout0_41 Vdout0_41ck19 = 0.9 time = 100
.meas tran vdout0_41ck19 FIND v(dout0_41) AT=100.025n

* CHECK dout0_42 Vdout0_42ck19 = 0.9 time = 100
.meas tran vdout0_42ck19 FIND v(dout0_42) AT=100.025n

* CHECK dout0_43 Vdout0_43ck19 = 0.9 time = 100
.meas tran vdout0_43ck19 FIND v(dout0_43) AT=100.025n

* CHECK dout0_44 Vdout0_44ck19 = 0.9 time = 100
.meas tran vdout0_44ck19 FIND v(dout0_44) AT=100.025n

* CHECK dout0_45 Vdout0_45ck19 = 0.9 time = 100
.meas tran vdout0_45ck19 FIND v(dout0_45) AT=100.025n

* CHECK dout0_46 Vdout0_46ck19 = 0.9 time = 100
.meas tran vdout0_46ck19 FIND v(dout0_46) AT=100.025n

* CHECK dout0_47 Vdout0_47ck19 = 0 time = 100
.meas tran vdout0_47ck19 FIND v(dout0_47) AT=100.025n

* CHECK dout0_48 Vdout0_48ck19 = 0 time = 100
.meas tran vdout0_48ck19 FIND v(dout0_48) AT=100.025n

* CHECK dout0_49 Vdout0_49ck19 = 0 time = 100
.meas tran vdout0_49ck19 FIND v(dout0_49) AT=100.025n

* CHECK dout0_50 Vdout0_50ck19 = 0.9 time = 100
.meas tran vdout0_50ck19 FIND v(dout0_50) AT=100.025n

* CHECK dout0_51 Vdout0_51ck19 = 0 time = 100
.meas tran vdout0_51ck19 FIND v(dout0_51) AT=100.025n

* CHECK dout0_52 Vdout0_52ck19 = 0.9 time = 100
.meas tran vdout0_52ck19 FIND v(dout0_52) AT=100.025n

* CHECK dout0_53 Vdout0_53ck19 = 0 time = 100
.meas tran vdout0_53ck19 FIND v(dout0_53) AT=100.025n

* CHECK dout0_54 Vdout0_54ck19 = 0 time = 100
.meas tran vdout0_54ck19 FIND v(dout0_54) AT=100.025n

* CHECK dout0_55 Vdout0_55ck19 = 0 time = 100
.meas tran vdout0_55ck19 FIND v(dout0_55) AT=100.025n

* CHECK dout0_56 Vdout0_56ck19 = 0 time = 100
.meas tran vdout0_56ck19 FIND v(dout0_56) AT=100.025n

* CHECK dout0_57 Vdout0_57ck19 = 0.9 time = 100
.meas tran vdout0_57ck19 FIND v(dout0_57) AT=100.025n

* CHECK dout0_58 Vdout0_58ck19 = 0.9 time = 100
.meas tran vdout0_58ck19 FIND v(dout0_58) AT=100.025n

* CHECK dout0_59 Vdout0_59ck19 = 0 time = 100
.meas tran vdout0_59ck19 FIND v(dout0_59) AT=100.025n

* CHECK dout0_60 Vdout0_60ck19 = 0.9 time = 100
.meas tran vdout0_60ck19 FIND v(dout0_60) AT=100.025n

* CHECK dout0_61 Vdout0_61ck19 = 0 time = 100
.meas tran vdout0_61ck19 FIND v(dout0_61) AT=100.025n

* CHECK dout0_62 Vdout0_62ck19 = 0 time = 100
.meas tran vdout0_62ck19 FIND v(dout0_62) AT=100.025n

* CHECK dout0_63 Vdout0_63ck19 = 0 time = 100
.meas tran vdout0_63ck19 FIND v(dout0_63) AT=100.025n

* CHECK dout0_64 Vdout0_64ck19 = 0 time = 100
.meas tran vdout0_64ck19 FIND v(dout0_64) AT=100.025n

* CHECK dout0_65 Vdout0_65ck19 = 0.9 time = 100
.meas tran vdout0_65ck19 FIND v(dout0_65) AT=100.025n

* CHECK dout0_66 Vdout0_66ck19 = 0.9 time = 100
.meas tran vdout0_66ck19 FIND v(dout0_66) AT=100.025n

* CHECK dout0_67 Vdout0_67ck19 = 0.9 time = 100
.meas tran vdout0_67ck19 FIND v(dout0_67) AT=100.025n

* CHECK dout0_68 Vdout0_68ck19 = 0.9 time = 100
.meas tran vdout0_68ck19 FIND v(dout0_68) AT=100.025n

* CHECK dout0_69 Vdout0_69ck19 = 0 time = 100
.meas tran vdout0_69ck19 FIND v(dout0_69) AT=100.025n

* CHECK dout0_70 Vdout0_70ck19 = 0.9 time = 100
.meas tran vdout0_70ck19 FIND v(dout0_70) AT=100.025n

* CHECK dout0_71 Vdout0_71ck19 = 0.9 time = 100
.meas tran vdout0_71ck19 FIND v(dout0_71) AT=100.025n

* CHECK dout0_72 Vdout0_72ck19 = 0 time = 100
.meas tran vdout0_72ck19 FIND v(dout0_72) AT=100.025n

* CHECK dout0_73 Vdout0_73ck19 = 0.9 time = 100
.meas tran vdout0_73ck19 FIND v(dout0_73) AT=100.025n

* CHECK dout0_74 Vdout0_74ck19 = 0.9 time = 100
.meas tran vdout0_74ck19 FIND v(dout0_74) AT=100.025n

* CHECK dout0_75 Vdout0_75ck19 = 0 time = 100
.meas tran vdout0_75ck19 FIND v(dout0_75) AT=100.025n

* CHECK dout0_76 Vdout0_76ck19 = 0 time = 100
.meas tran vdout0_76ck19 FIND v(dout0_76) AT=100.025n

* CHECK dout0_77 Vdout0_77ck19 = 0 time = 100
.meas tran vdout0_77ck19 FIND v(dout0_77) AT=100.025n

* CHECK dout0_78 Vdout0_78ck19 = 0 time = 100
.meas tran vdout0_78ck19 FIND v(dout0_78) AT=100.025n

* CHECK dout0_79 Vdout0_79ck19 = 0.9 time = 100
.meas tran vdout0_79ck19 FIND v(dout0_79) AT=100.025n

* CHECK dout0_80 Vdout0_80ck19 = 0.9 time = 100
.meas tran vdout0_80ck19 FIND v(dout0_80) AT=100.025n

* CHECK dout0_81 Vdout0_81ck19 = 0.9 time = 100
.meas tran vdout0_81ck19 FIND v(dout0_81) AT=100.025n

* CHECK dout0_82 Vdout0_82ck19 = 0 time = 100
.meas tran vdout0_82ck19 FIND v(dout0_82) AT=100.025n

* CHECK dout0_83 Vdout0_83ck19 = 0 time = 100
.meas tran vdout0_83ck19 FIND v(dout0_83) AT=100.025n

* CHECK dout0_84 Vdout0_84ck19 = 0.9 time = 100
.meas tran vdout0_84ck19 FIND v(dout0_84) AT=100.025n

* CHECK dout0_85 Vdout0_85ck19 = 0 time = 100
.meas tran vdout0_85ck19 FIND v(dout0_85) AT=100.025n

* CHECK dout0_86 Vdout0_86ck19 = 0 time = 100
.meas tran vdout0_86ck19 FIND v(dout0_86) AT=100.025n

* CHECK dout0_87 Vdout0_87ck19 = 0 time = 100
.meas tran vdout0_87ck19 FIND v(dout0_87) AT=100.025n

* CHECK dout0_0 Vdout0_0ck20 = 0 time = 105
.meas tran vdout0_0ck20 FIND v(dout0_0) AT=105.025n

* CHECK dout0_1 Vdout0_1ck20 = 0.9 time = 105
.meas tran vdout0_1ck20 FIND v(dout0_1) AT=105.025n

* CHECK dout0_2 Vdout0_2ck20 = 0.9 time = 105
.meas tran vdout0_2ck20 FIND v(dout0_2) AT=105.025n

* CHECK dout0_3 Vdout0_3ck20 = 0 time = 105
.meas tran vdout0_3ck20 FIND v(dout0_3) AT=105.025n

* CHECK dout0_4 Vdout0_4ck20 = 0.9 time = 105
.meas tran vdout0_4ck20 FIND v(dout0_4) AT=105.025n

* CHECK dout0_5 Vdout0_5ck20 = 0 time = 105
.meas tran vdout0_5ck20 FIND v(dout0_5) AT=105.025n

* CHECK dout0_6 Vdout0_6ck20 = 0.9 time = 105
.meas tran vdout0_6ck20 FIND v(dout0_6) AT=105.025n

* CHECK dout0_7 Vdout0_7ck20 = 0.9 time = 105
.meas tran vdout0_7ck20 FIND v(dout0_7) AT=105.025n

* CHECK dout0_8 Vdout0_8ck20 = 0 time = 105
.meas tran vdout0_8ck20 FIND v(dout0_8) AT=105.025n

* CHECK dout0_9 Vdout0_9ck20 = 0 time = 105
.meas tran vdout0_9ck20 FIND v(dout0_9) AT=105.025n

* CHECK dout0_10 Vdout0_10ck20 = 0 time = 105
.meas tran vdout0_10ck20 FIND v(dout0_10) AT=105.025n

* CHECK dout0_11 Vdout0_11ck20 = 0 time = 105
.meas tran vdout0_11ck20 FIND v(dout0_11) AT=105.025n

* CHECK dout0_12 Vdout0_12ck20 = 0 time = 105
.meas tran vdout0_12ck20 FIND v(dout0_12) AT=105.025n

* CHECK dout0_13 Vdout0_13ck20 = 0.9 time = 105
.meas tran vdout0_13ck20 FIND v(dout0_13) AT=105.025n

* CHECK dout0_14 Vdout0_14ck20 = 0 time = 105
.meas tran vdout0_14ck20 FIND v(dout0_14) AT=105.025n

* CHECK dout0_15 Vdout0_15ck20 = 0.9 time = 105
.meas tran vdout0_15ck20 FIND v(dout0_15) AT=105.025n

* CHECK dout0_16 Vdout0_16ck20 = 0.9 time = 105
.meas tran vdout0_16ck20 FIND v(dout0_16) AT=105.025n

* CHECK dout0_17 Vdout0_17ck20 = 0 time = 105
.meas tran vdout0_17ck20 FIND v(dout0_17) AT=105.025n

* CHECK dout0_18 Vdout0_18ck20 = 0.9 time = 105
.meas tran vdout0_18ck20 FIND v(dout0_18) AT=105.025n

* CHECK dout0_19 Vdout0_19ck20 = 0.9 time = 105
.meas tran vdout0_19ck20 FIND v(dout0_19) AT=105.025n

* CHECK dout0_20 Vdout0_20ck20 = 0 time = 105
.meas tran vdout0_20ck20 FIND v(dout0_20) AT=105.025n

* CHECK dout0_21 Vdout0_21ck20 = 0.9 time = 105
.meas tran vdout0_21ck20 FIND v(dout0_21) AT=105.025n

* CHECK dout0_22 Vdout0_22ck20 = 0 time = 105
.meas tran vdout0_22ck20 FIND v(dout0_22) AT=105.025n

* CHECK dout0_23 Vdout0_23ck20 = 0 time = 105
.meas tran vdout0_23ck20 FIND v(dout0_23) AT=105.025n

* CHECK dout0_24 Vdout0_24ck20 = 0 time = 105
.meas tran vdout0_24ck20 FIND v(dout0_24) AT=105.025n

* CHECK dout0_25 Vdout0_25ck20 = 0 time = 105
.meas tran vdout0_25ck20 FIND v(dout0_25) AT=105.025n

* CHECK dout0_26 Vdout0_26ck20 = 0 time = 105
.meas tran vdout0_26ck20 FIND v(dout0_26) AT=105.025n

* CHECK dout0_27 Vdout0_27ck20 = 0.9 time = 105
.meas tran vdout0_27ck20 FIND v(dout0_27) AT=105.025n

* CHECK dout0_28 Vdout0_28ck20 = 0.9 time = 105
.meas tran vdout0_28ck20 FIND v(dout0_28) AT=105.025n

* CHECK dout0_29 Vdout0_29ck20 = 0.9 time = 105
.meas tran vdout0_29ck20 FIND v(dout0_29) AT=105.025n

* CHECK dout0_30 Vdout0_30ck20 = 0.9 time = 105
.meas tran vdout0_30ck20 FIND v(dout0_30) AT=105.025n

* CHECK dout0_31 Vdout0_31ck20 = 0 time = 105
.meas tran vdout0_31ck20 FIND v(dout0_31) AT=105.025n

* CHECK dout0_32 Vdout0_32ck20 = 0 time = 105
.meas tran vdout0_32ck20 FIND v(dout0_32) AT=105.025n

* CHECK dout0_33 Vdout0_33ck20 = 0.9 time = 105
.meas tran vdout0_33ck20 FIND v(dout0_33) AT=105.025n

* CHECK dout0_34 Vdout0_34ck20 = 0 time = 105
.meas tran vdout0_34ck20 FIND v(dout0_34) AT=105.025n

* CHECK dout0_35 Vdout0_35ck20 = 0 time = 105
.meas tran vdout0_35ck20 FIND v(dout0_35) AT=105.025n

* CHECK dout0_36 Vdout0_36ck20 = 0 time = 105
.meas tran vdout0_36ck20 FIND v(dout0_36) AT=105.025n

* CHECK dout0_37 Vdout0_37ck20 = 0.9 time = 105
.meas tran vdout0_37ck20 FIND v(dout0_37) AT=105.025n

* CHECK dout0_38 Vdout0_38ck20 = 0 time = 105
.meas tran vdout0_38ck20 FIND v(dout0_38) AT=105.025n

* CHECK dout0_39 Vdout0_39ck20 = 0.9 time = 105
.meas tran vdout0_39ck20 FIND v(dout0_39) AT=105.025n

* CHECK dout0_40 Vdout0_40ck20 = 0 time = 105
.meas tran vdout0_40ck20 FIND v(dout0_40) AT=105.025n

* CHECK dout0_41 Vdout0_41ck20 = 0.9 time = 105
.meas tran vdout0_41ck20 FIND v(dout0_41) AT=105.025n

* CHECK dout0_42 Vdout0_42ck20 = 0.9 time = 105
.meas tran vdout0_42ck20 FIND v(dout0_42) AT=105.025n

* CHECK dout0_43 Vdout0_43ck20 = 0.9 time = 105
.meas tran vdout0_43ck20 FIND v(dout0_43) AT=105.025n

* CHECK dout0_44 Vdout0_44ck20 = 0.9 time = 105
.meas tran vdout0_44ck20 FIND v(dout0_44) AT=105.025n

* CHECK dout0_45 Vdout0_45ck20 = 0.9 time = 105
.meas tran vdout0_45ck20 FIND v(dout0_45) AT=105.025n

* CHECK dout0_46 Vdout0_46ck20 = 0.9 time = 105
.meas tran vdout0_46ck20 FIND v(dout0_46) AT=105.025n

* CHECK dout0_47 Vdout0_47ck20 = 0 time = 105
.meas tran vdout0_47ck20 FIND v(dout0_47) AT=105.025n

* CHECK dout0_48 Vdout0_48ck20 = 0 time = 105
.meas tran vdout0_48ck20 FIND v(dout0_48) AT=105.025n

* CHECK dout0_49 Vdout0_49ck20 = 0 time = 105
.meas tran vdout0_49ck20 FIND v(dout0_49) AT=105.025n

* CHECK dout0_50 Vdout0_50ck20 = 0.9 time = 105
.meas tran vdout0_50ck20 FIND v(dout0_50) AT=105.025n

* CHECK dout0_51 Vdout0_51ck20 = 0 time = 105
.meas tran vdout0_51ck20 FIND v(dout0_51) AT=105.025n

* CHECK dout0_52 Vdout0_52ck20 = 0.9 time = 105
.meas tran vdout0_52ck20 FIND v(dout0_52) AT=105.025n

* CHECK dout0_53 Vdout0_53ck20 = 0 time = 105
.meas tran vdout0_53ck20 FIND v(dout0_53) AT=105.025n

* CHECK dout0_54 Vdout0_54ck20 = 0 time = 105
.meas tran vdout0_54ck20 FIND v(dout0_54) AT=105.025n

* CHECK dout0_55 Vdout0_55ck20 = 0 time = 105
.meas tran vdout0_55ck20 FIND v(dout0_55) AT=105.025n

* CHECK dout0_56 Vdout0_56ck20 = 0 time = 105
.meas tran vdout0_56ck20 FIND v(dout0_56) AT=105.025n

* CHECK dout0_57 Vdout0_57ck20 = 0.9 time = 105
.meas tran vdout0_57ck20 FIND v(dout0_57) AT=105.025n

* CHECK dout0_58 Vdout0_58ck20 = 0.9 time = 105
.meas tran vdout0_58ck20 FIND v(dout0_58) AT=105.025n

* CHECK dout0_59 Vdout0_59ck20 = 0 time = 105
.meas tran vdout0_59ck20 FIND v(dout0_59) AT=105.025n

* CHECK dout0_60 Vdout0_60ck20 = 0.9 time = 105
.meas tran vdout0_60ck20 FIND v(dout0_60) AT=105.025n

* CHECK dout0_61 Vdout0_61ck20 = 0 time = 105
.meas tran vdout0_61ck20 FIND v(dout0_61) AT=105.025n

* CHECK dout0_62 Vdout0_62ck20 = 0 time = 105
.meas tran vdout0_62ck20 FIND v(dout0_62) AT=105.025n

* CHECK dout0_63 Vdout0_63ck20 = 0 time = 105
.meas tran vdout0_63ck20 FIND v(dout0_63) AT=105.025n

* CHECK dout0_64 Vdout0_64ck20 = 0 time = 105
.meas tran vdout0_64ck20 FIND v(dout0_64) AT=105.025n

* CHECK dout0_65 Vdout0_65ck20 = 0.9 time = 105
.meas tran vdout0_65ck20 FIND v(dout0_65) AT=105.025n

* CHECK dout0_66 Vdout0_66ck20 = 0.9 time = 105
.meas tran vdout0_66ck20 FIND v(dout0_66) AT=105.025n

* CHECK dout0_67 Vdout0_67ck20 = 0.9 time = 105
.meas tran vdout0_67ck20 FIND v(dout0_67) AT=105.025n

* CHECK dout0_68 Vdout0_68ck20 = 0.9 time = 105
.meas tran vdout0_68ck20 FIND v(dout0_68) AT=105.025n

* CHECK dout0_69 Vdout0_69ck20 = 0 time = 105
.meas tran vdout0_69ck20 FIND v(dout0_69) AT=105.025n

* CHECK dout0_70 Vdout0_70ck20 = 0.9 time = 105
.meas tran vdout0_70ck20 FIND v(dout0_70) AT=105.025n

* CHECK dout0_71 Vdout0_71ck20 = 0.9 time = 105
.meas tran vdout0_71ck20 FIND v(dout0_71) AT=105.025n

* CHECK dout0_72 Vdout0_72ck20 = 0 time = 105
.meas tran vdout0_72ck20 FIND v(dout0_72) AT=105.025n

* CHECK dout0_73 Vdout0_73ck20 = 0.9 time = 105
.meas tran vdout0_73ck20 FIND v(dout0_73) AT=105.025n

* CHECK dout0_74 Vdout0_74ck20 = 0.9 time = 105
.meas tran vdout0_74ck20 FIND v(dout0_74) AT=105.025n

* CHECK dout0_75 Vdout0_75ck20 = 0 time = 105
.meas tran vdout0_75ck20 FIND v(dout0_75) AT=105.025n

* CHECK dout0_76 Vdout0_76ck20 = 0 time = 105
.meas tran vdout0_76ck20 FIND v(dout0_76) AT=105.025n

* CHECK dout0_77 Vdout0_77ck20 = 0 time = 105
.meas tran vdout0_77ck20 FIND v(dout0_77) AT=105.025n

* CHECK dout0_78 Vdout0_78ck20 = 0 time = 105
.meas tran vdout0_78ck20 FIND v(dout0_78) AT=105.025n

* CHECK dout0_79 Vdout0_79ck20 = 0.9 time = 105
.meas tran vdout0_79ck20 FIND v(dout0_79) AT=105.025n

* CHECK dout0_80 Vdout0_80ck20 = 0.9 time = 105
.meas tran vdout0_80ck20 FIND v(dout0_80) AT=105.025n

* CHECK dout0_81 Vdout0_81ck20 = 0.9 time = 105
.meas tran vdout0_81ck20 FIND v(dout0_81) AT=105.025n

* CHECK dout0_82 Vdout0_82ck20 = 0 time = 105
.meas tran vdout0_82ck20 FIND v(dout0_82) AT=105.025n

* CHECK dout0_83 Vdout0_83ck20 = 0 time = 105
.meas tran vdout0_83ck20 FIND v(dout0_83) AT=105.025n

* CHECK dout0_84 Vdout0_84ck20 = 0.9 time = 105
.meas tran vdout0_84ck20 FIND v(dout0_84) AT=105.025n

* CHECK dout0_85 Vdout0_85ck20 = 0 time = 105
.meas tran vdout0_85ck20 FIND v(dout0_85) AT=105.025n

* CHECK dout0_86 Vdout0_86ck20 = 0 time = 105
.meas tran vdout0_86ck20 FIND v(dout0_86) AT=105.025n

* CHECK dout0_87 Vdout0_87ck20 = 0 time = 105
.meas tran vdout0_87ck20 FIND v(dout0_87) AT=105.025n

* CHECK dout0_0 Vdout0_0ck21 = 0 time = 110
.meas tran vdout0_0ck21 FIND v(dout0_0) AT=110.025n

* CHECK dout0_1 Vdout0_1ck21 = 0.9 time = 110
.meas tran vdout0_1ck21 FIND v(dout0_1) AT=110.025n

* CHECK dout0_2 Vdout0_2ck21 = 0.9 time = 110
.meas tran vdout0_2ck21 FIND v(dout0_2) AT=110.025n

* CHECK dout0_3 Vdout0_3ck21 = 0 time = 110
.meas tran vdout0_3ck21 FIND v(dout0_3) AT=110.025n

* CHECK dout0_4 Vdout0_4ck21 = 0.9 time = 110
.meas tran vdout0_4ck21 FIND v(dout0_4) AT=110.025n

* CHECK dout0_5 Vdout0_5ck21 = 0 time = 110
.meas tran vdout0_5ck21 FIND v(dout0_5) AT=110.025n

* CHECK dout0_6 Vdout0_6ck21 = 0.9 time = 110
.meas tran vdout0_6ck21 FIND v(dout0_6) AT=110.025n

* CHECK dout0_7 Vdout0_7ck21 = 0.9 time = 110
.meas tran vdout0_7ck21 FIND v(dout0_7) AT=110.025n

* CHECK dout0_8 Vdout0_8ck21 = 0 time = 110
.meas tran vdout0_8ck21 FIND v(dout0_8) AT=110.025n

* CHECK dout0_9 Vdout0_9ck21 = 0 time = 110
.meas tran vdout0_9ck21 FIND v(dout0_9) AT=110.025n

* CHECK dout0_10 Vdout0_10ck21 = 0 time = 110
.meas tran vdout0_10ck21 FIND v(dout0_10) AT=110.025n

* CHECK dout0_11 Vdout0_11ck21 = 0 time = 110
.meas tran vdout0_11ck21 FIND v(dout0_11) AT=110.025n

* CHECK dout0_12 Vdout0_12ck21 = 0 time = 110
.meas tran vdout0_12ck21 FIND v(dout0_12) AT=110.025n

* CHECK dout0_13 Vdout0_13ck21 = 0.9 time = 110
.meas tran vdout0_13ck21 FIND v(dout0_13) AT=110.025n

* CHECK dout0_14 Vdout0_14ck21 = 0 time = 110
.meas tran vdout0_14ck21 FIND v(dout0_14) AT=110.025n

* CHECK dout0_15 Vdout0_15ck21 = 0.9 time = 110
.meas tran vdout0_15ck21 FIND v(dout0_15) AT=110.025n

* CHECK dout0_16 Vdout0_16ck21 = 0.9 time = 110
.meas tran vdout0_16ck21 FIND v(dout0_16) AT=110.025n

* CHECK dout0_17 Vdout0_17ck21 = 0 time = 110
.meas tran vdout0_17ck21 FIND v(dout0_17) AT=110.025n

* CHECK dout0_18 Vdout0_18ck21 = 0.9 time = 110
.meas tran vdout0_18ck21 FIND v(dout0_18) AT=110.025n

* CHECK dout0_19 Vdout0_19ck21 = 0.9 time = 110
.meas tran vdout0_19ck21 FIND v(dout0_19) AT=110.025n

* CHECK dout0_20 Vdout0_20ck21 = 0 time = 110
.meas tran vdout0_20ck21 FIND v(dout0_20) AT=110.025n

* CHECK dout0_21 Vdout0_21ck21 = 0.9 time = 110
.meas tran vdout0_21ck21 FIND v(dout0_21) AT=110.025n

* CHECK dout0_22 Vdout0_22ck21 = 0 time = 110
.meas tran vdout0_22ck21 FIND v(dout0_22) AT=110.025n

* CHECK dout0_23 Vdout0_23ck21 = 0 time = 110
.meas tran vdout0_23ck21 FIND v(dout0_23) AT=110.025n

* CHECK dout0_24 Vdout0_24ck21 = 0 time = 110
.meas tran vdout0_24ck21 FIND v(dout0_24) AT=110.025n

* CHECK dout0_25 Vdout0_25ck21 = 0 time = 110
.meas tran vdout0_25ck21 FIND v(dout0_25) AT=110.025n

* CHECK dout0_26 Vdout0_26ck21 = 0 time = 110
.meas tran vdout0_26ck21 FIND v(dout0_26) AT=110.025n

* CHECK dout0_27 Vdout0_27ck21 = 0.9 time = 110
.meas tran vdout0_27ck21 FIND v(dout0_27) AT=110.025n

* CHECK dout0_28 Vdout0_28ck21 = 0.9 time = 110
.meas tran vdout0_28ck21 FIND v(dout0_28) AT=110.025n

* CHECK dout0_29 Vdout0_29ck21 = 0.9 time = 110
.meas tran vdout0_29ck21 FIND v(dout0_29) AT=110.025n

* CHECK dout0_30 Vdout0_30ck21 = 0.9 time = 110
.meas tran vdout0_30ck21 FIND v(dout0_30) AT=110.025n

* CHECK dout0_31 Vdout0_31ck21 = 0 time = 110
.meas tran vdout0_31ck21 FIND v(dout0_31) AT=110.025n

* CHECK dout0_32 Vdout0_32ck21 = 0 time = 110
.meas tran vdout0_32ck21 FIND v(dout0_32) AT=110.025n

* CHECK dout0_33 Vdout0_33ck21 = 0.9 time = 110
.meas tran vdout0_33ck21 FIND v(dout0_33) AT=110.025n

* CHECK dout0_34 Vdout0_34ck21 = 0 time = 110
.meas tran vdout0_34ck21 FIND v(dout0_34) AT=110.025n

* CHECK dout0_35 Vdout0_35ck21 = 0 time = 110
.meas tran vdout0_35ck21 FIND v(dout0_35) AT=110.025n

* CHECK dout0_36 Vdout0_36ck21 = 0 time = 110
.meas tran vdout0_36ck21 FIND v(dout0_36) AT=110.025n

* CHECK dout0_37 Vdout0_37ck21 = 0.9 time = 110
.meas tran vdout0_37ck21 FIND v(dout0_37) AT=110.025n

* CHECK dout0_38 Vdout0_38ck21 = 0 time = 110
.meas tran vdout0_38ck21 FIND v(dout0_38) AT=110.025n

* CHECK dout0_39 Vdout0_39ck21 = 0.9 time = 110
.meas tran vdout0_39ck21 FIND v(dout0_39) AT=110.025n

* CHECK dout0_40 Vdout0_40ck21 = 0 time = 110
.meas tran vdout0_40ck21 FIND v(dout0_40) AT=110.025n

* CHECK dout0_41 Vdout0_41ck21 = 0.9 time = 110
.meas tran vdout0_41ck21 FIND v(dout0_41) AT=110.025n

* CHECK dout0_42 Vdout0_42ck21 = 0.9 time = 110
.meas tran vdout0_42ck21 FIND v(dout0_42) AT=110.025n

* CHECK dout0_43 Vdout0_43ck21 = 0.9 time = 110
.meas tran vdout0_43ck21 FIND v(dout0_43) AT=110.025n

* CHECK dout0_44 Vdout0_44ck21 = 0.9 time = 110
.meas tran vdout0_44ck21 FIND v(dout0_44) AT=110.025n

* CHECK dout0_45 Vdout0_45ck21 = 0.9 time = 110
.meas tran vdout0_45ck21 FIND v(dout0_45) AT=110.025n

* CHECK dout0_46 Vdout0_46ck21 = 0.9 time = 110
.meas tran vdout0_46ck21 FIND v(dout0_46) AT=110.025n

* CHECK dout0_47 Vdout0_47ck21 = 0 time = 110
.meas tran vdout0_47ck21 FIND v(dout0_47) AT=110.025n

* CHECK dout0_48 Vdout0_48ck21 = 0 time = 110
.meas tran vdout0_48ck21 FIND v(dout0_48) AT=110.025n

* CHECK dout0_49 Vdout0_49ck21 = 0 time = 110
.meas tran vdout0_49ck21 FIND v(dout0_49) AT=110.025n

* CHECK dout0_50 Vdout0_50ck21 = 0.9 time = 110
.meas tran vdout0_50ck21 FIND v(dout0_50) AT=110.025n

* CHECK dout0_51 Vdout0_51ck21 = 0 time = 110
.meas tran vdout0_51ck21 FIND v(dout0_51) AT=110.025n

* CHECK dout0_52 Vdout0_52ck21 = 0.9 time = 110
.meas tran vdout0_52ck21 FIND v(dout0_52) AT=110.025n

* CHECK dout0_53 Vdout0_53ck21 = 0 time = 110
.meas tran vdout0_53ck21 FIND v(dout0_53) AT=110.025n

* CHECK dout0_54 Vdout0_54ck21 = 0 time = 110
.meas tran vdout0_54ck21 FIND v(dout0_54) AT=110.025n

* CHECK dout0_55 Vdout0_55ck21 = 0 time = 110
.meas tran vdout0_55ck21 FIND v(dout0_55) AT=110.025n

* CHECK dout0_56 Vdout0_56ck21 = 0 time = 110
.meas tran vdout0_56ck21 FIND v(dout0_56) AT=110.025n

* CHECK dout0_57 Vdout0_57ck21 = 0.9 time = 110
.meas tran vdout0_57ck21 FIND v(dout0_57) AT=110.025n

* CHECK dout0_58 Vdout0_58ck21 = 0.9 time = 110
.meas tran vdout0_58ck21 FIND v(dout0_58) AT=110.025n

* CHECK dout0_59 Vdout0_59ck21 = 0 time = 110
.meas tran vdout0_59ck21 FIND v(dout0_59) AT=110.025n

* CHECK dout0_60 Vdout0_60ck21 = 0.9 time = 110
.meas tran vdout0_60ck21 FIND v(dout0_60) AT=110.025n

* CHECK dout0_61 Vdout0_61ck21 = 0 time = 110
.meas tran vdout0_61ck21 FIND v(dout0_61) AT=110.025n

* CHECK dout0_62 Vdout0_62ck21 = 0 time = 110
.meas tran vdout0_62ck21 FIND v(dout0_62) AT=110.025n

* CHECK dout0_63 Vdout0_63ck21 = 0 time = 110
.meas tran vdout0_63ck21 FIND v(dout0_63) AT=110.025n

* CHECK dout0_64 Vdout0_64ck21 = 0 time = 110
.meas tran vdout0_64ck21 FIND v(dout0_64) AT=110.025n

* CHECK dout0_65 Vdout0_65ck21 = 0.9 time = 110
.meas tran vdout0_65ck21 FIND v(dout0_65) AT=110.025n

* CHECK dout0_66 Vdout0_66ck21 = 0.9 time = 110
.meas tran vdout0_66ck21 FIND v(dout0_66) AT=110.025n

* CHECK dout0_67 Vdout0_67ck21 = 0.9 time = 110
.meas tran vdout0_67ck21 FIND v(dout0_67) AT=110.025n

* CHECK dout0_68 Vdout0_68ck21 = 0.9 time = 110
.meas tran vdout0_68ck21 FIND v(dout0_68) AT=110.025n

* CHECK dout0_69 Vdout0_69ck21 = 0 time = 110
.meas tran vdout0_69ck21 FIND v(dout0_69) AT=110.025n

* CHECK dout0_70 Vdout0_70ck21 = 0.9 time = 110
.meas tran vdout0_70ck21 FIND v(dout0_70) AT=110.025n

* CHECK dout0_71 Vdout0_71ck21 = 0.9 time = 110
.meas tran vdout0_71ck21 FIND v(dout0_71) AT=110.025n

* CHECK dout0_72 Vdout0_72ck21 = 0 time = 110
.meas tran vdout0_72ck21 FIND v(dout0_72) AT=110.025n

* CHECK dout0_73 Vdout0_73ck21 = 0.9 time = 110
.meas tran vdout0_73ck21 FIND v(dout0_73) AT=110.025n

* CHECK dout0_74 Vdout0_74ck21 = 0.9 time = 110
.meas tran vdout0_74ck21 FIND v(dout0_74) AT=110.025n

* CHECK dout0_75 Vdout0_75ck21 = 0 time = 110
.meas tran vdout0_75ck21 FIND v(dout0_75) AT=110.025n

* CHECK dout0_76 Vdout0_76ck21 = 0 time = 110
.meas tran vdout0_76ck21 FIND v(dout0_76) AT=110.025n

* CHECK dout0_77 Vdout0_77ck21 = 0 time = 110
.meas tran vdout0_77ck21 FIND v(dout0_77) AT=110.025n

* CHECK dout0_78 Vdout0_78ck21 = 0 time = 110
.meas tran vdout0_78ck21 FIND v(dout0_78) AT=110.025n

* CHECK dout0_79 Vdout0_79ck21 = 0.9 time = 110
.meas tran vdout0_79ck21 FIND v(dout0_79) AT=110.025n

* CHECK dout0_80 Vdout0_80ck21 = 0.9 time = 110
.meas tran vdout0_80ck21 FIND v(dout0_80) AT=110.025n

* CHECK dout0_81 Vdout0_81ck21 = 0.9 time = 110
.meas tran vdout0_81ck21 FIND v(dout0_81) AT=110.025n

* CHECK dout0_82 Vdout0_82ck21 = 0 time = 110
.meas tran vdout0_82ck21 FIND v(dout0_82) AT=110.025n

* CHECK dout0_83 Vdout0_83ck21 = 0 time = 110
.meas tran vdout0_83ck21 FIND v(dout0_83) AT=110.025n

* CHECK dout0_84 Vdout0_84ck21 = 0.9 time = 110
.meas tran vdout0_84ck21 FIND v(dout0_84) AT=110.025n

* CHECK dout0_85 Vdout0_85ck21 = 0 time = 110
.meas tran vdout0_85ck21 FIND v(dout0_85) AT=110.025n

* CHECK dout0_86 Vdout0_86ck21 = 0 time = 110
.meas tran vdout0_86ck21 FIND v(dout0_86) AT=110.025n

* CHECK dout0_87 Vdout0_87ck21 = 0 time = 110
.meas tran vdout0_87ck21 FIND v(dout0_87) AT=110.025n

* CHECK dout0_0 Vdout0_0ck24 = 0.9 time = 125
.meas tran vdout0_0ck24 FIND v(dout0_0) AT=125.025n

* CHECK dout0_1 Vdout0_1ck24 = 0 time = 125
.meas tran vdout0_1ck24 FIND v(dout0_1) AT=125.025n

* CHECK dout0_2 Vdout0_2ck24 = 0.9 time = 125
.meas tran vdout0_2ck24 FIND v(dout0_2) AT=125.025n

* CHECK dout0_3 Vdout0_3ck24 = 0 time = 125
.meas tran vdout0_3ck24 FIND v(dout0_3) AT=125.025n

* CHECK dout0_4 Vdout0_4ck24 = 0.9 time = 125
.meas tran vdout0_4ck24 FIND v(dout0_4) AT=125.025n

* CHECK dout0_5 Vdout0_5ck24 = 0 time = 125
.meas tran vdout0_5ck24 FIND v(dout0_5) AT=125.025n

* CHECK dout0_6 Vdout0_6ck24 = 0 time = 125
.meas tran vdout0_6ck24 FIND v(dout0_6) AT=125.025n

* CHECK dout0_7 Vdout0_7ck24 = 0 time = 125
.meas tran vdout0_7ck24 FIND v(dout0_7) AT=125.025n

* CHECK dout0_8 Vdout0_8ck24 = 0.9 time = 125
.meas tran vdout0_8ck24 FIND v(dout0_8) AT=125.025n

* CHECK dout0_9 Vdout0_9ck24 = 0 time = 125
.meas tran vdout0_9ck24 FIND v(dout0_9) AT=125.025n

* CHECK dout0_10 Vdout0_10ck24 = 0 time = 125
.meas tran vdout0_10ck24 FIND v(dout0_10) AT=125.025n

* CHECK dout0_11 Vdout0_11ck24 = 0 time = 125
.meas tran vdout0_11ck24 FIND v(dout0_11) AT=125.025n

* CHECK dout0_12 Vdout0_12ck24 = 0 time = 125
.meas tran vdout0_12ck24 FIND v(dout0_12) AT=125.025n

* CHECK dout0_13 Vdout0_13ck24 = 0.9 time = 125
.meas tran vdout0_13ck24 FIND v(dout0_13) AT=125.025n

* CHECK dout0_14 Vdout0_14ck24 = 0.9 time = 125
.meas tran vdout0_14ck24 FIND v(dout0_14) AT=125.025n

* CHECK dout0_15 Vdout0_15ck24 = 0.9 time = 125
.meas tran vdout0_15ck24 FIND v(dout0_15) AT=125.025n

* CHECK dout0_16 Vdout0_16ck24 = 0.9 time = 125
.meas tran vdout0_16ck24 FIND v(dout0_16) AT=125.025n

* CHECK dout0_17 Vdout0_17ck24 = 0.9 time = 125
.meas tran vdout0_17ck24 FIND v(dout0_17) AT=125.025n

* CHECK dout0_18 Vdout0_18ck24 = 0 time = 125
.meas tran vdout0_18ck24 FIND v(dout0_18) AT=125.025n

* CHECK dout0_19 Vdout0_19ck24 = 0.9 time = 125
.meas tran vdout0_19ck24 FIND v(dout0_19) AT=125.025n

* CHECK dout0_20 Vdout0_20ck24 = 0.9 time = 125
.meas tran vdout0_20ck24 FIND v(dout0_20) AT=125.025n

* CHECK dout0_21 Vdout0_21ck24 = 0 time = 125
.meas tran vdout0_21ck24 FIND v(dout0_21) AT=125.025n

* CHECK dout0_22 Vdout0_22ck24 = 0.9 time = 125
.meas tran vdout0_22ck24 FIND v(dout0_22) AT=125.025n

* CHECK dout0_23 Vdout0_23ck24 = 0 time = 125
.meas tran vdout0_23ck24 FIND v(dout0_23) AT=125.025n

* CHECK dout0_24 Vdout0_24ck24 = 0.9 time = 125
.meas tran vdout0_24ck24 FIND v(dout0_24) AT=125.025n

* CHECK dout0_25 Vdout0_25ck24 = 0.9 time = 125
.meas tran vdout0_25ck24 FIND v(dout0_25) AT=125.025n

* CHECK dout0_26 Vdout0_26ck24 = 0.9 time = 125
.meas tran vdout0_26ck24 FIND v(dout0_26) AT=125.025n

* CHECK dout0_27 Vdout0_27ck24 = 0 time = 125
.meas tran vdout0_27ck24 FIND v(dout0_27) AT=125.025n

* CHECK dout0_28 Vdout0_28ck24 = 0.9 time = 125
.meas tran vdout0_28ck24 FIND v(dout0_28) AT=125.025n

* CHECK dout0_29 Vdout0_29ck24 = 0.9 time = 125
.meas tran vdout0_29ck24 FIND v(dout0_29) AT=125.025n

* CHECK dout0_30 Vdout0_30ck24 = 0.9 time = 125
.meas tran vdout0_30ck24 FIND v(dout0_30) AT=125.025n

* CHECK dout0_31 Vdout0_31ck24 = 0.9 time = 125
.meas tran vdout0_31ck24 FIND v(dout0_31) AT=125.025n

* CHECK dout0_32 Vdout0_32ck24 = 0.9 time = 125
.meas tran vdout0_32ck24 FIND v(dout0_32) AT=125.025n

* CHECK dout0_33 Vdout0_33ck24 = 0.9 time = 125
.meas tran vdout0_33ck24 FIND v(dout0_33) AT=125.025n

* CHECK dout0_34 Vdout0_34ck24 = 0.9 time = 125
.meas tran vdout0_34ck24 FIND v(dout0_34) AT=125.025n

* CHECK dout0_35 Vdout0_35ck24 = 0.9 time = 125
.meas tran vdout0_35ck24 FIND v(dout0_35) AT=125.025n

* CHECK dout0_36 Vdout0_36ck24 = 0.9 time = 125
.meas tran vdout0_36ck24 FIND v(dout0_36) AT=125.025n

* CHECK dout0_37 Vdout0_37ck24 = 0 time = 125
.meas tran vdout0_37ck24 FIND v(dout0_37) AT=125.025n

* CHECK dout0_38 Vdout0_38ck24 = 0 time = 125
.meas tran vdout0_38ck24 FIND v(dout0_38) AT=125.025n

* CHECK dout0_39 Vdout0_39ck24 = 0 time = 125
.meas tran vdout0_39ck24 FIND v(dout0_39) AT=125.025n

* CHECK dout0_40 Vdout0_40ck24 = 0.9 time = 125
.meas tran vdout0_40ck24 FIND v(dout0_40) AT=125.025n

* CHECK dout0_41 Vdout0_41ck24 = 0 time = 125
.meas tran vdout0_41ck24 FIND v(dout0_41) AT=125.025n

* CHECK dout0_42 Vdout0_42ck24 = 0.9 time = 125
.meas tran vdout0_42ck24 FIND v(dout0_42) AT=125.025n

* CHECK dout0_43 Vdout0_43ck24 = 0 time = 125
.meas tran vdout0_43ck24 FIND v(dout0_43) AT=125.025n

* CHECK dout0_44 Vdout0_44ck24 = 0.9 time = 125
.meas tran vdout0_44ck24 FIND v(dout0_44) AT=125.025n

* CHECK dout0_45 Vdout0_45ck24 = 0 time = 125
.meas tran vdout0_45ck24 FIND v(dout0_45) AT=125.025n

* CHECK dout0_46 Vdout0_46ck24 = 0 time = 125
.meas tran vdout0_46ck24 FIND v(dout0_46) AT=125.025n

* CHECK dout0_47 Vdout0_47ck24 = 0.9 time = 125
.meas tran vdout0_47ck24 FIND v(dout0_47) AT=125.025n

* CHECK dout0_48 Vdout0_48ck24 = 0.9 time = 125
.meas tran vdout0_48ck24 FIND v(dout0_48) AT=125.025n

* CHECK dout0_49 Vdout0_49ck24 = 0.9 time = 125
.meas tran vdout0_49ck24 FIND v(dout0_49) AT=125.025n

* CHECK dout0_50 Vdout0_50ck24 = 0 time = 125
.meas tran vdout0_50ck24 FIND v(dout0_50) AT=125.025n

* CHECK dout0_51 Vdout0_51ck24 = 0 time = 125
.meas tran vdout0_51ck24 FIND v(dout0_51) AT=125.025n

* CHECK dout0_52 Vdout0_52ck24 = 0.9 time = 125
.meas tran vdout0_52ck24 FIND v(dout0_52) AT=125.025n

* CHECK dout0_53 Vdout0_53ck24 = 0 time = 125
.meas tran vdout0_53ck24 FIND v(dout0_53) AT=125.025n

* CHECK dout0_54 Vdout0_54ck24 = 0 time = 125
.meas tran vdout0_54ck24 FIND v(dout0_54) AT=125.025n

* CHECK dout0_55 Vdout0_55ck24 = 0.9 time = 125
.meas tran vdout0_55ck24 FIND v(dout0_55) AT=125.025n

* CHECK dout0_56 Vdout0_56ck24 = 0.9 time = 125
.meas tran vdout0_56ck24 FIND v(dout0_56) AT=125.025n

* CHECK dout0_57 Vdout0_57ck24 = 0 time = 125
.meas tran vdout0_57ck24 FIND v(dout0_57) AT=125.025n

* CHECK dout0_58 Vdout0_58ck24 = 0.9 time = 125
.meas tran vdout0_58ck24 FIND v(dout0_58) AT=125.025n

* CHECK dout0_59 Vdout0_59ck24 = 0.9 time = 125
.meas tran vdout0_59ck24 FIND v(dout0_59) AT=125.025n

* CHECK dout0_60 Vdout0_60ck24 = 0 time = 125
.meas tran vdout0_60ck24 FIND v(dout0_60) AT=125.025n

* CHECK dout0_61 Vdout0_61ck24 = 0 time = 125
.meas tran vdout0_61ck24 FIND v(dout0_61) AT=125.025n

* CHECK dout0_62 Vdout0_62ck24 = 0.9 time = 125
.meas tran vdout0_62ck24 FIND v(dout0_62) AT=125.025n

* CHECK dout0_63 Vdout0_63ck24 = 0 time = 125
.meas tran vdout0_63ck24 FIND v(dout0_63) AT=125.025n

* CHECK dout0_64 Vdout0_64ck24 = 0 time = 125
.meas tran vdout0_64ck24 FIND v(dout0_64) AT=125.025n

* CHECK dout0_65 Vdout0_65ck24 = 0.9 time = 125
.meas tran vdout0_65ck24 FIND v(dout0_65) AT=125.025n

* CHECK dout0_66 Vdout0_66ck24 = 0.9 time = 125
.meas tran vdout0_66ck24 FIND v(dout0_66) AT=125.025n

* CHECK dout0_67 Vdout0_67ck24 = 0 time = 125
.meas tran vdout0_67ck24 FIND v(dout0_67) AT=125.025n

* CHECK dout0_68 Vdout0_68ck24 = 0 time = 125
.meas tran vdout0_68ck24 FIND v(dout0_68) AT=125.025n

* CHECK dout0_69 Vdout0_69ck24 = 0 time = 125
.meas tran vdout0_69ck24 FIND v(dout0_69) AT=125.025n

* CHECK dout0_70 Vdout0_70ck24 = 0.9 time = 125
.meas tran vdout0_70ck24 FIND v(dout0_70) AT=125.025n

* CHECK dout0_71 Vdout0_71ck24 = 0.9 time = 125
.meas tran vdout0_71ck24 FIND v(dout0_71) AT=125.025n

* CHECK dout0_72 Vdout0_72ck24 = 0 time = 125
.meas tran vdout0_72ck24 FIND v(dout0_72) AT=125.025n

* CHECK dout0_73 Vdout0_73ck24 = 0 time = 125
.meas tran vdout0_73ck24 FIND v(dout0_73) AT=125.025n

* CHECK dout0_74 Vdout0_74ck24 = 0 time = 125
.meas tran vdout0_74ck24 FIND v(dout0_74) AT=125.025n

* CHECK dout0_75 Vdout0_75ck24 = 0.9 time = 125
.meas tran vdout0_75ck24 FIND v(dout0_75) AT=125.025n

* CHECK dout0_76 Vdout0_76ck24 = 0.9 time = 125
.meas tran vdout0_76ck24 FIND v(dout0_76) AT=125.025n

* CHECK dout0_77 Vdout0_77ck24 = 0.9 time = 125
.meas tran vdout0_77ck24 FIND v(dout0_77) AT=125.025n

* CHECK dout0_78 Vdout0_78ck24 = 0.9 time = 125
.meas tran vdout0_78ck24 FIND v(dout0_78) AT=125.025n

* CHECK dout0_79 Vdout0_79ck24 = 0 time = 125
.meas tran vdout0_79ck24 FIND v(dout0_79) AT=125.025n

* CHECK dout0_80 Vdout0_80ck24 = 0.9 time = 125
.meas tran vdout0_80ck24 FIND v(dout0_80) AT=125.025n

* CHECK dout0_81 Vdout0_81ck24 = 0 time = 125
.meas tran vdout0_81ck24 FIND v(dout0_81) AT=125.025n

* CHECK dout0_82 Vdout0_82ck24 = 0 time = 125
.meas tran vdout0_82ck24 FIND v(dout0_82) AT=125.025n

* CHECK dout0_83 Vdout0_83ck24 = 0 time = 125
.meas tran vdout0_83ck24 FIND v(dout0_83) AT=125.025n

* CHECK dout0_84 Vdout0_84ck24 = 0 time = 125
.meas tran vdout0_84ck24 FIND v(dout0_84) AT=125.025n

* CHECK dout0_85 Vdout0_85ck24 = 0 time = 125
.meas tran vdout0_85ck24 FIND v(dout0_85) AT=125.025n

* CHECK dout0_86 Vdout0_86ck24 = 0 time = 125
.meas tran vdout0_86ck24 FIND v(dout0_86) AT=125.025n

* CHECK dout0_87 Vdout0_87ck24 = 0.9 time = 125
.meas tran vdout0_87ck24 FIND v(dout0_87) AT=125.025n

* CHECK dout0_0 Vdout0_0ck25 = 0.9 time = 130
.meas tran vdout0_0ck25 FIND v(dout0_0) AT=130.025n

* CHECK dout0_1 Vdout0_1ck25 = 0 time = 130
.meas tran vdout0_1ck25 FIND v(dout0_1) AT=130.025n

* CHECK dout0_2 Vdout0_2ck25 = 0.9 time = 130
.meas tran vdout0_2ck25 FIND v(dout0_2) AT=130.025n

* CHECK dout0_3 Vdout0_3ck25 = 0 time = 130
.meas tran vdout0_3ck25 FIND v(dout0_3) AT=130.025n

* CHECK dout0_4 Vdout0_4ck25 = 0.9 time = 130
.meas tran vdout0_4ck25 FIND v(dout0_4) AT=130.025n

* CHECK dout0_5 Vdout0_5ck25 = 0 time = 130
.meas tran vdout0_5ck25 FIND v(dout0_5) AT=130.025n

* CHECK dout0_6 Vdout0_6ck25 = 0 time = 130
.meas tran vdout0_6ck25 FIND v(dout0_6) AT=130.025n

* CHECK dout0_7 Vdout0_7ck25 = 0 time = 130
.meas tran vdout0_7ck25 FIND v(dout0_7) AT=130.025n

* CHECK dout0_8 Vdout0_8ck25 = 0.9 time = 130
.meas tran vdout0_8ck25 FIND v(dout0_8) AT=130.025n

* CHECK dout0_9 Vdout0_9ck25 = 0 time = 130
.meas tran vdout0_9ck25 FIND v(dout0_9) AT=130.025n

* CHECK dout0_10 Vdout0_10ck25 = 0 time = 130
.meas tran vdout0_10ck25 FIND v(dout0_10) AT=130.025n

* CHECK dout0_11 Vdout0_11ck25 = 0 time = 130
.meas tran vdout0_11ck25 FIND v(dout0_11) AT=130.025n

* CHECK dout0_12 Vdout0_12ck25 = 0 time = 130
.meas tran vdout0_12ck25 FIND v(dout0_12) AT=130.025n

* CHECK dout0_13 Vdout0_13ck25 = 0.9 time = 130
.meas tran vdout0_13ck25 FIND v(dout0_13) AT=130.025n

* CHECK dout0_14 Vdout0_14ck25 = 0.9 time = 130
.meas tran vdout0_14ck25 FIND v(dout0_14) AT=130.025n

* CHECK dout0_15 Vdout0_15ck25 = 0.9 time = 130
.meas tran vdout0_15ck25 FIND v(dout0_15) AT=130.025n

* CHECK dout0_16 Vdout0_16ck25 = 0.9 time = 130
.meas tran vdout0_16ck25 FIND v(dout0_16) AT=130.025n

* CHECK dout0_17 Vdout0_17ck25 = 0.9 time = 130
.meas tran vdout0_17ck25 FIND v(dout0_17) AT=130.025n

* CHECK dout0_18 Vdout0_18ck25 = 0 time = 130
.meas tran vdout0_18ck25 FIND v(dout0_18) AT=130.025n

* CHECK dout0_19 Vdout0_19ck25 = 0.9 time = 130
.meas tran vdout0_19ck25 FIND v(dout0_19) AT=130.025n

* CHECK dout0_20 Vdout0_20ck25 = 0.9 time = 130
.meas tran vdout0_20ck25 FIND v(dout0_20) AT=130.025n

* CHECK dout0_21 Vdout0_21ck25 = 0 time = 130
.meas tran vdout0_21ck25 FIND v(dout0_21) AT=130.025n

* CHECK dout0_22 Vdout0_22ck25 = 0.9 time = 130
.meas tran vdout0_22ck25 FIND v(dout0_22) AT=130.025n

* CHECK dout0_23 Vdout0_23ck25 = 0 time = 130
.meas tran vdout0_23ck25 FIND v(dout0_23) AT=130.025n

* CHECK dout0_24 Vdout0_24ck25 = 0.9 time = 130
.meas tran vdout0_24ck25 FIND v(dout0_24) AT=130.025n

* CHECK dout0_25 Vdout0_25ck25 = 0.9 time = 130
.meas tran vdout0_25ck25 FIND v(dout0_25) AT=130.025n

* CHECK dout0_26 Vdout0_26ck25 = 0.9 time = 130
.meas tran vdout0_26ck25 FIND v(dout0_26) AT=130.025n

* CHECK dout0_27 Vdout0_27ck25 = 0 time = 130
.meas tran vdout0_27ck25 FIND v(dout0_27) AT=130.025n

* CHECK dout0_28 Vdout0_28ck25 = 0.9 time = 130
.meas tran vdout0_28ck25 FIND v(dout0_28) AT=130.025n

* CHECK dout0_29 Vdout0_29ck25 = 0.9 time = 130
.meas tran vdout0_29ck25 FIND v(dout0_29) AT=130.025n

* CHECK dout0_30 Vdout0_30ck25 = 0.9 time = 130
.meas tran vdout0_30ck25 FIND v(dout0_30) AT=130.025n

* CHECK dout0_31 Vdout0_31ck25 = 0.9 time = 130
.meas tran vdout0_31ck25 FIND v(dout0_31) AT=130.025n

* CHECK dout0_32 Vdout0_32ck25 = 0.9 time = 130
.meas tran vdout0_32ck25 FIND v(dout0_32) AT=130.025n

* CHECK dout0_33 Vdout0_33ck25 = 0.9 time = 130
.meas tran vdout0_33ck25 FIND v(dout0_33) AT=130.025n

* CHECK dout0_34 Vdout0_34ck25 = 0.9 time = 130
.meas tran vdout0_34ck25 FIND v(dout0_34) AT=130.025n

* CHECK dout0_35 Vdout0_35ck25 = 0.9 time = 130
.meas tran vdout0_35ck25 FIND v(dout0_35) AT=130.025n

* CHECK dout0_36 Vdout0_36ck25 = 0.9 time = 130
.meas tran vdout0_36ck25 FIND v(dout0_36) AT=130.025n

* CHECK dout0_37 Vdout0_37ck25 = 0 time = 130
.meas tran vdout0_37ck25 FIND v(dout0_37) AT=130.025n

* CHECK dout0_38 Vdout0_38ck25 = 0 time = 130
.meas tran vdout0_38ck25 FIND v(dout0_38) AT=130.025n

* CHECK dout0_39 Vdout0_39ck25 = 0 time = 130
.meas tran vdout0_39ck25 FIND v(dout0_39) AT=130.025n

* CHECK dout0_40 Vdout0_40ck25 = 0.9 time = 130
.meas tran vdout0_40ck25 FIND v(dout0_40) AT=130.025n

* CHECK dout0_41 Vdout0_41ck25 = 0 time = 130
.meas tran vdout0_41ck25 FIND v(dout0_41) AT=130.025n

* CHECK dout0_42 Vdout0_42ck25 = 0.9 time = 130
.meas tran vdout0_42ck25 FIND v(dout0_42) AT=130.025n

* CHECK dout0_43 Vdout0_43ck25 = 0 time = 130
.meas tran vdout0_43ck25 FIND v(dout0_43) AT=130.025n

* CHECK dout0_44 Vdout0_44ck25 = 0.9 time = 130
.meas tran vdout0_44ck25 FIND v(dout0_44) AT=130.025n

* CHECK dout0_45 Vdout0_45ck25 = 0 time = 130
.meas tran vdout0_45ck25 FIND v(dout0_45) AT=130.025n

* CHECK dout0_46 Vdout0_46ck25 = 0 time = 130
.meas tran vdout0_46ck25 FIND v(dout0_46) AT=130.025n

* CHECK dout0_47 Vdout0_47ck25 = 0.9 time = 130
.meas tran vdout0_47ck25 FIND v(dout0_47) AT=130.025n

* CHECK dout0_48 Vdout0_48ck25 = 0.9 time = 130
.meas tran vdout0_48ck25 FIND v(dout0_48) AT=130.025n

* CHECK dout0_49 Vdout0_49ck25 = 0.9 time = 130
.meas tran vdout0_49ck25 FIND v(dout0_49) AT=130.025n

* CHECK dout0_50 Vdout0_50ck25 = 0 time = 130
.meas tran vdout0_50ck25 FIND v(dout0_50) AT=130.025n

* CHECK dout0_51 Vdout0_51ck25 = 0 time = 130
.meas tran vdout0_51ck25 FIND v(dout0_51) AT=130.025n

* CHECK dout0_52 Vdout0_52ck25 = 0.9 time = 130
.meas tran vdout0_52ck25 FIND v(dout0_52) AT=130.025n

* CHECK dout0_53 Vdout0_53ck25 = 0 time = 130
.meas tran vdout0_53ck25 FIND v(dout0_53) AT=130.025n

* CHECK dout0_54 Vdout0_54ck25 = 0 time = 130
.meas tran vdout0_54ck25 FIND v(dout0_54) AT=130.025n

* CHECK dout0_55 Vdout0_55ck25 = 0.9 time = 130
.meas tran vdout0_55ck25 FIND v(dout0_55) AT=130.025n

* CHECK dout0_56 Vdout0_56ck25 = 0.9 time = 130
.meas tran vdout0_56ck25 FIND v(dout0_56) AT=130.025n

* CHECK dout0_57 Vdout0_57ck25 = 0 time = 130
.meas tran vdout0_57ck25 FIND v(dout0_57) AT=130.025n

* CHECK dout0_58 Vdout0_58ck25 = 0.9 time = 130
.meas tran vdout0_58ck25 FIND v(dout0_58) AT=130.025n

* CHECK dout0_59 Vdout0_59ck25 = 0.9 time = 130
.meas tran vdout0_59ck25 FIND v(dout0_59) AT=130.025n

* CHECK dout0_60 Vdout0_60ck25 = 0 time = 130
.meas tran vdout0_60ck25 FIND v(dout0_60) AT=130.025n

* CHECK dout0_61 Vdout0_61ck25 = 0 time = 130
.meas tran vdout0_61ck25 FIND v(dout0_61) AT=130.025n

* CHECK dout0_62 Vdout0_62ck25 = 0.9 time = 130
.meas tran vdout0_62ck25 FIND v(dout0_62) AT=130.025n

* CHECK dout0_63 Vdout0_63ck25 = 0 time = 130
.meas tran vdout0_63ck25 FIND v(dout0_63) AT=130.025n

* CHECK dout0_64 Vdout0_64ck25 = 0 time = 130
.meas tran vdout0_64ck25 FIND v(dout0_64) AT=130.025n

* CHECK dout0_65 Vdout0_65ck25 = 0.9 time = 130
.meas tran vdout0_65ck25 FIND v(dout0_65) AT=130.025n

* CHECK dout0_66 Vdout0_66ck25 = 0.9 time = 130
.meas tran vdout0_66ck25 FIND v(dout0_66) AT=130.025n

* CHECK dout0_67 Vdout0_67ck25 = 0 time = 130
.meas tran vdout0_67ck25 FIND v(dout0_67) AT=130.025n

* CHECK dout0_68 Vdout0_68ck25 = 0 time = 130
.meas tran vdout0_68ck25 FIND v(dout0_68) AT=130.025n

* CHECK dout0_69 Vdout0_69ck25 = 0 time = 130
.meas tran vdout0_69ck25 FIND v(dout0_69) AT=130.025n

* CHECK dout0_70 Vdout0_70ck25 = 0.9 time = 130
.meas tran vdout0_70ck25 FIND v(dout0_70) AT=130.025n

* CHECK dout0_71 Vdout0_71ck25 = 0.9 time = 130
.meas tran vdout0_71ck25 FIND v(dout0_71) AT=130.025n

* CHECK dout0_72 Vdout0_72ck25 = 0 time = 130
.meas tran vdout0_72ck25 FIND v(dout0_72) AT=130.025n

* CHECK dout0_73 Vdout0_73ck25 = 0 time = 130
.meas tran vdout0_73ck25 FIND v(dout0_73) AT=130.025n

* CHECK dout0_74 Vdout0_74ck25 = 0 time = 130
.meas tran vdout0_74ck25 FIND v(dout0_74) AT=130.025n

* CHECK dout0_75 Vdout0_75ck25 = 0.9 time = 130
.meas tran vdout0_75ck25 FIND v(dout0_75) AT=130.025n

* CHECK dout0_76 Vdout0_76ck25 = 0.9 time = 130
.meas tran vdout0_76ck25 FIND v(dout0_76) AT=130.025n

* CHECK dout0_77 Vdout0_77ck25 = 0.9 time = 130
.meas tran vdout0_77ck25 FIND v(dout0_77) AT=130.025n

* CHECK dout0_78 Vdout0_78ck25 = 0.9 time = 130
.meas tran vdout0_78ck25 FIND v(dout0_78) AT=130.025n

* CHECK dout0_79 Vdout0_79ck25 = 0 time = 130
.meas tran vdout0_79ck25 FIND v(dout0_79) AT=130.025n

* CHECK dout0_80 Vdout0_80ck25 = 0.9 time = 130
.meas tran vdout0_80ck25 FIND v(dout0_80) AT=130.025n

* CHECK dout0_81 Vdout0_81ck25 = 0 time = 130
.meas tran vdout0_81ck25 FIND v(dout0_81) AT=130.025n

* CHECK dout0_82 Vdout0_82ck25 = 0 time = 130
.meas tran vdout0_82ck25 FIND v(dout0_82) AT=130.025n

* CHECK dout0_83 Vdout0_83ck25 = 0 time = 130
.meas tran vdout0_83ck25 FIND v(dout0_83) AT=130.025n

* CHECK dout0_84 Vdout0_84ck25 = 0 time = 130
.meas tran vdout0_84ck25 FIND v(dout0_84) AT=130.025n

* CHECK dout0_85 Vdout0_85ck25 = 0 time = 130
.meas tran vdout0_85ck25 FIND v(dout0_85) AT=130.025n

* CHECK dout0_86 Vdout0_86ck25 = 0 time = 130
.meas tran vdout0_86ck25 FIND v(dout0_86) AT=130.025n

* CHECK dout0_87 Vdout0_87ck25 = 0.9 time = 130
.meas tran vdout0_87ck25 FIND v(dout0_87) AT=130.025n

* CHECK dout0_0 Vdout0_0ck26 = 0.9 time = 135
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=135.025n

* CHECK dout0_1 Vdout0_1ck26 = 0 time = 135
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=135.025n

* CHECK dout0_2 Vdout0_2ck26 = 0.9 time = 135
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=135.025n

* CHECK dout0_3 Vdout0_3ck26 = 0 time = 135
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=135.025n

* CHECK dout0_4 Vdout0_4ck26 = 0.9 time = 135
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=135.025n

* CHECK dout0_5 Vdout0_5ck26 = 0 time = 135
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=135.025n

* CHECK dout0_6 Vdout0_6ck26 = 0 time = 135
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=135.025n

* CHECK dout0_7 Vdout0_7ck26 = 0 time = 135
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=135.025n

* CHECK dout0_8 Vdout0_8ck26 = 0.9 time = 135
.meas tran vdout0_8ck26 FIND v(dout0_8) AT=135.025n

* CHECK dout0_9 Vdout0_9ck26 = 0 time = 135
.meas tran vdout0_9ck26 FIND v(dout0_9) AT=135.025n

* CHECK dout0_10 Vdout0_10ck26 = 0 time = 135
.meas tran vdout0_10ck26 FIND v(dout0_10) AT=135.025n

* CHECK dout0_11 Vdout0_11ck26 = 0 time = 135
.meas tran vdout0_11ck26 FIND v(dout0_11) AT=135.025n

* CHECK dout0_12 Vdout0_12ck26 = 0 time = 135
.meas tran vdout0_12ck26 FIND v(dout0_12) AT=135.025n

* CHECK dout0_13 Vdout0_13ck26 = 0.9 time = 135
.meas tran vdout0_13ck26 FIND v(dout0_13) AT=135.025n

* CHECK dout0_14 Vdout0_14ck26 = 0.9 time = 135
.meas tran vdout0_14ck26 FIND v(dout0_14) AT=135.025n

* CHECK dout0_15 Vdout0_15ck26 = 0.9 time = 135
.meas tran vdout0_15ck26 FIND v(dout0_15) AT=135.025n

* CHECK dout0_16 Vdout0_16ck26 = 0.9 time = 135
.meas tran vdout0_16ck26 FIND v(dout0_16) AT=135.025n

* CHECK dout0_17 Vdout0_17ck26 = 0.9 time = 135
.meas tran vdout0_17ck26 FIND v(dout0_17) AT=135.025n

* CHECK dout0_18 Vdout0_18ck26 = 0 time = 135
.meas tran vdout0_18ck26 FIND v(dout0_18) AT=135.025n

* CHECK dout0_19 Vdout0_19ck26 = 0.9 time = 135
.meas tran vdout0_19ck26 FIND v(dout0_19) AT=135.025n

* CHECK dout0_20 Vdout0_20ck26 = 0.9 time = 135
.meas tran vdout0_20ck26 FIND v(dout0_20) AT=135.025n

* CHECK dout0_21 Vdout0_21ck26 = 0 time = 135
.meas tran vdout0_21ck26 FIND v(dout0_21) AT=135.025n

* CHECK dout0_22 Vdout0_22ck26 = 0.9 time = 135
.meas tran vdout0_22ck26 FIND v(dout0_22) AT=135.025n

* CHECK dout0_23 Vdout0_23ck26 = 0 time = 135
.meas tran vdout0_23ck26 FIND v(dout0_23) AT=135.025n

* CHECK dout0_24 Vdout0_24ck26 = 0.9 time = 135
.meas tran vdout0_24ck26 FIND v(dout0_24) AT=135.025n

* CHECK dout0_25 Vdout0_25ck26 = 0.9 time = 135
.meas tran vdout0_25ck26 FIND v(dout0_25) AT=135.025n

* CHECK dout0_26 Vdout0_26ck26 = 0.9 time = 135
.meas tran vdout0_26ck26 FIND v(dout0_26) AT=135.025n

* CHECK dout0_27 Vdout0_27ck26 = 0 time = 135
.meas tran vdout0_27ck26 FIND v(dout0_27) AT=135.025n

* CHECK dout0_28 Vdout0_28ck26 = 0.9 time = 135
.meas tran vdout0_28ck26 FIND v(dout0_28) AT=135.025n

* CHECK dout0_29 Vdout0_29ck26 = 0.9 time = 135
.meas tran vdout0_29ck26 FIND v(dout0_29) AT=135.025n

* CHECK dout0_30 Vdout0_30ck26 = 0.9 time = 135
.meas tran vdout0_30ck26 FIND v(dout0_30) AT=135.025n

* CHECK dout0_31 Vdout0_31ck26 = 0.9 time = 135
.meas tran vdout0_31ck26 FIND v(dout0_31) AT=135.025n

* CHECK dout0_32 Vdout0_32ck26 = 0.9 time = 135
.meas tran vdout0_32ck26 FIND v(dout0_32) AT=135.025n

* CHECK dout0_33 Vdout0_33ck26 = 0.9 time = 135
.meas tran vdout0_33ck26 FIND v(dout0_33) AT=135.025n

* CHECK dout0_34 Vdout0_34ck26 = 0.9 time = 135
.meas tran vdout0_34ck26 FIND v(dout0_34) AT=135.025n

* CHECK dout0_35 Vdout0_35ck26 = 0.9 time = 135
.meas tran vdout0_35ck26 FIND v(dout0_35) AT=135.025n

* CHECK dout0_36 Vdout0_36ck26 = 0.9 time = 135
.meas tran vdout0_36ck26 FIND v(dout0_36) AT=135.025n

* CHECK dout0_37 Vdout0_37ck26 = 0 time = 135
.meas tran vdout0_37ck26 FIND v(dout0_37) AT=135.025n

* CHECK dout0_38 Vdout0_38ck26 = 0 time = 135
.meas tran vdout0_38ck26 FIND v(dout0_38) AT=135.025n

* CHECK dout0_39 Vdout0_39ck26 = 0 time = 135
.meas tran vdout0_39ck26 FIND v(dout0_39) AT=135.025n

* CHECK dout0_40 Vdout0_40ck26 = 0.9 time = 135
.meas tran vdout0_40ck26 FIND v(dout0_40) AT=135.025n

* CHECK dout0_41 Vdout0_41ck26 = 0 time = 135
.meas tran vdout0_41ck26 FIND v(dout0_41) AT=135.025n

* CHECK dout0_42 Vdout0_42ck26 = 0.9 time = 135
.meas tran vdout0_42ck26 FIND v(dout0_42) AT=135.025n

* CHECK dout0_43 Vdout0_43ck26 = 0 time = 135
.meas tran vdout0_43ck26 FIND v(dout0_43) AT=135.025n

* CHECK dout0_44 Vdout0_44ck26 = 0.9 time = 135
.meas tran vdout0_44ck26 FIND v(dout0_44) AT=135.025n

* CHECK dout0_45 Vdout0_45ck26 = 0 time = 135
.meas tran vdout0_45ck26 FIND v(dout0_45) AT=135.025n

* CHECK dout0_46 Vdout0_46ck26 = 0 time = 135
.meas tran vdout0_46ck26 FIND v(dout0_46) AT=135.025n

* CHECK dout0_47 Vdout0_47ck26 = 0.9 time = 135
.meas tran vdout0_47ck26 FIND v(dout0_47) AT=135.025n

* CHECK dout0_48 Vdout0_48ck26 = 0.9 time = 135
.meas tran vdout0_48ck26 FIND v(dout0_48) AT=135.025n

* CHECK dout0_49 Vdout0_49ck26 = 0.9 time = 135
.meas tran vdout0_49ck26 FIND v(dout0_49) AT=135.025n

* CHECK dout0_50 Vdout0_50ck26 = 0 time = 135
.meas tran vdout0_50ck26 FIND v(dout0_50) AT=135.025n

* CHECK dout0_51 Vdout0_51ck26 = 0 time = 135
.meas tran vdout0_51ck26 FIND v(dout0_51) AT=135.025n

* CHECK dout0_52 Vdout0_52ck26 = 0.9 time = 135
.meas tran vdout0_52ck26 FIND v(dout0_52) AT=135.025n

* CHECK dout0_53 Vdout0_53ck26 = 0 time = 135
.meas tran vdout0_53ck26 FIND v(dout0_53) AT=135.025n

* CHECK dout0_54 Vdout0_54ck26 = 0 time = 135
.meas tran vdout0_54ck26 FIND v(dout0_54) AT=135.025n

* CHECK dout0_55 Vdout0_55ck26 = 0.9 time = 135
.meas tran vdout0_55ck26 FIND v(dout0_55) AT=135.025n

* CHECK dout0_56 Vdout0_56ck26 = 0.9 time = 135
.meas tran vdout0_56ck26 FIND v(dout0_56) AT=135.025n

* CHECK dout0_57 Vdout0_57ck26 = 0 time = 135
.meas tran vdout0_57ck26 FIND v(dout0_57) AT=135.025n

* CHECK dout0_58 Vdout0_58ck26 = 0.9 time = 135
.meas tran vdout0_58ck26 FIND v(dout0_58) AT=135.025n

* CHECK dout0_59 Vdout0_59ck26 = 0.9 time = 135
.meas tran vdout0_59ck26 FIND v(dout0_59) AT=135.025n

* CHECK dout0_60 Vdout0_60ck26 = 0 time = 135
.meas tran vdout0_60ck26 FIND v(dout0_60) AT=135.025n

* CHECK dout0_61 Vdout0_61ck26 = 0 time = 135
.meas tran vdout0_61ck26 FIND v(dout0_61) AT=135.025n

* CHECK dout0_62 Vdout0_62ck26 = 0.9 time = 135
.meas tran vdout0_62ck26 FIND v(dout0_62) AT=135.025n

* CHECK dout0_63 Vdout0_63ck26 = 0 time = 135
.meas tran vdout0_63ck26 FIND v(dout0_63) AT=135.025n

* CHECK dout0_64 Vdout0_64ck26 = 0 time = 135
.meas tran vdout0_64ck26 FIND v(dout0_64) AT=135.025n

* CHECK dout0_65 Vdout0_65ck26 = 0.9 time = 135
.meas tran vdout0_65ck26 FIND v(dout0_65) AT=135.025n

* CHECK dout0_66 Vdout0_66ck26 = 0.9 time = 135
.meas tran vdout0_66ck26 FIND v(dout0_66) AT=135.025n

* CHECK dout0_67 Vdout0_67ck26 = 0 time = 135
.meas tran vdout0_67ck26 FIND v(dout0_67) AT=135.025n

* CHECK dout0_68 Vdout0_68ck26 = 0 time = 135
.meas tran vdout0_68ck26 FIND v(dout0_68) AT=135.025n

* CHECK dout0_69 Vdout0_69ck26 = 0 time = 135
.meas tran vdout0_69ck26 FIND v(dout0_69) AT=135.025n

* CHECK dout0_70 Vdout0_70ck26 = 0.9 time = 135
.meas tran vdout0_70ck26 FIND v(dout0_70) AT=135.025n

* CHECK dout0_71 Vdout0_71ck26 = 0.9 time = 135
.meas tran vdout0_71ck26 FIND v(dout0_71) AT=135.025n

* CHECK dout0_72 Vdout0_72ck26 = 0 time = 135
.meas tran vdout0_72ck26 FIND v(dout0_72) AT=135.025n

* CHECK dout0_73 Vdout0_73ck26 = 0 time = 135
.meas tran vdout0_73ck26 FIND v(dout0_73) AT=135.025n

* CHECK dout0_74 Vdout0_74ck26 = 0 time = 135
.meas tran vdout0_74ck26 FIND v(dout0_74) AT=135.025n

* CHECK dout0_75 Vdout0_75ck26 = 0.9 time = 135
.meas tran vdout0_75ck26 FIND v(dout0_75) AT=135.025n

* CHECK dout0_76 Vdout0_76ck26 = 0.9 time = 135
.meas tran vdout0_76ck26 FIND v(dout0_76) AT=135.025n

* CHECK dout0_77 Vdout0_77ck26 = 0.9 time = 135
.meas tran vdout0_77ck26 FIND v(dout0_77) AT=135.025n

* CHECK dout0_78 Vdout0_78ck26 = 0.9 time = 135
.meas tran vdout0_78ck26 FIND v(dout0_78) AT=135.025n

* CHECK dout0_79 Vdout0_79ck26 = 0 time = 135
.meas tran vdout0_79ck26 FIND v(dout0_79) AT=135.025n

* CHECK dout0_80 Vdout0_80ck26 = 0.9 time = 135
.meas tran vdout0_80ck26 FIND v(dout0_80) AT=135.025n

* CHECK dout0_81 Vdout0_81ck26 = 0 time = 135
.meas tran vdout0_81ck26 FIND v(dout0_81) AT=135.025n

* CHECK dout0_82 Vdout0_82ck26 = 0 time = 135
.meas tran vdout0_82ck26 FIND v(dout0_82) AT=135.025n

* CHECK dout0_83 Vdout0_83ck26 = 0 time = 135
.meas tran vdout0_83ck26 FIND v(dout0_83) AT=135.025n

* CHECK dout0_84 Vdout0_84ck26 = 0 time = 135
.meas tran vdout0_84ck26 FIND v(dout0_84) AT=135.025n

* CHECK dout0_85 Vdout0_85ck26 = 0 time = 135
.meas tran vdout0_85ck26 FIND v(dout0_85) AT=135.025n

* CHECK dout0_86 Vdout0_86ck26 = 0 time = 135
.meas tran vdout0_86ck26 FIND v(dout0_86) AT=135.025n

* CHECK dout0_87 Vdout0_87ck26 = 0.9 time = 135
.meas tran vdout0_87ck26 FIND v(dout0_87) AT=135.025n

* CHECK dout0_0 Vdout0_0ck27 = 0 time = 140
.meas tran vdout0_0ck27 FIND v(dout0_0) AT=140.025n

* CHECK dout0_1 Vdout0_1ck27 = 0.9 time = 140
.meas tran vdout0_1ck27 FIND v(dout0_1) AT=140.025n

* CHECK dout0_2 Vdout0_2ck27 = 0.9 time = 140
.meas tran vdout0_2ck27 FIND v(dout0_2) AT=140.025n

* CHECK dout0_3 Vdout0_3ck27 = 0 time = 140
.meas tran vdout0_3ck27 FIND v(dout0_3) AT=140.025n

* CHECK dout0_4 Vdout0_4ck27 = 0.9 time = 140
.meas tran vdout0_4ck27 FIND v(dout0_4) AT=140.025n

* CHECK dout0_5 Vdout0_5ck27 = 0 time = 140
.meas tran vdout0_5ck27 FIND v(dout0_5) AT=140.025n

* CHECK dout0_6 Vdout0_6ck27 = 0.9 time = 140
.meas tran vdout0_6ck27 FIND v(dout0_6) AT=140.025n

* CHECK dout0_7 Vdout0_7ck27 = 0.9 time = 140
.meas tran vdout0_7ck27 FIND v(dout0_7) AT=140.025n

* CHECK dout0_8 Vdout0_8ck27 = 0 time = 140
.meas tran vdout0_8ck27 FIND v(dout0_8) AT=140.025n

* CHECK dout0_9 Vdout0_9ck27 = 0 time = 140
.meas tran vdout0_9ck27 FIND v(dout0_9) AT=140.025n

* CHECK dout0_10 Vdout0_10ck27 = 0 time = 140
.meas tran vdout0_10ck27 FIND v(dout0_10) AT=140.025n

* CHECK dout0_11 Vdout0_11ck27 = 0 time = 140
.meas tran vdout0_11ck27 FIND v(dout0_11) AT=140.025n

* CHECK dout0_12 Vdout0_12ck27 = 0 time = 140
.meas tran vdout0_12ck27 FIND v(dout0_12) AT=140.025n

* CHECK dout0_13 Vdout0_13ck27 = 0.9 time = 140
.meas tran vdout0_13ck27 FIND v(dout0_13) AT=140.025n

* CHECK dout0_14 Vdout0_14ck27 = 0 time = 140
.meas tran vdout0_14ck27 FIND v(dout0_14) AT=140.025n

* CHECK dout0_15 Vdout0_15ck27 = 0.9 time = 140
.meas tran vdout0_15ck27 FIND v(dout0_15) AT=140.025n

* CHECK dout0_16 Vdout0_16ck27 = 0.9 time = 140
.meas tran vdout0_16ck27 FIND v(dout0_16) AT=140.025n

* CHECK dout0_17 Vdout0_17ck27 = 0 time = 140
.meas tran vdout0_17ck27 FIND v(dout0_17) AT=140.025n

* CHECK dout0_18 Vdout0_18ck27 = 0.9 time = 140
.meas tran vdout0_18ck27 FIND v(dout0_18) AT=140.025n

* CHECK dout0_19 Vdout0_19ck27 = 0.9 time = 140
.meas tran vdout0_19ck27 FIND v(dout0_19) AT=140.025n

* CHECK dout0_20 Vdout0_20ck27 = 0 time = 140
.meas tran vdout0_20ck27 FIND v(dout0_20) AT=140.025n

* CHECK dout0_21 Vdout0_21ck27 = 0.9 time = 140
.meas tran vdout0_21ck27 FIND v(dout0_21) AT=140.025n

* CHECK dout0_22 Vdout0_22ck27 = 0 time = 140
.meas tran vdout0_22ck27 FIND v(dout0_22) AT=140.025n

* CHECK dout0_23 Vdout0_23ck27 = 0 time = 140
.meas tran vdout0_23ck27 FIND v(dout0_23) AT=140.025n

* CHECK dout0_24 Vdout0_24ck27 = 0 time = 140
.meas tran vdout0_24ck27 FIND v(dout0_24) AT=140.025n

* CHECK dout0_25 Vdout0_25ck27 = 0 time = 140
.meas tran vdout0_25ck27 FIND v(dout0_25) AT=140.025n

* CHECK dout0_26 Vdout0_26ck27 = 0 time = 140
.meas tran vdout0_26ck27 FIND v(dout0_26) AT=140.025n

* CHECK dout0_27 Vdout0_27ck27 = 0.9 time = 140
.meas tran vdout0_27ck27 FIND v(dout0_27) AT=140.025n

* CHECK dout0_28 Vdout0_28ck27 = 0.9 time = 140
.meas tran vdout0_28ck27 FIND v(dout0_28) AT=140.025n

* CHECK dout0_29 Vdout0_29ck27 = 0.9 time = 140
.meas tran vdout0_29ck27 FIND v(dout0_29) AT=140.025n

* CHECK dout0_30 Vdout0_30ck27 = 0.9 time = 140
.meas tran vdout0_30ck27 FIND v(dout0_30) AT=140.025n

* CHECK dout0_31 Vdout0_31ck27 = 0 time = 140
.meas tran vdout0_31ck27 FIND v(dout0_31) AT=140.025n

* CHECK dout0_32 Vdout0_32ck27 = 0 time = 140
.meas tran vdout0_32ck27 FIND v(dout0_32) AT=140.025n

* CHECK dout0_33 Vdout0_33ck27 = 0.9 time = 140
.meas tran vdout0_33ck27 FIND v(dout0_33) AT=140.025n

* CHECK dout0_34 Vdout0_34ck27 = 0 time = 140
.meas tran vdout0_34ck27 FIND v(dout0_34) AT=140.025n

* CHECK dout0_35 Vdout0_35ck27 = 0 time = 140
.meas tran vdout0_35ck27 FIND v(dout0_35) AT=140.025n

* CHECK dout0_36 Vdout0_36ck27 = 0 time = 140
.meas tran vdout0_36ck27 FIND v(dout0_36) AT=140.025n

* CHECK dout0_37 Vdout0_37ck27 = 0.9 time = 140
.meas tran vdout0_37ck27 FIND v(dout0_37) AT=140.025n

* CHECK dout0_38 Vdout0_38ck27 = 0 time = 140
.meas tran vdout0_38ck27 FIND v(dout0_38) AT=140.025n

* CHECK dout0_39 Vdout0_39ck27 = 0.9 time = 140
.meas tran vdout0_39ck27 FIND v(dout0_39) AT=140.025n

* CHECK dout0_40 Vdout0_40ck27 = 0 time = 140
.meas tran vdout0_40ck27 FIND v(dout0_40) AT=140.025n

* CHECK dout0_41 Vdout0_41ck27 = 0.9 time = 140
.meas tran vdout0_41ck27 FIND v(dout0_41) AT=140.025n

* CHECK dout0_42 Vdout0_42ck27 = 0.9 time = 140
.meas tran vdout0_42ck27 FIND v(dout0_42) AT=140.025n

* CHECK dout0_43 Vdout0_43ck27 = 0.9 time = 140
.meas tran vdout0_43ck27 FIND v(dout0_43) AT=140.025n

* CHECK dout0_44 Vdout0_44ck27 = 0.9 time = 140
.meas tran vdout0_44ck27 FIND v(dout0_44) AT=140.025n

* CHECK dout0_45 Vdout0_45ck27 = 0.9 time = 140
.meas tran vdout0_45ck27 FIND v(dout0_45) AT=140.025n

* CHECK dout0_46 Vdout0_46ck27 = 0.9 time = 140
.meas tran vdout0_46ck27 FIND v(dout0_46) AT=140.025n

* CHECK dout0_47 Vdout0_47ck27 = 0 time = 140
.meas tran vdout0_47ck27 FIND v(dout0_47) AT=140.025n

* CHECK dout0_48 Vdout0_48ck27 = 0 time = 140
.meas tran vdout0_48ck27 FIND v(dout0_48) AT=140.025n

* CHECK dout0_49 Vdout0_49ck27 = 0 time = 140
.meas tran vdout0_49ck27 FIND v(dout0_49) AT=140.025n

* CHECK dout0_50 Vdout0_50ck27 = 0.9 time = 140
.meas tran vdout0_50ck27 FIND v(dout0_50) AT=140.025n

* CHECK dout0_51 Vdout0_51ck27 = 0 time = 140
.meas tran vdout0_51ck27 FIND v(dout0_51) AT=140.025n

* CHECK dout0_52 Vdout0_52ck27 = 0.9 time = 140
.meas tran vdout0_52ck27 FIND v(dout0_52) AT=140.025n

* CHECK dout0_53 Vdout0_53ck27 = 0 time = 140
.meas tran vdout0_53ck27 FIND v(dout0_53) AT=140.025n

* CHECK dout0_54 Vdout0_54ck27 = 0 time = 140
.meas tran vdout0_54ck27 FIND v(dout0_54) AT=140.025n

* CHECK dout0_55 Vdout0_55ck27 = 0 time = 140
.meas tran vdout0_55ck27 FIND v(dout0_55) AT=140.025n

* CHECK dout0_56 Vdout0_56ck27 = 0 time = 140
.meas tran vdout0_56ck27 FIND v(dout0_56) AT=140.025n

* CHECK dout0_57 Vdout0_57ck27 = 0.9 time = 140
.meas tran vdout0_57ck27 FIND v(dout0_57) AT=140.025n

* CHECK dout0_58 Vdout0_58ck27 = 0.9 time = 140
.meas tran vdout0_58ck27 FIND v(dout0_58) AT=140.025n

* CHECK dout0_59 Vdout0_59ck27 = 0 time = 140
.meas tran vdout0_59ck27 FIND v(dout0_59) AT=140.025n

* CHECK dout0_60 Vdout0_60ck27 = 0.9 time = 140
.meas tran vdout0_60ck27 FIND v(dout0_60) AT=140.025n

* CHECK dout0_61 Vdout0_61ck27 = 0 time = 140
.meas tran vdout0_61ck27 FIND v(dout0_61) AT=140.025n

* CHECK dout0_62 Vdout0_62ck27 = 0 time = 140
.meas tran vdout0_62ck27 FIND v(dout0_62) AT=140.025n

* CHECK dout0_63 Vdout0_63ck27 = 0 time = 140
.meas tran vdout0_63ck27 FIND v(dout0_63) AT=140.025n

* CHECK dout0_64 Vdout0_64ck27 = 0 time = 140
.meas tran vdout0_64ck27 FIND v(dout0_64) AT=140.025n

* CHECK dout0_65 Vdout0_65ck27 = 0.9 time = 140
.meas tran vdout0_65ck27 FIND v(dout0_65) AT=140.025n

* CHECK dout0_66 Vdout0_66ck27 = 0.9 time = 140
.meas tran vdout0_66ck27 FIND v(dout0_66) AT=140.025n

* CHECK dout0_67 Vdout0_67ck27 = 0.9 time = 140
.meas tran vdout0_67ck27 FIND v(dout0_67) AT=140.025n

* CHECK dout0_68 Vdout0_68ck27 = 0.9 time = 140
.meas tran vdout0_68ck27 FIND v(dout0_68) AT=140.025n

* CHECK dout0_69 Vdout0_69ck27 = 0 time = 140
.meas tran vdout0_69ck27 FIND v(dout0_69) AT=140.025n

* CHECK dout0_70 Vdout0_70ck27 = 0.9 time = 140
.meas tran vdout0_70ck27 FIND v(dout0_70) AT=140.025n

* CHECK dout0_71 Vdout0_71ck27 = 0.9 time = 140
.meas tran vdout0_71ck27 FIND v(dout0_71) AT=140.025n

* CHECK dout0_72 Vdout0_72ck27 = 0 time = 140
.meas tran vdout0_72ck27 FIND v(dout0_72) AT=140.025n

* CHECK dout0_73 Vdout0_73ck27 = 0.9 time = 140
.meas tran vdout0_73ck27 FIND v(dout0_73) AT=140.025n

* CHECK dout0_74 Vdout0_74ck27 = 0.9 time = 140
.meas tran vdout0_74ck27 FIND v(dout0_74) AT=140.025n

* CHECK dout0_75 Vdout0_75ck27 = 0 time = 140
.meas tran vdout0_75ck27 FIND v(dout0_75) AT=140.025n

* CHECK dout0_76 Vdout0_76ck27 = 0 time = 140
.meas tran vdout0_76ck27 FIND v(dout0_76) AT=140.025n

* CHECK dout0_77 Vdout0_77ck27 = 0 time = 140
.meas tran vdout0_77ck27 FIND v(dout0_77) AT=140.025n

* CHECK dout0_78 Vdout0_78ck27 = 0 time = 140
.meas tran vdout0_78ck27 FIND v(dout0_78) AT=140.025n

* CHECK dout0_79 Vdout0_79ck27 = 0.9 time = 140
.meas tran vdout0_79ck27 FIND v(dout0_79) AT=140.025n

* CHECK dout0_80 Vdout0_80ck27 = 0.9 time = 140
.meas tran vdout0_80ck27 FIND v(dout0_80) AT=140.025n

* CHECK dout0_81 Vdout0_81ck27 = 0.9 time = 140
.meas tran vdout0_81ck27 FIND v(dout0_81) AT=140.025n

* CHECK dout0_82 Vdout0_82ck27 = 0 time = 140
.meas tran vdout0_82ck27 FIND v(dout0_82) AT=140.025n

* CHECK dout0_83 Vdout0_83ck27 = 0 time = 140
.meas tran vdout0_83ck27 FIND v(dout0_83) AT=140.025n

* CHECK dout0_84 Vdout0_84ck27 = 0.9 time = 140
.meas tran vdout0_84ck27 FIND v(dout0_84) AT=140.025n

* CHECK dout0_85 Vdout0_85ck27 = 0 time = 140
.meas tran vdout0_85ck27 FIND v(dout0_85) AT=140.025n

* CHECK dout0_86 Vdout0_86ck27 = 0 time = 140
.meas tran vdout0_86ck27 FIND v(dout0_86) AT=140.025n

* CHECK dout0_87 Vdout0_87ck27 = 0 time = 140
.meas tran vdout0_87ck27 FIND v(dout0_87) AT=140.025n

* CHECK dout0_0 Vdout0_0ck30 = 0.9 time = 155
.meas tran vdout0_0ck30 FIND v(dout0_0) AT=155.025n

* CHECK dout0_1 Vdout0_1ck30 = 0.9 time = 155
.meas tran vdout0_1ck30 FIND v(dout0_1) AT=155.025n

* CHECK dout0_2 Vdout0_2ck30 = 0 time = 155
.meas tran vdout0_2ck30 FIND v(dout0_2) AT=155.025n

* CHECK dout0_3 Vdout0_3ck30 = 0.9 time = 155
.meas tran vdout0_3ck30 FIND v(dout0_3) AT=155.025n

* CHECK dout0_4 Vdout0_4ck30 = 0 time = 155
.meas tran vdout0_4ck30 FIND v(dout0_4) AT=155.025n

* CHECK dout0_5 Vdout0_5ck30 = 0.9 time = 155
.meas tran vdout0_5ck30 FIND v(dout0_5) AT=155.025n

* CHECK dout0_6 Vdout0_6ck30 = 0.9 time = 155
.meas tran vdout0_6ck30 FIND v(dout0_6) AT=155.025n

* CHECK dout0_7 Vdout0_7ck30 = 0 time = 155
.meas tran vdout0_7ck30 FIND v(dout0_7) AT=155.025n

* CHECK dout0_8 Vdout0_8ck30 = 0 time = 155
.meas tran vdout0_8ck30 FIND v(dout0_8) AT=155.025n

* CHECK dout0_9 Vdout0_9ck30 = 0.9 time = 155
.meas tran vdout0_9ck30 FIND v(dout0_9) AT=155.025n

* CHECK dout0_10 Vdout0_10ck30 = 0 time = 155
.meas tran vdout0_10ck30 FIND v(dout0_10) AT=155.025n

* CHECK dout0_11 Vdout0_11ck30 = 0 time = 155
.meas tran vdout0_11ck30 FIND v(dout0_11) AT=155.025n

* CHECK dout0_12 Vdout0_12ck30 = 0.9 time = 155
.meas tran vdout0_12ck30 FIND v(dout0_12) AT=155.025n

* CHECK dout0_13 Vdout0_13ck30 = 0.9 time = 155
.meas tran vdout0_13ck30 FIND v(dout0_13) AT=155.025n

* CHECK dout0_14 Vdout0_14ck30 = 0.9 time = 155
.meas tran vdout0_14ck30 FIND v(dout0_14) AT=155.025n

* CHECK dout0_15 Vdout0_15ck30 = 0 time = 155
.meas tran vdout0_15ck30 FIND v(dout0_15) AT=155.025n

* CHECK dout0_16 Vdout0_16ck30 = 0 time = 155
.meas tran vdout0_16ck30 FIND v(dout0_16) AT=155.025n

* CHECK dout0_17 Vdout0_17ck30 = 0.9 time = 155
.meas tran vdout0_17ck30 FIND v(dout0_17) AT=155.025n

* CHECK dout0_18 Vdout0_18ck30 = 0.9 time = 155
.meas tran vdout0_18ck30 FIND v(dout0_18) AT=155.025n

* CHECK dout0_19 Vdout0_19ck30 = 0 time = 155
.meas tran vdout0_19ck30 FIND v(dout0_19) AT=155.025n

* CHECK dout0_20 Vdout0_20ck30 = 0 time = 155
.meas tran vdout0_20ck30 FIND v(dout0_20) AT=155.025n

* CHECK dout0_21 Vdout0_21ck30 = 0.9 time = 155
.meas tran vdout0_21ck30 FIND v(dout0_21) AT=155.025n

* CHECK dout0_22 Vdout0_22ck30 = 0 time = 155
.meas tran vdout0_22ck30 FIND v(dout0_22) AT=155.025n

* CHECK dout0_23 Vdout0_23ck30 = 0.9 time = 155
.meas tran vdout0_23ck30 FIND v(dout0_23) AT=155.025n

* CHECK dout0_24 Vdout0_24ck30 = 0 time = 155
.meas tran vdout0_24ck30 FIND v(dout0_24) AT=155.025n

* CHECK dout0_25 Vdout0_25ck30 = 0 time = 155
.meas tran vdout0_25ck30 FIND v(dout0_25) AT=155.025n

* CHECK dout0_26 Vdout0_26ck30 = 0.9 time = 155
.meas tran vdout0_26ck30 FIND v(dout0_26) AT=155.025n

* CHECK dout0_27 Vdout0_27ck30 = 0 time = 155
.meas tran vdout0_27ck30 FIND v(dout0_27) AT=155.025n

* CHECK dout0_28 Vdout0_28ck30 = 0 time = 155
.meas tran vdout0_28ck30 FIND v(dout0_28) AT=155.025n

* CHECK dout0_29 Vdout0_29ck30 = 0 time = 155
.meas tran vdout0_29ck30 FIND v(dout0_29) AT=155.025n

* CHECK dout0_30 Vdout0_30ck30 = 0.9 time = 155
.meas tran vdout0_30ck30 FIND v(dout0_30) AT=155.025n

* CHECK dout0_31 Vdout0_31ck30 = 0 time = 155
.meas tran vdout0_31ck30 FIND v(dout0_31) AT=155.025n

* CHECK dout0_32 Vdout0_32ck30 = 0 time = 155
.meas tran vdout0_32ck30 FIND v(dout0_32) AT=155.025n

* CHECK dout0_33 Vdout0_33ck30 = 0.9 time = 155
.meas tran vdout0_33ck30 FIND v(dout0_33) AT=155.025n

* CHECK dout0_34 Vdout0_34ck30 = 0 time = 155
.meas tran vdout0_34ck30 FIND v(dout0_34) AT=155.025n

* CHECK dout0_35 Vdout0_35ck30 = 0 time = 155
.meas tran vdout0_35ck30 FIND v(dout0_35) AT=155.025n

* CHECK dout0_36 Vdout0_36ck30 = 0 time = 155
.meas tran vdout0_36ck30 FIND v(dout0_36) AT=155.025n

* CHECK dout0_37 Vdout0_37ck30 = 0.9 time = 155
.meas tran vdout0_37ck30 FIND v(dout0_37) AT=155.025n

* CHECK dout0_38 Vdout0_38ck30 = 0 time = 155
.meas tran vdout0_38ck30 FIND v(dout0_38) AT=155.025n

* CHECK dout0_39 Vdout0_39ck30 = 0.9 time = 155
.meas tran vdout0_39ck30 FIND v(dout0_39) AT=155.025n

* CHECK dout0_40 Vdout0_40ck30 = 0 time = 155
.meas tran vdout0_40ck30 FIND v(dout0_40) AT=155.025n

* CHECK dout0_41 Vdout0_41ck30 = 0.9 time = 155
.meas tran vdout0_41ck30 FIND v(dout0_41) AT=155.025n

* CHECK dout0_42 Vdout0_42ck30 = 0 time = 155
.meas tran vdout0_42ck30 FIND v(dout0_42) AT=155.025n

* CHECK dout0_43 Vdout0_43ck30 = 0 time = 155
.meas tran vdout0_43ck30 FIND v(dout0_43) AT=155.025n

* CHECK dout0_44 Vdout0_44ck30 = 0 time = 155
.meas tran vdout0_44ck30 FIND v(dout0_44) AT=155.025n

* CHECK dout0_45 Vdout0_45ck30 = 0 time = 155
.meas tran vdout0_45ck30 FIND v(dout0_45) AT=155.025n

* CHECK dout0_46 Vdout0_46ck30 = 0 time = 155
.meas tran vdout0_46ck30 FIND v(dout0_46) AT=155.025n

* CHECK dout0_47 Vdout0_47ck30 = 0.9 time = 155
.meas tran vdout0_47ck30 FIND v(dout0_47) AT=155.025n

* CHECK dout0_48 Vdout0_48ck30 = 0.9 time = 155
.meas tran vdout0_48ck30 FIND v(dout0_48) AT=155.025n

* CHECK dout0_49 Vdout0_49ck30 = 0.9 time = 155
.meas tran vdout0_49ck30 FIND v(dout0_49) AT=155.025n

* CHECK dout0_50 Vdout0_50ck30 = 0.9 time = 155
.meas tran vdout0_50ck30 FIND v(dout0_50) AT=155.025n

* CHECK dout0_51 Vdout0_51ck30 = 0 time = 155
.meas tran vdout0_51ck30 FIND v(dout0_51) AT=155.025n

* CHECK dout0_52 Vdout0_52ck30 = 0 time = 155
.meas tran vdout0_52ck30 FIND v(dout0_52) AT=155.025n

* CHECK dout0_53 Vdout0_53ck30 = 0 time = 155
.meas tran vdout0_53ck30 FIND v(dout0_53) AT=155.025n

* CHECK dout0_54 Vdout0_54ck30 = 0 time = 155
.meas tran vdout0_54ck30 FIND v(dout0_54) AT=155.025n

* CHECK dout0_55 Vdout0_55ck30 = 0 time = 155
.meas tran vdout0_55ck30 FIND v(dout0_55) AT=155.025n

* CHECK dout0_56 Vdout0_56ck30 = 0 time = 155
.meas tran vdout0_56ck30 FIND v(dout0_56) AT=155.025n

* CHECK dout0_57 Vdout0_57ck30 = 0.9 time = 155
.meas tran vdout0_57ck30 FIND v(dout0_57) AT=155.025n

* CHECK dout0_58 Vdout0_58ck30 = 0 time = 155
.meas tran vdout0_58ck30 FIND v(dout0_58) AT=155.025n

* CHECK dout0_59 Vdout0_59ck30 = 0.9 time = 155
.meas tran vdout0_59ck30 FIND v(dout0_59) AT=155.025n

* CHECK dout0_60 Vdout0_60ck30 = 0 time = 155
.meas tran vdout0_60ck30 FIND v(dout0_60) AT=155.025n

* CHECK dout0_61 Vdout0_61ck30 = 0.9 time = 155
.meas tran vdout0_61ck30 FIND v(dout0_61) AT=155.025n

* CHECK dout0_62 Vdout0_62ck30 = 0 time = 155
.meas tran vdout0_62ck30 FIND v(dout0_62) AT=155.025n

* CHECK dout0_63 Vdout0_63ck30 = 0.9 time = 155
.meas tran vdout0_63ck30 FIND v(dout0_63) AT=155.025n

* CHECK dout0_64 Vdout0_64ck30 = 0.9 time = 155
.meas tran vdout0_64ck30 FIND v(dout0_64) AT=155.025n

* CHECK dout0_65 Vdout0_65ck30 = 0.9 time = 155
.meas tran vdout0_65ck30 FIND v(dout0_65) AT=155.025n

* CHECK dout0_66 Vdout0_66ck30 = 0 time = 155
.meas tran vdout0_66ck30 FIND v(dout0_66) AT=155.025n

* CHECK dout0_67 Vdout0_67ck30 = 0 time = 155
.meas tran vdout0_67ck30 FIND v(dout0_67) AT=155.025n

* CHECK dout0_68 Vdout0_68ck30 = 0 time = 155
.meas tran vdout0_68ck30 FIND v(dout0_68) AT=155.025n

* CHECK dout0_69 Vdout0_69ck30 = 0.9 time = 155
.meas tran vdout0_69ck30 FIND v(dout0_69) AT=155.025n

* CHECK dout0_70 Vdout0_70ck30 = 0 time = 155
.meas tran vdout0_70ck30 FIND v(dout0_70) AT=155.025n

* CHECK dout0_71 Vdout0_71ck30 = 0 time = 155
.meas tran vdout0_71ck30 FIND v(dout0_71) AT=155.025n

* CHECK dout0_72 Vdout0_72ck30 = 0 time = 155
.meas tran vdout0_72ck30 FIND v(dout0_72) AT=155.025n

* CHECK dout0_73 Vdout0_73ck30 = 0.9 time = 155
.meas tran vdout0_73ck30 FIND v(dout0_73) AT=155.025n

* CHECK dout0_74 Vdout0_74ck30 = 0.9 time = 155
.meas tran vdout0_74ck30 FIND v(dout0_74) AT=155.025n

* CHECK dout0_75 Vdout0_75ck30 = 0.9 time = 155
.meas tran vdout0_75ck30 FIND v(dout0_75) AT=155.025n

* CHECK dout0_76 Vdout0_76ck30 = 0 time = 155
.meas tran vdout0_76ck30 FIND v(dout0_76) AT=155.025n

* CHECK dout0_77 Vdout0_77ck30 = 0.9 time = 155
.meas tran vdout0_77ck30 FIND v(dout0_77) AT=155.025n

* CHECK dout0_78 Vdout0_78ck30 = 0.9 time = 155
.meas tran vdout0_78ck30 FIND v(dout0_78) AT=155.025n

* CHECK dout0_79 Vdout0_79ck30 = 0 time = 155
.meas tran vdout0_79ck30 FIND v(dout0_79) AT=155.025n

* CHECK dout0_80 Vdout0_80ck30 = 0 time = 155
.meas tran vdout0_80ck30 FIND v(dout0_80) AT=155.025n

* CHECK dout0_81 Vdout0_81ck30 = 0 time = 155
.meas tran vdout0_81ck30 FIND v(dout0_81) AT=155.025n

* CHECK dout0_82 Vdout0_82ck30 = 0 time = 155
.meas tran vdout0_82ck30 FIND v(dout0_82) AT=155.025n

* CHECK dout0_83 Vdout0_83ck30 = 0 time = 155
.meas tran vdout0_83ck30 FIND v(dout0_83) AT=155.025n

* CHECK dout0_84 Vdout0_84ck30 = 0.9 time = 155
.meas tran vdout0_84ck30 FIND v(dout0_84) AT=155.025n

* CHECK dout0_85 Vdout0_85ck30 = 0 time = 155
.meas tran vdout0_85ck30 FIND v(dout0_85) AT=155.025n

* CHECK dout0_86 Vdout0_86ck30 = 0.9 time = 155
.meas tran vdout0_86ck30 FIND v(dout0_86) AT=155.025n

* CHECK dout0_87 Vdout0_87ck30 = 0 time = 155
.meas tran vdout0_87ck30 FIND v(dout0_87) AT=155.025n

* CHECK dout0_0 Vdout0_0ck31 = 0 time = 160
.meas tran vdout0_0ck31 FIND v(dout0_0) AT=160.025n

* CHECK dout0_1 Vdout0_1ck31 = 0.9 time = 160
.meas tran vdout0_1ck31 FIND v(dout0_1) AT=160.025n

* CHECK dout0_2 Vdout0_2ck31 = 0.9 time = 160
.meas tran vdout0_2ck31 FIND v(dout0_2) AT=160.025n

* CHECK dout0_3 Vdout0_3ck31 = 0 time = 160
.meas tran vdout0_3ck31 FIND v(dout0_3) AT=160.025n

* CHECK dout0_4 Vdout0_4ck31 = 0.9 time = 160
.meas tran vdout0_4ck31 FIND v(dout0_4) AT=160.025n

* CHECK dout0_5 Vdout0_5ck31 = 0 time = 160
.meas tran vdout0_5ck31 FIND v(dout0_5) AT=160.025n

* CHECK dout0_6 Vdout0_6ck31 = 0.9 time = 160
.meas tran vdout0_6ck31 FIND v(dout0_6) AT=160.025n

* CHECK dout0_7 Vdout0_7ck31 = 0.9 time = 160
.meas tran vdout0_7ck31 FIND v(dout0_7) AT=160.025n

* CHECK dout0_8 Vdout0_8ck31 = 0 time = 160
.meas tran vdout0_8ck31 FIND v(dout0_8) AT=160.025n

* CHECK dout0_9 Vdout0_9ck31 = 0 time = 160
.meas tran vdout0_9ck31 FIND v(dout0_9) AT=160.025n

* CHECK dout0_10 Vdout0_10ck31 = 0 time = 160
.meas tran vdout0_10ck31 FIND v(dout0_10) AT=160.025n

* CHECK dout0_11 Vdout0_11ck31 = 0 time = 160
.meas tran vdout0_11ck31 FIND v(dout0_11) AT=160.025n

* CHECK dout0_12 Vdout0_12ck31 = 0 time = 160
.meas tran vdout0_12ck31 FIND v(dout0_12) AT=160.025n

* CHECK dout0_13 Vdout0_13ck31 = 0.9 time = 160
.meas tran vdout0_13ck31 FIND v(dout0_13) AT=160.025n

* CHECK dout0_14 Vdout0_14ck31 = 0 time = 160
.meas tran vdout0_14ck31 FIND v(dout0_14) AT=160.025n

* CHECK dout0_15 Vdout0_15ck31 = 0.9 time = 160
.meas tran vdout0_15ck31 FIND v(dout0_15) AT=160.025n

* CHECK dout0_16 Vdout0_16ck31 = 0.9 time = 160
.meas tran vdout0_16ck31 FIND v(dout0_16) AT=160.025n

* CHECK dout0_17 Vdout0_17ck31 = 0 time = 160
.meas tran vdout0_17ck31 FIND v(dout0_17) AT=160.025n

* CHECK dout0_18 Vdout0_18ck31 = 0.9 time = 160
.meas tran vdout0_18ck31 FIND v(dout0_18) AT=160.025n

* CHECK dout0_19 Vdout0_19ck31 = 0.9 time = 160
.meas tran vdout0_19ck31 FIND v(dout0_19) AT=160.025n

* CHECK dout0_20 Vdout0_20ck31 = 0 time = 160
.meas tran vdout0_20ck31 FIND v(dout0_20) AT=160.025n

* CHECK dout0_21 Vdout0_21ck31 = 0.9 time = 160
.meas tran vdout0_21ck31 FIND v(dout0_21) AT=160.025n

* CHECK dout0_22 Vdout0_22ck31 = 0 time = 160
.meas tran vdout0_22ck31 FIND v(dout0_22) AT=160.025n

* CHECK dout0_23 Vdout0_23ck31 = 0 time = 160
.meas tran vdout0_23ck31 FIND v(dout0_23) AT=160.025n

* CHECK dout0_24 Vdout0_24ck31 = 0 time = 160
.meas tran vdout0_24ck31 FIND v(dout0_24) AT=160.025n

* CHECK dout0_25 Vdout0_25ck31 = 0 time = 160
.meas tran vdout0_25ck31 FIND v(dout0_25) AT=160.025n

* CHECK dout0_26 Vdout0_26ck31 = 0 time = 160
.meas tran vdout0_26ck31 FIND v(dout0_26) AT=160.025n

* CHECK dout0_27 Vdout0_27ck31 = 0.9 time = 160
.meas tran vdout0_27ck31 FIND v(dout0_27) AT=160.025n

* CHECK dout0_28 Vdout0_28ck31 = 0.9 time = 160
.meas tran vdout0_28ck31 FIND v(dout0_28) AT=160.025n

* CHECK dout0_29 Vdout0_29ck31 = 0.9 time = 160
.meas tran vdout0_29ck31 FIND v(dout0_29) AT=160.025n

* CHECK dout0_30 Vdout0_30ck31 = 0.9 time = 160
.meas tran vdout0_30ck31 FIND v(dout0_30) AT=160.025n

* CHECK dout0_31 Vdout0_31ck31 = 0 time = 160
.meas tran vdout0_31ck31 FIND v(dout0_31) AT=160.025n

* CHECK dout0_32 Vdout0_32ck31 = 0 time = 160
.meas tran vdout0_32ck31 FIND v(dout0_32) AT=160.025n

* CHECK dout0_33 Vdout0_33ck31 = 0.9 time = 160
.meas tran vdout0_33ck31 FIND v(dout0_33) AT=160.025n

* CHECK dout0_34 Vdout0_34ck31 = 0 time = 160
.meas tran vdout0_34ck31 FIND v(dout0_34) AT=160.025n

* CHECK dout0_35 Vdout0_35ck31 = 0 time = 160
.meas tran vdout0_35ck31 FIND v(dout0_35) AT=160.025n

* CHECK dout0_36 Vdout0_36ck31 = 0 time = 160
.meas tran vdout0_36ck31 FIND v(dout0_36) AT=160.025n

* CHECK dout0_37 Vdout0_37ck31 = 0.9 time = 160
.meas tran vdout0_37ck31 FIND v(dout0_37) AT=160.025n

* CHECK dout0_38 Vdout0_38ck31 = 0 time = 160
.meas tran vdout0_38ck31 FIND v(dout0_38) AT=160.025n

* CHECK dout0_39 Vdout0_39ck31 = 0.9 time = 160
.meas tran vdout0_39ck31 FIND v(dout0_39) AT=160.025n

* CHECK dout0_40 Vdout0_40ck31 = 0 time = 160
.meas tran vdout0_40ck31 FIND v(dout0_40) AT=160.025n

* CHECK dout0_41 Vdout0_41ck31 = 0.9 time = 160
.meas tran vdout0_41ck31 FIND v(dout0_41) AT=160.025n

* CHECK dout0_42 Vdout0_42ck31 = 0.9 time = 160
.meas tran vdout0_42ck31 FIND v(dout0_42) AT=160.025n

* CHECK dout0_43 Vdout0_43ck31 = 0.9 time = 160
.meas tran vdout0_43ck31 FIND v(dout0_43) AT=160.025n

* CHECK dout0_44 Vdout0_44ck31 = 0.9 time = 160
.meas tran vdout0_44ck31 FIND v(dout0_44) AT=160.025n

* CHECK dout0_45 Vdout0_45ck31 = 0.9 time = 160
.meas tran vdout0_45ck31 FIND v(dout0_45) AT=160.025n

* CHECK dout0_46 Vdout0_46ck31 = 0.9 time = 160
.meas tran vdout0_46ck31 FIND v(dout0_46) AT=160.025n

* CHECK dout0_47 Vdout0_47ck31 = 0 time = 160
.meas tran vdout0_47ck31 FIND v(dout0_47) AT=160.025n

* CHECK dout0_48 Vdout0_48ck31 = 0 time = 160
.meas tran vdout0_48ck31 FIND v(dout0_48) AT=160.025n

* CHECK dout0_49 Vdout0_49ck31 = 0 time = 160
.meas tran vdout0_49ck31 FIND v(dout0_49) AT=160.025n

* CHECK dout0_50 Vdout0_50ck31 = 0.9 time = 160
.meas tran vdout0_50ck31 FIND v(dout0_50) AT=160.025n

* CHECK dout0_51 Vdout0_51ck31 = 0 time = 160
.meas tran vdout0_51ck31 FIND v(dout0_51) AT=160.025n

* CHECK dout0_52 Vdout0_52ck31 = 0.9 time = 160
.meas tran vdout0_52ck31 FIND v(dout0_52) AT=160.025n

* CHECK dout0_53 Vdout0_53ck31 = 0 time = 160
.meas tran vdout0_53ck31 FIND v(dout0_53) AT=160.025n

* CHECK dout0_54 Vdout0_54ck31 = 0 time = 160
.meas tran vdout0_54ck31 FIND v(dout0_54) AT=160.025n

* CHECK dout0_55 Vdout0_55ck31 = 0 time = 160
.meas tran vdout0_55ck31 FIND v(dout0_55) AT=160.025n

* CHECK dout0_56 Vdout0_56ck31 = 0 time = 160
.meas tran vdout0_56ck31 FIND v(dout0_56) AT=160.025n

* CHECK dout0_57 Vdout0_57ck31 = 0.9 time = 160
.meas tran vdout0_57ck31 FIND v(dout0_57) AT=160.025n

* CHECK dout0_58 Vdout0_58ck31 = 0.9 time = 160
.meas tran vdout0_58ck31 FIND v(dout0_58) AT=160.025n

* CHECK dout0_59 Vdout0_59ck31 = 0 time = 160
.meas tran vdout0_59ck31 FIND v(dout0_59) AT=160.025n

* CHECK dout0_60 Vdout0_60ck31 = 0.9 time = 160
.meas tran vdout0_60ck31 FIND v(dout0_60) AT=160.025n

* CHECK dout0_61 Vdout0_61ck31 = 0 time = 160
.meas tran vdout0_61ck31 FIND v(dout0_61) AT=160.025n

* CHECK dout0_62 Vdout0_62ck31 = 0 time = 160
.meas tran vdout0_62ck31 FIND v(dout0_62) AT=160.025n

* CHECK dout0_63 Vdout0_63ck31 = 0 time = 160
.meas tran vdout0_63ck31 FIND v(dout0_63) AT=160.025n

* CHECK dout0_64 Vdout0_64ck31 = 0 time = 160
.meas tran vdout0_64ck31 FIND v(dout0_64) AT=160.025n

* CHECK dout0_65 Vdout0_65ck31 = 0.9 time = 160
.meas tran vdout0_65ck31 FIND v(dout0_65) AT=160.025n

* CHECK dout0_66 Vdout0_66ck31 = 0.9 time = 160
.meas tran vdout0_66ck31 FIND v(dout0_66) AT=160.025n

* CHECK dout0_67 Vdout0_67ck31 = 0.9 time = 160
.meas tran vdout0_67ck31 FIND v(dout0_67) AT=160.025n

* CHECK dout0_68 Vdout0_68ck31 = 0.9 time = 160
.meas tran vdout0_68ck31 FIND v(dout0_68) AT=160.025n

* CHECK dout0_69 Vdout0_69ck31 = 0 time = 160
.meas tran vdout0_69ck31 FIND v(dout0_69) AT=160.025n

* CHECK dout0_70 Vdout0_70ck31 = 0.9 time = 160
.meas tran vdout0_70ck31 FIND v(dout0_70) AT=160.025n

* CHECK dout0_71 Vdout0_71ck31 = 0.9 time = 160
.meas tran vdout0_71ck31 FIND v(dout0_71) AT=160.025n

* CHECK dout0_72 Vdout0_72ck31 = 0 time = 160
.meas tran vdout0_72ck31 FIND v(dout0_72) AT=160.025n

* CHECK dout0_73 Vdout0_73ck31 = 0.9 time = 160
.meas tran vdout0_73ck31 FIND v(dout0_73) AT=160.025n

* CHECK dout0_74 Vdout0_74ck31 = 0.9 time = 160
.meas tran vdout0_74ck31 FIND v(dout0_74) AT=160.025n

* CHECK dout0_75 Vdout0_75ck31 = 0 time = 160
.meas tran vdout0_75ck31 FIND v(dout0_75) AT=160.025n

* CHECK dout0_76 Vdout0_76ck31 = 0 time = 160
.meas tran vdout0_76ck31 FIND v(dout0_76) AT=160.025n

* CHECK dout0_77 Vdout0_77ck31 = 0 time = 160
.meas tran vdout0_77ck31 FIND v(dout0_77) AT=160.025n

* CHECK dout0_78 Vdout0_78ck31 = 0 time = 160
.meas tran vdout0_78ck31 FIND v(dout0_78) AT=160.025n

* CHECK dout0_79 Vdout0_79ck31 = 0.9 time = 160
.meas tran vdout0_79ck31 FIND v(dout0_79) AT=160.025n

* CHECK dout0_80 Vdout0_80ck31 = 0.9 time = 160
.meas tran vdout0_80ck31 FIND v(dout0_80) AT=160.025n

* CHECK dout0_81 Vdout0_81ck31 = 0.9 time = 160
.meas tran vdout0_81ck31 FIND v(dout0_81) AT=160.025n

* CHECK dout0_82 Vdout0_82ck31 = 0 time = 160
.meas tran vdout0_82ck31 FIND v(dout0_82) AT=160.025n

* CHECK dout0_83 Vdout0_83ck31 = 0 time = 160
.meas tran vdout0_83ck31 FIND v(dout0_83) AT=160.025n

* CHECK dout0_84 Vdout0_84ck31 = 0.9 time = 160
.meas tran vdout0_84ck31 FIND v(dout0_84) AT=160.025n

* CHECK dout0_85 Vdout0_85ck31 = 0 time = 160
.meas tran vdout0_85ck31 FIND v(dout0_85) AT=160.025n

* CHECK dout0_86 Vdout0_86ck31 = 0 time = 160
.meas tran vdout0_86ck31 FIND v(dout0_86) AT=160.025n

* CHECK dout0_87 Vdout0_87ck31 = 0 time = 160
.meas tran vdout0_87ck31 FIND v(dout0_87) AT=160.025n

* CHECK dout0_0 Vdout0_0ck32 = 0 time = 165
.meas tran vdout0_0ck32 FIND v(dout0_0) AT=165.025n

* CHECK dout0_1 Vdout0_1ck32 = 0.9 time = 165
.meas tran vdout0_1ck32 FIND v(dout0_1) AT=165.025n

* CHECK dout0_2 Vdout0_2ck32 = 0.9 time = 165
.meas tran vdout0_2ck32 FIND v(dout0_2) AT=165.025n

* CHECK dout0_3 Vdout0_3ck32 = 0 time = 165
.meas tran vdout0_3ck32 FIND v(dout0_3) AT=165.025n

* CHECK dout0_4 Vdout0_4ck32 = 0.9 time = 165
.meas tran vdout0_4ck32 FIND v(dout0_4) AT=165.025n

* CHECK dout0_5 Vdout0_5ck32 = 0 time = 165
.meas tran vdout0_5ck32 FIND v(dout0_5) AT=165.025n

* CHECK dout0_6 Vdout0_6ck32 = 0.9 time = 165
.meas tran vdout0_6ck32 FIND v(dout0_6) AT=165.025n

* CHECK dout0_7 Vdout0_7ck32 = 0.9 time = 165
.meas tran vdout0_7ck32 FIND v(dout0_7) AT=165.025n

* CHECK dout0_8 Vdout0_8ck32 = 0 time = 165
.meas tran vdout0_8ck32 FIND v(dout0_8) AT=165.025n

* CHECK dout0_9 Vdout0_9ck32 = 0 time = 165
.meas tran vdout0_9ck32 FIND v(dout0_9) AT=165.025n

* CHECK dout0_10 Vdout0_10ck32 = 0 time = 165
.meas tran vdout0_10ck32 FIND v(dout0_10) AT=165.025n

* CHECK dout0_11 Vdout0_11ck32 = 0 time = 165
.meas tran vdout0_11ck32 FIND v(dout0_11) AT=165.025n

* CHECK dout0_12 Vdout0_12ck32 = 0 time = 165
.meas tran vdout0_12ck32 FIND v(dout0_12) AT=165.025n

* CHECK dout0_13 Vdout0_13ck32 = 0.9 time = 165
.meas tran vdout0_13ck32 FIND v(dout0_13) AT=165.025n

* CHECK dout0_14 Vdout0_14ck32 = 0 time = 165
.meas tran vdout0_14ck32 FIND v(dout0_14) AT=165.025n

* CHECK dout0_15 Vdout0_15ck32 = 0.9 time = 165
.meas tran vdout0_15ck32 FIND v(dout0_15) AT=165.025n

* CHECK dout0_16 Vdout0_16ck32 = 0.9 time = 165
.meas tran vdout0_16ck32 FIND v(dout0_16) AT=165.025n

* CHECK dout0_17 Vdout0_17ck32 = 0 time = 165
.meas tran vdout0_17ck32 FIND v(dout0_17) AT=165.025n

* CHECK dout0_18 Vdout0_18ck32 = 0.9 time = 165
.meas tran vdout0_18ck32 FIND v(dout0_18) AT=165.025n

* CHECK dout0_19 Vdout0_19ck32 = 0.9 time = 165
.meas tran vdout0_19ck32 FIND v(dout0_19) AT=165.025n

* CHECK dout0_20 Vdout0_20ck32 = 0 time = 165
.meas tran vdout0_20ck32 FIND v(dout0_20) AT=165.025n

* CHECK dout0_21 Vdout0_21ck32 = 0.9 time = 165
.meas tran vdout0_21ck32 FIND v(dout0_21) AT=165.025n

* CHECK dout0_22 Vdout0_22ck32 = 0 time = 165
.meas tran vdout0_22ck32 FIND v(dout0_22) AT=165.025n

* CHECK dout0_23 Vdout0_23ck32 = 0 time = 165
.meas tran vdout0_23ck32 FIND v(dout0_23) AT=165.025n

* CHECK dout0_24 Vdout0_24ck32 = 0 time = 165
.meas tran vdout0_24ck32 FIND v(dout0_24) AT=165.025n

* CHECK dout0_25 Vdout0_25ck32 = 0 time = 165
.meas tran vdout0_25ck32 FIND v(dout0_25) AT=165.025n

* CHECK dout0_26 Vdout0_26ck32 = 0 time = 165
.meas tran vdout0_26ck32 FIND v(dout0_26) AT=165.025n

* CHECK dout0_27 Vdout0_27ck32 = 0.9 time = 165
.meas tran vdout0_27ck32 FIND v(dout0_27) AT=165.025n

* CHECK dout0_28 Vdout0_28ck32 = 0.9 time = 165
.meas tran vdout0_28ck32 FIND v(dout0_28) AT=165.025n

* CHECK dout0_29 Vdout0_29ck32 = 0.9 time = 165
.meas tran vdout0_29ck32 FIND v(dout0_29) AT=165.025n

* CHECK dout0_30 Vdout0_30ck32 = 0.9 time = 165
.meas tran vdout0_30ck32 FIND v(dout0_30) AT=165.025n

* CHECK dout0_31 Vdout0_31ck32 = 0 time = 165
.meas tran vdout0_31ck32 FIND v(dout0_31) AT=165.025n

* CHECK dout0_32 Vdout0_32ck32 = 0 time = 165
.meas tran vdout0_32ck32 FIND v(dout0_32) AT=165.025n

* CHECK dout0_33 Vdout0_33ck32 = 0.9 time = 165
.meas tran vdout0_33ck32 FIND v(dout0_33) AT=165.025n

* CHECK dout0_34 Vdout0_34ck32 = 0 time = 165
.meas tran vdout0_34ck32 FIND v(dout0_34) AT=165.025n

* CHECK dout0_35 Vdout0_35ck32 = 0 time = 165
.meas tran vdout0_35ck32 FIND v(dout0_35) AT=165.025n

* CHECK dout0_36 Vdout0_36ck32 = 0 time = 165
.meas tran vdout0_36ck32 FIND v(dout0_36) AT=165.025n

* CHECK dout0_37 Vdout0_37ck32 = 0.9 time = 165
.meas tran vdout0_37ck32 FIND v(dout0_37) AT=165.025n

* CHECK dout0_38 Vdout0_38ck32 = 0 time = 165
.meas tran vdout0_38ck32 FIND v(dout0_38) AT=165.025n

* CHECK dout0_39 Vdout0_39ck32 = 0.9 time = 165
.meas tran vdout0_39ck32 FIND v(dout0_39) AT=165.025n

* CHECK dout0_40 Vdout0_40ck32 = 0 time = 165
.meas tran vdout0_40ck32 FIND v(dout0_40) AT=165.025n

* CHECK dout0_41 Vdout0_41ck32 = 0.9 time = 165
.meas tran vdout0_41ck32 FIND v(dout0_41) AT=165.025n

* CHECK dout0_42 Vdout0_42ck32 = 0.9 time = 165
.meas tran vdout0_42ck32 FIND v(dout0_42) AT=165.025n

* CHECK dout0_43 Vdout0_43ck32 = 0.9 time = 165
.meas tran vdout0_43ck32 FIND v(dout0_43) AT=165.025n

* CHECK dout0_44 Vdout0_44ck32 = 0.9 time = 165
.meas tran vdout0_44ck32 FIND v(dout0_44) AT=165.025n

* CHECK dout0_45 Vdout0_45ck32 = 0.9 time = 165
.meas tran vdout0_45ck32 FIND v(dout0_45) AT=165.025n

* CHECK dout0_46 Vdout0_46ck32 = 0.9 time = 165
.meas tran vdout0_46ck32 FIND v(dout0_46) AT=165.025n

* CHECK dout0_47 Vdout0_47ck32 = 0 time = 165
.meas tran vdout0_47ck32 FIND v(dout0_47) AT=165.025n

* CHECK dout0_48 Vdout0_48ck32 = 0 time = 165
.meas tran vdout0_48ck32 FIND v(dout0_48) AT=165.025n

* CHECK dout0_49 Vdout0_49ck32 = 0 time = 165
.meas tran vdout0_49ck32 FIND v(dout0_49) AT=165.025n

* CHECK dout0_50 Vdout0_50ck32 = 0.9 time = 165
.meas tran vdout0_50ck32 FIND v(dout0_50) AT=165.025n

* CHECK dout0_51 Vdout0_51ck32 = 0 time = 165
.meas tran vdout0_51ck32 FIND v(dout0_51) AT=165.025n

* CHECK dout0_52 Vdout0_52ck32 = 0.9 time = 165
.meas tran vdout0_52ck32 FIND v(dout0_52) AT=165.025n

* CHECK dout0_53 Vdout0_53ck32 = 0 time = 165
.meas tran vdout0_53ck32 FIND v(dout0_53) AT=165.025n

* CHECK dout0_54 Vdout0_54ck32 = 0 time = 165
.meas tran vdout0_54ck32 FIND v(dout0_54) AT=165.025n

* CHECK dout0_55 Vdout0_55ck32 = 0 time = 165
.meas tran vdout0_55ck32 FIND v(dout0_55) AT=165.025n

* CHECK dout0_56 Vdout0_56ck32 = 0 time = 165
.meas tran vdout0_56ck32 FIND v(dout0_56) AT=165.025n

* CHECK dout0_57 Vdout0_57ck32 = 0.9 time = 165
.meas tran vdout0_57ck32 FIND v(dout0_57) AT=165.025n

* CHECK dout0_58 Vdout0_58ck32 = 0.9 time = 165
.meas tran vdout0_58ck32 FIND v(dout0_58) AT=165.025n

* CHECK dout0_59 Vdout0_59ck32 = 0 time = 165
.meas tran vdout0_59ck32 FIND v(dout0_59) AT=165.025n

* CHECK dout0_60 Vdout0_60ck32 = 0.9 time = 165
.meas tran vdout0_60ck32 FIND v(dout0_60) AT=165.025n

* CHECK dout0_61 Vdout0_61ck32 = 0 time = 165
.meas tran vdout0_61ck32 FIND v(dout0_61) AT=165.025n

* CHECK dout0_62 Vdout0_62ck32 = 0 time = 165
.meas tran vdout0_62ck32 FIND v(dout0_62) AT=165.025n

* CHECK dout0_63 Vdout0_63ck32 = 0 time = 165
.meas tran vdout0_63ck32 FIND v(dout0_63) AT=165.025n

* CHECK dout0_64 Vdout0_64ck32 = 0 time = 165
.meas tran vdout0_64ck32 FIND v(dout0_64) AT=165.025n

* CHECK dout0_65 Vdout0_65ck32 = 0.9 time = 165
.meas tran vdout0_65ck32 FIND v(dout0_65) AT=165.025n

* CHECK dout0_66 Vdout0_66ck32 = 0.9 time = 165
.meas tran vdout0_66ck32 FIND v(dout0_66) AT=165.025n

* CHECK dout0_67 Vdout0_67ck32 = 0.9 time = 165
.meas tran vdout0_67ck32 FIND v(dout0_67) AT=165.025n

* CHECK dout0_68 Vdout0_68ck32 = 0.9 time = 165
.meas tran vdout0_68ck32 FIND v(dout0_68) AT=165.025n

* CHECK dout0_69 Vdout0_69ck32 = 0 time = 165
.meas tran vdout0_69ck32 FIND v(dout0_69) AT=165.025n

* CHECK dout0_70 Vdout0_70ck32 = 0.9 time = 165
.meas tran vdout0_70ck32 FIND v(dout0_70) AT=165.025n

* CHECK dout0_71 Vdout0_71ck32 = 0.9 time = 165
.meas tran vdout0_71ck32 FIND v(dout0_71) AT=165.025n

* CHECK dout0_72 Vdout0_72ck32 = 0 time = 165
.meas tran vdout0_72ck32 FIND v(dout0_72) AT=165.025n

* CHECK dout0_73 Vdout0_73ck32 = 0.9 time = 165
.meas tran vdout0_73ck32 FIND v(dout0_73) AT=165.025n

* CHECK dout0_74 Vdout0_74ck32 = 0.9 time = 165
.meas tran vdout0_74ck32 FIND v(dout0_74) AT=165.025n

* CHECK dout0_75 Vdout0_75ck32 = 0 time = 165
.meas tran vdout0_75ck32 FIND v(dout0_75) AT=165.025n

* CHECK dout0_76 Vdout0_76ck32 = 0 time = 165
.meas tran vdout0_76ck32 FIND v(dout0_76) AT=165.025n

* CHECK dout0_77 Vdout0_77ck32 = 0 time = 165
.meas tran vdout0_77ck32 FIND v(dout0_77) AT=165.025n

* CHECK dout0_78 Vdout0_78ck32 = 0 time = 165
.meas tran vdout0_78ck32 FIND v(dout0_78) AT=165.025n

* CHECK dout0_79 Vdout0_79ck32 = 0.9 time = 165
.meas tran vdout0_79ck32 FIND v(dout0_79) AT=165.025n

* CHECK dout0_80 Vdout0_80ck32 = 0.9 time = 165
.meas tran vdout0_80ck32 FIND v(dout0_80) AT=165.025n

* CHECK dout0_81 Vdout0_81ck32 = 0.9 time = 165
.meas tran vdout0_81ck32 FIND v(dout0_81) AT=165.025n

* CHECK dout0_82 Vdout0_82ck32 = 0 time = 165
.meas tran vdout0_82ck32 FIND v(dout0_82) AT=165.025n

* CHECK dout0_83 Vdout0_83ck32 = 0 time = 165
.meas tran vdout0_83ck32 FIND v(dout0_83) AT=165.025n

* CHECK dout0_84 Vdout0_84ck32 = 0.9 time = 165
.meas tran vdout0_84ck32 FIND v(dout0_84) AT=165.025n

* CHECK dout0_85 Vdout0_85ck32 = 0 time = 165
.meas tran vdout0_85ck32 FIND v(dout0_85) AT=165.025n

* CHECK dout0_86 Vdout0_86ck32 = 0 time = 165
.meas tran vdout0_86ck32 FIND v(dout0_86) AT=165.025n

* CHECK dout0_87 Vdout0_87ck32 = 0 time = 165
.meas tran vdout0_87ck32 FIND v(dout0_87) AT=165.025n

* CHECK dout0_0 Vdout0_0ck33 = 0 time = 170
.meas tran vdout0_0ck33 FIND v(dout0_0) AT=170.025n

* CHECK dout0_1 Vdout0_1ck33 = 0.9 time = 170
.meas tran vdout0_1ck33 FIND v(dout0_1) AT=170.025n

* CHECK dout0_2 Vdout0_2ck33 = 0.9 time = 170
.meas tran vdout0_2ck33 FIND v(dout0_2) AT=170.025n

* CHECK dout0_3 Vdout0_3ck33 = 0 time = 170
.meas tran vdout0_3ck33 FIND v(dout0_3) AT=170.025n

* CHECK dout0_4 Vdout0_4ck33 = 0.9 time = 170
.meas tran vdout0_4ck33 FIND v(dout0_4) AT=170.025n

* CHECK dout0_5 Vdout0_5ck33 = 0 time = 170
.meas tran vdout0_5ck33 FIND v(dout0_5) AT=170.025n

* CHECK dout0_6 Vdout0_6ck33 = 0.9 time = 170
.meas tran vdout0_6ck33 FIND v(dout0_6) AT=170.025n

* CHECK dout0_7 Vdout0_7ck33 = 0.9 time = 170
.meas tran vdout0_7ck33 FIND v(dout0_7) AT=170.025n

* CHECK dout0_8 Vdout0_8ck33 = 0 time = 170
.meas tran vdout0_8ck33 FIND v(dout0_8) AT=170.025n

* CHECK dout0_9 Vdout0_9ck33 = 0 time = 170
.meas tran vdout0_9ck33 FIND v(dout0_9) AT=170.025n

* CHECK dout0_10 Vdout0_10ck33 = 0 time = 170
.meas tran vdout0_10ck33 FIND v(dout0_10) AT=170.025n

* CHECK dout0_11 Vdout0_11ck33 = 0 time = 170
.meas tran vdout0_11ck33 FIND v(dout0_11) AT=170.025n

* CHECK dout0_12 Vdout0_12ck33 = 0 time = 170
.meas tran vdout0_12ck33 FIND v(dout0_12) AT=170.025n

* CHECK dout0_13 Vdout0_13ck33 = 0.9 time = 170
.meas tran vdout0_13ck33 FIND v(dout0_13) AT=170.025n

* CHECK dout0_14 Vdout0_14ck33 = 0 time = 170
.meas tran vdout0_14ck33 FIND v(dout0_14) AT=170.025n

* CHECK dout0_15 Vdout0_15ck33 = 0.9 time = 170
.meas tran vdout0_15ck33 FIND v(dout0_15) AT=170.025n

* CHECK dout0_16 Vdout0_16ck33 = 0.9 time = 170
.meas tran vdout0_16ck33 FIND v(dout0_16) AT=170.025n

* CHECK dout0_17 Vdout0_17ck33 = 0 time = 170
.meas tran vdout0_17ck33 FIND v(dout0_17) AT=170.025n

* CHECK dout0_18 Vdout0_18ck33 = 0.9 time = 170
.meas tran vdout0_18ck33 FIND v(dout0_18) AT=170.025n

* CHECK dout0_19 Vdout0_19ck33 = 0.9 time = 170
.meas tran vdout0_19ck33 FIND v(dout0_19) AT=170.025n

* CHECK dout0_20 Vdout0_20ck33 = 0 time = 170
.meas tran vdout0_20ck33 FIND v(dout0_20) AT=170.025n

* CHECK dout0_21 Vdout0_21ck33 = 0.9 time = 170
.meas tran vdout0_21ck33 FIND v(dout0_21) AT=170.025n

* CHECK dout0_22 Vdout0_22ck33 = 0 time = 170
.meas tran vdout0_22ck33 FIND v(dout0_22) AT=170.025n

* CHECK dout0_23 Vdout0_23ck33 = 0 time = 170
.meas tran vdout0_23ck33 FIND v(dout0_23) AT=170.025n

* CHECK dout0_24 Vdout0_24ck33 = 0 time = 170
.meas tran vdout0_24ck33 FIND v(dout0_24) AT=170.025n

* CHECK dout0_25 Vdout0_25ck33 = 0 time = 170
.meas tran vdout0_25ck33 FIND v(dout0_25) AT=170.025n

* CHECK dout0_26 Vdout0_26ck33 = 0 time = 170
.meas tran vdout0_26ck33 FIND v(dout0_26) AT=170.025n

* CHECK dout0_27 Vdout0_27ck33 = 0.9 time = 170
.meas tran vdout0_27ck33 FIND v(dout0_27) AT=170.025n

* CHECK dout0_28 Vdout0_28ck33 = 0.9 time = 170
.meas tran vdout0_28ck33 FIND v(dout0_28) AT=170.025n

* CHECK dout0_29 Vdout0_29ck33 = 0.9 time = 170
.meas tran vdout0_29ck33 FIND v(dout0_29) AT=170.025n

* CHECK dout0_30 Vdout0_30ck33 = 0.9 time = 170
.meas tran vdout0_30ck33 FIND v(dout0_30) AT=170.025n

* CHECK dout0_31 Vdout0_31ck33 = 0 time = 170
.meas tran vdout0_31ck33 FIND v(dout0_31) AT=170.025n

* CHECK dout0_32 Vdout0_32ck33 = 0 time = 170
.meas tran vdout0_32ck33 FIND v(dout0_32) AT=170.025n

* CHECK dout0_33 Vdout0_33ck33 = 0.9 time = 170
.meas tran vdout0_33ck33 FIND v(dout0_33) AT=170.025n

* CHECK dout0_34 Vdout0_34ck33 = 0 time = 170
.meas tran vdout0_34ck33 FIND v(dout0_34) AT=170.025n

* CHECK dout0_35 Vdout0_35ck33 = 0 time = 170
.meas tran vdout0_35ck33 FIND v(dout0_35) AT=170.025n

* CHECK dout0_36 Vdout0_36ck33 = 0 time = 170
.meas tran vdout0_36ck33 FIND v(dout0_36) AT=170.025n

* CHECK dout0_37 Vdout0_37ck33 = 0.9 time = 170
.meas tran vdout0_37ck33 FIND v(dout0_37) AT=170.025n

* CHECK dout0_38 Vdout0_38ck33 = 0 time = 170
.meas tran vdout0_38ck33 FIND v(dout0_38) AT=170.025n

* CHECK dout0_39 Vdout0_39ck33 = 0.9 time = 170
.meas tran vdout0_39ck33 FIND v(dout0_39) AT=170.025n

* CHECK dout0_40 Vdout0_40ck33 = 0 time = 170
.meas tran vdout0_40ck33 FIND v(dout0_40) AT=170.025n

* CHECK dout0_41 Vdout0_41ck33 = 0.9 time = 170
.meas tran vdout0_41ck33 FIND v(dout0_41) AT=170.025n

* CHECK dout0_42 Vdout0_42ck33 = 0.9 time = 170
.meas tran vdout0_42ck33 FIND v(dout0_42) AT=170.025n

* CHECK dout0_43 Vdout0_43ck33 = 0.9 time = 170
.meas tran vdout0_43ck33 FIND v(dout0_43) AT=170.025n

* CHECK dout0_44 Vdout0_44ck33 = 0.9 time = 170
.meas tran vdout0_44ck33 FIND v(dout0_44) AT=170.025n

* CHECK dout0_45 Vdout0_45ck33 = 0.9 time = 170
.meas tran vdout0_45ck33 FIND v(dout0_45) AT=170.025n

* CHECK dout0_46 Vdout0_46ck33 = 0.9 time = 170
.meas tran vdout0_46ck33 FIND v(dout0_46) AT=170.025n

* CHECK dout0_47 Vdout0_47ck33 = 0 time = 170
.meas tran vdout0_47ck33 FIND v(dout0_47) AT=170.025n

* CHECK dout0_48 Vdout0_48ck33 = 0 time = 170
.meas tran vdout0_48ck33 FIND v(dout0_48) AT=170.025n

* CHECK dout0_49 Vdout0_49ck33 = 0 time = 170
.meas tran vdout0_49ck33 FIND v(dout0_49) AT=170.025n

* CHECK dout0_50 Vdout0_50ck33 = 0.9 time = 170
.meas tran vdout0_50ck33 FIND v(dout0_50) AT=170.025n

* CHECK dout0_51 Vdout0_51ck33 = 0 time = 170
.meas tran vdout0_51ck33 FIND v(dout0_51) AT=170.025n

* CHECK dout0_52 Vdout0_52ck33 = 0.9 time = 170
.meas tran vdout0_52ck33 FIND v(dout0_52) AT=170.025n

* CHECK dout0_53 Vdout0_53ck33 = 0 time = 170
.meas tran vdout0_53ck33 FIND v(dout0_53) AT=170.025n

* CHECK dout0_54 Vdout0_54ck33 = 0 time = 170
.meas tran vdout0_54ck33 FIND v(dout0_54) AT=170.025n

* CHECK dout0_55 Vdout0_55ck33 = 0 time = 170
.meas tran vdout0_55ck33 FIND v(dout0_55) AT=170.025n

* CHECK dout0_56 Vdout0_56ck33 = 0 time = 170
.meas tran vdout0_56ck33 FIND v(dout0_56) AT=170.025n

* CHECK dout0_57 Vdout0_57ck33 = 0.9 time = 170
.meas tran vdout0_57ck33 FIND v(dout0_57) AT=170.025n

* CHECK dout0_58 Vdout0_58ck33 = 0.9 time = 170
.meas tran vdout0_58ck33 FIND v(dout0_58) AT=170.025n

* CHECK dout0_59 Vdout0_59ck33 = 0 time = 170
.meas tran vdout0_59ck33 FIND v(dout0_59) AT=170.025n

* CHECK dout0_60 Vdout0_60ck33 = 0.9 time = 170
.meas tran vdout0_60ck33 FIND v(dout0_60) AT=170.025n

* CHECK dout0_61 Vdout0_61ck33 = 0 time = 170
.meas tran vdout0_61ck33 FIND v(dout0_61) AT=170.025n

* CHECK dout0_62 Vdout0_62ck33 = 0 time = 170
.meas tran vdout0_62ck33 FIND v(dout0_62) AT=170.025n

* CHECK dout0_63 Vdout0_63ck33 = 0 time = 170
.meas tran vdout0_63ck33 FIND v(dout0_63) AT=170.025n

* CHECK dout0_64 Vdout0_64ck33 = 0 time = 170
.meas tran vdout0_64ck33 FIND v(dout0_64) AT=170.025n

* CHECK dout0_65 Vdout0_65ck33 = 0.9 time = 170
.meas tran vdout0_65ck33 FIND v(dout0_65) AT=170.025n

* CHECK dout0_66 Vdout0_66ck33 = 0.9 time = 170
.meas tran vdout0_66ck33 FIND v(dout0_66) AT=170.025n

* CHECK dout0_67 Vdout0_67ck33 = 0.9 time = 170
.meas tran vdout0_67ck33 FIND v(dout0_67) AT=170.025n

* CHECK dout0_68 Vdout0_68ck33 = 0.9 time = 170
.meas tran vdout0_68ck33 FIND v(dout0_68) AT=170.025n

* CHECK dout0_69 Vdout0_69ck33 = 0 time = 170
.meas tran vdout0_69ck33 FIND v(dout0_69) AT=170.025n

* CHECK dout0_70 Vdout0_70ck33 = 0.9 time = 170
.meas tran vdout0_70ck33 FIND v(dout0_70) AT=170.025n

* CHECK dout0_71 Vdout0_71ck33 = 0.9 time = 170
.meas tran vdout0_71ck33 FIND v(dout0_71) AT=170.025n

* CHECK dout0_72 Vdout0_72ck33 = 0 time = 170
.meas tran vdout0_72ck33 FIND v(dout0_72) AT=170.025n

* CHECK dout0_73 Vdout0_73ck33 = 0.9 time = 170
.meas tran vdout0_73ck33 FIND v(dout0_73) AT=170.025n

* CHECK dout0_74 Vdout0_74ck33 = 0.9 time = 170
.meas tran vdout0_74ck33 FIND v(dout0_74) AT=170.025n

* CHECK dout0_75 Vdout0_75ck33 = 0 time = 170
.meas tran vdout0_75ck33 FIND v(dout0_75) AT=170.025n

* CHECK dout0_76 Vdout0_76ck33 = 0 time = 170
.meas tran vdout0_76ck33 FIND v(dout0_76) AT=170.025n

* CHECK dout0_77 Vdout0_77ck33 = 0 time = 170
.meas tran vdout0_77ck33 FIND v(dout0_77) AT=170.025n

* CHECK dout0_78 Vdout0_78ck33 = 0 time = 170
.meas tran vdout0_78ck33 FIND v(dout0_78) AT=170.025n

* CHECK dout0_79 Vdout0_79ck33 = 0.9 time = 170
.meas tran vdout0_79ck33 FIND v(dout0_79) AT=170.025n

* CHECK dout0_80 Vdout0_80ck33 = 0.9 time = 170
.meas tran vdout0_80ck33 FIND v(dout0_80) AT=170.025n

* CHECK dout0_81 Vdout0_81ck33 = 0.9 time = 170
.meas tran vdout0_81ck33 FIND v(dout0_81) AT=170.025n

* CHECK dout0_82 Vdout0_82ck33 = 0 time = 170
.meas tran vdout0_82ck33 FIND v(dout0_82) AT=170.025n

* CHECK dout0_83 Vdout0_83ck33 = 0 time = 170
.meas tran vdout0_83ck33 FIND v(dout0_83) AT=170.025n

* CHECK dout0_84 Vdout0_84ck33 = 0.9 time = 170
.meas tran vdout0_84ck33 FIND v(dout0_84) AT=170.025n

* CHECK dout0_85 Vdout0_85ck33 = 0 time = 170
.meas tran vdout0_85ck33 FIND v(dout0_85) AT=170.025n

* CHECK dout0_86 Vdout0_86ck33 = 0 time = 170
.meas tran vdout0_86ck33 FIND v(dout0_86) AT=170.025n

* CHECK dout0_87 Vdout0_87ck33 = 0 time = 170
.meas tran vdout0_87ck33 FIND v(dout0_87) AT=170.025n

* CHECK dout0_0 Vdout0_0ck38 = 0.9 time = 195
.meas tran vdout0_0ck38 FIND v(dout0_0) AT=195.025n

* CHECK dout0_1 Vdout0_1ck38 = 0 time = 195
.meas tran vdout0_1ck38 FIND v(dout0_1) AT=195.025n

* CHECK dout0_2 Vdout0_2ck38 = 0 time = 195
.meas tran vdout0_2ck38 FIND v(dout0_2) AT=195.025n

* CHECK dout0_3 Vdout0_3ck38 = 0.9 time = 195
.meas tran vdout0_3ck38 FIND v(dout0_3) AT=195.025n

* CHECK dout0_4 Vdout0_4ck38 = 0.9 time = 195
.meas tran vdout0_4ck38 FIND v(dout0_4) AT=195.025n

* CHECK dout0_5 Vdout0_5ck38 = 0 time = 195
.meas tran vdout0_5ck38 FIND v(dout0_5) AT=195.025n

* CHECK dout0_6 Vdout0_6ck38 = 0.9 time = 195
.meas tran vdout0_6ck38 FIND v(dout0_6) AT=195.025n

* CHECK dout0_7 Vdout0_7ck38 = 0.9 time = 195
.meas tran vdout0_7ck38 FIND v(dout0_7) AT=195.025n

* CHECK dout0_8 Vdout0_8ck38 = 0 time = 195
.meas tran vdout0_8ck38 FIND v(dout0_8) AT=195.025n

* CHECK dout0_9 Vdout0_9ck38 = 0.9 time = 195
.meas tran vdout0_9ck38 FIND v(dout0_9) AT=195.025n

* CHECK dout0_10 Vdout0_10ck38 = 0 time = 195
.meas tran vdout0_10ck38 FIND v(dout0_10) AT=195.025n

* CHECK dout0_11 Vdout0_11ck38 = 0.9 time = 195
.meas tran vdout0_11ck38 FIND v(dout0_11) AT=195.025n

* CHECK dout0_12 Vdout0_12ck38 = 0 time = 195
.meas tran vdout0_12ck38 FIND v(dout0_12) AT=195.025n

* CHECK dout0_13 Vdout0_13ck38 = 0 time = 195
.meas tran vdout0_13ck38 FIND v(dout0_13) AT=195.025n

* CHECK dout0_14 Vdout0_14ck38 = 0.9 time = 195
.meas tran vdout0_14ck38 FIND v(dout0_14) AT=195.025n

* CHECK dout0_15 Vdout0_15ck38 = 0.9 time = 195
.meas tran vdout0_15ck38 FIND v(dout0_15) AT=195.025n

* CHECK dout0_16 Vdout0_16ck38 = 0 time = 195
.meas tran vdout0_16ck38 FIND v(dout0_16) AT=195.025n

* CHECK dout0_17 Vdout0_17ck38 = 0 time = 195
.meas tran vdout0_17ck38 FIND v(dout0_17) AT=195.025n

* CHECK dout0_18 Vdout0_18ck38 = 0 time = 195
.meas tran vdout0_18ck38 FIND v(dout0_18) AT=195.025n

* CHECK dout0_19 Vdout0_19ck38 = 0.9 time = 195
.meas tran vdout0_19ck38 FIND v(dout0_19) AT=195.025n

* CHECK dout0_20 Vdout0_20ck38 = 0.9 time = 195
.meas tran vdout0_20ck38 FIND v(dout0_20) AT=195.025n

* CHECK dout0_21 Vdout0_21ck38 = 0 time = 195
.meas tran vdout0_21ck38 FIND v(dout0_21) AT=195.025n

* CHECK dout0_22 Vdout0_22ck38 = 0 time = 195
.meas tran vdout0_22ck38 FIND v(dout0_22) AT=195.025n

* CHECK dout0_23 Vdout0_23ck38 = 0 time = 195
.meas tran vdout0_23ck38 FIND v(dout0_23) AT=195.025n

* CHECK dout0_24 Vdout0_24ck38 = 0 time = 195
.meas tran vdout0_24ck38 FIND v(dout0_24) AT=195.025n

* CHECK dout0_25 Vdout0_25ck38 = 0.9 time = 195
.meas tran vdout0_25ck38 FIND v(dout0_25) AT=195.025n

* CHECK dout0_26 Vdout0_26ck38 = 0.9 time = 195
.meas tran vdout0_26ck38 FIND v(dout0_26) AT=195.025n

* CHECK dout0_27 Vdout0_27ck38 = 0 time = 195
.meas tran vdout0_27ck38 FIND v(dout0_27) AT=195.025n

* CHECK dout0_28 Vdout0_28ck38 = 0.9 time = 195
.meas tran vdout0_28ck38 FIND v(dout0_28) AT=195.025n

* CHECK dout0_29 Vdout0_29ck38 = 0.9 time = 195
.meas tran vdout0_29ck38 FIND v(dout0_29) AT=195.025n

* CHECK dout0_30 Vdout0_30ck38 = 0 time = 195
.meas tran vdout0_30ck38 FIND v(dout0_30) AT=195.025n

* CHECK dout0_31 Vdout0_31ck38 = 0 time = 195
.meas tran vdout0_31ck38 FIND v(dout0_31) AT=195.025n

* CHECK dout0_32 Vdout0_32ck38 = 0.9 time = 195
.meas tran vdout0_32ck38 FIND v(dout0_32) AT=195.025n

* CHECK dout0_33 Vdout0_33ck38 = 0 time = 195
.meas tran vdout0_33ck38 FIND v(dout0_33) AT=195.025n

* CHECK dout0_34 Vdout0_34ck38 = 0 time = 195
.meas tran vdout0_34ck38 FIND v(dout0_34) AT=195.025n

* CHECK dout0_35 Vdout0_35ck38 = 0 time = 195
.meas tran vdout0_35ck38 FIND v(dout0_35) AT=195.025n

* CHECK dout0_36 Vdout0_36ck38 = 0.9 time = 195
.meas tran vdout0_36ck38 FIND v(dout0_36) AT=195.025n

* CHECK dout0_37 Vdout0_37ck38 = 0 time = 195
.meas tran vdout0_37ck38 FIND v(dout0_37) AT=195.025n

* CHECK dout0_38 Vdout0_38ck38 = 0.9 time = 195
.meas tran vdout0_38ck38 FIND v(dout0_38) AT=195.025n

* CHECK dout0_39 Vdout0_39ck38 = 0 time = 195
.meas tran vdout0_39ck38 FIND v(dout0_39) AT=195.025n

* CHECK dout0_40 Vdout0_40ck38 = 0.9 time = 195
.meas tran vdout0_40ck38 FIND v(dout0_40) AT=195.025n

* CHECK dout0_41 Vdout0_41ck38 = 0.9 time = 195
.meas tran vdout0_41ck38 FIND v(dout0_41) AT=195.025n

* CHECK dout0_42 Vdout0_42ck38 = 0 time = 195
.meas tran vdout0_42ck38 FIND v(dout0_42) AT=195.025n

* CHECK dout0_43 Vdout0_43ck38 = 0 time = 195
.meas tran vdout0_43ck38 FIND v(dout0_43) AT=195.025n

* CHECK dout0_44 Vdout0_44ck38 = 0.9 time = 195
.meas tran vdout0_44ck38 FIND v(dout0_44) AT=195.025n

* CHECK dout0_45 Vdout0_45ck38 = 0 time = 195
.meas tran vdout0_45ck38 FIND v(dout0_45) AT=195.025n

* CHECK dout0_46 Vdout0_46ck38 = 0 time = 195
.meas tran vdout0_46ck38 FIND v(dout0_46) AT=195.025n

* CHECK dout0_47 Vdout0_47ck38 = 0 time = 195
.meas tran vdout0_47ck38 FIND v(dout0_47) AT=195.025n

* CHECK dout0_48 Vdout0_48ck38 = 0.9 time = 195
.meas tran vdout0_48ck38 FIND v(dout0_48) AT=195.025n

* CHECK dout0_49 Vdout0_49ck38 = 0.9 time = 195
.meas tran vdout0_49ck38 FIND v(dout0_49) AT=195.025n

* CHECK dout0_50 Vdout0_50ck38 = 0.9 time = 195
.meas tran vdout0_50ck38 FIND v(dout0_50) AT=195.025n

* CHECK dout0_51 Vdout0_51ck38 = 0 time = 195
.meas tran vdout0_51ck38 FIND v(dout0_51) AT=195.025n

* CHECK dout0_52 Vdout0_52ck38 = 0.9 time = 195
.meas tran vdout0_52ck38 FIND v(dout0_52) AT=195.025n

* CHECK dout0_53 Vdout0_53ck38 = 0 time = 195
.meas tran vdout0_53ck38 FIND v(dout0_53) AT=195.025n

* CHECK dout0_54 Vdout0_54ck38 = 0 time = 195
.meas tran vdout0_54ck38 FIND v(dout0_54) AT=195.025n

* CHECK dout0_55 Vdout0_55ck38 = 0 time = 195
.meas tran vdout0_55ck38 FIND v(dout0_55) AT=195.025n

* CHECK dout0_56 Vdout0_56ck38 = 0 time = 195
.meas tran vdout0_56ck38 FIND v(dout0_56) AT=195.025n

* CHECK dout0_57 Vdout0_57ck38 = 0 time = 195
.meas tran vdout0_57ck38 FIND v(dout0_57) AT=195.025n

* CHECK dout0_58 Vdout0_58ck38 = 0 time = 195
.meas tran vdout0_58ck38 FIND v(dout0_58) AT=195.025n

* CHECK dout0_59 Vdout0_59ck38 = 0 time = 195
.meas tran vdout0_59ck38 FIND v(dout0_59) AT=195.025n

* CHECK dout0_60 Vdout0_60ck38 = 0 time = 195
.meas tran vdout0_60ck38 FIND v(dout0_60) AT=195.025n

* CHECK dout0_61 Vdout0_61ck38 = 0.9 time = 195
.meas tran vdout0_61ck38 FIND v(dout0_61) AT=195.025n

* CHECK dout0_62 Vdout0_62ck38 = 0 time = 195
.meas tran vdout0_62ck38 FIND v(dout0_62) AT=195.025n

* CHECK dout0_63 Vdout0_63ck38 = 0.9 time = 195
.meas tran vdout0_63ck38 FIND v(dout0_63) AT=195.025n

* CHECK dout0_64 Vdout0_64ck38 = 0 time = 195
.meas tran vdout0_64ck38 FIND v(dout0_64) AT=195.025n

* CHECK dout0_65 Vdout0_65ck38 = 0.9 time = 195
.meas tran vdout0_65ck38 FIND v(dout0_65) AT=195.025n

* CHECK dout0_66 Vdout0_66ck38 = 0 time = 195
.meas tran vdout0_66ck38 FIND v(dout0_66) AT=195.025n

* CHECK dout0_67 Vdout0_67ck38 = 0.9 time = 195
.meas tran vdout0_67ck38 FIND v(dout0_67) AT=195.025n

* CHECK dout0_68 Vdout0_68ck38 = 0.9 time = 195
.meas tran vdout0_68ck38 FIND v(dout0_68) AT=195.025n

* CHECK dout0_69 Vdout0_69ck38 = 0 time = 195
.meas tran vdout0_69ck38 FIND v(dout0_69) AT=195.025n

* CHECK dout0_70 Vdout0_70ck38 = 0.9 time = 195
.meas tran vdout0_70ck38 FIND v(dout0_70) AT=195.025n

* CHECK dout0_71 Vdout0_71ck38 = 0.9 time = 195
.meas tran vdout0_71ck38 FIND v(dout0_71) AT=195.025n

* CHECK dout0_72 Vdout0_72ck38 = 0 time = 195
.meas tran vdout0_72ck38 FIND v(dout0_72) AT=195.025n

* CHECK dout0_73 Vdout0_73ck38 = 0.9 time = 195
.meas tran vdout0_73ck38 FIND v(dout0_73) AT=195.025n

* CHECK dout0_74 Vdout0_74ck38 = 0 time = 195
.meas tran vdout0_74ck38 FIND v(dout0_74) AT=195.025n

* CHECK dout0_75 Vdout0_75ck38 = 0.9 time = 195
.meas tran vdout0_75ck38 FIND v(dout0_75) AT=195.025n

* CHECK dout0_76 Vdout0_76ck38 = 0 time = 195
.meas tran vdout0_76ck38 FIND v(dout0_76) AT=195.025n

* CHECK dout0_77 Vdout0_77ck38 = 0.9 time = 195
.meas tran vdout0_77ck38 FIND v(dout0_77) AT=195.025n

* CHECK dout0_78 Vdout0_78ck38 = 0 time = 195
.meas tran vdout0_78ck38 FIND v(dout0_78) AT=195.025n

* CHECK dout0_79 Vdout0_79ck38 = 0 time = 195
.meas tran vdout0_79ck38 FIND v(dout0_79) AT=195.025n

* CHECK dout0_80 Vdout0_80ck38 = 0 time = 195
.meas tran vdout0_80ck38 FIND v(dout0_80) AT=195.025n

* CHECK dout0_81 Vdout0_81ck38 = 0 time = 195
.meas tran vdout0_81ck38 FIND v(dout0_81) AT=195.025n

* CHECK dout0_82 Vdout0_82ck38 = 0.9 time = 195
.meas tran vdout0_82ck38 FIND v(dout0_82) AT=195.025n

* CHECK dout0_83 Vdout0_83ck38 = 0.9 time = 195
.meas tran vdout0_83ck38 FIND v(dout0_83) AT=195.025n

* CHECK dout0_84 Vdout0_84ck38 = 0.9 time = 195
.meas tran vdout0_84ck38 FIND v(dout0_84) AT=195.025n

* CHECK dout0_85 Vdout0_85ck38 = 0 time = 195
.meas tran vdout0_85ck38 FIND v(dout0_85) AT=195.025n

* CHECK dout0_86 Vdout0_86ck38 = 0.9 time = 195
.meas tran vdout0_86ck38 FIND v(dout0_86) AT=195.025n

* CHECK dout0_87 Vdout0_87ck38 = 0.9 time = 195
.meas tran vdout0_87ck38 FIND v(dout0_87) AT=195.025n

* CHECK dout0_0 Vdout0_0ck39 = 0.9 time = 200
.meas tran vdout0_0ck39 FIND v(dout0_0) AT=200.025n

* CHECK dout0_1 Vdout0_1ck39 = 0 time = 200
.meas tran vdout0_1ck39 FIND v(dout0_1) AT=200.025n

* CHECK dout0_2 Vdout0_2ck39 = 0 time = 200
.meas tran vdout0_2ck39 FIND v(dout0_2) AT=200.025n

* CHECK dout0_3 Vdout0_3ck39 = 0.9 time = 200
.meas tran vdout0_3ck39 FIND v(dout0_3) AT=200.025n

* CHECK dout0_4 Vdout0_4ck39 = 0.9 time = 200
.meas tran vdout0_4ck39 FIND v(dout0_4) AT=200.025n

* CHECK dout0_5 Vdout0_5ck39 = 0 time = 200
.meas tran vdout0_5ck39 FIND v(dout0_5) AT=200.025n

* CHECK dout0_6 Vdout0_6ck39 = 0.9 time = 200
.meas tran vdout0_6ck39 FIND v(dout0_6) AT=200.025n

* CHECK dout0_7 Vdout0_7ck39 = 0.9 time = 200
.meas tran vdout0_7ck39 FIND v(dout0_7) AT=200.025n

* CHECK dout0_8 Vdout0_8ck39 = 0 time = 200
.meas tran vdout0_8ck39 FIND v(dout0_8) AT=200.025n

* CHECK dout0_9 Vdout0_9ck39 = 0.9 time = 200
.meas tran vdout0_9ck39 FIND v(dout0_9) AT=200.025n

* CHECK dout0_10 Vdout0_10ck39 = 0 time = 200
.meas tran vdout0_10ck39 FIND v(dout0_10) AT=200.025n

* CHECK dout0_11 Vdout0_11ck39 = 0.9 time = 200
.meas tran vdout0_11ck39 FIND v(dout0_11) AT=200.025n

* CHECK dout0_12 Vdout0_12ck39 = 0 time = 200
.meas tran vdout0_12ck39 FIND v(dout0_12) AT=200.025n

* CHECK dout0_13 Vdout0_13ck39 = 0 time = 200
.meas tran vdout0_13ck39 FIND v(dout0_13) AT=200.025n

* CHECK dout0_14 Vdout0_14ck39 = 0.9 time = 200
.meas tran vdout0_14ck39 FIND v(dout0_14) AT=200.025n

* CHECK dout0_15 Vdout0_15ck39 = 0.9 time = 200
.meas tran vdout0_15ck39 FIND v(dout0_15) AT=200.025n

* CHECK dout0_16 Vdout0_16ck39 = 0 time = 200
.meas tran vdout0_16ck39 FIND v(dout0_16) AT=200.025n

* CHECK dout0_17 Vdout0_17ck39 = 0 time = 200
.meas tran vdout0_17ck39 FIND v(dout0_17) AT=200.025n

* CHECK dout0_18 Vdout0_18ck39 = 0 time = 200
.meas tran vdout0_18ck39 FIND v(dout0_18) AT=200.025n

* CHECK dout0_19 Vdout0_19ck39 = 0.9 time = 200
.meas tran vdout0_19ck39 FIND v(dout0_19) AT=200.025n

* CHECK dout0_20 Vdout0_20ck39 = 0.9 time = 200
.meas tran vdout0_20ck39 FIND v(dout0_20) AT=200.025n

* CHECK dout0_21 Vdout0_21ck39 = 0 time = 200
.meas tran vdout0_21ck39 FIND v(dout0_21) AT=200.025n

* CHECK dout0_22 Vdout0_22ck39 = 0 time = 200
.meas tran vdout0_22ck39 FIND v(dout0_22) AT=200.025n

* CHECK dout0_23 Vdout0_23ck39 = 0 time = 200
.meas tran vdout0_23ck39 FIND v(dout0_23) AT=200.025n

* CHECK dout0_24 Vdout0_24ck39 = 0 time = 200
.meas tran vdout0_24ck39 FIND v(dout0_24) AT=200.025n

* CHECK dout0_25 Vdout0_25ck39 = 0.9 time = 200
.meas tran vdout0_25ck39 FIND v(dout0_25) AT=200.025n

* CHECK dout0_26 Vdout0_26ck39 = 0.9 time = 200
.meas tran vdout0_26ck39 FIND v(dout0_26) AT=200.025n

* CHECK dout0_27 Vdout0_27ck39 = 0 time = 200
.meas tran vdout0_27ck39 FIND v(dout0_27) AT=200.025n

* CHECK dout0_28 Vdout0_28ck39 = 0.9 time = 200
.meas tran vdout0_28ck39 FIND v(dout0_28) AT=200.025n

* CHECK dout0_29 Vdout0_29ck39 = 0.9 time = 200
.meas tran vdout0_29ck39 FIND v(dout0_29) AT=200.025n

* CHECK dout0_30 Vdout0_30ck39 = 0 time = 200
.meas tran vdout0_30ck39 FIND v(dout0_30) AT=200.025n

* CHECK dout0_31 Vdout0_31ck39 = 0 time = 200
.meas tran vdout0_31ck39 FIND v(dout0_31) AT=200.025n

* CHECK dout0_32 Vdout0_32ck39 = 0.9 time = 200
.meas tran vdout0_32ck39 FIND v(dout0_32) AT=200.025n

* CHECK dout0_33 Vdout0_33ck39 = 0 time = 200
.meas tran vdout0_33ck39 FIND v(dout0_33) AT=200.025n

* CHECK dout0_34 Vdout0_34ck39 = 0 time = 200
.meas tran vdout0_34ck39 FIND v(dout0_34) AT=200.025n

* CHECK dout0_35 Vdout0_35ck39 = 0 time = 200
.meas tran vdout0_35ck39 FIND v(dout0_35) AT=200.025n

* CHECK dout0_36 Vdout0_36ck39 = 0.9 time = 200
.meas tran vdout0_36ck39 FIND v(dout0_36) AT=200.025n

* CHECK dout0_37 Vdout0_37ck39 = 0 time = 200
.meas tran vdout0_37ck39 FIND v(dout0_37) AT=200.025n

* CHECK dout0_38 Vdout0_38ck39 = 0.9 time = 200
.meas tran vdout0_38ck39 FIND v(dout0_38) AT=200.025n

* CHECK dout0_39 Vdout0_39ck39 = 0 time = 200
.meas tran vdout0_39ck39 FIND v(dout0_39) AT=200.025n

* CHECK dout0_40 Vdout0_40ck39 = 0.9 time = 200
.meas tran vdout0_40ck39 FIND v(dout0_40) AT=200.025n

* CHECK dout0_41 Vdout0_41ck39 = 0.9 time = 200
.meas tran vdout0_41ck39 FIND v(dout0_41) AT=200.025n

* CHECK dout0_42 Vdout0_42ck39 = 0 time = 200
.meas tran vdout0_42ck39 FIND v(dout0_42) AT=200.025n

* CHECK dout0_43 Vdout0_43ck39 = 0 time = 200
.meas tran vdout0_43ck39 FIND v(dout0_43) AT=200.025n

* CHECK dout0_44 Vdout0_44ck39 = 0.9 time = 200
.meas tran vdout0_44ck39 FIND v(dout0_44) AT=200.025n

* CHECK dout0_45 Vdout0_45ck39 = 0 time = 200
.meas tran vdout0_45ck39 FIND v(dout0_45) AT=200.025n

* CHECK dout0_46 Vdout0_46ck39 = 0 time = 200
.meas tran vdout0_46ck39 FIND v(dout0_46) AT=200.025n

* CHECK dout0_47 Vdout0_47ck39 = 0 time = 200
.meas tran vdout0_47ck39 FIND v(dout0_47) AT=200.025n

* CHECK dout0_48 Vdout0_48ck39 = 0.9 time = 200
.meas tran vdout0_48ck39 FIND v(dout0_48) AT=200.025n

* CHECK dout0_49 Vdout0_49ck39 = 0.9 time = 200
.meas tran vdout0_49ck39 FIND v(dout0_49) AT=200.025n

* CHECK dout0_50 Vdout0_50ck39 = 0.9 time = 200
.meas tran vdout0_50ck39 FIND v(dout0_50) AT=200.025n

* CHECK dout0_51 Vdout0_51ck39 = 0 time = 200
.meas tran vdout0_51ck39 FIND v(dout0_51) AT=200.025n

* CHECK dout0_52 Vdout0_52ck39 = 0.9 time = 200
.meas tran vdout0_52ck39 FIND v(dout0_52) AT=200.025n

* CHECK dout0_53 Vdout0_53ck39 = 0 time = 200
.meas tran vdout0_53ck39 FIND v(dout0_53) AT=200.025n

* CHECK dout0_54 Vdout0_54ck39 = 0 time = 200
.meas tran vdout0_54ck39 FIND v(dout0_54) AT=200.025n

* CHECK dout0_55 Vdout0_55ck39 = 0 time = 200
.meas tran vdout0_55ck39 FIND v(dout0_55) AT=200.025n

* CHECK dout0_56 Vdout0_56ck39 = 0 time = 200
.meas tran vdout0_56ck39 FIND v(dout0_56) AT=200.025n

* CHECK dout0_57 Vdout0_57ck39 = 0 time = 200
.meas tran vdout0_57ck39 FIND v(dout0_57) AT=200.025n

* CHECK dout0_58 Vdout0_58ck39 = 0 time = 200
.meas tran vdout0_58ck39 FIND v(dout0_58) AT=200.025n

* CHECK dout0_59 Vdout0_59ck39 = 0 time = 200
.meas tran vdout0_59ck39 FIND v(dout0_59) AT=200.025n

* CHECK dout0_60 Vdout0_60ck39 = 0 time = 200
.meas tran vdout0_60ck39 FIND v(dout0_60) AT=200.025n

* CHECK dout0_61 Vdout0_61ck39 = 0.9 time = 200
.meas tran vdout0_61ck39 FIND v(dout0_61) AT=200.025n

* CHECK dout0_62 Vdout0_62ck39 = 0 time = 200
.meas tran vdout0_62ck39 FIND v(dout0_62) AT=200.025n

* CHECK dout0_63 Vdout0_63ck39 = 0.9 time = 200
.meas tran vdout0_63ck39 FIND v(dout0_63) AT=200.025n

* CHECK dout0_64 Vdout0_64ck39 = 0 time = 200
.meas tran vdout0_64ck39 FIND v(dout0_64) AT=200.025n

* CHECK dout0_65 Vdout0_65ck39 = 0.9 time = 200
.meas tran vdout0_65ck39 FIND v(dout0_65) AT=200.025n

* CHECK dout0_66 Vdout0_66ck39 = 0 time = 200
.meas tran vdout0_66ck39 FIND v(dout0_66) AT=200.025n

* CHECK dout0_67 Vdout0_67ck39 = 0.9 time = 200
.meas tran vdout0_67ck39 FIND v(dout0_67) AT=200.025n

* CHECK dout0_68 Vdout0_68ck39 = 0.9 time = 200
.meas tran vdout0_68ck39 FIND v(dout0_68) AT=200.025n

* CHECK dout0_69 Vdout0_69ck39 = 0 time = 200
.meas tran vdout0_69ck39 FIND v(dout0_69) AT=200.025n

* CHECK dout0_70 Vdout0_70ck39 = 0.9 time = 200
.meas tran vdout0_70ck39 FIND v(dout0_70) AT=200.025n

* CHECK dout0_71 Vdout0_71ck39 = 0.9 time = 200
.meas tran vdout0_71ck39 FIND v(dout0_71) AT=200.025n

* CHECK dout0_72 Vdout0_72ck39 = 0 time = 200
.meas tran vdout0_72ck39 FIND v(dout0_72) AT=200.025n

* CHECK dout0_73 Vdout0_73ck39 = 0.9 time = 200
.meas tran vdout0_73ck39 FIND v(dout0_73) AT=200.025n

* CHECK dout0_74 Vdout0_74ck39 = 0 time = 200
.meas tran vdout0_74ck39 FIND v(dout0_74) AT=200.025n

* CHECK dout0_75 Vdout0_75ck39 = 0.9 time = 200
.meas tran vdout0_75ck39 FIND v(dout0_75) AT=200.025n

* CHECK dout0_76 Vdout0_76ck39 = 0 time = 200
.meas tran vdout0_76ck39 FIND v(dout0_76) AT=200.025n

* CHECK dout0_77 Vdout0_77ck39 = 0.9 time = 200
.meas tran vdout0_77ck39 FIND v(dout0_77) AT=200.025n

* CHECK dout0_78 Vdout0_78ck39 = 0 time = 200
.meas tran vdout0_78ck39 FIND v(dout0_78) AT=200.025n

* CHECK dout0_79 Vdout0_79ck39 = 0 time = 200
.meas tran vdout0_79ck39 FIND v(dout0_79) AT=200.025n

* CHECK dout0_80 Vdout0_80ck39 = 0 time = 200
.meas tran vdout0_80ck39 FIND v(dout0_80) AT=200.025n

* CHECK dout0_81 Vdout0_81ck39 = 0 time = 200
.meas tran vdout0_81ck39 FIND v(dout0_81) AT=200.025n

* CHECK dout0_82 Vdout0_82ck39 = 0.9 time = 200
.meas tran vdout0_82ck39 FIND v(dout0_82) AT=200.025n

* CHECK dout0_83 Vdout0_83ck39 = 0.9 time = 200
.meas tran vdout0_83ck39 FIND v(dout0_83) AT=200.025n

* CHECK dout0_84 Vdout0_84ck39 = 0.9 time = 200
.meas tran vdout0_84ck39 FIND v(dout0_84) AT=200.025n

* CHECK dout0_85 Vdout0_85ck39 = 0 time = 200
.meas tran vdout0_85ck39 FIND v(dout0_85) AT=200.025n

* CHECK dout0_86 Vdout0_86ck39 = 0.9 time = 200
.meas tran vdout0_86ck39 FIND v(dout0_86) AT=200.025n

* CHECK dout0_87 Vdout0_87ck39 = 0.9 time = 200
.meas tran vdout0_87ck39 FIND v(dout0_87) AT=200.025n

* CHECK dout0_0 Vdout0_0ck40 = 0.9 time = 205
.meas tran vdout0_0ck40 FIND v(dout0_0) AT=205.025n

* CHECK dout0_1 Vdout0_1ck40 = 0 time = 205
.meas tran vdout0_1ck40 FIND v(dout0_1) AT=205.025n

* CHECK dout0_2 Vdout0_2ck40 = 0 time = 205
.meas tran vdout0_2ck40 FIND v(dout0_2) AT=205.025n

* CHECK dout0_3 Vdout0_3ck40 = 0.9 time = 205
.meas tran vdout0_3ck40 FIND v(dout0_3) AT=205.025n

* CHECK dout0_4 Vdout0_4ck40 = 0.9 time = 205
.meas tran vdout0_4ck40 FIND v(dout0_4) AT=205.025n

* CHECK dout0_5 Vdout0_5ck40 = 0 time = 205
.meas tran vdout0_5ck40 FIND v(dout0_5) AT=205.025n

* CHECK dout0_6 Vdout0_6ck40 = 0.9 time = 205
.meas tran vdout0_6ck40 FIND v(dout0_6) AT=205.025n

* CHECK dout0_7 Vdout0_7ck40 = 0.9 time = 205
.meas tran vdout0_7ck40 FIND v(dout0_7) AT=205.025n

* CHECK dout0_8 Vdout0_8ck40 = 0 time = 205
.meas tran vdout0_8ck40 FIND v(dout0_8) AT=205.025n

* CHECK dout0_9 Vdout0_9ck40 = 0.9 time = 205
.meas tran vdout0_9ck40 FIND v(dout0_9) AT=205.025n

* CHECK dout0_10 Vdout0_10ck40 = 0 time = 205
.meas tran vdout0_10ck40 FIND v(dout0_10) AT=205.025n

* CHECK dout0_11 Vdout0_11ck40 = 0.9 time = 205
.meas tran vdout0_11ck40 FIND v(dout0_11) AT=205.025n

* CHECK dout0_12 Vdout0_12ck40 = 0 time = 205
.meas tran vdout0_12ck40 FIND v(dout0_12) AT=205.025n

* CHECK dout0_13 Vdout0_13ck40 = 0 time = 205
.meas tran vdout0_13ck40 FIND v(dout0_13) AT=205.025n

* CHECK dout0_14 Vdout0_14ck40 = 0.9 time = 205
.meas tran vdout0_14ck40 FIND v(dout0_14) AT=205.025n

* CHECK dout0_15 Vdout0_15ck40 = 0.9 time = 205
.meas tran vdout0_15ck40 FIND v(dout0_15) AT=205.025n

* CHECK dout0_16 Vdout0_16ck40 = 0 time = 205
.meas tran vdout0_16ck40 FIND v(dout0_16) AT=205.025n

* CHECK dout0_17 Vdout0_17ck40 = 0 time = 205
.meas tran vdout0_17ck40 FIND v(dout0_17) AT=205.025n

* CHECK dout0_18 Vdout0_18ck40 = 0 time = 205
.meas tran vdout0_18ck40 FIND v(dout0_18) AT=205.025n

* CHECK dout0_19 Vdout0_19ck40 = 0.9 time = 205
.meas tran vdout0_19ck40 FIND v(dout0_19) AT=205.025n

* CHECK dout0_20 Vdout0_20ck40 = 0.9 time = 205
.meas tran vdout0_20ck40 FIND v(dout0_20) AT=205.025n

* CHECK dout0_21 Vdout0_21ck40 = 0 time = 205
.meas tran vdout0_21ck40 FIND v(dout0_21) AT=205.025n

* CHECK dout0_22 Vdout0_22ck40 = 0 time = 205
.meas tran vdout0_22ck40 FIND v(dout0_22) AT=205.025n

* CHECK dout0_23 Vdout0_23ck40 = 0 time = 205
.meas tran vdout0_23ck40 FIND v(dout0_23) AT=205.025n

* CHECK dout0_24 Vdout0_24ck40 = 0 time = 205
.meas tran vdout0_24ck40 FIND v(dout0_24) AT=205.025n

* CHECK dout0_25 Vdout0_25ck40 = 0.9 time = 205
.meas tran vdout0_25ck40 FIND v(dout0_25) AT=205.025n

* CHECK dout0_26 Vdout0_26ck40 = 0.9 time = 205
.meas tran vdout0_26ck40 FIND v(dout0_26) AT=205.025n

* CHECK dout0_27 Vdout0_27ck40 = 0 time = 205
.meas tran vdout0_27ck40 FIND v(dout0_27) AT=205.025n

* CHECK dout0_28 Vdout0_28ck40 = 0.9 time = 205
.meas tran vdout0_28ck40 FIND v(dout0_28) AT=205.025n

* CHECK dout0_29 Vdout0_29ck40 = 0.9 time = 205
.meas tran vdout0_29ck40 FIND v(dout0_29) AT=205.025n

* CHECK dout0_30 Vdout0_30ck40 = 0 time = 205
.meas tran vdout0_30ck40 FIND v(dout0_30) AT=205.025n

* CHECK dout0_31 Vdout0_31ck40 = 0 time = 205
.meas tran vdout0_31ck40 FIND v(dout0_31) AT=205.025n

* CHECK dout0_32 Vdout0_32ck40 = 0.9 time = 205
.meas tran vdout0_32ck40 FIND v(dout0_32) AT=205.025n

* CHECK dout0_33 Vdout0_33ck40 = 0 time = 205
.meas tran vdout0_33ck40 FIND v(dout0_33) AT=205.025n

* CHECK dout0_34 Vdout0_34ck40 = 0 time = 205
.meas tran vdout0_34ck40 FIND v(dout0_34) AT=205.025n

* CHECK dout0_35 Vdout0_35ck40 = 0 time = 205
.meas tran vdout0_35ck40 FIND v(dout0_35) AT=205.025n

* CHECK dout0_36 Vdout0_36ck40 = 0.9 time = 205
.meas tran vdout0_36ck40 FIND v(dout0_36) AT=205.025n

* CHECK dout0_37 Vdout0_37ck40 = 0 time = 205
.meas tran vdout0_37ck40 FIND v(dout0_37) AT=205.025n

* CHECK dout0_38 Vdout0_38ck40 = 0.9 time = 205
.meas tran vdout0_38ck40 FIND v(dout0_38) AT=205.025n

* CHECK dout0_39 Vdout0_39ck40 = 0 time = 205
.meas tran vdout0_39ck40 FIND v(dout0_39) AT=205.025n

* CHECK dout0_40 Vdout0_40ck40 = 0.9 time = 205
.meas tran vdout0_40ck40 FIND v(dout0_40) AT=205.025n

* CHECK dout0_41 Vdout0_41ck40 = 0.9 time = 205
.meas tran vdout0_41ck40 FIND v(dout0_41) AT=205.025n

* CHECK dout0_42 Vdout0_42ck40 = 0 time = 205
.meas tran vdout0_42ck40 FIND v(dout0_42) AT=205.025n

* CHECK dout0_43 Vdout0_43ck40 = 0 time = 205
.meas tran vdout0_43ck40 FIND v(dout0_43) AT=205.025n

* CHECK dout0_44 Vdout0_44ck40 = 0.9 time = 205
.meas tran vdout0_44ck40 FIND v(dout0_44) AT=205.025n

* CHECK dout0_45 Vdout0_45ck40 = 0 time = 205
.meas tran vdout0_45ck40 FIND v(dout0_45) AT=205.025n

* CHECK dout0_46 Vdout0_46ck40 = 0 time = 205
.meas tran vdout0_46ck40 FIND v(dout0_46) AT=205.025n

* CHECK dout0_47 Vdout0_47ck40 = 0 time = 205
.meas tran vdout0_47ck40 FIND v(dout0_47) AT=205.025n

* CHECK dout0_48 Vdout0_48ck40 = 0.9 time = 205
.meas tran vdout0_48ck40 FIND v(dout0_48) AT=205.025n

* CHECK dout0_49 Vdout0_49ck40 = 0.9 time = 205
.meas tran vdout0_49ck40 FIND v(dout0_49) AT=205.025n

* CHECK dout0_50 Vdout0_50ck40 = 0.9 time = 205
.meas tran vdout0_50ck40 FIND v(dout0_50) AT=205.025n

* CHECK dout0_51 Vdout0_51ck40 = 0 time = 205
.meas tran vdout0_51ck40 FIND v(dout0_51) AT=205.025n

* CHECK dout0_52 Vdout0_52ck40 = 0.9 time = 205
.meas tran vdout0_52ck40 FIND v(dout0_52) AT=205.025n

* CHECK dout0_53 Vdout0_53ck40 = 0 time = 205
.meas tran vdout0_53ck40 FIND v(dout0_53) AT=205.025n

* CHECK dout0_54 Vdout0_54ck40 = 0 time = 205
.meas tran vdout0_54ck40 FIND v(dout0_54) AT=205.025n

* CHECK dout0_55 Vdout0_55ck40 = 0 time = 205
.meas tran vdout0_55ck40 FIND v(dout0_55) AT=205.025n

* CHECK dout0_56 Vdout0_56ck40 = 0 time = 205
.meas tran vdout0_56ck40 FIND v(dout0_56) AT=205.025n

* CHECK dout0_57 Vdout0_57ck40 = 0 time = 205
.meas tran vdout0_57ck40 FIND v(dout0_57) AT=205.025n

* CHECK dout0_58 Vdout0_58ck40 = 0 time = 205
.meas tran vdout0_58ck40 FIND v(dout0_58) AT=205.025n

* CHECK dout0_59 Vdout0_59ck40 = 0 time = 205
.meas tran vdout0_59ck40 FIND v(dout0_59) AT=205.025n

* CHECK dout0_60 Vdout0_60ck40 = 0 time = 205
.meas tran vdout0_60ck40 FIND v(dout0_60) AT=205.025n

* CHECK dout0_61 Vdout0_61ck40 = 0.9 time = 205
.meas tran vdout0_61ck40 FIND v(dout0_61) AT=205.025n

* CHECK dout0_62 Vdout0_62ck40 = 0 time = 205
.meas tran vdout0_62ck40 FIND v(dout0_62) AT=205.025n

* CHECK dout0_63 Vdout0_63ck40 = 0.9 time = 205
.meas tran vdout0_63ck40 FIND v(dout0_63) AT=205.025n

* CHECK dout0_64 Vdout0_64ck40 = 0 time = 205
.meas tran vdout0_64ck40 FIND v(dout0_64) AT=205.025n

* CHECK dout0_65 Vdout0_65ck40 = 0.9 time = 205
.meas tran vdout0_65ck40 FIND v(dout0_65) AT=205.025n

* CHECK dout0_66 Vdout0_66ck40 = 0 time = 205
.meas tran vdout0_66ck40 FIND v(dout0_66) AT=205.025n

* CHECK dout0_67 Vdout0_67ck40 = 0.9 time = 205
.meas tran vdout0_67ck40 FIND v(dout0_67) AT=205.025n

* CHECK dout0_68 Vdout0_68ck40 = 0.9 time = 205
.meas tran vdout0_68ck40 FIND v(dout0_68) AT=205.025n

* CHECK dout0_69 Vdout0_69ck40 = 0 time = 205
.meas tran vdout0_69ck40 FIND v(dout0_69) AT=205.025n

* CHECK dout0_70 Vdout0_70ck40 = 0.9 time = 205
.meas tran vdout0_70ck40 FIND v(dout0_70) AT=205.025n

* CHECK dout0_71 Vdout0_71ck40 = 0.9 time = 205
.meas tran vdout0_71ck40 FIND v(dout0_71) AT=205.025n

* CHECK dout0_72 Vdout0_72ck40 = 0 time = 205
.meas tran vdout0_72ck40 FIND v(dout0_72) AT=205.025n

* CHECK dout0_73 Vdout0_73ck40 = 0.9 time = 205
.meas tran vdout0_73ck40 FIND v(dout0_73) AT=205.025n

* CHECK dout0_74 Vdout0_74ck40 = 0 time = 205
.meas tran vdout0_74ck40 FIND v(dout0_74) AT=205.025n

* CHECK dout0_75 Vdout0_75ck40 = 0.9 time = 205
.meas tran vdout0_75ck40 FIND v(dout0_75) AT=205.025n

* CHECK dout0_76 Vdout0_76ck40 = 0 time = 205
.meas tran vdout0_76ck40 FIND v(dout0_76) AT=205.025n

* CHECK dout0_77 Vdout0_77ck40 = 0.9 time = 205
.meas tran vdout0_77ck40 FIND v(dout0_77) AT=205.025n

* CHECK dout0_78 Vdout0_78ck40 = 0 time = 205
.meas tran vdout0_78ck40 FIND v(dout0_78) AT=205.025n

* CHECK dout0_79 Vdout0_79ck40 = 0 time = 205
.meas tran vdout0_79ck40 FIND v(dout0_79) AT=205.025n

* CHECK dout0_80 Vdout0_80ck40 = 0 time = 205
.meas tran vdout0_80ck40 FIND v(dout0_80) AT=205.025n

* CHECK dout0_81 Vdout0_81ck40 = 0 time = 205
.meas tran vdout0_81ck40 FIND v(dout0_81) AT=205.025n

* CHECK dout0_82 Vdout0_82ck40 = 0.9 time = 205
.meas tran vdout0_82ck40 FIND v(dout0_82) AT=205.025n

* CHECK dout0_83 Vdout0_83ck40 = 0.9 time = 205
.meas tran vdout0_83ck40 FIND v(dout0_83) AT=205.025n

* CHECK dout0_84 Vdout0_84ck40 = 0.9 time = 205
.meas tran vdout0_84ck40 FIND v(dout0_84) AT=205.025n

* CHECK dout0_85 Vdout0_85ck40 = 0 time = 205
.meas tran vdout0_85ck40 FIND v(dout0_85) AT=205.025n

* CHECK dout0_86 Vdout0_86ck40 = 0.9 time = 205
.meas tran vdout0_86ck40 FIND v(dout0_86) AT=205.025n

* CHECK dout0_87 Vdout0_87ck40 = 0.9 time = 205
.meas tran vdout0_87ck40 FIND v(dout0_87) AT=205.025n

* CHECK dout0_0 Vdout0_0ck45 = 0 time = 230
.meas tran vdout0_0ck45 FIND v(dout0_0) AT=230.025n

* CHECK dout0_1 Vdout0_1ck45 = 0 time = 230
.meas tran vdout0_1ck45 FIND v(dout0_1) AT=230.025n

* CHECK dout0_2 Vdout0_2ck45 = 0.9 time = 230
.meas tran vdout0_2ck45 FIND v(dout0_2) AT=230.025n

* CHECK dout0_3 Vdout0_3ck45 = 0 time = 230
.meas tran vdout0_3ck45 FIND v(dout0_3) AT=230.025n

* CHECK dout0_4 Vdout0_4ck45 = 0 time = 230
.meas tran vdout0_4ck45 FIND v(dout0_4) AT=230.025n

* CHECK dout0_5 Vdout0_5ck45 = 0.9 time = 230
.meas tran vdout0_5ck45 FIND v(dout0_5) AT=230.025n

* CHECK dout0_6 Vdout0_6ck45 = 0 time = 230
.meas tran vdout0_6ck45 FIND v(dout0_6) AT=230.025n

* CHECK dout0_7 Vdout0_7ck45 = 0 time = 230
.meas tran vdout0_7ck45 FIND v(dout0_7) AT=230.025n

* CHECK dout0_8 Vdout0_8ck45 = 0 time = 230
.meas tran vdout0_8ck45 FIND v(dout0_8) AT=230.025n

* CHECK dout0_9 Vdout0_9ck45 = 0 time = 230
.meas tran vdout0_9ck45 FIND v(dout0_9) AT=230.025n

* CHECK dout0_10 Vdout0_10ck45 = 0 time = 230
.meas tran vdout0_10ck45 FIND v(dout0_10) AT=230.025n

* CHECK dout0_11 Vdout0_11ck45 = 0.9 time = 230
.meas tran vdout0_11ck45 FIND v(dout0_11) AT=230.025n

* CHECK dout0_12 Vdout0_12ck45 = 0 time = 230
.meas tran vdout0_12ck45 FIND v(dout0_12) AT=230.025n

* CHECK dout0_13 Vdout0_13ck45 = 0.9 time = 230
.meas tran vdout0_13ck45 FIND v(dout0_13) AT=230.025n

* CHECK dout0_14 Vdout0_14ck45 = 0 time = 230
.meas tran vdout0_14ck45 FIND v(dout0_14) AT=230.025n

* CHECK dout0_15 Vdout0_15ck45 = 0 time = 230
.meas tran vdout0_15ck45 FIND v(dout0_15) AT=230.025n

* CHECK dout0_16 Vdout0_16ck45 = 0 time = 230
.meas tran vdout0_16ck45 FIND v(dout0_16) AT=230.025n

* CHECK dout0_17 Vdout0_17ck45 = 0 time = 230
.meas tran vdout0_17ck45 FIND v(dout0_17) AT=230.025n

* CHECK dout0_18 Vdout0_18ck45 = 0.9 time = 230
.meas tran vdout0_18ck45 FIND v(dout0_18) AT=230.025n

* CHECK dout0_19 Vdout0_19ck45 = 0 time = 230
.meas tran vdout0_19ck45 FIND v(dout0_19) AT=230.025n

* CHECK dout0_20 Vdout0_20ck45 = 0.9 time = 230
.meas tran vdout0_20ck45 FIND v(dout0_20) AT=230.025n

* CHECK dout0_21 Vdout0_21ck45 = 0 time = 230
.meas tran vdout0_21ck45 FIND v(dout0_21) AT=230.025n

* CHECK dout0_22 Vdout0_22ck45 = 0 time = 230
.meas tran vdout0_22ck45 FIND v(dout0_22) AT=230.025n

* CHECK dout0_23 Vdout0_23ck45 = 0.9 time = 230
.meas tran vdout0_23ck45 FIND v(dout0_23) AT=230.025n

* CHECK dout0_24 Vdout0_24ck45 = 0.9 time = 230
.meas tran vdout0_24ck45 FIND v(dout0_24) AT=230.025n

* CHECK dout0_25 Vdout0_25ck45 = 0.9 time = 230
.meas tran vdout0_25ck45 FIND v(dout0_25) AT=230.025n

* CHECK dout0_26 Vdout0_26ck45 = 0.9 time = 230
.meas tran vdout0_26ck45 FIND v(dout0_26) AT=230.025n

* CHECK dout0_27 Vdout0_27ck45 = 0 time = 230
.meas tran vdout0_27ck45 FIND v(dout0_27) AT=230.025n

* CHECK dout0_28 Vdout0_28ck45 = 0.9 time = 230
.meas tran vdout0_28ck45 FIND v(dout0_28) AT=230.025n

* CHECK dout0_29 Vdout0_29ck45 = 0.9 time = 230
.meas tran vdout0_29ck45 FIND v(dout0_29) AT=230.025n

* CHECK dout0_30 Vdout0_30ck45 = 0.9 time = 230
.meas tran vdout0_30ck45 FIND v(dout0_30) AT=230.025n

* CHECK dout0_31 Vdout0_31ck45 = 0 time = 230
.meas tran vdout0_31ck45 FIND v(dout0_31) AT=230.025n

* CHECK dout0_32 Vdout0_32ck45 = 0.9 time = 230
.meas tran vdout0_32ck45 FIND v(dout0_32) AT=230.025n

* CHECK dout0_33 Vdout0_33ck45 = 0.9 time = 230
.meas tran vdout0_33ck45 FIND v(dout0_33) AT=230.025n

* CHECK dout0_34 Vdout0_34ck45 = 0.9 time = 230
.meas tran vdout0_34ck45 FIND v(dout0_34) AT=230.025n

* CHECK dout0_35 Vdout0_35ck45 = 0 time = 230
.meas tran vdout0_35ck45 FIND v(dout0_35) AT=230.025n

* CHECK dout0_36 Vdout0_36ck45 = 0.9 time = 230
.meas tran vdout0_36ck45 FIND v(dout0_36) AT=230.025n

* CHECK dout0_37 Vdout0_37ck45 = 0.9 time = 230
.meas tran vdout0_37ck45 FIND v(dout0_37) AT=230.025n

* CHECK dout0_38 Vdout0_38ck45 = 0 time = 230
.meas tran vdout0_38ck45 FIND v(dout0_38) AT=230.025n

* CHECK dout0_39 Vdout0_39ck45 = 0.9 time = 230
.meas tran vdout0_39ck45 FIND v(dout0_39) AT=230.025n

* CHECK dout0_40 Vdout0_40ck45 = 0.9 time = 230
.meas tran vdout0_40ck45 FIND v(dout0_40) AT=230.025n

* CHECK dout0_41 Vdout0_41ck45 = 0 time = 230
.meas tran vdout0_41ck45 FIND v(dout0_41) AT=230.025n

* CHECK dout0_42 Vdout0_42ck45 = 0 time = 230
.meas tran vdout0_42ck45 FIND v(dout0_42) AT=230.025n

* CHECK dout0_43 Vdout0_43ck45 = 0 time = 230
.meas tran vdout0_43ck45 FIND v(dout0_43) AT=230.025n

* CHECK dout0_44 Vdout0_44ck45 = 0 time = 230
.meas tran vdout0_44ck45 FIND v(dout0_44) AT=230.025n

* CHECK dout0_45 Vdout0_45ck45 = 0 time = 230
.meas tran vdout0_45ck45 FIND v(dout0_45) AT=230.025n

* CHECK dout0_46 Vdout0_46ck45 = 0.9 time = 230
.meas tran vdout0_46ck45 FIND v(dout0_46) AT=230.025n

* CHECK dout0_47 Vdout0_47ck45 = 0.9 time = 230
.meas tran vdout0_47ck45 FIND v(dout0_47) AT=230.025n

* CHECK dout0_48 Vdout0_48ck45 = 0.9 time = 230
.meas tran vdout0_48ck45 FIND v(dout0_48) AT=230.025n

* CHECK dout0_49 Vdout0_49ck45 = 0 time = 230
.meas tran vdout0_49ck45 FIND v(dout0_49) AT=230.025n

* CHECK dout0_50 Vdout0_50ck45 = 0 time = 230
.meas tran vdout0_50ck45 FIND v(dout0_50) AT=230.025n

* CHECK dout0_51 Vdout0_51ck45 = 0 time = 230
.meas tran vdout0_51ck45 FIND v(dout0_51) AT=230.025n

* CHECK dout0_52 Vdout0_52ck45 = 0 time = 230
.meas tran vdout0_52ck45 FIND v(dout0_52) AT=230.025n

* CHECK dout0_53 Vdout0_53ck45 = 0 time = 230
.meas tran vdout0_53ck45 FIND v(dout0_53) AT=230.025n

* CHECK dout0_54 Vdout0_54ck45 = 0 time = 230
.meas tran vdout0_54ck45 FIND v(dout0_54) AT=230.025n

* CHECK dout0_55 Vdout0_55ck45 = 0 time = 230
.meas tran vdout0_55ck45 FIND v(dout0_55) AT=230.025n

* CHECK dout0_56 Vdout0_56ck45 = 0 time = 230
.meas tran vdout0_56ck45 FIND v(dout0_56) AT=230.025n

* CHECK dout0_57 Vdout0_57ck45 = 0.9 time = 230
.meas tran vdout0_57ck45 FIND v(dout0_57) AT=230.025n

* CHECK dout0_58 Vdout0_58ck45 = 0.9 time = 230
.meas tran vdout0_58ck45 FIND v(dout0_58) AT=230.025n

* CHECK dout0_59 Vdout0_59ck45 = 0.9 time = 230
.meas tran vdout0_59ck45 FIND v(dout0_59) AT=230.025n

* CHECK dout0_60 Vdout0_60ck45 = 0 time = 230
.meas tran vdout0_60ck45 FIND v(dout0_60) AT=230.025n

* CHECK dout0_61 Vdout0_61ck45 = 0.9 time = 230
.meas tran vdout0_61ck45 FIND v(dout0_61) AT=230.025n

* CHECK dout0_62 Vdout0_62ck45 = 0.9 time = 230
.meas tran vdout0_62ck45 FIND v(dout0_62) AT=230.025n

* CHECK dout0_63 Vdout0_63ck45 = 0 time = 230
.meas tran vdout0_63ck45 FIND v(dout0_63) AT=230.025n

* CHECK dout0_64 Vdout0_64ck45 = 0 time = 230
.meas tran vdout0_64ck45 FIND v(dout0_64) AT=230.025n

* CHECK dout0_65 Vdout0_65ck45 = 0 time = 230
.meas tran vdout0_65ck45 FIND v(dout0_65) AT=230.025n

* CHECK dout0_66 Vdout0_66ck45 = 0.9 time = 230
.meas tran vdout0_66ck45 FIND v(dout0_66) AT=230.025n

* CHECK dout0_67 Vdout0_67ck45 = 0.9 time = 230
.meas tran vdout0_67ck45 FIND v(dout0_67) AT=230.025n

* CHECK dout0_68 Vdout0_68ck45 = 0 time = 230
.meas tran vdout0_68ck45 FIND v(dout0_68) AT=230.025n

* CHECK dout0_69 Vdout0_69ck45 = 0 time = 230
.meas tran vdout0_69ck45 FIND v(dout0_69) AT=230.025n

* CHECK dout0_70 Vdout0_70ck45 = 0.9 time = 230
.meas tran vdout0_70ck45 FIND v(dout0_70) AT=230.025n

* CHECK dout0_71 Vdout0_71ck45 = 0 time = 230
.meas tran vdout0_71ck45 FIND v(dout0_71) AT=230.025n

* CHECK dout0_72 Vdout0_72ck45 = 0.9 time = 230
.meas tran vdout0_72ck45 FIND v(dout0_72) AT=230.025n

* CHECK dout0_73 Vdout0_73ck45 = 0 time = 230
.meas tran vdout0_73ck45 FIND v(dout0_73) AT=230.025n

* CHECK dout0_74 Vdout0_74ck45 = 0.9 time = 230
.meas tran vdout0_74ck45 FIND v(dout0_74) AT=230.025n

* CHECK dout0_75 Vdout0_75ck45 = 0 time = 230
.meas tran vdout0_75ck45 FIND v(dout0_75) AT=230.025n

* CHECK dout0_76 Vdout0_76ck45 = 0.9 time = 230
.meas tran vdout0_76ck45 FIND v(dout0_76) AT=230.025n

* CHECK dout0_77 Vdout0_77ck45 = 0.9 time = 230
.meas tran vdout0_77ck45 FIND v(dout0_77) AT=230.025n

* CHECK dout0_78 Vdout0_78ck45 = 0.9 time = 230
.meas tran vdout0_78ck45 FIND v(dout0_78) AT=230.025n

* CHECK dout0_79 Vdout0_79ck45 = 0 time = 230
.meas tran vdout0_79ck45 FIND v(dout0_79) AT=230.025n

* CHECK dout0_80 Vdout0_80ck45 = 0 time = 230
.meas tran vdout0_80ck45 FIND v(dout0_80) AT=230.025n

* CHECK dout0_81 Vdout0_81ck45 = 0 time = 230
.meas tran vdout0_81ck45 FIND v(dout0_81) AT=230.025n

* CHECK dout0_82 Vdout0_82ck45 = 0 time = 230
.meas tran vdout0_82ck45 FIND v(dout0_82) AT=230.025n

* CHECK dout0_83 Vdout0_83ck45 = 0 time = 230
.meas tran vdout0_83ck45 FIND v(dout0_83) AT=230.025n

* CHECK dout0_84 Vdout0_84ck45 = 0.9 time = 230
.meas tran vdout0_84ck45 FIND v(dout0_84) AT=230.025n

* CHECK dout0_85 Vdout0_85ck45 = 0.9 time = 230
.meas tran vdout0_85ck45 FIND v(dout0_85) AT=230.025n

* CHECK dout0_86 Vdout0_86ck45 = 0 time = 230
.meas tran vdout0_86ck45 FIND v(dout0_86) AT=230.025n

* CHECK dout0_87 Vdout0_87ck45 = 0.9 time = 230
.meas tran vdout0_87ck45 FIND v(dout0_87) AT=230.025n

* CHECK dout0_0 Vdout0_0ck50 = 0 time = 255
.meas tran vdout0_0ck50 FIND v(dout0_0) AT=255.025n

* CHECK dout0_1 Vdout0_1ck50 = 0.9 time = 255
.meas tran vdout0_1ck50 FIND v(dout0_1) AT=255.025n

* CHECK dout0_2 Vdout0_2ck50 = 0.9 time = 255
.meas tran vdout0_2ck50 FIND v(dout0_2) AT=255.025n

* CHECK dout0_3 Vdout0_3ck50 = 0.9 time = 255
.meas tran vdout0_3ck50 FIND v(dout0_3) AT=255.025n

* CHECK dout0_4 Vdout0_4ck50 = 0 time = 255
.meas tran vdout0_4ck50 FIND v(dout0_4) AT=255.025n

* CHECK dout0_5 Vdout0_5ck50 = 0 time = 255
.meas tran vdout0_5ck50 FIND v(dout0_5) AT=255.025n

* CHECK dout0_6 Vdout0_6ck50 = 0 time = 255
.meas tran vdout0_6ck50 FIND v(dout0_6) AT=255.025n

* CHECK dout0_7 Vdout0_7ck50 = 0.9 time = 255
.meas tran vdout0_7ck50 FIND v(dout0_7) AT=255.025n

* CHECK dout0_8 Vdout0_8ck50 = 0.9 time = 255
.meas tran vdout0_8ck50 FIND v(dout0_8) AT=255.025n

* CHECK dout0_9 Vdout0_9ck50 = 0.9 time = 255
.meas tran vdout0_9ck50 FIND v(dout0_9) AT=255.025n

* CHECK dout0_10 Vdout0_10ck50 = 0.9 time = 255
.meas tran vdout0_10ck50 FIND v(dout0_10) AT=255.025n

* CHECK dout0_11 Vdout0_11ck50 = 0 time = 255
.meas tran vdout0_11ck50 FIND v(dout0_11) AT=255.025n

* CHECK dout0_12 Vdout0_12ck50 = 0.9 time = 255
.meas tran vdout0_12ck50 FIND v(dout0_12) AT=255.025n

* CHECK dout0_13 Vdout0_13ck50 = 0.9 time = 255
.meas tran vdout0_13ck50 FIND v(dout0_13) AT=255.025n

* CHECK dout0_14 Vdout0_14ck50 = 0 time = 255
.meas tran vdout0_14ck50 FIND v(dout0_14) AT=255.025n

* CHECK dout0_15 Vdout0_15ck50 = 0.9 time = 255
.meas tran vdout0_15ck50 FIND v(dout0_15) AT=255.025n

* CHECK dout0_16 Vdout0_16ck50 = 0.9 time = 255
.meas tran vdout0_16ck50 FIND v(dout0_16) AT=255.025n

* CHECK dout0_17 Vdout0_17ck50 = 0 time = 255
.meas tran vdout0_17ck50 FIND v(dout0_17) AT=255.025n

* CHECK dout0_18 Vdout0_18ck50 = 0.9 time = 255
.meas tran vdout0_18ck50 FIND v(dout0_18) AT=255.025n

* CHECK dout0_19 Vdout0_19ck50 = 0.9 time = 255
.meas tran vdout0_19ck50 FIND v(dout0_19) AT=255.025n

* CHECK dout0_20 Vdout0_20ck50 = 0.9 time = 255
.meas tran vdout0_20ck50 FIND v(dout0_20) AT=255.025n

* CHECK dout0_21 Vdout0_21ck50 = 0.9 time = 255
.meas tran vdout0_21ck50 FIND v(dout0_21) AT=255.025n

* CHECK dout0_22 Vdout0_22ck50 = 0.9 time = 255
.meas tran vdout0_22ck50 FIND v(dout0_22) AT=255.025n

* CHECK dout0_23 Vdout0_23ck50 = 0 time = 255
.meas tran vdout0_23ck50 FIND v(dout0_23) AT=255.025n

* CHECK dout0_24 Vdout0_24ck50 = 0.9 time = 255
.meas tran vdout0_24ck50 FIND v(dout0_24) AT=255.025n

* CHECK dout0_25 Vdout0_25ck50 = 0 time = 255
.meas tran vdout0_25ck50 FIND v(dout0_25) AT=255.025n

* CHECK dout0_26 Vdout0_26ck50 = 0.9 time = 255
.meas tran vdout0_26ck50 FIND v(dout0_26) AT=255.025n

* CHECK dout0_27 Vdout0_27ck50 = 0 time = 255
.meas tran vdout0_27ck50 FIND v(dout0_27) AT=255.025n

* CHECK dout0_28 Vdout0_28ck50 = 0.9 time = 255
.meas tran vdout0_28ck50 FIND v(dout0_28) AT=255.025n

* CHECK dout0_29 Vdout0_29ck50 = 0 time = 255
.meas tran vdout0_29ck50 FIND v(dout0_29) AT=255.025n

* CHECK dout0_30 Vdout0_30ck50 = 0 time = 255
.meas tran vdout0_30ck50 FIND v(dout0_30) AT=255.025n

* CHECK dout0_31 Vdout0_31ck50 = 0.9 time = 255
.meas tran vdout0_31ck50 FIND v(dout0_31) AT=255.025n

* CHECK dout0_32 Vdout0_32ck50 = 0 time = 255
.meas tran vdout0_32ck50 FIND v(dout0_32) AT=255.025n

* CHECK dout0_33 Vdout0_33ck50 = 0 time = 255
.meas tran vdout0_33ck50 FIND v(dout0_33) AT=255.025n

* CHECK dout0_34 Vdout0_34ck50 = 0 time = 255
.meas tran vdout0_34ck50 FIND v(dout0_34) AT=255.025n

* CHECK dout0_35 Vdout0_35ck50 = 0 time = 255
.meas tran vdout0_35ck50 FIND v(dout0_35) AT=255.025n

* CHECK dout0_36 Vdout0_36ck50 = 0 time = 255
.meas tran vdout0_36ck50 FIND v(dout0_36) AT=255.025n

* CHECK dout0_37 Vdout0_37ck50 = 0 time = 255
.meas tran vdout0_37ck50 FIND v(dout0_37) AT=255.025n

* CHECK dout0_38 Vdout0_38ck50 = 0.9 time = 255
.meas tran vdout0_38ck50 FIND v(dout0_38) AT=255.025n

* CHECK dout0_39 Vdout0_39ck50 = 0.9 time = 255
.meas tran vdout0_39ck50 FIND v(dout0_39) AT=255.025n

* CHECK dout0_40 Vdout0_40ck50 = 0.9 time = 255
.meas tran vdout0_40ck50 FIND v(dout0_40) AT=255.025n

* CHECK dout0_41 Vdout0_41ck50 = 0.9 time = 255
.meas tran vdout0_41ck50 FIND v(dout0_41) AT=255.025n

* CHECK dout0_42 Vdout0_42ck50 = 0.9 time = 255
.meas tran vdout0_42ck50 FIND v(dout0_42) AT=255.025n

* CHECK dout0_43 Vdout0_43ck50 = 0 time = 255
.meas tran vdout0_43ck50 FIND v(dout0_43) AT=255.025n

* CHECK dout0_44 Vdout0_44ck50 = 0 time = 255
.meas tran vdout0_44ck50 FIND v(dout0_44) AT=255.025n

* CHECK dout0_45 Vdout0_45ck50 = 0 time = 255
.meas tran vdout0_45ck50 FIND v(dout0_45) AT=255.025n

* CHECK dout0_46 Vdout0_46ck50 = 0.9 time = 255
.meas tran vdout0_46ck50 FIND v(dout0_46) AT=255.025n

* CHECK dout0_47 Vdout0_47ck50 = 0.9 time = 255
.meas tran vdout0_47ck50 FIND v(dout0_47) AT=255.025n

* CHECK dout0_48 Vdout0_48ck50 = 0 time = 255
.meas tran vdout0_48ck50 FIND v(dout0_48) AT=255.025n

* CHECK dout0_49 Vdout0_49ck50 = 0 time = 255
.meas tran vdout0_49ck50 FIND v(dout0_49) AT=255.025n

* CHECK dout0_50 Vdout0_50ck50 = 0 time = 255
.meas tran vdout0_50ck50 FIND v(dout0_50) AT=255.025n

* CHECK dout0_51 Vdout0_51ck50 = 0 time = 255
.meas tran vdout0_51ck50 FIND v(dout0_51) AT=255.025n

* CHECK dout0_52 Vdout0_52ck50 = 0.9 time = 255
.meas tran vdout0_52ck50 FIND v(dout0_52) AT=255.025n

* CHECK dout0_53 Vdout0_53ck50 = 0.9 time = 255
.meas tran vdout0_53ck50 FIND v(dout0_53) AT=255.025n

* CHECK dout0_54 Vdout0_54ck50 = 0.9 time = 255
.meas tran vdout0_54ck50 FIND v(dout0_54) AT=255.025n

* CHECK dout0_55 Vdout0_55ck50 = 0 time = 255
.meas tran vdout0_55ck50 FIND v(dout0_55) AT=255.025n

* CHECK dout0_56 Vdout0_56ck50 = 0 time = 255
.meas tran vdout0_56ck50 FIND v(dout0_56) AT=255.025n

* CHECK dout0_57 Vdout0_57ck50 = 0.9 time = 255
.meas tran vdout0_57ck50 FIND v(dout0_57) AT=255.025n

* CHECK dout0_58 Vdout0_58ck50 = 0 time = 255
.meas tran vdout0_58ck50 FIND v(dout0_58) AT=255.025n

* CHECK dout0_59 Vdout0_59ck50 = 0.9 time = 255
.meas tran vdout0_59ck50 FIND v(dout0_59) AT=255.025n

* CHECK dout0_60 Vdout0_60ck50 = 0 time = 255
.meas tran vdout0_60ck50 FIND v(dout0_60) AT=255.025n

* CHECK dout0_61 Vdout0_61ck50 = 0.9 time = 255
.meas tran vdout0_61ck50 FIND v(dout0_61) AT=255.025n

* CHECK dout0_62 Vdout0_62ck50 = 0.9 time = 255
.meas tran vdout0_62ck50 FIND v(dout0_62) AT=255.025n

* CHECK dout0_63 Vdout0_63ck50 = 0.9 time = 255
.meas tran vdout0_63ck50 FIND v(dout0_63) AT=255.025n

* CHECK dout0_64 Vdout0_64ck50 = 0.9 time = 255
.meas tran vdout0_64ck50 FIND v(dout0_64) AT=255.025n

* CHECK dout0_65 Vdout0_65ck50 = 0.9 time = 255
.meas tran vdout0_65ck50 FIND v(dout0_65) AT=255.025n

* CHECK dout0_66 Vdout0_66ck50 = 0.9 time = 255
.meas tran vdout0_66ck50 FIND v(dout0_66) AT=255.025n

* CHECK dout0_67 Vdout0_67ck50 = 0 time = 255
.meas tran vdout0_67ck50 FIND v(dout0_67) AT=255.025n

* CHECK dout0_68 Vdout0_68ck50 = 0 time = 255
.meas tran vdout0_68ck50 FIND v(dout0_68) AT=255.025n

* CHECK dout0_69 Vdout0_69ck50 = 0 time = 255
.meas tran vdout0_69ck50 FIND v(dout0_69) AT=255.025n

* CHECK dout0_70 Vdout0_70ck50 = 0.9 time = 255
.meas tran vdout0_70ck50 FIND v(dout0_70) AT=255.025n

* CHECK dout0_71 Vdout0_71ck50 = 0.9 time = 255
.meas tran vdout0_71ck50 FIND v(dout0_71) AT=255.025n

* CHECK dout0_72 Vdout0_72ck50 = 0 time = 255
.meas tran vdout0_72ck50 FIND v(dout0_72) AT=255.025n

* CHECK dout0_73 Vdout0_73ck50 = 0 time = 255
.meas tran vdout0_73ck50 FIND v(dout0_73) AT=255.025n

* CHECK dout0_74 Vdout0_74ck50 = 0.9 time = 255
.meas tran vdout0_74ck50 FIND v(dout0_74) AT=255.025n

* CHECK dout0_75 Vdout0_75ck50 = 0 time = 255
.meas tran vdout0_75ck50 FIND v(dout0_75) AT=255.025n

* CHECK dout0_76 Vdout0_76ck50 = 0 time = 255
.meas tran vdout0_76ck50 FIND v(dout0_76) AT=255.025n

* CHECK dout0_77 Vdout0_77ck50 = 0.9 time = 255
.meas tran vdout0_77ck50 FIND v(dout0_77) AT=255.025n

* CHECK dout0_78 Vdout0_78ck50 = 0.9 time = 255
.meas tran vdout0_78ck50 FIND v(dout0_78) AT=255.025n

* CHECK dout0_79 Vdout0_79ck50 = 0.9 time = 255
.meas tran vdout0_79ck50 FIND v(dout0_79) AT=255.025n

* CHECK dout0_80 Vdout0_80ck50 = 0.9 time = 255
.meas tran vdout0_80ck50 FIND v(dout0_80) AT=255.025n

* CHECK dout0_81 Vdout0_81ck50 = 0.9 time = 255
.meas tran vdout0_81ck50 FIND v(dout0_81) AT=255.025n

* CHECK dout0_82 Vdout0_82ck50 = 0 time = 255
.meas tran vdout0_82ck50 FIND v(dout0_82) AT=255.025n

* CHECK dout0_83 Vdout0_83ck50 = 0 time = 255
.meas tran vdout0_83ck50 FIND v(dout0_83) AT=255.025n

* CHECK dout0_84 Vdout0_84ck50 = 0.9 time = 255
.meas tran vdout0_84ck50 FIND v(dout0_84) AT=255.025n

* CHECK dout0_85 Vdout0_85ck50 = 0 time = 255
.meas tran vdout0_85ck50 FIND v(dout0_85) AT=255.025n

* CHECK dout0_86 Vdout0_86ck50 = 0 time = 255
.meas tran vdout0_86ck50 FIND v(dout0_86) AT=255.025n

* CHECK dout0_87 Vdout0_87ck50 = 0 time = 255
.meas tran vdout0_87ck50 FIND v(dout0_87) AT=255.025n

* CHECK dout0_0 Vdout0_0ck51 = 0 time = 260
.meas tran vdout0_0ck51 FIND v(dout0_0) AT=260.025n

* CHECK dout0_1 Vdout0_1ck51 = 0.9 time = 260
.meas tran vdout0_1ck51 FIND v(dout0_1) AT=260.025n

* CHECK dout0_2 Vdout0_2ck51 = 0.9 time = 260
.meas tran vdout0_2ck51 FIND v(dout0_2) AT=260.025n

* CHECK dout0_3 Vdout0_3ck51 = 0.9 time = 260
.meas tran vdout0_3ck51 FIND v(dout0_3) AT=260.025n

* CHECK dout0_4 Vdout0_4ck51 = 0 time = 260
.meas tran vdout0_4ck51 FIND v(dout0_4) AT=260.025n

* CHECK dout0_5 Vdout0_5ck51 = 0.9 time = 260
.meas tran vdout0_5ck51 FIND v(dout0_5) AT=260.025n

* CHECK dout0_6 Vdout0_6ck51 = 0.9 time = 260
.meas tran vdout0_6ck51 FIND v(dout0_6) AT=260.025n

* CHECK dout0_7 Vdout0_7ck51 = 0.9 time = 260
.meas tran vdout0_7ck51 FIND v(dout0_7) AT=260.025n

* CHECK dout0_8 Vdout0_8ck51 = 0.9 time = 260
.meas tran vdout0_8ck51 FIND v(dout0_8) AT=260.025n

* CHECK dout0_9 Vdout0_9ck51 = 0.9 time = 260
.meas tran vdout0_9ck51 FIND v(dout0_9) AT=260.025n

* CHECK dout0_10 Vdout0_10ck51 = 0 time = 260
.meas tran vdout0_10ck51 FIND v(dout0_10) AT=260.025n

* CHECK dout0_11 Vdout0_11ck51 = 0.9 time = 260
.meas tran vdout0_11ck51 FIND v(dout0_11) AT=260.025n

* CHECK dout0_12 Vdout0_12ck51 = 0.9 time = 260
.meas tran vdout0_12ck51 FIND v(dout0_12) AT=260.025n

* CHECK dout0_13 Vdout0_13ck51 = 0 time = 260
.meas tran vdout0_13ck51 FIND v(dout0_13) AT=260.025n

* CHECK dout0_14 Vdout0_14ck51 = 0.9 time = 260
.meas tran vdout0_14ck51 FIND v(dout0_14) AT=260.025n

* CHECK dout0_15 Vdout0_15ck51 = 0 time = 260
.meas tran vdout0_15ck51 FIND v(dout0_15) AT=260.025n

* CHECK dout0_16 Vdout0_16ck51 = 0 time = 260
.meas tran vdout0_16ck51 FIND v(dout0_16) AT=260.025n

* CHECK dout0_17 Vdout0_17ck51 = 0 time = 260
.meas tran vdout0_17ck51 FIND v(dout0_17) AT=260.025n

* CHECK dout0_18 Vdout0_18ck51 = 0.9 time = 260
.meas tran vdout0_18ck51 FIND v(dout0_18) AT=260.025n

* CHECK dout0_19 Vdout0_19ck51 = 0.9 time = 260
.meas tran vdout0_19ck51 FIND v(dout0_19) AT=260.025n

* CHECK dout0_20 Vdout0_20ck51 = 0.9 time = 260
.meas tran vdout0_20ck51 FIND v(dout0_20) AT=260.025n

* CHECK dout0_21 Vdout0_21ck51 = 0.9 time = 260
.meas tran vdout0_21ck51 FIND v(dout0_21) AT=260.025n

* CHECK dout0_22 Vdout0_22ck51 = 0 time = 260
.meas tran vdout0_22ck51 FIND v(dout0_22) AT=260.025n

* CHECK dout0_23 Vdout0_23ck51 = 0 time = 260
.meas tran vdout0_23ck51 FIND v(dout0_23) AT=260.025n

* CHECK dout0_24 Vdout0_24ck51 = 0.9 time = 260
.meas tran vdout0_24ck51 FIND v(dout0_24) AT=260.025n

* CHECK dout0_25 Vdout0_25ck51 = 0 time = 260
.meas tran vdout0_25ck51 FIND v(dout0_25) AT=260.025n

* CHECK dout0_26 Vdout0_26ck51 = 0 time = 260
.meas tran vdout0_26ck51 FIND v(dout0_26) AT=260.025n

* CHECK dout0_27 Vdout0_27ck51 = 0.9 time = 260
.meas tran vdout0_27ck51 FIND v(dout0_27) AT=260.025n

* CHECK dout0_28 Vdout0_28ck51 = 0 time = 260
.meas tran vdout0_28ck51 FIND v(dout0_28) AT=260.025n

* CHECK dout0_29 Vdout0_29ck51 = 0.9 time = 260
.meas tran vdout0_29ck51 FIND v(dout0_29) AT=260.025n

* CHECK dout0_30 Vdout0_30ck51 = 0.9 time = 260
.meas tran vdout0_30ck51 FIND v(dout0_30) AT=260.025n

* CHECK dout0_31 Vdout0_31ck51 = 0.9 time = 260
.meas tran vdout0_31ck51 FIND v(dout0_31) AT=260.025n

* CHECK dout0_32 Vdout0_32ck51 = 0.9 time = 260
.meas tran vdout0_32ck51 FIND v(dout0_32) AT=260.025n

* CHECK dout0_33 Vdout0_33ck51 = 0.9 time = 260
.meas tran vdout0_33ck51 FIND v(dout0_33) AT=260.025n

* CHECK dout0_34 Vdout0_34ck51 = 0.9 time = 260
.meas tran vdout0_34ck51 FIND v(dout0_34) AT=260.025n

* CHECK dout0_35 Vdout0_35ck51 = 0.9 time = 260
.meas tran vdout0_35ck51 FIND v(dout0_35) AT=260.025n

* CHECK dout0_36 Vdout0_36ck51 = 0.9 time = 260
.meas tran vdout0_36ck51 FIND v(dout0_36) AT=260.025n

* CHECK dout0_37 Vdout0_37ck51 = 0.9 time = 260
.meas tran vdout0_37ck51 FIND v(dout0_37) AT=260.025n

* CHECK dout0_38 Vdout0_38ck51 = 0.9 time = 260
.meas tran vdout0_38ck51 FIND v(dout0_38) AT=260.025n

* CHECK dout0_39 Vdout0_39ck51 = 0.9 time = 260
.meas tran vdout0_39ck51 FIND v(dout0_39) AT=260.025n

* CHECK dout0_40 Vdout0_40ck51 = 0 time = 260
.meas tran vdout0_40ck51 FIND v(dout0_40) AT=260.025n

* CHECK dout0_41 Vdout0_41ck51 = 0 time = 260
.meas tran vdout0_41ck51 FIND v(dout0_41) AT=260.025n

* CHECK dout0_42 Vdout0_42ck51 = 0.9 time = 260
.meas tran vdout0_42ck51 FIND v(dout0_42) AT=260.025n

* CHECK dout0_43 Vdout0_43ck51 = 0.9 time = 260
.meas tran vdout0_43ck51 FIND v(dout0_43) AT=260.025n

* CHECK dout0_44 Vdout0_44ck51 = 0.9 time = 260
.meas tran vdout0_44ck51 FIND v(dout0_44) AT=260.025n

* CHECK dout0_45 Vdout0_45ck51 = 0 time = 260
.meas tran vdout0_45ck51 FIND v(dout0_45) AT=260.025n

* CHECK dout0_46 Vdout0_46ck51 = 0 time = 260
.meas tran vdout0_46ck51 FIND v(dout0_46) AT=260.025n

* CHECK dout0_47 Vdout0_47ck51 = 0 time = 260
.meas tran vdout0_47ck51 FIND v(dout0_47) AT=260.025n

* CHECK dout0_48 Vdout0_48ck51 = 0 time = 260
.meas tran vdout0_48ck51 FIND v(dout0_48) AT=260.025n

* CHECK dout0_49 Vdout0_49ck51 = 0 time = 260
.meas tran vdout0_49ck51 FIND v(dout0_49) AT=260.025n

* CHECK dout0_50 Vdout0_50ck51 = 0.9 time = 260
.meas tran vdout0_50ck51 FIND v(dout0_50) AT=260.025n

* CHECK dout0_51 Vdout0_51ck51 = 0.9 time = 260
.meas tran vdout0_51ck51 FIND v(dout0_51) AT=260.025n

* CHECK dout0_52 Vdout0_52ck51 = 0 time = 260
.meas tran vdout0_52ck51 FIND v(dout0_52) AT=260.025n

* CHECK dout0_53 Vdout0_53ck51 = 0.9 time = 260
.meas tran vdout0_53ck51 FIND v(dout0_53) AT=260.025n

* CHECK dout0_54 Vdout0_54ck51 = 0 time = 260
.meas tran vdout0_54ck51 FIND v(dout0_54) AT=260.025n

* CHECK dout0_55 Vdout0_55ck51 = 0.9 time = 260
.meas tran vdout0_55ck51 FIND v(dout0_55) AT=260.025n

* CHECK dout0_56 Vdout0_56ck51 = 0.9 time = 260
.meas tran vdout0_56ck51 FIND v(dout0_56) AT=260.025n

* CHECK dout0_57 Vdout0_57ck51 = 0.9 time = 260
.meas tran vdout0_57ck51 FIND v(dout0_57) AT=260.025n

* CHECK dout0_58 Vdout0_58ck51 = 0 time = 260
.meas tran vdout0_58ck51 FIND v(dout0_58) AT=260.025n

* CHECK dout0_59 Vdout0_59ck51 = 0.9 time = 260
.meas tran vdout0_59ck51 FIND v(dout0_59) AT=260.025n

* CHECK dout0_60 Vdout0_60ck51 = 0.9 time = 260
.meas tran vdout0_60ck51 FIND v(dout0_60) AT=260.025n

* CHECK dout0_61 Vdout0_61ck51 = 0 time = 260
.meas tran vdout0_61ck51 FIND v(dout0_61) AT=260.025n

* CHECK dout0_62 Vdout0_62ck51 = 0.9 time = 260
.meas tran vdout0_62ck51 FIND v(dout0_62) AT=260.025n

* CHECK dout0_63 Vdout0_63ck51 = 0 time = 260
.meas tran vdout0_63ck51 FIND v(dout0_63) AT=260.025n

* CHECK dout0_64 Vdout0_64ck51 = 0.9 time = 260
.meas tran vdout0_64ck51 FIND v(dout0_64) AT=260.025n

* CHECK dout0_65 Vdout0_65ck51 = 0.9 time = 260
.meas tran vdout0_65ck51 FIND v(dout0_65) AT=260.025n

* CHECK dout0_66 Vdout0_66ck51 = 0 time = 260
.meas tran vdout0_66ck51 FIND v(dout0_66) AT=260.025n

* CHECK dout0_67 Vdout0_67ck51 = 0 time = 260
.meas tran vdout0_67ck51 FIND v(dout0_67) AT=260.025n

* CHECK dout0_68 Vdout0_68ck51 = 0.9 time = 260
.meas tran vdout0_68ck51 FIND v(dout0_68) AT=260.025n

* CHECK dout0_69 Vdout0_69ck51 = 0 time = 260
.meas tran vdout0_69ck51 FIND v(dout0_69) AT=260.025n

* CHECK dout0_70 Vdout0_70ck51 = 0 time = 260
.meas tran vdout0_70ck51 FIND v(dout0_70) AT=260.025n

* CHECK dout0_71 Vdout0_71ck51 = 0.9 time = 260
.meas tran vdout0_71ck51 FIND v(dout0_71) AT=260.025n

* CHECK dout0_72 Vdout0_72ck51 = 0 time = 260
.meas tran vdout0_72ck51 FIND v(dout0_72) AT=260.025n

* CHECK dout0_73 Vdout0_73ck51 = 0 time = 260
.meas tran vdout0_73ck51 FIND v(dout0_73) AT=260.025n

* CHECK dout0_74 Vdout0_74ck51 = 0 time = 260
.meas tran vdout0_74ck51 FIND v(dout0_74) AT=260.025n

* CHECK dout0_75 Vdout0_75ck51 = 0 time = 260
.meas tran vdout0_75ck51 FIND v(dout0_75) AT=260.025n

* CHECK dout0_76 Vdout0_76ck51 = 0 time = 260
.meas tran vdout0_76ck51 FIND v(dout0_76) AT=260.025n

* CHECK dout0_77 Vdout0_77ck51 = 0 time = 260
.meas tran vdout0_77ck51 FIND v(dout0_77) AT=260.025n

* CHECK dout0_78 Vdout0_78ck51 = 0.9 time = 260
.meas tran vdout0_78ck51 FIND v(dout0_78) AT=260.025n

* CHECK dout0_79 Vdout0_79ck51 = 0.9 time = 260
.meas tran vdout0_79ck51 FIND v(dout0_79) AT=260.025n

* CHECK dout0_80 Vdout0_80ck51 = 0 time = 260
.meas tran vdout0_80ck51 FIND v(dout0_80) AT=260.025n

* CHECK dout0_81 Vdout0_81ck51 = 0.9 time = 260
.meas tran vdout0_81ck51 FIND v(dout0_81) AT=260.025n

* CHECK dout0_82 Vdout0_82ck51 = 0.9 time = 260
.meas tran vdout0_82ck51 FIND v(dout0_82) AT=260.025n

* CHECK dout0_83 Vdout0_83ck51 = 0.9 time = 260
.meas tran vdout0_83ck51 FIND v(dout0_83) AT=260.025n

* CHECK dout0_84 Vdout0_84ck51 = 0.9 time = 260
.meas tran vdout0_84ck51 FIND v(dout0_84) AT=260.025n

* CHECK dout0_85 Vdout0_85ck51 = 0 time = 260
.meas tran vdout0_85ck51 FIND v(dout0_85) AT=260.025n

* CHECK dout0_86 Vdout0_86ck51 = 0 time = 260
.meas tran vdout0_86ck51 FIND v(dout0_86) AT=260.025n

* CHECK dout0_87 Vdout0_87ck51 = 0 time = 260
.meas tran vdout0_87ck51 FIND v(dout0_87) AT=260.025n

* CHECK dout0_0 Vdout0_0ck54 = 0 time = 275
.meas tran vdout0_0ck54 FIND v(dout0_0) AT=275.025n

* CHECK dout0_1 Vdout0_1ck54 = 0.9 time = 275
.meas tran vdout0_1ck54 FIND v(dout0_1) AT=275.025n

* CHECK dout0_2 Vdout0_2ck54 = 0.9 time = 275
.meas tran vdout0_2ck54 FIND v(dout0_2) AT=275.025n

* CHECK dout0_3 Vdout0_3ck54 = 0.9 time = 275
.meas tran vdout0_3ck54 FIND v(dout0_3) AT=275.025n

* CHECK dout0_4 Vdout0_4ck54 = 0 time = 275
.meas tran vdout0_4ck54 FIND v(dout0_4) AT=275.025n

* CHECK dout0_5 Vdout0_5ck54 = 0 time = 275
.meas tran vdout0_5ck54 FIND v(dout0_5) AT=275.025n

* CHECK dout0_6 Vdout0_6ck54 = 0 time = 275
.meas tran vdout0_6ck54 FIND v(dout0_6) AT=275.025n

* CHECK dout0_7 Vdout0_7ck54 = 0.9 time = 275
.meas tran vdout0_7ck54 FIND v(dout0_7) AT=275.025n

* CHECK dout0_8 Vdout0_8ck54 = 0 time = 275
.meas tran vdout0_8ck54 FIND v(dout0_8) AT=275.025n

* CHECK dout0_9 Vdout0_9ck54 = 0 time = 275
.meas tran vdout0_9ck54 FIND v(dout0_9) AT=275.025n

* CHECK dout0_10 Vdout0_10ck54 = 0.9 time = 275
.meas tran vdout0_10ck54 FIND v(dout0_10) AT=275.025n

* CHECK dout0_11 Vdout0_11ck54 = 0.9 time = 275
.meas tran vdout0_11ck54 FIND v(dout0_11) AT=275.025n

* CHECK dout0_12 Vdout0_12ck54 = 0 time = 275
.meas tran vdout0_12ck54 FIND v(dout0_12) AT=275.025n

* CHECK dout0_13 Vdout0_13ck54 = 0.9 time = 275
.meas tran vdout0_13ck54 FIND v(dout0_13) AT=275.025n

* CHECK dout0_14 Vdout0_14ck54 = 0.9 time = 275
.meas tran vdout0_14ck54 FIND v(dout0_14) AT=275.025n

* CHECK dout0_15 Vdout0_15ck54 = 0.9 time = 275
.meas tran vdout0_15ck54 FIND v(dout0_15) AT=275.025n

* CHECK dout0_16 Vdout0_16ck54 = 0 time = 275
.meas tran vdout0_16ck54 FIND v(dout0_16) AT=275.025n

* CHECK dout0_17 Vdout0_17ck54 = 0.9 time = 275
.meas tran vdout0_17ck54 FIND v(dout0_17) AT=275.025n

* CHECK dout0_18 Vdout0_18ck54 = 0.9 time = 275
.meas tran vdout0_18ck54 FIND v(dout0_18) AT=275.025n

* CHECK dout0_19 Vdout0_19ck54 = 0.9 time = 275
.meas tran vdout0_19ck54 FIND v(dout0_19) AT=275.025n

* CHECK dout0_20 Vdout0_20ck54 = 0 time = 275
.meas tran vdout0_20ck54 FIND v(dout0_20) AT=275.025n

* CHECK dout0_21 Vdout0_21ck54 = 0 time = 275
.meas tran vdout0_21ck54 FIND v(dout0_21) AT=275.025n

* CHECK dout0_22 Vdout0_22ck54 = 0.9 time = 275
.meas tran vdout0_22ck54 FIND v(dout0_22) AT=275.025n

* CHECK dout0_23 Vdout0_23ck54 = 0 time = 275
.meas tran vdout0_23ck54 FIND v(dout0_23) AT=275.025n

* CHECK dout0_24 Vdout0_24ck54 = 0.9 time = 275
.meas tran vdout0_24ck54 FIND v(dout0_24) AT=275.025n

* CHECK dout0_25 Vdout0_25ck54 = 0 time = 275
.meas tran vdout0_25ck54 FIND v(dout0_25) AT=275.025n

* CHECK dout0_26 Vdout0_26ck54 = 0.9 time = 275
.meas tran vdout0_26ck54 FIND v(dout0_26) AT=275.025n

* CHECK dout0_27 Vdout0_27ck54 = 0 time = 275
.meas tran vdout0_27ck54 FIND v(dout0_27) AT=275.025n

* CHECK dout0_28 Vdout0_28ck54 = 0.9 time = 275
.meas tran vdout0_28ck54 FIND v(dout0_28) AT=275.025n

* CHECK dout0_29 Vdout0_29ck54 = 0 time = 275
.meas tran vdout0_29ck54 FIND v(dout0_29) AT=275.025n

* CHECK dout0_30 Vdout0_30ck54 = 0 time = 275
.meas tran vdout0_30ck54 FIND v(dout0_30) AT=275.025n

* CHECK dout0_31 Vdout0_31ck54 = 0.9 time = 275
.meas tran vdout0_31ck54 FIND v(dout0_31) AT=275.025n

* CHECK dout0_32 Vdout0_32ck54 = 0 time = 275
.meas tran vdout0_32ck54 FIND v(dout0_32) AT=275.025n

* CHECK dout0_33 Vdout0_33ck54 = 0 time = 275
.meas tran vdout0_33ck54 FIND v(dout0_33) AT=275.025n

* CHECK dout0_34 Vdout0_34ck54 = 0 time = 275
.meas tran vdout0_34ck54 FIND v(dout0_34) AT=275.025n

* CHECK dout0_35 Vdout0_35ck54 = 0 time = 275
.meas tran vdout0_35ck54 FIND v(dout0_35) AT=275.025n

* CHECK dout0_36 Vdout0_36ck54 = 0 time = 275
.meas tran vdout0_36ck54 FIND v(dout0_36) AT=275.025n

* CHECK dout0_37 Vdout0_37ck54 = 0 time = 275
.meas tran vdout0_37ck54 FIND v(dout0_37) AT=275.025n

* CHECK dout0_38 Vdout0_38ck54 = 0.9 time = 275
.meas tran vdout0_38ck54 FIND v(dout0_38) AT=275.025n

* CHECK dout0_39 Vdout0_39ck54 = 0.9 time = 275
.meas tran vdout0_39ck54 FIND v(dout0_39) AT=275.025n

* CHECK dout0_40 Vdout0_40ck54 = 0.9 time = 275
.meas tran vdout0_40ck54 FIND v(dout0_40) AT=275.025n

* CHECK dout0_41 Vdout0_41ck54 = 0.9 time = 275
.meas tran vdout0_41ck54 FIND v(dout0_41) AT=275.025n

* CHECK dout0_42 Vdout0_42ck54 = 0.9 time = 275
.meas tran vdout0_42ck54 FIND v(dout0_42) AT=275.025n

* CHECK dout0_43 Vdout0_43ck54 = 0 time = 275
.meas tran vdout0_43ck54 FIND v(dout0_43) AT=275.025n

* CHECK dout0_44 Vdout0_44ck54 = 0.9 time = 275
.meas tran vdout0_44ck54 FIND v(dout0_44) AT=275.025n

* CHECK dout0_45 Vdout0_45ck54 = 0.9 time = 275
.meas tran vdout0_45ck54 FIND v(dout0_45) AT=275.025n

* CHECK dout0_46 Vdout0_46ck54 = 0.9 time = 275
.meas tran vdout0_46ck54 FIND v(dout0_46) AT=275.025n

* CHECK dout0_47 Vdout0_47ck54 = 0.9 time = 275
.meas tran vdout0_47ck54 FIND v(dout0_47) AT=275.025n

* CHECK dout0_48 Vdout0_48ck54 = 0 time = 275
.meas tran vdout0_48ck54 FIND v(dout0_48) AT=275.025n

* CHECK dout0_49 Vdout0_49ck54 = 0 time = 275
.meas tran vdout0_49ck54 FIND v(dout0_49) AT=275.025n

* CHECK dout0_50 Vdout0_50ck54 = 0 time = 275
.meas tran vdout0_50ck54 FIND v(dout0_50) AT=275.025n

* CHECK dout0_51 Vdout0_51ck54 = 0.9 time = 275
.meas tran vdout0_51ck54 FIND v(dout0_51) AT=275.025n

* CHECK dout0_52 Vdout0_52ck54 = 0.9 time = 275
.meas tran vdout0_52ck54 FIND v(dout0_52) AT=275.025n

* CHECK dout0_53 Vdout0_53ck54 = 0.9 time = 275
.meas tran vdout0_53ck54 FIND v(dout0_53) AT=275.025n

* CHECK dout0_54 Vdout0_54ck54 = 0 time = 275
.meas tran vdout0_54ck54 FIND v(dout0_54) AT=275.025n

* CHECK dout0_55 Vdout0_55ck54 = 0 time = 275
.meas tran vdout0_55ck54 FIND v(dout0_55) AT=275.025n

* CHECK dout0_56 Vdout0_56ck54 = 0.9 time = 275
.meas tran vdout0_56ck54 FIND v(dout0_56) AT=275.025n

* CHECK dout0_57 Vdout0_57ck54 = 0.9 time = 275
.meas tran vdout0_57ck54 FIND v(dout0_57) AT=275.025n

* CHECK dout0_58 Vdout0_58ck54 = 0.9 time = 275
.meas tran vdout0_58ck54 FIND v(dout0_58) AT=275.025n

* CHECK dout0_59 Vdout0_59ck54 = 0 time = 275
.meas tran vdout0_59ck54 FIND v(dout0_59) AT=275.025n

* CHECK dout0_60 Vdout0_60ck54 = 0 time = 275
.meas tran vdout0_60ck54 FIND v(dout0_60) AT=275.025n

* CHECK dout0_61 Vdout0_61ck54 = 0 time = 275
.meas tran vdout0_61ck54 FIND v(dout0_61) AT=275.025n

* CHECK dout0_62 Vdout0_62ck54 = 0.9 time = 275
.meas tran vdout0_62ck54 FIND v(dout0_62) AT=275.025n

* CHECK dout0_63 Vdout0_63ck54 = 0.9 time = 275
.meas tran vdout0_63ck54 FIND v(dout0_63) AT=275.025n

* CHECK dout0_64 Vdout0_64ck54 = 0 time = 275
.meas tran vdout0_64ck54 FIND v(dout0_64) AT=275.025n

* CHECK dout0_65 Vdout0_65ck54 = 0.9 time = 275
.meas tran vdout0_65ck54 FIND v(dout0_65) AT=275.025n

* CHECK dout0_66 Vdout0_66ck54 = 0.9 time = 275
.meas tran vdout0_66ck54 FIND v(dout0_66) AT=275.025n

* CHECK dout0_67 Vdout0_67ck54 = 0 time = 275
.meas tran vdout0_67ck54 FIND v(dout0_67) AT=275.025n

* CHECK dout0_68 Vdout0_68ck54 = 0 time = 275
.meas tran vdout0_68ck54 FIND v(dout0_68) AT=275.025n

* CHECK dout0_69 Vdout0_69ck54 = 0.9 time = 275
.meas tran vdout0_69ck54 FIND v(dout0_69) AT=275.025n

* CHECK dout0_70 Vdout0_70ck54 = 0 time = 275
.meas tran vdout0_70ck54 FIND v(dout0_70) AT=275.025n

* CHECK dout0_71 Vdout0_71ck54 = 0.9 time = 275
.meas tran vdout0_71ck54 FIND v(dout0_71) AT=275.025n

* CHECK dout0_72 Vdout0_72ck54 = 0.9 time = 275
.meas tran vdout0_72ck54 FIND v(dout0_72) AT=275.025n

* CHECK dout0_73 Vdout0_73ck54 = 0.9 time = 275
.meas tran vdout0_73ck54 FIND v(dout0_73) AT=275.025n

* CHECK dout0_74 Vdout0_74ck54 = 0.9 time = 275
.meas tran vdout0_74ck54 FIND v(dout0_74) AT=275.025n

* CHECK dout0_75 Vdout0_75ck54 = 0.9 time = 275
.meas tran vdout0_75ck54 FIND v(dout0_75) AT=275.025n

* CHECK dout0_76 Vdout0_76ck54 = 0.9 time = 275
.meas tran vdout0_76ck54 FIND v(dout0_76) AT=275.025n

* CHECK dout0_77 Vdout0_77ck54 = 0 time = 275
.meas tran vdout0_77ck54 FIND v(dout0_77) AT=275.025n

* CHECK dout0_78 Vdout0_78ck54 = 0.9 time = 275
.meas tran vdout0_78ck54 FIND v(dout0_78) AT=275.025n

* CHECK dout0_79 Vdout0_79ck54 = 0 time = 275
.meas tran vdout0_79ck54 FIND v(dout0_79) AT=275.025n

* CHECK dout0_80 Vdout0_80ck54 = 0.9 time = 275
.meas tran vdout0_80ck54 FIND v(dout0_80) AT=275.025n

* CHECK dout0_81 Vdout0_81ck54 = 0 time = 275
.meas tran vdout0_81ck54 FIND v(dout0_81) AT=275.025n

* CHECK dout0_82 Vdout0_82ck54 = 0.9 time = 275
.meas tran vdout0_82ck54 FIND v(dout0_82) AT=275.025n

* CHECK dout0_83 Vdout0_83ck54 = 0.9 time = 275
.meas tran vdout0_83ck54 FIND v(dout0_83) AT=275.025n

* CHECK dout0_84 Vdout0_84ck54 = 0.9 time = 275
.meas tran vdout0_84ck54 FIND v(dout0_84) AT=275.025n

* CHECK dout0_85 Vdout0_85ck54 = 0.9 time = 275
.meas tran vdout0_85ck54 FIND v(dout0_85) AT=275.025n

* CHECK dout0_86 Vdout0_86ck54 = 0.9 time = 275
.meas tran vdout0_86ck54 FIND v(dout0_86) AT=275.025n

* CHECK dout0_87 Vdout0_87ck54 = 0 time = 275
.meas tran vdout0_87ck54 FIND v(dout0_87) AT=275.025n

* CHECK dout0_0 Vdout0_0ck55 = 0 time = 280
.meas tran vdout0_0ck55 FIND v(dout0_0) AT=280.025n

* CHECK dout0_1 Vdout0_1ck55 = 0.9 time = 280
.meas tran vdout0_1ck55 FIND v(dout0_1) AT=280.025n

* CHECK dout0_2 Vdout0_2ck55 = 0.9 time = 280
.meas tran vdout0_2ck55 FIND v(dout0_2) AT=280.025n

* CHECK dout0_3 Vdout0_3ck55 = 0.9 time = 280
.meas tran vdout0_3ck55 FIND v(dout0_3) AT=280.025n

* CHECK dout0_4 Vdout0_4ck55 = 0 time = 280
.meas tran vdout0_4ck55 FIND v(dout0_4) AT=280.025n

* CHECK dout0_5 Vdout0_5ck55 = 0 time = 280
.meas tran vdout0_5ck55 FIND v(dout0_5) AT=280.025n

* CHECK dout0_6 Vdout0_6ck55 = 0 time = 280
.meas tran vdout0_6ck55 FIND v(dout0_6) AT=280.025n

* CHECK dout0_7 Vdout0_7ck55 = 0.9 time = 280
.meas tran vdout0_7ck55 FIND v(dout0_7) AT=280.025n

* CHECK dout0_8 Vdout0_8ck55 = 0 time = 280
.meas tran vdout0_8ck55 FIND v(dout0_8) AT=280.025n

* CHECK dout0_9 Vdout0_9ck55 = 0 time = 280
.meas tran vdout0_9ck55 FIND v(dout0_9) AT=280.025n

* CHECK dout0_10 Vdout0_10ck55 = 0.9 time = 280
.meas tran vdout0_10ck55 FIND v(dout0_10) AT=280.025n

* CHECK dout0_11 Vdout0_11ck55 = 0.9 time = 280
.meas tran vdout0_11ck55 FIND v(dout0_11) AT=280.025n

* CHECK dout0_12 Vdout0_12ck55 = 0 time = 280
.meas tran vdout0_12ck55 FIND v(dout0_12) AT=280.025n

* CHECK dout0_13 Vdout0_13ck55 = 0.9 time = 280
.meas tran vdout0_13ck55 FIND v(dout0_13) AT=280.025n

* CHECK dout0_14 Vdout0_14ck55 = 0.9 time = 280
.meas tran vdout0_14ck55 FIND v(dout0_14) AT=280.025n

* CHECK dout0_15 Vdout0_15ck55 = 0.9 time = 280
.meas tran vdout0_15ck55 FIND v(dout0_15) AT=280.025n

* CHECK dout0_16 Vdout0_16ck55 = 0 time = 280
.meas tran vdout0_16ck55 FIND v(dout0_16) AT=280.025n

* CHECK dout0_17 Vdout0_17ck55 = 0.9 time = 280
.meas tran vdout0_17ck55 FIND v(dout0_17) AT=280.025n

* CHECK dout0_18 Vdout0_18ck55 = 0.9 time = 280
.meas tran vdout0_18ck55 FIND v(dout0_18) AT=280.025n

* CHECK dout0_19 Vdout0_19ck55 = 0.9 time = 280
.meas tran vdout0_19ck55 FIND v(dout0_19) AT=280.025n

* CHECK dout0_20 Vdout0_20ck55 = 0 time = 280
.meas tran vdout0_20ck55 FIND v(dout0_20) AT=280.025n

* CHECK dout0_21 Vdout0_21ck55 = 0 time = 280
.meas tran vdout0_21ck55 FIND v(dout0_21) AT=280.025n

* CHECK dout0_22 Vdout0_22ck55 = 0.9 time = 280
.meas tran vdout0_22ck55 FIND v(dout0_22) AT=280.025n

* CHECK dout0_23 Vdout0_23ck55 = 0 time = 280
.meas tran vdout0_23ck55 FIND v(dout0_23) AT=280.025n

* CHECK dout0_24 Vdout0_24ck55 = 0.9 time = 280
.meas tran vdout0_24ck55 FIND v(dout0_24) AT=280.025n

* CHECK dout0_25 Vdout0_25ck55 = 0 time = 280
.meas tran vdout0_25ck55 FIND v(dout0_25) AT=280.025n

* CHECK dout0_26 Vdout0_26ck55 = 0.9 time = 280
.meas tran vdout0_26ck55 FIND v(dout0_26) AT=280.025n

* CHECK dout0_27 Vdout0_27ck55 = 0 time = 280
.meas tran vdout0_27ck55 FIND v(dout0_27) AT=280.025n

* CHECK dout0_28 Vdout0_28ck55 = 0.9 time = 280
.meas tran vdout0_28ck55 FIND v(dout0_28) AT=280.025n

* CHECK dout0_29 Vdout0_29ck55 = 0 time = 280
.meas tran vdout0_29ck55 FIND v(dout0_29) AT=280.025n

* CHECK dout0_30 Vdout0_30ck55 = 0 time = 280
.meas tran vdout0_30ck55 FIND v(dout0_30) AT=280.025n

* CHECK dout0_31 Vdout0_31ck55 = 0.9 time = 280
.meas tran vdout0_31ck55 FIND v(dout0_31) AT=280.025n

* CHECK dout0_32 Vdout0_32ck55 = 0 time = 280
.meas tran vdout0_32ck55 FIND v(dout0_32) AT=280.025n

* CHECK dout0_33 Vdout0_33ck55 = 0 time = 280
.meas tran vdout0_33ck55 FIND v(dout0_33) AT=280.025n

* CHECK dout0_34 Vdout0_34ck55 = 0 time = 280
.meas tran vdout0_34ck55 FIND v(dout0_34) AT=280.025n

* CHECK dout0_35 Vdout0_35ck55 = 0 time = 280
.meas tran vdout0_35ck55 FIND v(dout0_35) AT=280.025n

* CHECK dout0_36 Vdout0_36ck55 = 0 time = 280
.meas tran vdout0_36ck55 FIND v(dout0_36) AT=280.025n

* CHECK dout0_37 Vdout0_37ck55 = 0 time = 280
.meas tran vdout0_37ck55 FIND v(dout0_37) AT=280.025n

* CHECK dout0_38 Vdout0_38ck55 = 0.9 time = 280
.meas tran vdout0_38ck55 FIND v(dout0_38) AT=280.025n

* CHECK dout0_39 Vdout0_39ck55 = 0.9 time = 280
.meas tran vdout0_39ck55 FIND v(dout0_39) AT=280.025n

* CHECK dout0_40 Vdout0_40ck55 = 0.9 time = 280
.meas tran vdout0_40ck55 FIND v(dout0_40) AT=280.025n

* CHECK dout0_41 Vdout0_41ck55 = 0.9 time = 280
.meas tran vdout0_41ck55 FIND v(dout0_41) AT=280.025n

* CHECK dout0_42 Vdout0_42ck55 = 0.9 time = 280
.meas tran vdout0_42ck55 FIND v(dout0_42) AT=280.025n

* CHECK dout0_43 Vdout0_43ck55 = 0 time = 280
.meas tran vdout0_43ck55 FIND v(dout0_43) AT=280.025n

* CHECK dout0_44 Vdout0_44ck55 = 0.9 time = 280
.meas tran vdout0_44ck55 FIND v(dout0_44) AT=280.025n

* CHECK dout0_45 Vdout0_45ck55 = 0.9 time = 280
.meas tran vdout0_45ck55 FIND v(dout0_45) AT=280.025n

* CHECK dout0_46 Vdout0_46ck55 = 0.9 time = 280
.meas tran vdout0_46ck55 FIND v(dout0_46) AT=280.025n

* CHECK dout0_47 Vdout0_47ck55 = 0.9 time = 280
.meas tran vdout0_47ck55 FIND v(dout0_47) AT=280.025n

* CHECK dout0_48 Vdout0_48ck55 = 0 time = 280
.meas tran vdout0_48ck55 FIND v(dout0_48) AT=280.025n

* CHECK dout0_49 Vdout0_49ck55 = 0 time = 280
.meas tran vdout0_49ck55 FIND v(dout0_49) AT=280.025n

* CHECK dout0_50 Vdout0_50ck55 = 0 time = 280
.meas tran vdout0_50ck55 FIND v(dout0_50) AT=280.025n

* CHECK dout0_51 Vdout0_51ck55 = 0.9 time = 280
.meas tran vdout0_51ck55 FIND v(dout0_51) AT=280.025n

* CHECK dout0_52 Vdout0_52ck55 = 0.9 time = 280
.meas tran vdout0_52ck55 FIND v(dout0_52) AT=280.025n

* CHECK dout0_53 Vdout0_53ck55 = 0.9 time = 280
.meas tran vdout0_53ck55 FIND v(dout0_53) AT=280.025n

* CHECK dout0_54 Vdout0_54ck55 = 0 time = 280
.meas tran vdout0_54ck55 FIND v(dout0_54) AT=280.025n

* CHECK dout0_55 Vdout0_55ck55 = 0 time = 280
.meas tran vdout0_55ck55 FIND v(dout0_55) AT=280.025n

* CHECK dout0_56 Vdout0_56ck55 = 0.9 time = 280
.meas tran vdout0_56ck55 FIND v(dout0_56) AT=280.025n

* CHECK dout0_57 Vdout0_57ck55 = 0.9 time = 280
.meas tran vdout0_57ck55 FIND v(dout0_57) AT=280.025n

* CHECK dout0_58 Vdout0_58ck55 = 0.9 time = 280
.meas tran vdout0_58ck55 FIND v(dout0_58) AT=280.025n

* CHECK dout0_59 Vdout0_59ck55 = 0 time = 280
.meas tran vdout0_59ck55 FIND v(dout0_59) AT=280.025n

* CHECK dout0_60 Vdout0_60ck55 = 0 time = 280
.meas tran vdout0_60ck55 FIND v(dout0_60) AT=280.025n

* CHECK dout0_61 Vdout0_61ck55 = 0 time = 280
.meas tran vdout0_61ck55 FIND v(dout0_61) AT=280.025n

* CHECK dout0_62 Vdout0_62ck55 = 0.9 time = 280
.meas tran vdout0_62ck55 FIND v(dout0_62) AT=280.025n

* CHECK dout0_63 Vdout0_63ck55 = 0.9 time = 280
.meas tran vdout0_63ck55 FIND v(dout0_63) AT=280.025n

* CHECK dout0_64 Vdout0_64ck55 = 0 time = 280
.meas tran vdout0_64ck55 FIND v(dout0_64) AT=280.025n

* CHECK dout0_65 Vdout0_65ck55 = 0.9 time = 280
.meas tran vdout0_65ck55 FIND v(dout0_65) AT=280.025n

* CHECK dout0_66 Vdout0_66ck55 = 0.9 time = 280
.meas tran vdout0_66ck55 FIND v(dout0_66) AT=280.025n

* CHECK dout0_67 Vdout0_67ck55 = 0 time = 280
.meas tran vdout0_67ck55 FIND v(dout0_67) AT=280.025n

* CHECK dout0_68 Vdout0_68ck55 = 0 time = 280
.meas tran vdout0_68ck55 FIND v(dout0_68) AT=280.025n

* CHECK dout0_69 Vdout0_69ck55 = 0.9 time = 280
.meas tran vdout0_69ck55 FIND v(dout0_69) AT=280.025n

* CHECK dout0_70 Vdout0_70ck55 = 0 time = 280
.meas tran vdout0_70ck55 FIND v(dout0_70) AT=280.025n

* CHECK dout0_71 Vdout0_71ck55 = 0.9 time = 280
.meas tran vdout0_71ck55 FIND v(dout0_71) AT=280.025n

* CHECK dout0_72 Vdout0_72ck55 = 0.9 time = 280
.meas tran vdout0_72ck55 FIND v(dout0_72) AT=280.025n

* CHECK dout0_73 Vdout0_73ck55 = 0.9 time = 280
.meas tran vdout0_73ck55 FIND v(dout0_73) AT=280.025n

* CHECK dout0_74 Vdout0_74ck55 = 0.9 time = 280
.meas tran vdout0_74ck55 FIND v(dout0_74) AT=280.025n

* CHECK dout0_75 Vdout0_75ck55 = 0.9 time = 280
.meas tran vdout0_75ck55 FIND v(dout0_75) AT=280.025n

* CHECK dout0_76 Vdout0_76ck55 = 0.9 time = 280
.meas tran vdout0_76ck55 FIND v(dout0_76) AT=280.025n

* CHECK dout0_77 Vdout0_77ck55 = 0 time = 280
.meas tran vdout0_77ck55 FIND v(dout0_77) AT=280.025n

* CHECK dout0_78 Vdout0_78ck55 = 0.9 time = 280
.meas tran vdout0_78ck55 FIND v(dout0_78) AT=280.025n

* CHECK dout0_79 Vdout0_79ck55 = 0 time = 280
.meas tran vdout0_79ck55 FIND v(dout0_79) AT=280.025n

* CHECK dout0_80 Vdout0_80ck55 = 0.9 time = 280
.meas tran vdout0_80ck55 FIND v(dout0_80) AT=280.025n

* CHECK dout0_81 Vdout0_81ck55 = 0 time = 280
.meas tran vdout0_81ck55 FIND v(dout0_81) AT=280.025n

* CHECK dout0_82 Vdout0_82ck55 = 0.9 time = 280
.meas tran vdout0_82ck55 FIND v(dout0_82) AT=280.025n

* CHECK dout0_83 Vdout0_83ck55 = 0.9 time = 280
.meas tran vdout0_83ck55 FIND v(dout0_83) AT=280.025n

* CHECK dout0_84 Vdout0_84ck55 = 0.9 time = 280
.meas tran vdout0_84ck55 FIND v(dout0_84) AT=280.025n

* CHECK dout0_85 Vdout0_85ck55 = 0.9 time = 280
.meas tran vdout0_85ck55 FIND v(dout0_85) AT=280.025n

* CHECK dout0_86 Vdout0_86ck55 = 0.9 time = 280
.meas tran vdout0_86ck55 FIND v(dout0_86) AT=280.025n

* CHECK dout0_87 Vdout0_87ck55 = 0 time = 280
.meas tran vdout0_87ck55 FIND v(dout0_87) AT=280.025n

* CHECK dout0_0 Vdout0_0ck58 = 0 time = 295
.meas tran vdout0_0ck58 FIND v(dout0_0) AT=295.025n

* CHECK dout0_1 Vdout0_1ck58 = 0.9 time = 295
.meas tran vdout0_1ck58 FIND v(dout0_1) AT=295.025n

* CHECK dout0_2 Vdout0_2ck58 = 0.9 time = 295
.meas tran vdout0_2ck58 FIND v(dout0_2) AT=295.025n

* CHECK dout0_3 Vdout0_3ck58 = 0.9 time = 295
.meas tran vdout0_3ck58 FIND v(dout0_3) AT=295.025n

* CHECK dout0_4 Vdout0_4ck58 = 0 time = 295
.meas tran vdout0_4ck58 FIND v(dout0_4) AT=295.025n

* CHECK dout0_5 Vdout0_5ck58 = 0 time = 295
.meas tran vdout0_5ck58 FIND v(dout0_5) AT=295.025n

* CHECK dout0_6 Vdout0_6ck58 = 0 time = 295
.meas tran vdout0_6ck58 FIND v(dout0_6) AT=295.025n

* CHECK dout0_7 Vdout0_7ck58 = 0.9 time = 295
.meas tran vdout0_7ck58 FIND v(dout0_7) AT=295.025n

* CHECK dout0_8 Vdout0_8ck58 = 0 time = 295
.meas tran vdout0_8ck58 FIND v(dout0_8) AT=295.025n

* CHECK dout0_9 Vdout0_9ck58 = 0 time = 295
.meas tran vdout0_9ck58 FIND v(dout0_9) AT=295.025n

* CHECK dout0_10 Vdout0_10ck58 = 0.9 time = 295
.meas tran vdout0_10ck58 FIND v(dout0_10) AT=295.025n

* CHECK dout0_11 Vdout0_11ck58 = 0.9 time = 295
.meas tran vdout0_11ck58 FIND v(dout0_11) AT=295.025n

* CHECK dout0_12 Vdout0_12ck58 = 0 time = 295
.meas tran vdout0_12ck58 FIND v(dout0_12) AT=295.025n

* CHECK dout0_13 Vdout0_13ck58 = 0.9 time = 295
.meas tran vdout0_13ck58 FIND v(dout0_13) AT=295.025n

* CHECK dout0_14 Vdout0_14ck58 = 0.9 time = 295
.meas tran vdout0_14ck58 FIND v(dout0_14) AT=295.025n

* CHECK dout0_15 Vdout0_15ck58 = 0.9 time = 295
.meas tran vdout0_15ck58 FIND v(dout0_15) AT=295.025n

* CHECK dout0_16 Vdout0_16ck58 = 0 time = 295
.meas tran vdout0_16ck58 FIND v(dout0_16) AT=295.025n

* CHECK dout0_17 Vdout0_17ck58 = 0.9 time = 295
.meas tran vdout0_17ck58 FIND v(dout0_17) AT=295.025n

* CHECK dout0_18 Vdout0_18ck58 = 0.9 time = 295
.meas tran vdout0_18ck58 FIND v(dout0_18) AT=295.025n

* CHECK dout0_19 Vdout0_19ck58 = 0.9 time = 295
.meas tran vdout0_19ck58 FIND v(dout0_19) AT=295.025n

* CHECK dout0_20 Vdout0_20ck58 = 0 time = 295
.meas tran vdout0_20ck58 FIND v(dout0_20) AT=295.025n

* CHECK dout0_21 Vdout0_21ck58 = 0 time = 295
.meas tran vdout0_21ck58 FIND v(dout0_21) AT=295.025n

* CHECK dout0_22 Vdout0_22ck58 = 0.9 time = 295
.meas tran vdout0_22ck58 FIND v(dout0_22) AT=295.025n

* CHECK dout0_23 Vdout0_23ck58 = 0 time = 295
.meas tran vdout0_23ck58 FIND v(dout0_23) AT=295.025n

* CHECK dout0_24 Vdout0_24ck58 = 0.9 time = 295
.meas tran vdout0_24ck58 FIND v(dout0_24) AT=295.025n

* CHECK dout0_25 Vdout0_25ck58 = 0 time = 295
.meas tran vdout0_25ck58 FIND v(dout0_25) AT=295.025n

* CHECK dout0_26 Vdout0_26ck58 = 0.9 time = 295
.meas tran vdout0_26ck58 FIND v(dout0_26) AT=295.025n

* CHECK dout0_27 Vdout0_27ck58 = 0 time = 295
.meas tran vdout0_27ck58 FIND v(dout0_27) AT=295.025n

* CHECK dout0_28 Vdout0_28ck58 = 0.9 time = 295
.meas tran vdout0_28ck58 FIND v(dout0_28) AT=295.025n

* CHECK dout0_29 Vdout0_29ck58 = 0 time = 295
.meas tran vdout0_29ck58 FIND v(dout0_29) AT=295.025n

* CHECK dout0_30 Vdout0_30ck58 = 0 time = 295
.meas tran vdout0_30ck58 FIND v(dout0_30) AT=295.025n

* CHECK dout0_31 Vdout0_31ck58 = 0.9 time = 295
.meas tran vdout0_31ck58 FIND v(dout0_31) AT=295.025n

* CHECK dout0_32 Vdout0_32ck58 = 0 time = 295
.meas tran vdout0_32ck58 FIND v(dout0_32) AT=295.025n

* CHECK dout0_33 Vdout0_33ck58 = 0 time = 295
.meas tran vdout0_33ck58 FIND v(dout0_33) AT=295.025n

* CHECK dout0_34 Vdout0_34ck58 = 0 time = 295
.meas tran vdout0_34ck58 FIND v(dout0_34) AT=295.025n

* CHECK dout0_35 Vdout0_35ck58 = 0 time = 295
.meas tran vdout0_35ck58 FIND v(dout0_35) AT=295.025n

* CHECK dout0_36 Vdout0_36ck58 = 0 time = 295
.meas tran vdout0_36ck58 FIND v(dout0_36) AT=295.025n

* CHECK dout0_37 Vdout0_37ck58 = 0 time = 295
.meas tran vdout0_37ck58 FIND v(dout0_37) AT=295.025n

* CHECK dout0_38 Vdout0_38ck58 = 0.9 time = 295
.meas tran vdout0_38ck58 FIND v(dout0_38) AT=295.025n

* CHECK dout0_39 Vdout0_39ck58 = 0.9 time = 295
.meas tran vdout0_39ck58 FIND v(dout0_39) AT=295.025n

* CHECK dout0_40 Vdout0_40ck58 = 0.9 time = 295
.meas tran vdout0_40ck58 FIND v(dout0_40) AT=295.025n

* CHECK dout0_41 Vdout0_41ck58 = 0.9 time = 295
.meas tran vdout0_41ck58 FIND v(dout0_41) AT=295.025n

* CHECK dout0_42 Vdout0_42ck58 = 0.9 time = 295
.meas tran vdout0_42ck58 FIND v(dout0_42) AT=295.025n

* CHECK dout0_43 Vdout0_43ck58 = 0 time = 295
.meas tran vdout0_43ck58 FIND v(dout0_43) AT=295.025n

* CHECK dout0_44 Vdout0_44ck58 = 0.9 time = 295
.meas tran vdout0_44ck58 FIND v(dout0_44) AT=295.025n

* CHECK dout0_45 Vdout0_45ck58 = 0.9 time = 295
.meas tran vdout0_45ck58 FIND v(dout0_45) AT=295.025n

* CHECK dout0_46 Vdout0_46ck58 = 0.9 time = 295
.meas tran vdout0_46ck58 FIND v(dout0_46) AT=295.025n

* CHECK dout0_47 Vdout0_47ck58 = 0.9 time = 295
.meas tran vdout0_47ck58 FIND v(dout0_47) AT=295.025n

* CHECK dout0_48 Vdout0_48ck58 = 0 time = 295
.meas tran vdout0_48ck58 FIND v(dout0_48) AT=295.025n

* CHECK dout0_49 Vdout0_49ck58 = 0 time = 295
.meas tran vdout0_49ck58 FIND v(dout0_49) AT=295.025n

* CHECK dout0_50 Vdout0_50ck58 = 0 time = 295
.meas tran vdout0_50ck58 FIND v(dout0_50) AT=295.025n

* CHECK dout0_51 Vdout0_51ck58 = 0.9 time = 295
.meas tran vdout0_51ck58 FIND v(dout0_51) AT=295.025n

* CHECK dout0_52 Vdout0_52ck58 = 0.9 time = 295
.meas tran vdout0_52ck58 FIND v(dout0_52) AT=295.025n

* CHECK dout0_53 Vdout0_53ck58 = 0.9 time = 295
.meas tran vdout0_53ck58 FIND v(dout0_53) AT=295.025n

* CHECK dout0_54 Vdout0_54ck58 = 0 time = 295
.meas tran vdout0_54ck58 FIND v(dout0_54) AT=295.025n

* CHECK dout0_55 Vdout0_55ck58 = 0 time = 295
.meas tran vdout0_55ck58 FIND v(dout0_55) AT=295.025n

* CHECK dout0_56 Vdout0_56ck58 = 0.9 time = 295
.meas tran vdout0_56ck58 FIND v(dout0_56) AT=295.025n

* CHECK dout0_57 Vdout0_57ck58 = 0.9 time = 295
.meas tran vdout0_57ck58 FIND v(dout0_57) AT=295.025n

* CHECK dout0_58 Vdout0_58ck58 = 0.9 time = 295
.meas tran vdout0_58ck58 FIND v(dout0_58) AT=295.025n

* CHECK dout0_59 Vdout0_59ck58 = 0 time = 295
.meas tran vdout0_59ck58 FIND v(dout0_59) AT=295.025n

* CHECK dout0_60 Vdout0_60ck58 = 0 time = 295
.meas tran vdout0_60ck58 FIND v(dout0_60) AT=295.025n

* CHECK dout0_61 Vdout0_61ck58 = 0 time = 295
.meas tran vdout0_61ck58 FIND v(dout0_61) AT=295.025n

* CHECK dout0_62 Vdout0_62ck58 = 0.9 time = 295
.meas tran vdout0_62ck58 FIND v(dout0_62) AT=295.025n

* CHECK dout0_63 Vdout0_63ck58 = 0.9 time = 295
.meas tran vdout0_63ck58 FIND v(dout0_63) AT=295.025n

* CHECK dout0_64 Vdout0_64ck58 = 0 time = 295
.meas tran vdout0_64ck58 FIND v(dout0_64) AT=295.025n

* CHECK dout0_65 Vdout0_65ck58 = 0.9 time = 295
.meas tran vdout0_65ck58 FIND v(dout0_65) AT=295.025n

* CHECK dout0_66 Vdout0_66ck58 = 0 time = 295
.meas tran vdout0_66ck58 FIND v(dout0_66) AT=295.025n

* CHECK dout0_67 Vdout0_67ck58 = 0 time = 295
.meas tran vdout0_67ck58 FIND v(dout0_67) AT=295.025n

* CHECK dout0_68 Vdout0_68ck58 = 0 time = 295
.meas tran vdout0_68ck58 FIND v(dout0_68) AT=295.025n

* CHECK dout0_69 Vdout0_69ck58 = 0 time = 295
.meas tran vdout0_69ck58 FIND v(dout0_69) AT=295.025n

* CHECK dout0_70 Vdout0_70ck58 = 0 time = 295
.meas tran vdout0_70ck58 FIND v(dout0_70) AT=295.025n

* CHECK dout0_71 Vdout0_71ck58 = 0.9 time = 295
.meas tran vdout0_71ck58 FIND v(dout0_71) AT=295.025n

* CHECK dout0_72 Vdout0_72ck58 = 0.9 time = 295
.meas tran vdout0_72ck58 FIND v(dout0_72) AT=295.025n

* CHECK dout0_73 Vdout0_73ck58 = 0.9 time = 295
.meas tran vdout0_73ck58 FIND v(dout0_73) AT=295.025n

* CHECK dout0_74 Vdout0_74ck58 = 0.9 time = 295
.meas tran vdout0_74ck58 FIND v(dout0_74) AT=295.025n

* CHECK dout0_75 Vdout0_75ck58 = 0 time = 295
.meas tran vdout0_75ck58 FIND v(dout0_75) AT=295.025n

* CHECK dout0_76 Vdout0_76ck58 = 0 time = 295
.meas tran vdout0_76ck58 FIND v(dout0_76) AT=295.025n

* CHECK dout0_77 Vdout0_77ck58 = 0 time = 295
.meas tran vdout0_77ck58 FIND v(dout0_77) AT=295.025n

* CHECK dout0_78 Vdout0_78ck58 = 0.9 time = 295
.meas tran vdout0_78ck58 FIND v(dout0_78) AT=295.025n

* CHECK dout0_79 Vdout0_79ck58 = 0 time = 295
.meas tran vdout0_79ck58 FIND v(dout0_79) AT=295.025n

* CHECK dout0_80 Vdout0_80ck58 = 0.9 time = 295
.meas tran vdout0_80ck58 FIND v(dout0_80) AT=295.025n

* CHECK dout0_81 Vdout0_81ck58 = 0 time = 295
.meas tran vdout0_81ck58 FIND v(dout0_81) AT=295.025n

* CHECK dout0_82 Vdout0_82ck58 = 0.9 time = 295
.meas tran vdout0_82ck58 FIND v(dout0_82) AT=295.025n

* CHECK dout0_83 Vdout0_83ck58 = 0 time = 295
.meas tran vdout0_83ck58 FIND v(dout0_83) AT=295.025n

* CHECK dout0_84 Vdout0_84ck58 = 0 time = 295
.meas tran vdout0_84ck58 FIND v(dout0_84) AT=295.025n

* CHECK dout0_85 Vdout0_85ck58 = 0.9 time = 295
.meas tran vdout0_85ck58 FIND v(dout0_85) AT=295.025n

* CHECK dout0_86 Vdout0_86ck58 = 0.9 time = 295
.meas tran vdout0_86ck58 FIND v(dout0_86) AT=295.025n

* CHECK dout0_87 Vdout0_87ck58 = 0 time = 295
.meas tran vdout0_87ck58 FIND v(dout0_87) AT=295.025n

* CHECK dout0_0 Vdout0_0ck59 = 0 time = 300
.meas tran vdout0_0ck59 FIND v(dout0_0) AT=300.025n

* CHECK dout0_1 Vdout0_1ck59 = 0.9 time = 300
.meas tran vdout0_1ck59 FIND v(dout0_1) AT=300.025n

* CHECK dout0_2 Vdout0_2ck59 = 0.9 time = 300
.meas tran vdout0_2ck59 FIND v(dout0_2) AT=300.025n

* CHECK dout0_3 Vdout0_3ck59 = 0.9 time = 300
.meas tran vdout0_3ck59 FIND v(dout0_3) AT=300.025n

* CHECK dout0_4 Vdout0_4ck59 = 0 time = 300
.meas tran vdout0_4ck59 FIND v(dout0_4) AT=300.025n

* CHECK dout0_5 Vdout0_5ck59 = 0 time = 300
.meas tran vdout0_5ck59 FIND v(dout0_5) AT=300.025n

* CHECK dout0_6 Vdout0_6ck59 = 0 time = 300
.meas tran vdout0_6ck59 FIND v(dout0_6) AT=300.025n

* CHECK dout0_7 Vdout0_7ck59 = 0.9 time = 300
.meas tran vdout0_7ck59 FIND v(dout0_7) AT=300.025n

* CHECK dout0_8 Vdout0_8ck59 = 0 time = 300
.meas tran vdout0_8ck59 FIND v(dout0_8) AT=300.025n

* CHECK dout0_9 Vdout0_9ck59 = 0 time = 300
.meas tran vdout0_9ck59 FIND v(dout0_9) AT=300.025n

* CHECK dout0_10 Vdout0_10ck59 = 0.9 time = 300
.meas tran vdout0_10ck59 FIND v(dout0_10) AT=300.025n

* CHECK dout0_11 Vdout0_11ck59 = 0.9 time = 300
.meas tran vdout0_11ck59 FIND v(dout0_11) AT=300.025n

* CHECK dout0_12 Vdout0_12ck59 = 0 time = 300
.meas tran vdout0_12ck59 FIND v(dout0_12) AT=300.025n

* CHECK dout0_13 Vdout0_13ck59 = 0.9 time = 300
.meas tran vdout0_13ck59 FIND v(dout0_13) AT=300.025n

* CHECK dout0_14 Vdout0_14ck59 = 0.9 time = 300
.meas tran vdout0_14ck59 FIND v(dout0_14) AT=300.025n

* CHECK dout0_15 Vdout0_15ck59 = 0.9 time = 300
.meas tran vdout0_15ck59 FIND v(dout0_15) AT=300.025n

* CHECK dout0_16 Vdout0_16ck59 = 0 time = 300
.meas tran vdout0_16ck59 FIND v(dout0_16) AT=300.025n

* CHECK dout0_17 Vdout0_17ck59 = 0.9 time = 300
.meas tran vdout0_17ck59 FIND v(dout0_17) AT=300.025n

* CHECK dout0_18 Vdout0_18ck59 = 0.9 time = 300
.meas tran vdout0_18ck59 FIND v(dout0_18) AT=300.025n

* CHECK dout0_19 Vdout0_19ck59 = 0.9 time = 300
.meas tran vdout0_19ck59 FIND v(dout0_19) AT=300.025n

* CHECK dout0_20 Vdout0_20ck59 = 0 time = 300
.meas tran vdout0_20ck59 FIND v(dout0_20) AT=300.025n

* CHECK dout0_21 Vdout0_21ck59 = 0 time = 300
.meas tran vdout0_21ck59 FIND v(dout0_21) AT=300.025n

* CHECK dout0_22 Vdout0_22ck59 = 0.9 time = 300
.meas tran vdout0_22ck59 FIND v(dout0_22) AT=300.025n

* CHECK dout0_23 Vdout0_23ck59 = 0 time = 300
.meas tran vdout0_23ck59 FIND v(dout0_23) AT=300.025n

* CHECK dout0_24 Vdout0_24ck59 = 0.9 time = 300
.meas tran vdout0_24ck59 FIND v(dout0_24) AT=300.025n

* CHECK dout0_25 Vdout0_25ck59 = 0 time = 300
.meas tran vdout0_25ck59 FIND v(dout0_25) AT=300.025n

* CHECK dout0_26 Vdout0_26ck59 = 0.9 time = 300
.meas tran vdout0_26ck59 FIND v(dout0_26) AT=300.025n

* CHECK dout0_27 Vdout0_27ck59 = 0 time = 300
.meas tran vdout0_27ck59 FIND v(dout0_27) AT=300.025n

* CHECK dout0_28 Vdout0_28ck59 = 0.9 time = 300
.meas tran vdout0_28ck59 FIND v(dout0_28) AT=300.025n

* CHECK dout0_29 Vdout0_29ck59 = 0 time = 300
.meas tran vdout0_29ck59 FIND v(dout0_29) AT=300.025n

* CHECK dout0_30 Vdout0_30ck59 = 0 time = 300
.meas tran vdout0_30ck59 FIND v(dout0_30) AT=300.025n

* CHECK dout0_31 Vdout0_31ck59 = 0.9 time = 300
.meas tran vdout0_31ck59 FIND v(dout0_31) AT=300.025n

* CHECK dout0_32 Vdout0_32ck59 = 0 time = 300
.meas tran vdout0_32ck59 FIND v(dout0_32) AT=300.025n

* CHECK dout0_33 Vdout0_33ck59 = 0 time = 300
.meas tran vdout0_33ck59 FIND v(dout0_33) AT=300.025n

* CHECK dout0_34 Vdout0_34ck59 = 0 time = 300
.meas tran vdout0_34ck59 FIND v(dout0_34) AT=300.025n

* CHECK dout0_35 Vdout0_35ck59 = 0 time = 300
.meas tran vdout0_35ck59 FIND v(dout0_35) AT=300.025n

* CHECK dout0_36 Vdout0_36ck59 = 0 time = 300
.meas tran vdout0_36ck59 FIND v(dout0_36) AT=300.025n

* CHECK dout0_37 Vdout0_37ck59 = 0 time = 300
.meas tran vdout0_37ck59 FIND v(dout0_37) AT=300.025n

* CHECK dout0_38 Vdout0_38ck59 = 0.9 time = 300
.meas tran vdout0_38ck59 FIND v(dout0_38) AT=300.025n

* CHECK dout0_39 Vdout0_39ck59 = 0.9 time = 300
.meas tran vdout0_39ck59 FIND v(dout0_39) AT=300.025n

* CHECK dout0_40 Vdout0_40ck59 = 0.9 time = 300
.meas tran vdout0_40ck59 FIND v(dout0_40) AT=300.025n

* CHECK dout0_41 Vdout0_41ck59 = 0.9 time = 300
.meas tran vdout0_41ck59 FIND v(dout0_41) AT=300.025n

* CHECK dout0_42 Vdout0_42ck59 = 0.9 time = 300
.meas tran vdout0_42ck59 FIND v(dout0_42) AT=300.025n

* CHECK dout0_43 Vdout0_43ck59 = 0 time = 300
.meas tran vdout0_43ck59 FIND v(dout0_43) AT=300.025n

* CHECK dout0_44 Vdout0_44ck59 = 0.9 time = 300
.meas tran vdout0_44ck59 FIND v(dout0_44) AT=300.025n

* CHECK dout0_45 Vdout0_45ck59 = 0.9 time = 300
.meas tran vdout0_45ck59 FIND v(dout0_45) AT=300.025n

* CHECK dout0_46 Vdout0_46ck59 = 0.9 time = 300
.meas tran vdout0_46ck59 FIND v(dout0_46) AT=300.025n

* CHECK dout0_47 Vdout0_47ck59 = 0.9 time = 300
.meas tran vdout0_47ck59 FIND v(dout0_47) AT=300.025n

* CHECK dout0_48 Vdout0_48ck59 = 0 time = 300
.meas tran vdout0_48ck59 FIND v(dout0_48) AT=300.025n

* CHECK dout0_49 Vdout0_49ck59 = 0 time = 300
.meas tran vdout0_49ck59 FIND v(dout0_49) AT=300.025n

* CHECK dout0_50 Vdout0_50ck59 = 0 time = 300
.meas tran vdout0_50ck59 FIND v(dout0_50) AT=300.025n

* CHECK dout0_51 Vdout0_51ck59 = 0.9 time = 300
.meas tran vdout0_51ck59 FIND v(dout0_51) AT=300.025n

* CHECK dout0_52 Vdout0_52ck59 = 0.9 time = 300
.meas tran vdout0_52ck59 FIND v(dout0_52) AT=300.025n

* CHECK dout0_53 Vdout0_53ck59 = 0.9 time = 300
.meas tran vdout0_53ck59 FIND v(dout0_53) AT=300.025n

* CHECK dout0_54 Vdout0_54ck59 = 0 time = 300
.meas tran vdout0_54ck59 FIND v(dout0_54) AT=300.025n

* CHECK dout0_55 Vdout0_55ck59 = 0 time = 300
.meas tran vdout0_55ck59 FIND v(dout0_55) AT=300.025n

* CHECK dout0_56 Vdout0_56ck59 = 0.9 time = 300
.meas tran vdout0_56ck59 FIND v(dout0_56) AT=300.025n

* CHECK dout0_57 Vdout0_57ck59 = 0.9 time = 300
.meas tran vdout0_57ck59 FIND v(dout0_57) AT=300.025n

* CHECK dout0_58 Vdout0_58ck59 = 0.9 time = 300
.meas tran vdout0_58ck59 FIND v(dout0_58) AT=300.025n

* CHECK dout0_59 Vdout0_59ck59 = 0 time = 300
.meas tran vdout0_59ck59 FIND v(dout0_59) AT=300.025n

* CHECK dout0_60 Vdout0_60ck59 = 0 time = 300
.meas tran vdout0_60ck59 FIND v(dout0_60) AT=300.025n

* CHECK dout0_61 Vdout0_61ck59 = 0 time = 300
.meas tran vdout0_61ck59 FIND v(dout0_61) AT=300.025n

* CHECK dout0_62 Vdout0_62ck59 = 0.9 time = 300
.meas tran vdout0_62ck59 FIND v(dout0_62) AT=300.025n

* CHECK dout0_63 Vdout0_63ck59 = 0.9 time = 300
.meas tran vdout0_63ck59 FIND v(dout0_63) AT=300.025n

* CHECK dout0_64 Vdout0_64ck59 = 0 time = 300
.meas tran vdout0_64ck59 FIND v(dout0_64) AT=300.025n

* CHECK dout0_65 Vdout0_65ck59 = 0.9 time = 300
.meas tran vdout0_65ck59 FIND v(dout0_65) AT=300.025n

* CHECK dout0_66 Vdout0_66ck59 = 0 time = 300
.meas tran vdout0_66ck59 FIND v(dout0_66) AT=300.025n

* CHECK dout0_67 Vdout0_67ck59 = 0 time = 300
.meas tran vdout0_67ck59 FIND v(dout0_67) AT=300.025n

* CHECK dout0_68 Vdout0_68ck59 = 0 time = 300
.meas tran vdout0_68ck59 FIND v(dout0_68) AT=300.025n

* CHECK dout0_69 Vdout0_69ck59 = 0 time = 300
.meas tran vdout0_69ck59 FIND v(dout0_69) AT=300.025n

* CHECK dout0_70 Vdout0_70ck59 = 0 time = 300
.meas tran vdout0_70ck59 FIND v(dout0_70) AT=300.025n

* CHECK dout0_71 Vdout0_71ck59 = 0.9 time = 300
.meas tran vdout0_71ck59 FIND v(dout0_71) AT=300.025n

* CHECK dout0_72 Vdout0_72ck59 = 0.9 time = 300
.meas tran vdout0_72ck59 FIND v(dout0_72) AT=300.025n

* CHECK dout0_73 Vdout0_73ck59 = 0.9 time = 300
.meas tran vdout0_73ck59 FIND v(dout0_73) AT=300.025n

* CHECK dout0_74 Vdout0_74ck59 = 0.9 time = 300
.meas tran vdout0_74ck59 FIND v(dout0_74) AT=300.025n

* CHECK dout0_75 Vdout0_75ck59 = 0 time = 300
.meas tran vdout0_75ck59 FIND v(dout0_75) AT=300.025n

* CHECK dout0_76 Vdout0_76ck59 = 0 time = 300
.meas tran vdout0_76ck59 FIND v(dout0_76) AT=300.025n

* CHECK dout0_77 Vdout0_77ck59 = 0 time = 300
.meas tran vdout0_77ck59 FIND v(dout0_77) AT=300.025n

* CHECK dout0_78 Vdout0_78ck59 = 0.9 time = 300
.meas tran vdout0_78ck59 FIND v(dout0_78) AT=300.025n

* CHECK dout0_79 Vdout0_79ck59 = 0 time = 300
.meas tran vdout0_79ck59 FIND v(dout0_79) AT=300.025n

* CHECK dout0_80 Vdout0_80ck59 = 0.9 time = 300
.meas tran vdout0_80ck59 FIND v(dout0_80) AT=300.025n

* CHECK dout0_81 Vdout0_81ck59 = 0 time = 300
.meas tran vdout0_81ck59 FIND v(dout0_81) AT=300.025n

* CHECK dout0_82 Vdout0_82ck59 = 0.9 time = 300
.meas tran vdout0_82ck59 FIND v(dout0_82) AT=300.025n

* CHECK dout0_83 Vdout0_83ck59 = 0 time = 300
.meas tran vdout0_83ck59 FIND v(dout0_83) AT=300.025n

* CHECK dout0_84 Vdout0_84ck59 = 0 time = 300
.meas tran vdout0_84ck59 FIND v(dout0_84) AT=300.025n

* CHECK dout0_85 Vdout0_85ck59 = 0.9 time = 300
.meas tran vdout0_85ck59 FIND v(dout0_85) AT=300.025n

* CHECK dout0_86 Vdout0_86ck59 = 0.9 time = 300
.meas tran vdout0_86ck59 FIND v(dout0_86) AT=300.025n

* CHECK dout0_87 Vdout0_87ck59 = 0 time = 300
.meas tran vdout0_87ck59 FIND v(dout0_87) AT=300.025n

* CHECK dout0_0 Vdout0_0ck63 = 0 time = 320
.meas tran vdout0_0ck63 FIND v(dout0_0) AT=320.025n

* CHECK dout0_1 Vdout0_1ck63 = 0.9 time = 320
.meas tran vdout0_1ck63 FIND v(dout0_1) AT=320.025n

* CHECK dout0_2 Vdout0_2ck63 = 0.9 time = 320
.meas tran vdout0_2ck63 FIND v(dout0_2) AT=320.025n

* CHECK dout0_3 Vdout0_3ck63 = 0.9 time = 320
.meas tran vdout0_3ck63 FIND v(dout0_3) AT=320.025n

* CHECK dout0_4 Vdout0_4ck63 = 0 time = 320
.meas tran vdout0_4ck63 FIND v(dout0_4) AT=320.025n

* CHECK dout0_5 Vdout0_5ck63 = 0.9 time = 320
.meas tran vdout0_5ck63 FIND v(dout0_5) AT=320.025n

* CHECK dout0_6 Vdout0_6ck63 = 0.9 time = 320
.meas tran vdout0_6ck63 FIND v(dout0_6) AT=320.025n

* CHECK dout0_7 Vdout0_7ck63 = 0.9 time = 320
.meas tran vdout0_7ck63 FIND v(dout0_7) AT=320.025n

* CHECK dout0_8 Vdout0_8ck63 = 0.9 time = 320
.meas tran vdout0_8ck63 FIND v(dout0_8) AT=320.025n

* CHECK dout0_9 Vdout0_9ck63 = 0.9 time = 320
.meas tran vdout0_9ck63 FIND v(dout0_9) AT=320.025n

* CHECK dout0_10 Vdout0_10ck63 = 0 time = 320
.meas tran vdout0_10ck63 FIND v(dout0_10) AT=320.025n

* CHECK dout0_11 Vdout0_11ck63 = 0.9 time = 320
.meas tran vdout0_11ck63 FIND v(dout0_11) AT=320.025n

* CHECK dout0_12 Vdout0_12ck63 = 0.9 time = 320
.meas tran vdout0_12ck63 FIND v(dout0_12) AT=320.025n

* CHECK dout0_13 Vdout0_13ck63 = 0 time = 320
.meas tran vdout0_13ck63 FIND v(dout0_13) AT=320.025n

* CHECK dout0_14 Vdout0_14ck63 = 0.9 time = 320
.meas tran vdout0_14ck63 FIND v(dout0_14) AT=320.025n

* CHECK dout0_15 Vdout0_15ck63 = 0 time = 320
.meas tran vdout0_15ck63 FIND v(dout0_15) AT=320.025n

* CHECK dout0_16 Vdout0_16ck63 = 0 time = 320
.meas tran vdout0_16ck63 FIND v(dout0_16) AT=320.025n

* CHECK dout0_17 Vdout0_17ck63 = 0 time = 320
.meas tran vdout0_17ck63 FIND v(dout0_17) AT=320.025n

* CHECK dout0_18 Vdout0_18ck63 = 0.9 time = 320
.meas tran vdout0_18ck63 FIND v(dout0_18) AT=320.025n

* CHECK dout0_19 Vdout0_19ck63 = 0.9 time = 320
.meas tran vdout0_19ck63 FIND v(dout0_19) AT=320.025n

* CHECK dout0_20 Vdout0_20ck63 = 0.9 time = 320
.meas tran vdout0_20ck63 FIND v(dout0_20) AT=320.025n

* CHECK dout0_21 Vdout0_21ck63 = 0.9 time = 320
.meas tran vdout0_21ck63 FIND v(dout0_21) AT=320.025n

* CHECK dout0_22 Vdout0_22ck63 = 0.9 time = 320
.meas tran vdout0_22ck63 FIND v(dout0_22) AT=320.025n

* CHECK dout0_23 Vdout0_23ck63 = 0.9 time = 320
.meas tran vdout0_23ck63 FIND v(dout0_23) AT=320.025n

* CHECK dout0_24 Vdout0_24ck63 = 0.9 time = 320
.meas tran vdout0_24ck63 FIND v(dout0_24) AT=320.025n

* CHECK dout0_25 Vdout0_25ck63 = 0 time = 320
.meas tran vdout0_25ck63 FIND v(dout0_25) AT=320.025n

* CHECK dout0_26 Vdout0_26ck63 = 0.9 time = 320
.meas tran vdout0_26ck63 FIND v(dout0_26) AT=320.025n

* CHECK dout0_27 Vdout0_27ck63 = 0 time = 320
.meas tran vdout0_27ck63 FIND v(dout0_27) AT=320.025n

* CHECK dout0_28 Vdout0_28ck63 = 0 time = 320
.meas tran vdout0_28ck63 FIND v(dout0_28) AT=320.025n

* CHECK dout0_29 Vdout0_29ck63 = 0.9 time = 320
.meas tran vdout0_29ck63 FIND v(dout0_29) AT=320.025n

* CHECK dout0_30 Vdout0_30ck63 = 0 time = 320
.meas tran vdout0_30ck63 FIND v(dout0_30) AT=320.025n

* CHECK dout0_31 Vdout0_31ck63 = 0 time = 320
.meas tran vdout0_31ck63 FIND v(dout0_31) AT=320.025n

* CHECK dout0_32 Vdout0_32ck63 = 0 time = 320
.meas tran vdout0_32ck63 FIND v(dout0_32) AT=320.025n

* CHECK dout0_33 Vdout0_33ck63 = 0.9 time = 320
.meas tran vdout0_33ck63 FIND v(dout0_33) AT=320.025n

* CHECK dout0_34 Vdout0_34ck63 = 0 time = 320
.meas tran vdout0_34ck63 FIND v(dout0_34) AT=320.025n

* CHECK dout0_35 Vdout0_35ck63 = 0 time = 320
.meas tran vdout0_35ck63 FIND v(dout0_35) AT=320.025n

* CHECK dout0_36 Vdout0_36ck63 = 0.9 time = 320
.meas tran vdout0_36ck63 FIND v(dout0_36) AT=320.025n

* CHECK dout0_37 Vdout0_37ck63 = 0.9 time = 320
.meas tran vdout0_37ck63 FIND v(dout0_37) AT=320.025n

* CHECK dout0_38 Vdout0_38ck63 = 0 time = 320
.meas tran vdout0_38ck63 FIND v(dout0_38) AT=320.025n

* CHECK dout0_39 Vdout0_39ck63 = 0 time = 320
.meas tran vdout0_39ck63 FIND v(dout0_39) AT=320.025n

* CHECK dout0_40 Vdout0_40ck63 = 0.9 time = 320
.meas tran vdout0_40ck63 FIND v(dout0_40) AT=320.025n

* CHECK dout0_41 Vdout0_41ck63 = 0 time = 320
.meas tran vdout0_41ck63 FIND v(dout0_41) AT=320.025n

* CHECK dout0_42 Vdout0_42ck63 = 0 time = 320
.meas tran vdout0_42ck63 FIND v(dout0_42) AT=320.025n

* CHECK dout0_43 Vdout0_43ck63 = 0 time = 320
.meas tran vdout0_43ck63 FIND v(dout0_43) AT=320.025n

* CHECK dout0_44 Vdout0_44ck63 = 0.9 time = 320
.meas tran vdout0_44ck63 FIND v(dout0_44) AT=320.025n

* CHECK dout0_45 Vdout0_45ck63 = 0.9 time = 320
.meas tran vdout0_45ck63 FIND v(dout0_45) AT=320.025n

* CHECK dout0_46 Vdout0_46ck63 = 0 time = 320
.meas tran vdout0_46ck63 FIND v(dout0_46) AT=320.025n

* CHECK dout0_47 Vdout0_47ck63 = 0.9 time = 320
.meas tran vdout0_47ck63 FIND v(dout0_47) AT=320.025n

* CHECK dout0_48 Vdout0_48ck63 = 0 time = 320
.meas tran vdout0_48ck63 FIND v(dout0_48) AT=320.025n

* CHECK dout0_49 Vdout0_49ck63 = 0.9 time = 320
.meas tran vdout0_49ck63 FIND v(dout0_49) AT=320.025n

* CHECK dout0_50 Vdout0_50ck63 = 0 time = 320
.meas tran vdout0_50ck63 FIND v(dout0_50) AT=320.025n

* CHECK dout0_51 Vdout0_51ck63 = 0 time = 320
.meas tran vdout0_51ck63 FIND v(dout0_51) AT=320.025n

* CHECK dout0_52 Vdout0_52ck63 = 0 time = 320
.meas tran vdout0_52ck63 FIND v(dout0_52) AT=320.025n

* CHECK dout0_53 Vdout0_53ck63 = 0.9 time = 320
.meas tran vdout0_53ck63 FIND v(dout0_53) AT=320.025n

* CHECK dout0_54 Vdout0_54ck63 = 0.9 time = 320
.meas tran vdout0_54ck63 FIND v(dout0_54) AT=320.025n

* CHECK dout0_55 Vdout0_55ck63 = 0.9 time = 320
.meas tran vdout0_55ck63 FIND v(dout0_55) AT=320.025n

* CHECK dout0_56 Vdout0_56ck63 = 0 time = 320
.meas tran vdout0_56ck63 FIND v(dout0_56) AT=320.025n

* CHECK dout0_57 Vdout0_57ck63 = 0 time = 320
.meas tran vdout0_57ck63 FIND v(dout0_57) AT=320.025n

* CHECK dout0_58 Vdout0_58ck63 = 0.9 time = 320
.meas tran vdout0_58ck63 FIND v(dout0_58) AT=320.025n

* CHECK dout0_59 Vdout0_59ck63 = 0.9 time = 320
.meas tran vdout0_59ck63 FIND v(dout0_59) AT=320.025n

* CHECK dout0_60 Vdout0_60ck63 = 0.9 time = 320
.meas tran vdout0_60ck63 FIND v(dout0_60) AT=320.025n

* CHECK dout0_61 Vdout0_61ck63 = 0 time = 320
.meas tran vdout0_61ck63 FIND v(dout0_61) AT=320.025n

* CHECK dout0_62 Vdout0_62ck63 = 0 time = 320
.meas tran vdout0_62ck63 FIND v(dout0_62) AT=320.025n

* CHECK dout0_63 Vdout0_63ck63 = 0.9 time = 320
.meas tran vdout0_63ck63 FIND v(dout0_63) AT=320.025n

* CHECK dout0_64 Vdout0_64ck63 = 0 time = 320
.meas tran vdout0_64ck63 FIND v(dout0_64) AT=320.025n

* CHECK dout0_65 Vdout0_65ck63 = 0 time = 320
.meas tran vdout0_65ck63 FIND v(dout0_65) AT=320.025n

* CHECK dout0_66 Vdout0_66ck63 = 0.9 time = 320
.meas tran vdout0_66ck63 FIND v(dout0_66) AT=320.025n

* CHECK dout0_67 Vdout0_67ck63 = 0.9 time = 320
.meas tran vdout0_67ck63 FIND v(dout0_67) AT=320.025n

* CHECK dout0_68 Vdout0_68ck63 = 0 time = 320
.meas tran vdout0_68ck63 FIND v(dout0_68) AT=320.025n

* CHECK dout0_69 Vdout0_69ck63 = 0 time = 320
.meas tran vdout0_69ck63 FIND v(dout0_69) AT=320.025n

* CHECK dout0_70 Vdout0_70ck63 = 0 time = 320
.meas tran vdout0_70ck63 FIND v(dout0_70) AT=320.025n

* CHECK dout0_71 Vdout0_71ck63 = 0 time = 320
.meas tran vdout0_71ck63 FIND v(dout0_71) AT=320.025n

* CHECK dout0_72 Vdout0_72ck63 = 0 time = 320
.meas tran vdout0_72ck63 FIND v(dout0_72) AT=320.025n

* CHECK dout0_73 Vdout0_73ck63 = 0 time = 320
.meas tran vdout0_73ck63 FIND v(dout0_73) AT=320.025n

* CHECK dout0_74 Vdout0_74ck63 = 0 time = 320
.meas tran vdout0_74ck63 FIND v(dout0_74) AT=320.025n

* CHECK dout0_75 Vdout0_75ck63 = 0 time = 320
.meas tran vdout0_75ck63 FIND v(dout0_75) AT=320.025n

* CHECK dout0_76 Vdout0_76ck63 = 0 time = 320
.meas tran vdout0_76ck63 FIND v(dout0_76) AT=320.025n

* CHECK dout0_77 Vdout0_77ck63 = 0 time = 320
.meas tran vdout0_77ck63 FIND v(dout0_77) AT=320.025n

* CHECK dout0_78 Vdout0_78ck63 = 0.9 time = 320
.meas tran vdout0_78ck63 FIND v(dout0_78) AT=320.025n

* CHECK dout0_79 Vdout0_79ck63 = 0 time = 320
.meas tran vdout0_79ck63 FIND v(dout0_79) AT=320.025n

* CHECK dout0_80 Vdout0_80ck63 = 0.9 time = 320
.meas tran vdout0_80ck63 FIND v(dout0_80) AT=320.025n

* CHECK dout0_81 Vdout0_81ck63 = 0 time = 320
.meas tran vdout0_81ck63 FIND v(dout0_81) AT=320.025n

* CHECK dout0_82 Vdout0_82ck63 = 0.9 time = 320
.meas tran vdout0_82ck63 FIND v(dout0_82) AT=320.025n

* CHECK dout0_83 Vdout0_83ck63 = 0.9 time = 320
.meas tran vdout0_83ck63 FIND v(dout0_83) AT=320.025n

* CHECK dout0_84 Vdout0_84ck63 = 0.9 time = 320
.meas tran vdout0_84ck63 FIND v(dout0_84) AT=320.025n

* CHECK dout0_85 Vdout0_85ck63 = 0.9 time = 320
.meas tran vdout0_85ck63 FIND v(dout0_85) AT=320.025n

* CHECK dout0_86 Vdout0_86ck63 = 0 time = 320
.meas tran vdout0_86ck63 FIND v(dout0_86) AT=320.025n

* CHECK dout0_87 Vdout0_87ck63 = 0.9 time = 320
.meas tran vdout0_87ck63 FIND v(dout0_87) AT=320.025n

* CHECK dout0_0 Vdout0_0ck64 = 0 time = 325
.meas tran vdout0_0ck64 FIND v(dout0_0) AT=325.025n

* CHECK dout0_1 Vdout0_1ck64 = 0.9 time = 325
.meas tran vdout0_1ck64 FIND v(dout0_1) AT=325.025n

* CHECK dout0_2 Vdout0_2ck64 = 0.9 time = 325
.meas tran vdout0_2ck64 FIND v(dout0_2) AT=325.025n

* CHECK dout0_3 Vdout0_3ck64 = 0.9 time = 325
.meas tran vdout0_3ck64 FIND v(dout0_3) AT=325.025n

* CHECK dout0_4 Vdout0_4ck64 = 0 time = 325
.meas tran vdout0_4ck64 FIND v(dout0_4) AT=325.025n

* CHECK dout0_5 Vdout0_5ck64 = 0.9 time = 325
.meas tran vdout0_5ck64 FIND v(dout0_5) AT=325.025n

* CHECK dout0_6 Vdout0_6ck64 = 0.9 time = 325
.meas tran vdout0_6ck64 FIND v(dout0_6) AT=325.025n

* CHECK dout0_7 Vdout0_7ck64 = 0.9 time = 325
.meas tran vdout0_7ck64 FIND v(dout0_7) AT=325.025n

* CHECK dout0_8 Vdout0_8ck64 = 0.9 time = 325
.meas tran vdout0_8ck64 FIND v(dout0_8) AT=325.025n

* CHECK dout0_9 Vdout0_9ck64 = 0.9 time = 325
.meas tran vdout0_9ck64 FIND v(dout0_9) AT=325.025n

* CHECK dout0_10 Vdout0_10ck64 = 0 time = 325
.meas tran vdout0_10ck64 FIND v(dout0_10) AT=325.025n

* CHECK dout0_11 Vdout0_11ck64 = 0.9 time = 325
.meas tran vdout0_11ck64 FIND v(dout0_11) AT=325.025n

* CHECK dout0_12 Vdout0_12ck64 = 0.9 time = 325
.meas tran vdout0_12ck64 FIND v(dout0_12) AT=325.025n

* CHECK dout0_13 Vdout0_13ck64 = 0 time = 325
.meas tran vdout0_13ck64 FIND v(dout0_13) AT=325.025n

* CHECK dout0_14 Vdout0_14ck64 = 0.9 time = 325
.meas tran vdout0_14ck64 FIND v(dout0_14) AT=325.025n

* CHECK dout0_15 Vdout0_15ck64 = 0 time = 325
.meas tran vdout0_15ck64 FIND v(dout0_15) AT=325.025n

* CHECK dout0_16 Vdout0_16ck64 = 0 time = 325
.meas tran vdout0_16ck64 FIND v(dout0_16) AT=325.025n

* CHECK dout0_17 Vdout0_17ck64 = 0 time = 325
.meas tran vdout0_17ck64 FIND v(dout0_17) AT=325.025n

* CHECK dout0_18 Vdout0_18ck64 = 0.9 time = 325
.meas tran vdout0_18ck64 FIND v(dout0_18) AT=325.025n

* CHECK dout0_19 Vdout0_19ck64 = 0.9 time = 325
.meas tran vdout0_19ck64 FIND v(dout0_19) AT=325.025n

* CHECK dout0_20 Vdout0_20ck64 = 0.9 time = 325
.meas tran vdout0_20ck64 FIND v(dout0_20) AT=325.025n

* CHECK dout0_21 Vdout0_21ck64 = 0.9 time = 325
.meas tran vdout0_21ck64 FIND v(dout0_21) AT=325.025n

* CHECK dout0_22 Vdout0_22ck64 = 0.9 time = 325
.meas tran vdout0_22ck64 FIND v(dout0_22) AT=325.025n

* CHECK dout0_23 Vdout0_23ck64 = 0.9 time = 325
.meas tran vdout0_23ck64 FIND v(dout0_23) AT=325.025n

* CHECK dout0_24 Vdout0_24ck64 = 0.9 time = 325
.meas tran vdout0_24ck64 FIND v(dout0_24) AT=325.025n

* CHECK dout0_25 Vdout0_25ck64 = 0 time = 325
.meas tran vdout0_25ck64 FIND v(dout0_25) AT=325.025n

* CHECK dout0_26 Vdout0_26ck64 = 0.9 time = 325
.meas tran vdout0_26ck64 FIND v(dout0_26) AT=325.025n

* CHECK dout0_27 Vdout0_27ck64 = 0 time = 325
.meas tran vdout0_27ck64 FIND v(dout0_27) AT=325.025n

* CHECK dout0_28 Vdout0_28ck64 = 0 time = 325
.meas tran vdout0_28ck64 FIND v(dout0_28) AT=325.025n

* CHECK dout0_29 Vdout0_29ck64 = 0.9 time = 325
.meas tran vdout0_29ck64 FIND v(dout0_29) AT=325.025n

* CHECK dout0_30 Vdout0_30ck64 = 0 time = 325
.meas tran vdout0_30ck64 FIND v(dout0_30) AT=325.025n

* CHECK dout0_31 Vdout0_31ck64 = 0 time = 325
.meas tran vdout0_31ck64 FIND v(dout0_31) AT=325.025n

* CHECK dout0_32 Vdout0_32ck64 = 0 time = 325
.meas tran vdout0_32ck64 FIND v(dout0_32) AT=325.025n

* CHECK dout0_33 Vdout0_33ck64 = 0.9 time = 325
.meas tran vdout0_33ck64 FIND v(dout0_33) AT=325.025n

* CHECK dout0_34 Vdout0_34ck64 = 0 time = 325
.meas tran vdout0_34ck64 FIND v(dout0_34) AT=325.025n

* CHECK dout0_35 Vdout0_35ck64 = 0 time = 325
.meas tran vdout0_35ck64 FIND v(dout0_35) AT=325.025n

* CHECK dout0_36 Vdout0_36ck64 = 0.9 time = 325
.meas tran vdout0_36ck64 FIND v(dout0_36) AT=325.025n

* CHECK dout0_37 Vdout0_37ck64 = 0.9 time = 325
.meas tran vdout0_37ck64 FIND v(dout0_37) AT=325.025n

* CHECK dout0_38 Vdout0_38ck64 = 0 time = 325
.meas tran vdout0_38ck64 FIND v(dout0_38) AT=325.025n

* CHECK dout0_39 Vdout0_39ck64 = 0 time = 325
.meas tran vdout0_39ck64 FIND v(dout0_39) AT=325.025n

* CHECK dout0_40 Vdout0_40ck64 = 0.9 time = 325
.meas tran vdout0_40ck64 FIND v(dout0_40) AT=325.025n

* CHECK dout0_41 Vdout0_41ck64 = 0 time = 325
.meas tran vdout0_41ck64 FIND v(dout0_41) AT=325.025n

* CHECK dout0_42 Vdout0_42ck64 = 0 time = 325
.meas tran vdout0_42ck64 FIND v(dout0_42) AT=325.025n

* CHECK dout0_43 Vdout0_43ck64 = 0 time = 325
.meas tran vdout0_43ck64 FIND v(dout0_43) AT=325.025n

* CHECK dout0_44 Vdout0_44ck64 = 0.9 time = 325
.meas tran vdout0_44ck64 FIND v(dout0_44) AT=325.025n

* CHECK dout0_45 Vdout0_45ck64 = 0.9 time = 325
.meas tran vdout0_45ck64 FIND v(dout0_45) AT=325.025n

* CHECK dout0_46 Vdout0_46ck64 = 0 time = 325
.meas tran vdout0_46ck64 FIND v(dout0_46) AT=325.025n

* CHECK dout0_47 Vdout0_47ck64 = 0.9 time = 325
.meas tran vdout0_47ck64 FIND v(dout0_47) AT=325.025n

* CHECK dout0_48 Vdout0_48ck64 = 0 time = 325
.meas tran vdout0_48ck64 FIND v(dout0_48) AT=325.025n

* CHECK dout0_49 Vdout0_49ck64 = 0.9 time = 325
.meas tran vdout0_49ck64 FIND v(dout0_49) AT=325.025n

* CHECK dout0_50 Vdout0_50ck64 = 0 time = 325
.meas tran vdout0_50ck64 FIND v(dout0_50) AT=325.025n

* CHECK dout0_51 Vdout0_51ck64 = 0 time = 325
.meas tran vdout0_51ck64 FIND v(dout0_51) AT=325.025n

* CHECK dout0_52 Vdout0_52ck64 = 0 time = 325
.meas tran vdout0_52ck64 FIND v(dout0_52) AT=325.025n

* CHECK dout0_53 Vdout0_53ck64 = 0.9 time = 325
.meas tran vdout0_53ck64 FIND v(dout0_53) AT=325.025n

* CHECK dout0_54 Vdout0_54ck64 = 0.9 time = 325
.meas tran vdout0_54ck64 FIND v(dout0_54) AT=325.025n

* CHECK dout0_55 Vdout0_55ck64 = 0.9 time = 325
.meas tran vdout0_55ck64 FIND v(dout0_55) AT=325.025n

* CHECK dout0_56 Vdout0_56ck64 = 0 time = 325
.meas tran vdout0_56ck64 FIND v(dout0_56) AT=325.025n

* CHECK dout0_57 Vdout0_57ck64 = 0 time = 325
.meas tran vdout0_57ck64 FIND v(dout0_57) AT=325.025n

* CHECK dout0_58 Vdout0_58ck64 = 0.9 time = 325
.meas tran vdout0_58ck64 FIND v(dout0_58) AT=325.025n

* CHECK dout0_59 Vdout0_59ck64 = 0.9 time = 325
.meas tran vdout0_59ck64 FIND v(dout0_59) AT=325.025n

* CHECK dout0_60 Vdout0_60ck64 = 0.9 time = 325
.meas tran vdout0_60ck64 FIND v(dout0_60) AT=325.025n

* CHECK dout0_61 Vdout0_61ck64 = 0 time = 325
.meas tran vdout0_61ck64 FIND v(dout0_61) AT=325.025n

* CHECK dout0_62 Vdout0_62ck64 = 0 time = 325
.meas tran vdout0_62ck64 FIND v(dout0_62) AT=325.025n

* CHECK dout0_63 Vdout0_63ck64 = 0.9 time = 325
.meas tran vdout0_63ck64 FIND v(dout0_63) AT=325.025n

* CHECK dout0_64 Vdout0_64ck64 = 0 time = 325
.meas tran vdout0_64ck64 FIND v(dout0_64) AT=325.025n

* CHECK dout0_65 Vdout0_65ck64 = 0 time = 325
.meas tran vdout0_65ck64 FIND v(dout0_65) AT=325.025n

* CHECK dout0_66 Vdout0_66ck64 = 0.9 time = 325
.meas tran vdout0_66ck64 FIND v(dout0_66) AT=325.025n

* CHECK dout0_67 Vdout0_67ck64 = 0.9 time = 325
.meas tran vdout0_67ck64 FIND v(dout0_67) AT=325.025n

* CHECK dout0_68 Vdout0_68ck64 = 0 time = 325
.meas tran vdout0_68ck64 FIND v(dout0_68) AT=325.025n

* CHECK dout0_69 Vdout0_69ck64 = 0 time = 325
.meas tran vdout0_69ck64 FIND v(dout0_69) AT=325.025n

* CHECK dout0_70 Vdout0_70ck64 = 0 time = 325
.meas tran vdout0_70ck64 FIND v(dout0_70) AT=325.025n

* CHECK dout0_71 Vdout0_71ck64 = 0 time = 325
.meas tran vdout0_71ck64 FIND v(dout0_71) AT=325.025n

* CHECK dout0_72 Vdout0_72ck64 = 0 time = 325
.meas tran vdout0_72ck64 FIND v(dout0_72) AT=325.025n

* CHECK dout0_73 Vdout0_73ck64 = 0 time = 325
.meas tran vdout0_73ck64 FIND v(dout0_73) AT=325.025n

* CHECK dout0_74 Vdout0_74ck64 = 0 time = 325
.meas tran vdout0_74ck64 FIND v(dout0_74) AT=325.025n

* CHECK dout0_75 Vdout0_75ck64 = 0 time = 325
.meas tran vdout0_75ck64 FIND v(dout0_75) AT=325.025n

* CHECK dout0_76 Vdout0_76ck64 = 0 time = 325
.meas tran vdout0_76ck64 FIND v(dout0_76) AT=325.025n

* CHECK dout0_77 Vdout0_77ck64 = 0 time = 325
.meas tran vdout0_77ck64 FIND v(dout0_77) AT=325.025n

* CHECK dout0_78 Vdout0_78ck64 = 0.9 time = 325
.meas tran vdout0_78ck64 FIND v(dout0_78) AT=325.025n

* CHECK dout0_79 Vdout0_79ck64 = 0 time = 325
.meas tran vdout0_79ck64 FIND v(dout0_79) AT=325.025n

* CHECK dout0_80 Vdout0_80ck64 = 0.9 time = 325
.meas tran vdout0_80ck64 FIND v(dout0_80) AT=325.025n

* CHECK dout0_81 Vdout0_81ck64 = 0 time = 325
.meas tran vdout0_81ck64 FIND v(dout0_81) AT=325.025n

* CHECK dout0_82 Vdout0_82ck64 = 0.9 time = 325
.meas tran vdout0_82ck64 FIND v(dout0_82) AT=325.025n

* CHECK dout0_83 Vdout0_83ck64 = 0.9 time = 325
.meas tran vdout0_83ck64 FIND v(dout0_83) AT=325.025n

* CHECK dout0_84 Vdout0_84ck64 = 0.9 time = 325
.meas tran vdout0_84ck64 FIND v(dout0_84) AT=325.025n

* CHECK dout0_85 Vdout0_85ck64 = 0.9 time = 325
.meas tran vdout0_85ck64 FIND v(dout0_85) AT=325.025n

* CHECK dout0_86 Vdout0_86ck64 = 0 time = 325
.meas tran vdout0_86ck64 FIND v(dout0_86) AT=325.025n

* CHECK dout0_87 Vdout0_87ck64 = 0.9 time = 325
.meas tran vdout0_87ck64 FIND v(dout0_87) AT=325.025n

* CHECK dout0_0 Vdout0_0ck66 = 0 time = 335
.meas tran vdout0_0ck66 FIND v(dout0_0) AT=335.025n

* CHECK dout0_1 Vdout0_1ck66 = 0.9 time = 335
.meas tran vdout0_1ck66 FIND v(dout0_1) AT=335.025n

* CHECK dout0_2 Vdout0_2ck66 = 0.9 time = 335
.meas tran vdout0_2ck66 FIND v(dout0_2) AT=335.025n

* CHECK dout0_3 Vdout0_3ck66 = 0.9 time = 335
.meas tran vdout0_3ck66 FIND v(dout0_3) AT=335.025n

* CHECK dout0_4 Vdout0_4ck66 = 0 time = 335
.meas tran vdout0_4ck66 FIND v(dout0_4) AT=335.025n

* CHECK dout0_5 Vdout0_5ck66 = 0 time = 335
.meas tran vdout0_5ck66 FIND v(dout0_5) AT=335.025n

* CHECK dout0_6 Vdout0_6ck66 = 0 time = 335
.meas tran vdout0_6ck66 FIND v(dout0_6) AT=335.025n

* CHECK dout0_7 Vdout0_7ck66 = 0.9 time = 335
.meas tran vdout0_7ck66 FIND v(dout0_7) AT=335.025n

* CHECK dout0_8 Vdout0_8ck66 = 0 time = 335
.meas tran vdout0_8ck66 FIND v(dout0_8) AT=335.025n

* CHECK dout0_9 Vdout0_9ck66 = 0 time = 335
.meas tran vdout0_9ck66 FIND v(dout0_9) AT=335.025n

* CHECK dout0_10 Vdout0_10ck66 = 0.9 time = 335
.meas tran vdout0_10ck66 FIND v(dout0_10) AT=335.025n

* CHECK dout0_11 Vdout0_11ck66 = 0.9 time = 335
.meas tran vdout0_11ck66 FIND v(dout0_11) AT=335.025n

* CHECK dout0_12 Vdout0_12ck66 = 0 time = 335
.meas tran vdout0_12ck66 FIND v(dout0_12) AT=335.025n

* CHECK dout0_13 Vdout0_13ck66 = 0.9 time = 335
.meas tran vdout0_13ck66 FIND v(dout0_13) AT=335.025n

* CHECK dout0_14 Vdout0_14ck66 = 0.9 time = 335
.meas tran vdout0_14ck66 FIND v(dout0_14) AT=335.025n

* CHECK dout0_15 Vdout0_15ck66 = 0.9 time = 335
.meas tran vdout0_15ck66 FIND v(dout0_15) AT=335.025n

* CHECK dout0_16 Vdout0_16ck66 = 0 time = 335
.meas tran vdout0_16ck66 FIND v(dout0_16) AT=335.025n

* CHECK dout0_17 Vdout0_17ck66 = 0.9 time = 335
.meas tran vdout0_17ck66 FIND v(dout0_17) AT=335.025n

* CHECK dout0_18 Vdout0_18ck66 = 0.9 time = 335
.meas tran vdout0_18ck66 FIND v(dout0_18) AT=335.025n

* CHECK dout0_19 Vdout0_19ck66 = 0.9 time = 335
.meas tran vdout0_19ck66 FIND v(dout0_19) AT=335.025n

* CHECK dout0_20 Vdout0_20ck66 = 0 time = 335
.meas tran vdout0_20ck66 FIND v(dout0_20) AT=335.025n

* CHECK dout0_21 Vdout0_21ck66 = 0 time = 335
.meas tran vdout0_21ck66 FIND v(dout0_21) AT=335.025n

* CHECK dout0_22 Vdout0_22ck66 = 0.9 time = 335
.meas tran vdout0_22ck66 FIND v(dout0_22) AT=335.025n

* CHECK dout0_23 Vdout0_23ck66 = 0 time = 335
.meas tran vdout0_23ck66 FIND v(dout0_23) AT=335.025n

* CHECK dout0_24 Vdout0_24ck66 = 0.9 time = 335
.meas tran vdout0_24ck66 FIND v(dout0_24) AT=335.025n

* CHECK dout0_25 Vdout0_25ck66 = 0 time = 335
.meas tran vdout0_25ck66 FIND v(dout0_25) AT=335.025n

* CHECK dout0_26 Vdout0_26ck66 = 0.9 time = 335
.meas tran vdout0_26ck66 FIND v(dout0_26) AT=335.025n

* CHECK dout0_27 Vdout0_27ck66 = 0 time = 335
.meas tran vdout0_27ck66 FIND v(dout0_27) AT=335.025n

* CHECK dout0_28 Vdout0_28ck66 = 0.9 time = 335
.meas tran vdout0_28ck66 FIND v(dout0_28) AT=335.025n

* CHECK dout0_29 Vdout0_29ck66 = 0 time = 335
.meas tran vdout0_29ck66 FIND v(dout0_29) AT=335.025n

* CHECK dout0_30 Vdout0_30ck66 = 0 time = 335
.meas tran vdout0_30ck66 FIND v(dout0_30) AT=335.025n

* CHECK dout0_31 Vdout0_31ck66 = 0.9 time = 335
.meas tran vdout0_31ck66 FIND v(dout0_31) AT=335.025n

* CHECK dout0_32 Vdout0_32ck66 = 0 time = 335
.meas tran vdout0_32ck66 FIND v(dout0_32) AT=335.025n

* CHECK dout0_33 Vdout0_33ck66 = 0 time = 335
.meas tran vdout0_33ck66 FIND v(dout0_33) AT=335.025n

* CHECK dout0_34 Vdout0_34ck66 = 0 time = 335
.meas tran vdout0_34ck66 FIND v(dout0_34) AT=335.025n

* CHECK dout0_35 Vdout0_35ck66 = 0 time = 335
.meas tran vdout0_35ck66 FIND v(dout0_35) AT=335.025n

* CHECK dout0_36 Vdout0_36ck66 = 0 time = 335
.meas tran vdout0_36ck66 FIND v(dout0_36) AT=335.025n

* CHECK dout0_37 Vdout0_37ck66 = 0 time = 335
.meas tran vdout0_37ck66 FIND v(dout0_37) AT=335.025n

* CHECK dout0_38 Vdout0_38ck66 = 0.9 time = 335
.meas tran vdout0_38ck66 FIND v(dout0_38) AT=335.025n

* CHECK dout0_39 Vdout0_39ck66 = 0.9 time = 335
.meas tran vdout0_39ck66 FIND v(dout0_39) AT=335.025n

* CHECK dout0_40 Vdout0_40ck66 = 0.9 time = 335
.meas tran vdout0_40ck66 FIND v(dout0_40) AT=335.025n

* CHECK dout0_41 Vdout0_41ck66 = 0.9 time = 335
.meas tran vdout0_41ck66 FIND v(dout0_41) AT=335.025n

* CHECK dout0_42 Vdout0_42ck66 = 0.9 time = 335
.meas tran vdout0_42ck66 FIND v(dout0_42) AT=335.025n

* CHECK dout0_43 Vdout0_43ck66 = 0 time = 335
.meas tran vdout0_43ck66 FIND v(dout0_43) AT=335.025n

* CHECK dout0_44 Vdout0_44ck66 = 0.9 time = 335
.meas tran vdout0_44ck66 FIND v(dout0_44) AT=335.025n

* CHECK dout0_45 Vdout0_45ck66 = 0.9 time = 335
.meas tran vdout0_45ck66 FIND v(dout0_45) AT=335.025n

* CHECK dout0_46 Vdout0_46ck66 = 0.9 time = 335
.meas tran vdout0_46ck66 FIND v(dout0_46) AT=335.025n

* CHECK dout0_47 Vdout0_47ck66 = 0.9 time = 335
.meas tran vdout0_47ck66 FIND v(dout0_47) AT=335.025n

* CHECK dout0_48 Vdout0_48ck66 = 0 time = 335
.meas tran vdout0_48ck66 FIND v(dout0_48) AT=335.025n

* CHECK dout0_49 Vdout0_49ck66 = 0 time = 335
.meas tran vdout0_49ck66 FIND v(dout0_49) AT=335.025n

* CHECK dout0_50 Vdout0_50ck66 = 0 time = 335
.meas tran vdout0_50ck66 FIND v(dout0_50) AT=335.025n

* CHECK dout0_51 Vdout0_51ck66 = 0.9 time = 335
.meas tran vdout0_51ck66 FIND v(dout0_51) AT=335.025n

* CHECK dout0_52 Vdout0_52ck66 = 0.9 time = 335
.meas tran vdout0_52ck66 FIND v(dout0_52) AT=335.025n

* CHECK dout0_53 Vdout0_53ck66 = 0.9 time = 335
.meas tran vdout0_53ck66 FIND v(dout0_53) AT=335.025n

* CHECK dout0_54 Vdout0_54ck66 = 0 time = 335
.meas tran vdout0_54ck66 FIND v(dout0_54) AT=335.025n

* CHECK dout0_55 Vdout0_55ck66 = 0 time = 335
.meas tran vdout0_55ck66 FIND v(dout0_55) AT=335.025n

* CHECK dout0_56 Vdout0_56ck66 = 0.9 time = 335
.meas tran vdout0_56ck66 FIND v(dout0_56) AT=335.025n

* CHECK dout0_57 Vdout0_57ck66 = 0.9 time = 335
.meas tran vdout0_57ck66 FIND v(dout0_57) AT=335.025n

* CHECK dout0_58 Vdout0_58ck66 = 0.9 time = 335
.meas tran vdout0_58ck66 FIND v(dout0_58) AT=335.025n

* CHECK dout0_59 Vdout0_59ck66 = 0 time = 335
.meas tran vdout0_59ck66 FIND v(dout0_59) AT=335.025n

* CHECK dout0_60 Vdout0_60ck66 = 0 time = 335
.meas tran vdout0_60ck66 FIND v(dout0_60) AT=335.025n

* CHECK dout0_61 Vdout0_61ck66 = 0 time = 335
.meas tran vdout0_61ck66 FIND v(dout0_61) AT=335.025n

* CHECK dout0_62 Vdout0_62ck66 = 0.9 time = 335
.meas tran vdout0_62ck66 FIND v(dout0_62) AT=335.025n

* CHECK dout0_63 Vdout0_63ck66 = 0.9 time = 335
.meas tran vdout0_63ck66 FIND v(dout0_63) AT=335.025n

* CHECK dout0_64 Vdout0_64ck66 = 0 time = 335
.meas tran vdout0_64ck66 FIND v(dout0_64) AT=335.025n

* CHECK dout0_65 Vdout0_65ck66 = 0.9 time = 335
.meas tran vdout0_65ck66 FIND v(dout0_65) AT=335.025n

* CHECK dout0_66 Vdout0_66ck66 = 0 time = 335
.meas tran vdout0_66ck66 FIND v(dout0_66) AT=335.025n

* CHECK dout0_67 Vdout0_67ck66 = 0 time = 335
.meas tran vdout0_67ck66 FIND v(dout0_67) AT=335.025n

* CHECK dout0_68 Vdout0_68ck66 = 0 time = 335
.meas tran vdout0_68ck66 FIND v(dout0_68) AT=335.025n

* CHECK dout0_69 Vdout0_69ck66 = 0 time = 335
.meas tran vdout0_69ck66 FIND v(dout0_69) AT=335.025n

* CHECK dout0_70 Vdout0_70ck66 = 0 time = 335
.meas tran vdout0_70ck66 FIND v(dout0_70) AT=335.025n

* CHECK dout0_71 Vdout0_71ck66 = 0.9 time = 335
.meas tran vdout0_71ck66 FIND v(dout0_71) AT=335.025n

* CHECK dout0_72 Vdout0_72ck66 = 0.9 time = 335
.meas tran vdout0_72ck66 FIND v(dout0_72) AT=335.025n

* CHECK dout0_73 Vdout0_73ck66 = 0.9 time = 335
.meas tran vdout0_73ck66 FIND v(dout0_73) AT=335.025n

* CHECK dout0_74 Vdout0_74ck66 = 0.9 time = 335
.meas tran vdout0_74ck66 FIND v(dout0_74) AT=335.025n

* CHECK dout0_75 Vdout0_75ck66 = 0 time = 335
.meas tran vdout0_75ck66 FIND v(dout0_75) AT=335.025n

* CHECK dout0_76 Vdout0_76ck66 = 0 time = 335
.meas tran vdout0_76ck66 FIND v(dout0_76) AT=335.025n

* CHECK dout0_77 Vdout0_77ck66 = 0 time = 335
.meas tran vdout0_77ck66 FIND v(dout0_77) AT=335.025n

* CHECK dout0_78 Vdout0_78ck66 = 0.9 time = 335
.meas tran vdout0_78ck66 FIND v(dout0_78) AT=335.025n

* CHECK dout0_79 Vdout0_79ck66 = 0 time = 335
.meas tran vdout0_79ck66 FIND v(dout0_79) AT=335.025n

* CHECK dout0_80 Vdout0_80ck66 = 0.9 time = 335
.meas tran vdout0_80ck66 FIND v(dout0_80) AT=335.025n

* CHECK dout0_81 Vdout0_81ck66 = 0 time = 335
.meas tran vdout0_81ck66 FIND v(dout0_81) AT=335.025n

* CHECK dout0_82 Vdout0_82ck66 = 0.9 time = 335
.meas tran vdout0_82ck66 FIND v(dout0_82) AT=335.025n

* CHECK dout0_83 Vdout0_83ck66 = 0 time = 335
.meas tran vdout0_83ck66 FIND v(dout0_83) AT=335.025n

* CHECK dout0_84 Vdout0_84ck66 = 0 time = 335
.meas tran vdout0_84ck66 FIND v(dout0_84) AT=335.025n

* CHECK dout0_85 Vdout0_85ck66 = 0.9 time = 335
.meas tran vdout0_85ck66 FIND v(dout0_85) AT=335.025n

* CHECK dout0_86 Vdout0_86ck66 = 0.9 time = 335
.meas tran vdout0_86ck66 FIND v(dout0_86) AT=335.025n

* CHECK dout0_87 Vdout0_87ck66 = 0 time = 335
.meas tran vdout0_87ck66 FIND v(dout0_87) AT=335.025n

* CHECK dout0_0 Vdout0_0ck72 = 0 time = 365
.meas tran vdout0_0ck72 FIND v(dout0_0) AT=365.025n

* CHECK dout0_1 Vdout0_1ck72 = 0 time = 365
.meas tran vdout0_1ck72 FIND v(dout0_1) AT=365.025n

* CHECK dout0_2 Vdout0_2ck72 = 0 time = 365
.meas tran vdout0_2ck72 FIND v(dout0_2) AT=365.025n

* CHECK dout0_3 Vdout0_3ck72 = 0.9 time = 365
.meas tran vdout0_3ck72 FIND v(dout0_3) AT=365.025n

* CHECK dout0_4 Vdout0_4ck72 = 0 time = 365
.meas tran vdout0_4ck72 FIND v(dout0_4) AT=365.025n

* CHECK dout0_5 Vdout0_5ck72 = 0 time = 365
.meas tran vdout0_5ck72 FIND v(dout0_5) AT=365.025n

* CHECK dout0_6 Vdout0_6ck72 = 0 time = 365
.meas tran vdout0_6ck72 FIND v(dout0_6) AT=365.025n

* CHECK dout0_7 Vdout0_7ck72 = 0.9 time = 365
.meas tran vdout0_7ck72 FIND v(dout0_7) AT=365.025n

* CHECK dout0_8 Vdout0_8ck72 = 0 time = 365
.meas tran vdout0_8ck72 FIND v(dout0_8) AT=365.025n

* CHECK dout0_9 Vdout0_9ck72 = 0 time = 365
.meas tran vdout0_9ck72 FIND v(dout0_9) AT=365.025n

* CHECK dout0_10 Vdout0_10ck72 = 0.9 time = 365
.meas tran vdout0_10ck72 FIND v(dout0_10) AT=365.025n

* CHECK dout0_11 Vdout0_11ck72 = 0 time = 365
.meas tran vdout0_11ck72 FIND v(dout0_11) AT=365.025n

* CHECK dout0_12 Vdout0_12ck72 = 0 time = 365
.meas tran vdout0_12ck72 FIND v(dout0_12) AT=365.025n

* CHECK dout0_13 Vdout0_13ck72 = 0.9 time = 365
.meas tran vdout0_13ck72 FIND v(dout0_13) AT=365.025n

* CHECK dout0_14 Vdout0_14ck72 = 0.9 time = 365
.meas tran vdout0_14ck72 FIND v(dout0_14) AT=365.025n

* CHECK dout0_15 Vdout0_15ck72 = 0 time = 365
.meas tran vdout0_15ck72 FIND v(dout0_15) AT=365.025n

* CHECK dout0_16 Vdout0_16ck72 = 0.9 time = 365
.meas tran vdout0_16ck72 FIND v(dout0_16) AT=365.025n

* CHECK dout0_17 Vdout0_17ck72 = 0 time = 365
.meas tran vdout0_17ck72 FIND v(dout0_17) AT=365.025n

* CHECK dout0_18 Vdout0_18ck72 = 0 time = 365
.meas tran vdout0_18ck72 FIND v(dout0_18) AT=365.025n

* CHECK dout0_19 Vdout0_19ck72 = 0.9 time = 365
.meas tran vdout0_19ck72 FIND v(dout0_19) AT=365.025n

* CHECK dout0_20 Vdout0_20ck72 = 0.9 time = 365
.meas tran vdout0_20ck72 FIND v(dout0_20) AT=365.025n

* CHECK dout0_21 Vdout0_21ck72 = 0.9 time = 365
.meas tran vdout0_21ck72 FIND v(dout0_21) AT=365.025n

* CHECK dout0_22 Vdout0_22ck72 = 0.9 time = 365
.meas tran vdout0_22ck72 FIND v(dout0_22) AT=365.025n

* CHECK dout0_23 Vdout0_23ck72 = 0 time = 365
.meas tran vdout0_23ck72 FIND v(dout0_23) AT=365.025n

* CHECK dout0_24 Vdout0_24ck72 = 0.9 time = 365
.meas tran vdout0_24ck72 FIND v(dout0_24) AT=365.025n

* CHECK dout0_25 Vdout0_25ck72 = 0.9 time = 365
.meas tran vdout0_25ck72 FIND v(dout0_25) AT=365.025n

* CHECK dout0_26 Vdout0_26ck72 = 0.9 time = 365
.meas tran vdout0_26ck72 FIND v(dout0_26) AT=365.025n

* CHECK dout0_27 Vdout0_27ck72 = 0.9 time = 365
.meas tran vdout0_27ck72 FIND v(dout0_27) AT=365.025n

* CHECK dout0_28 Vdout0_28ck72 = 0 time = 365
.meas tran vdout0_28ck72 FIND v(dout0_28) AT=365.025n

* CHECK dout0_29 Vdout0_29ck72 = 0.9 time = 365
.meas tran vdout0_29ck72 FIND v(dout0_29) AT=365.025n

* CHECK dout0_30 Vdout0_30ck72 = 0 time = 365
.meas tran vdout0_30ck72 FIND v(dout0_30) AT=365.025n

* CHECK dout0_31 Vdout0_31ck72 = 0 time = 365
.meas tran vdout0_31ck72 FIND v(dout0_31) AT=365.025n

* CHECK dout0_32 Vdout0_32ck72 = 0.9 time = 365
.meas tran vdout0_32ck72 FIND v(dout0_32) AT=365.025n

* CHECK dout0_33 Vdout0_33ck72 = 0 time = 365
.meas tran vdout0_33ck72 FIND v(dout0_33) AT=365.025n

* CHECK dout0_34 Vdout0_34ck72 = 0 time = 365
.meas tran vdout0_34ck72 FIND v(dout0_34) AT=365.025n

* CHECK dout0_35 Vdout0_35ck72 = 0.9 time = 365
.meas tran vdout0_35ck72 FIND v(dout0_35) AT=365.025n

* CHECK dout0_36 Vdout0_36ck72 = 0 time = 365
.meas tran vdout0_36ck72 FIND v(dout0_36) AT=365.025n

* CHECK dout0_37 Vdout0_37ck72 = 0.9 time = 365
.meas tran vdout0_37ck72 FIND v(dout0_37) AT=365.025n

* CHECK dout0_38 Vdout0_38ck72 = 0 time = 365
.meas tran vdout0_38ck72 FIND v(dout0_38) AT=365.025n

* CHECK dout0_39 Vdout0_39ck72 = 0.9 time = 365
.meas tran vdout0_39ck72 FIND v(dout0_39) AT=365.025n

* CHECK dout0_40 Vdout0_40ck72 = 0.9 time = 365
.meas tran vdout0_40ck72 FIND v(dout0_40) AT=365.025n

* CHECK dout0_41 Vdout0_41ck72 = 0.9 time = 365
.meas tran vdout0_41ck72 FIND v(dout0_41) AT=365.025n

* CHECK dout0_42 Vdout0_42ck72 = 0.9 time = 365
.meas tran vdout0_42ck72 FIND v(dout0_42) AT=365.025n

* CHECK dout0_43 Vdout0_43ck72 = 0.9 time = 365
.meas tran vdout0_43ck72 FIND v(dout0_43) AT=365.025n

* CHECK dout0_44 Vdout0_44ck72 = 0.9 time = 365
.meas tran vdout0_44ck72 FIND v(dout0_44) AT=365.025n

* CHECK dout0_45 Vdout0_45ck72 = 0 time = 365
.meas tran vdout0_45ck72 FIND v(dout0_45) AT=365.025n

* CHECK dout0_46 Vdout0_46ck72 = 0 time = 365
.meas tran vdout0_46ck72 FIND v(dout0_46) AT=365.025n

* CHECK dout0_47 Vdout0_47ck72 = 0.9 time = 365
.meas tran vdout0_47ck72 FIND v(dout0_47) AT=365.025n

* CHECK dout0_48 Vdout0_48ck72 = 0 time = 365
.meas tran vdout0_48ck72 FIND v(dout0_48) AT=365.025n

* CHECK dout0_49 Vdout0_49ck72 = 0 time = 365
.meas tran vdout0_49ck72 FIND v(dout0_49) AT=365.025n

* CHECK dout0_50 Vdout0_50ck72 = 0.9 time = 365
.meas tran vdout0_50ck72 FIND v(dout0_50) AT=365.025n

* CHECK dout0_51 Vdout0_51ck72 = 0 time = 365
.meas tran vdout0_51ck72 FIND v(dout0_51) AT=365.025n

* CHECK dout0_52 Vdout0_52ck72 = 0.9 time = 365
.meas tran vdout0_52ck72 FIND v(dout0_52) AT=365.025n

* CHECK dout0_53 Vdout0_53ck72 = 0.9 time = 365
.meas tran vdout0_53ck72 FIND v(dout0_53) AT=365.025n

* CHECK dout0_54 Vdout0_54ck72 = 0 time = 365
.meas tran vdout0_54ck72 FIND v(dout0_54) AT=365.025n

* CHECK dout0_55 Vdout0_55ck72 = 0.9 time = 365
.meas tran vdout0_55ck72 FIND v(dout0_55) AT=365.025n

* CHECK dout0_56 Vdout0_56ck72 = 0.9 time = 365
.meas tran vdout0_56ck72 FIND v(dout0_56) AT=365.025n

* CHECK dout0_57 Vdout0_57ck72 = 0 time = 365
.meas tran vdout0_57ck72 FIND v(dout0_57) AT=365.025n

* CHECK dout0_58 Vdout0_58ck72 = 0 time = 365
.meas tran vdout0_58ck72 FIND v(dout0_58) AT=365.025n

* CHECK dout0_59 Vdout0_59ck72 = 0.9 time = 365
.meas tran vdout0_59ck72 FIND v(dout0_59) AT=365.025n

* CHECK dout0_60 Vdout0_60ck72 = 0 time = 365
.meas tran vdout0_60ck72 FIND v(dout0_60) AT=365.025n

* CHECK dout0_61 Vdout0_61ck72 = 0.9 time = 365
.meas tran vdout0_61ck72 FIND v(dout0_61) AT=365.025n

* CHECK dout0_62 Vdout0_62ck72 = 0 time = 365
.meas tran vdout0_62ck72 FIND v(dout0_62) AT=365.025n

* CHECK dout0_63 Vdout0_63ck72 = 0 time = 365
.meas tran vdout0_63ck72 FIND v(dout0_63) AT=365.025n

* CHECK dout0_64 Vdout0_64ck72 = 0.9 time = 365
.meas tran vdout0_64ck72 FIND v(dout0_64) AT=365.025n

* CHECK dout0_65 Vdout0_65ck72 = 0 time = 365
.meas tran vdout0_65ck72 FIND v(dout0_65) AT=365.025n

* CHECK dout0_66 Vdout0_66ck72 = 0 time = 365
.meas tran vdout0_66ck72 FIND v(dout0_66) AT=365.025n

* CHECK dout0_67 Vdout0_67ck72 = 0 time = 365
.meas tran vdout0_67ck72 FIND v(dout0_67) AT=365.025n

* CHECK dout0_68 Vdout0_68ck72 = 0.9 time = 365
.meas tran vdout0_68ck72 FIND v(dout0_68) AT=365.025n

* CHECK dout0_69 Vdout0_69ck72 = 0 time = 365
.meas tran vdout0_69ck72 FIND v(dout0_69) AT=365.025n

* CHECK dout0_70 Vdout0_70ck72 = 0 time = 365
.meas tran vdout0_70ck72 FIND v(dout0_70) AT=365.025n

* CHECK dout0_71 Vdout0_71ck72 = 0 time = 365
.meas tran vdout0_71ck72 FIND v(dout0_71) AT=365.025n

* CHECK dout0_72 Vdout0_72ck72 = 0.9 time = 365
.meas tran vdout0_72ck72 FIND v(dout0_72) AT=365.025n

* CHECK dout0_73 Vdout0_73ck72 = 0 time = 365
.meas tran vdout0_73ck72 FIND v(dout0_73) AT=365.025n

* CHECK dout0_74 Vdout0_74ck72 = 0.9 time = 365
.meas tran vdout0_74ck72 FIND v(dout0_74) AT=365.025n

* CHECK dout0_75 Vdout0_75ck72 = 0 time = 365
.meas tran vdout0_75ck72 FIND v(dout0_75) AT=365.025n

* CHECK dout0_76 Vdout0_76ck72 = 0 time = 365
.meas tran vdout0_76ck72 FIND v(dout0_76) AT=365.025n

* CHECK dout0_77 Vdout0_77ck72 = 0.9 time = 365
.meas tran vdout0_77ck72 FIND v(dout0_77) AT=365.025n

* CHECK dout0_78 Vdout0_78ck72 = 0 time = 365
.meas tran vdout0_78ck72 FIND v(dout0_78) AT=365.025n

* CHECK dout0_79 Vdout0_79ck72 = 0 time = 365
.meas tran vdout0_79ck72 FIND v(dout0_79) AT=365.025n

* CHECK dout0_80 Vdout0_80ck72 = 0.9 time = 365
.meas tran vdout0_80ck72 FIND v(dout0_80) AT=365.025n

* CHECK dout0_81 Vdout0_81ck72 = 0 time = 365
.meas tran vdout0_81ck72 FIND v(dout0_81) AT=365.025n

* CHECK dout0_82 Vdout0_82ck72 = 0 time = 365
.meas tran vdout0_82ck72 FIND v(dout0_82) AT=365.025n

* CHECK dout0_83 Vdout0_83ck72 = 0 time = 365
.meas tran vdout0_83ck72 FIND v(dout0_83) AT=365.025n

* CHECK dout0_84 Vdout0_84ck72 = 0 time = 365
.meas tran vdout0_84ck72 FIND v(dout0_84) AT=365.025n

* CHECK dout0_85 Vdout0_85ck72 = 0 time = 365
.meas tran vdout0_85ck72 FIND v(dout0_85) AT=365.025n

* CHECK dout0_86 Vdout0_86ck72 = 0 time = 365
.meas tran vdout0_86ck72 FIND v(dout0_86) AT=365.025n

* CHECK dout0_87 Vdout0_87ck72 = 0.9 time = 365
.meas tran vdout0_87ck72 FIND v(dout0_87) AT=365.025n

* CHECK dout0_0 Vdout0_0ck77 = 0 time = 390
.meas tran vdout0_0ck77 FIND v(dout0_0) AT=390.025n

* CHECK dout0_1 Vdout0_1ck77 = 0.9 time = 390
.meas tran vdout0_1ck77 FIND v(dout0_1) AT=390.025n

* CHECK dout0_2 Vdout0_2ck77 = 0.9 time = 390
.meas tran vdout0_2ck77 FIND v(dout0_2) AT=390.025n

* CHECK dout0_3 Vdout0_3ck77 = 0 time = 390
.meas tran vdout0_3ck77 FIND v(dout0_3) AT=390.025n

* CHECK dout0_4 Vdout0_4ck77 = 0 time = 390
.meas tran vdout0_4ck77 FIND v(dout0_4) AT=390.025n

* CHECK dout0_5 Vdout0_5ck77 = 0 time = 390
.meas tran vdout0_5ck77 FIND v(dout0_5) AT=390.025n

* CHECK dout0_6 Vdout0_6ck77 = 0.9 time = 390
.meas tran vdout0_6ck77 FIND v(dout0_6) AT=390.025n

* CHECK dout0_7 Vdout0_7ck77 = 0 time = 390
.meas tran vdout0_7ck77 FIND v(dout0_7) AT=390.025n

* CHECK dout0_8 Vdout0_8ck77 = 0 time = 390
.meas tran vdout0_8ck77 FIND v(dout0_8) AT=390.025n

* CHECK dout0_9 Vdout0_9ck77 = 0 time = 390
.meas tran vdout0_9ck77 FIND v(dout0_9) AT=390.025n

* CHECK dout0_10 Vdout0_10ck77 = 0 time = 390
.meas tran vdout0_10ck77 FIND v(dout0_10) AT=390.025n

* CHECK dout0_11 Vdout0_11ck77 = 0 time = 390
.meas tran vdout0_11ck77 FIND v(dout0_11) AT=390.025n

* CHECK dout0_12 Vdout0_12ck77 = 0.9 time = 390
.meas tran vdout0_12ck77 FIND v(dout0_12) AT=390.025n

* CHECK dout0_13 Vdout0_13ck77 = 0.9 time = 390
.meas tran vdout0_13ck77 FIND v(dout0_13) AT=390.025n

* CHECK dout0_14 Vdout0_14ck77 = 0.9 time = 390
.meas tran vdout0_14ck77 FIND v(dout0_14) AT=390.025n

* CHECK dout0_15 Vdout0_15ck77 = 0.9 time = 390
.meas tran vdout0_15ck77 FIND v(dout0_15) AT=390.025n

* CHECK dout0_16 Vdout0_16ck77 = 0 time = 390
.meas tran vdout0_16ck77 FIND v(dout0_16) AT=390.025n

* CHECK dout0_17 Vdout0_17ck77 = 0 time = 390
.meas tran vdout0_17ck77 FIND v(dout0_17) AT=390.025n

* CHECK dout0_18 Vdout0_18ck77 = 0 time = 390
.meas tran vdout0_18ck77 FIND v(dout0_18) AT=390.025n

* CHECK dout0_19 Vdout0_19ck77 = 0 time = 390
.meas tran vdout0_19ck77 FIND v(dout0_19) AT=390.025n

* CHECK dout0_20 Vdout0_20ck77 = 0 time = 390
.meas tran vdout0_20ck77 FIND v(dout0_20) AT=390.025n

* CHECK dout0_21 Vdout0_21ck77 = 0 time = 390
.meas tran vdout0_21ck77 FIND v(dout0_21) AT=390.025n

* CHECK dout0_22 Vdout0_22ck77 = 0 time = 390
.meas tran vdout0_22ck77 FIND v(dout0_22) AT=390.025n

* CHECK dout0_23 Vdout0_23ck77 = 0.9 time = 390
.meas tran vdout0_23ck77 FIND v(dout0_23) AT=390.025n

* CHECK dout0_24 Vdout0_24ck77 = 0.9 time = 390
.meas tran vdout0_24ck77 FIND v(dout0_24) AT=390.025n

* CHECK dout0_25 Vdout0_25ck77 = 0 time = 390
.meas tran vdout0_25ck77 FIND v(dout0_25) AT=390.025n

* CHECK dout0_26 Vdout0_26ck77 = 0.9 time = 390
.meas tran vdout0_26ck77 FIND v(dout0_26) AT=390.025n

* CHECK dout0_27 Vdout0_27ck77 = 0.9 time = 390
.meas tran vdout0_27ck77 FIND v(dout0_27) AT=390.025n

* CHECK dout0_28 Vdout0_28ck77 = 0.9 time = 390
.meas tran vdout0_28ck77 FIND v(dout0_28) AT=390.025n

* CHECK dout0_29 Vdout0_29ck77 = 0 time = 390
.meas tran vdout0_29ck77 FIND v(dout0_29) AT=390.025n

* CHECK dout0_30 Vdout0_30ck77 = 0.9 time = 390
.meas tran vdout0_30ck77 FIND v(dout0_30) AT=390.025n

* CHECK dout0_31 Vdout0_31ck77 = 0 time = 390
.meas tran vdout0_31ck77 FIND v(dout0_31) AT=390.025n

* CHECK dout0_32 Vdout0_32ck77 = 0.9 time = 390
.meas tran vdout0_32ck77 FIND v(dout0_32) AT=390.025n

* CHECK dout0_33 Vdout0_33ck77 = 0.9 time = 390
.meas tran vdout0_33ck77 FIND v(dout0_33) AT=390.025n

* CHECK dout0_34 Vdout0_34ck77 = 0.9 time = 390
.meas tran vdout0_34ck77 FIND v(dout0_34) AT=390.025n

* CHECK dout0_35 Vdout0_35ck77 = 0.9 time = 390
.meas tran vdout0_35ck77 FIND v(dout0_35) AT=390.025n

* CHECK dout0_36 Vdout0_36ck77 = 0.9 time = 390
.meas tran vdout0_36ck77 FIND v(dout0_36) AT=390.025n

* CHECK dout0_37 Vdout0_37ck77 = 0 time = 390
.meas tran vdout0_37ck77 FIND v(dout0_37) AT=390.025n

* CHECK dout0_38 Vdout0_38ck77 = 0.9 time = 390
.meas tran vdout0_38ck77 FIND v(dout0_38) AT=390.025n

* CHECK dout0_39 Vdout0_39ck77 = 0.9 time = 390
.meas tran vdout0_39ck77 FIND v(dout0_39) AT=390.025n

* CHECK dout0_40 Vdout0_40ck77 = 0.9 time = 390
.meas tran vdout0_40ck77 FIND v(dout0_40) AT=390.025n

* CHECK dout0_41 Vdout0_41ck77 = 0 time = 390
.meas tran vdout0_41ck77 FIND v(dout0_41) AT=390.025n

* CHECK dout0_42 Vdout0_42ck77 = 0 time = 390
.meas tran vdout0_42ck77 FIND v(dout0_42) AT=390.025n

* CHECK dout0_43 Vdout0_43ck77 = 0 time = 390
.meas tran vdout0_43ck77 FIND v(dout0_43) AT=390.025n

* CHECK dout0_44 Vdout0_44ck77 = 0.9 time = 390
.meas tran vdout0_44ck77 FIND v(dout0_44) AT=390.025n

* CHECK dout0_45 Vdout0_45ck77 = 0 time = 390
.meas tran vdout0_45ck77 FIND v(dout0_45) AT=390.025n

* CHECK dout0_46 Vdout0_46ck77 = 0.9 time = 390
.meas tran vdout0_46ck77 FIND v(dout0_46) AT=390.025n

* CHECK dout0_47 Vdout0_47ck77 = 0 time = 390
.meas tran vdout0_47ck77 FIND v(dout0_47) AT=390.025n

* CHECK dout0_48 Vdout0_48ck77 = 0.9 time = 390
.meas tran vdout0_48ck77 FIND v(dout0_48) AT=390.025n

* CHECK dout0_49 Vdout0_49ck77 = 0.9 time = 390
.meas tran vdout0_49ck77 FIND v(dout0_49) AT=390.025n

* CHECK dout0_50 Vdout0_50ck77 = 0 time = 390
.meas tran vdout0_50ck77 FIND v(dout0_50) AT=390.025n

* CHECK dout0_51 Vdout0_51ck77 = 0.9 time = 390
.meas tran vdout0_51ck77 FIND v(dout0_51) AT=390.025n

* CHECK dout0_52 Vdout0_52ck77 = 0 time = 390
.meas tran vdout0_52ck77 FIND v(dout0_52) AT=390.025n

* CHECK dout0_53 Vdout0_53ck77 = 0 time = 390
.meas tran vdout0_53ck77 FIND v(dout0_53) AT=390.025n

* CHECK dout0_54 Vdout0_54ck77 = 0.9 time = 390
.meas tran vdout0_54ck77 FIND v(dout0_54) AT=390.025n

* CHECK dout0_55 Vdout0_55ck77 = 0.9 time = 390
.meas tran vdout0_55ck77 FIND v(dout0_55) AT=390.025n

* CHECK dout0_56 Vdout0_56ck77 = 0.9 time = 390
.meas tran vdout0_56ck77 FIND v(dout0_56) AT=390.025n

* CHECK dout0_57 Vdout0_57ck77 = 0 time = 390
.meas tran vdout0_57ck77 FIND v(dout0_57) AT=390.025n

* CHECK dout0_58 Vdout0_58ck77 = 0.9 time = 390
.meas tran vdout0_58ck77 FIND v(dout0_58) AT=390.025n

* CHECK dout0_59 Vdout0_59ck77 = 0.9 time = 390
.meas tran vdout0_59ck77 FIND v(dout0_59) AT=390.025n

* CHECK dout0_60 Vdout0_60ck77 = 0.9 time = 390
.meas tran vdout0_60ck77 FIND v(dout0_60) AT=390.025n

* CHECK dout0_61 Vdout0_61ck77 = 0 time = 390
.meas tran vdout0_61ck77 FIND v(dout0_61) AT=390.025n

* CHECK dout0_62 Vdout0_62ck77 = 0 time = 390
.meas tran vdout0_62ck77 FIND v(dout0_62) AT=390.025n

* CHECK dout0_63 Vdout0_63ck77 = 0 time = 390
.meas tran vdout0_63ck77 FIND v(dout0_63) AT=390.025n

* CHECK dout0_64 Vdout0_64ck77 = 0.9 time = 390
.meas tran vdout0_64ck77 FIND v(dout0_64) AT=390.025n

* CHECK dout0_65 Vdout0_65ck77 = 0 time = 390
.meas tran vdout0_65ck77 FIND v(dout0_65) AT=390.025n

* CHECK dout0_66 Vdout0_66ck77 = 0 time = 390
.meas tran vdout0_66ck77 FIND v(dout0_66) AT=390.025n

* CHECK dout0_67 Vdout0_67ck77 = 0 time = 390
.meas tran vdout0_67ck77 FIND v(dout0_67) AT=390.025n

* CHECK dout0_68 Vdout0_68ck77 = 0 time = 390
.meas tran vdout0_68ck77 FIND v(dout0_68) AT=390.025n

* CHECK dout0_69 Vdout0_69ck77 = 0 time = 390
.meas tran vdout0_69ck77 FIND v(dout0_69) AT=390.025n

* CHECK dout0_70 Vdout0_70ck77 = 0.9 time = 390
.meas tran vdout0_70ck77 FIND v(dout0_70) AT=390.025n

* CHECK dout0_71 Vdout0_71ck77 = 0.9 time = 390
.meas tran vdout0_71ck77 FIND v(dout0_71) AT=390.025n

* CHECK dout0_72 Vdout0_72ck77 = 0 time = 390
.meas tran vdout0_72ck77 FIND v(dout0_72) AT=390.025n

* CHECK dout0_73 Vdout0_73ck77 = 0 time = 390
.meas tran vdout0_73ck77 FIND v(dout0_73) AT=390.025n

* CHECK dout0_74 Vdout0_74ck77 = 0.9 time = 390
.meas tran vdout0_74ck77 FIND v(dout0_74) AT=390.025n

* CHECK dout0_75 Vdout0_75ck77 = 0.9 time = 390
.meas tran vdout0_75ck77 FIND v(dout0_75) AT=390.025n

* CHECK dout0_76 Vdout0_76ck77 = 0.9 time = 390
.meas tran vdout0_76ck77 FIND v(dout0_76) AT=390.025n

* CHECK dout0_77 Vdout0_77ck77 = 0 time = 390
.meas tran vdout0_77ck77 FIND v(dout0_77) AT=390.025n

* CHECK dout0_78 Vdout0_78ck77 = 0.9 time = 390
.meas tran vdout0_78ck77 FIND v(dout0_78) AT=390.025n

* CHECK dout0_79 Vdout0_79ck77 = 0 time = 390
.meas tran vdout0_79ck77 FIND v(dout0_79) AT=390.025n

* CHECK dout0_80 Vdout0_80ck77 = 0.9 time = 390
.meas tran vdout0_80ck77 FIND v(dout0_80) AT=390.025n

* CHECK dout0_81 Vdout0_81ck77 = 0 time = 390
.meas tran vdout0_81ck77 FIND v(dout0_81) AT=390.025n

* CHECK dout0_82 Vdout0_82ck77 = 0 time = 390
.meas tran vdout0_82ck77 FIND v(dout0_82) AT=390.025n

* CHECK dout0_83 Vdout0_83ck77 = 0 time = 390
.meas tran vdout0_83ck77 FIND v(dout0_83) AT=390.025n

* CHECK dout0_84 Vdout0_84ck77 = 0 time = 390
.meas tran vdout0_84ck77 FIND v(dout0_84) AT=390.025n

* CHECK dout0_85 Vdout0_85ck77 = 0 time = 390
.meas tran vdout0_85ck77 FIND v(dout0_85) AT=390.025n

* CHECK dout0_86 Vdout0_86ck77 = 0 time = 390
.meas tran vdout0_86ck77 FIND v(dout0_86) AT=390.025n

* CHECK dout0_87 Vdout0_87ck77 = 0.9 time = 390
.meas tran vdout0_87ck77 FIND v(dout0_87) AT=390.025n

* CHECK dout0_0 Vdout0_0ck79 = 0 time = 400
.meas tran vdout0_0ck79 FIND v(dout0_0) AT=400.025n

* CHECK dout0_1 Vdout0_1ck79 = 0.9 time = 400
.meas tran vdout0_1ck79 FIND v(dout0_1) AT=400.025n

* CHECK dout0_2 Vdout0_2ck79 = 0.9 time = 400
.meas tran vdout0_2ck79 FIND v(dout0_2) AT=400.025n

* CHECK dout0_3 Vdout0_3ck79 = 0 time = 400
.meas tran vdout0_3ck79 FIND v(dout0_3) AT=400.025n

* CHECK dout0_4 Vdout0_4ck79 = 0 time = 400
.meas tran vdout0_4ck79 FIND v(dout0_4) AT=400.025n

* CHECK dout0_5 Vdout0_5ck79 = 0 time = 400
.meas tran vdout0_5ck79 FIND v(dout0_5) AT=400.025n

* CHECK dout0_6 Vdout0_6ck79 = 0.9 time = 400
.meas tran vdout0_6ck79 FIND v(dout0_6) AT=400.025n

* CHECK dout0_7 Vdout0_7ck79 = 0 time = 400
.meas tran vdout0_7ck79 FIND v(dout0_7) AT=400.025n

* CHECK dout0_8 Vdout0_8ck79 = 0 time = 400
.meas tran vdout0_8ck79 FIND v(dout0_8) AT=400.025n

* CHECK dout0_9 Vdout0_9ck79 = 0 time = 400
.meas tran vdout0_9ck79 FIND v(dout0_9) AT=400.025n

* CHECK dout0_10 Vdout0_10ck79 = 0 time = 400
.meas tran vdout0_10ck79 FIND v(dout0_10) AT=400.025n

* CHECK dout0_11 Vdout0_11ck79 = 0 time = 400
.meas tran vdout0_11ck79 FIND v(dout0_11) AT=400.025n

* CHECK dout0_12 Vdout0_12ck79 = 0.9 time = 400
.meas tran vdout0_12ck79 FIND v(dout0_12) AT=400.025n

* CHECK dout0_13 Vdout0_13ck79 = 0.9 time = 400
.meas tran vdout0_13ck79 FIND v(dout0_13) AT=400.025n

* CHECK dout0_14 Vdout0_14ck79 = 0.9 time = 400
.meas tran vdout0_14ck79 FIND v(dout0_14) AT=400.025n

* CHECK dout0_15 Vdout0_15ck79 = 0.9 time = 400
.meas tran vdout0_15ck79 FIND v(dout0_15) AT=400.025n

* CHECK dout0_16 Vdout0_16ck79 = 0 time = 400
.meas tran vdout0_16ck79 FIND v(dout0_16) AT=400.025n

* CHECK dout0_17 Vdout0_17ck79 = 0 time = 400
.meas tran vdout0_17ck79 FIND v(dout0_17) AT=400.025n

* CHECK dout0_18 Vdout0_18ck79 = 0 time = 400
.meas tran vdout0_18ck79 FIND v(dout0_18) AT=400.025n

* CHECK dout0_19 Vdout0_19ck79 = 0 time = 400
.meas tran vdout0_19ck79 FIND v(dout0_19) AT=400.025n

* CHECK dout0_20 Vdout0_20ck79 = 0 time = 400
.meas tran vdout0_20ck79 FIND v(dout0_20) AT=400.025n

* CHECK dout0_21 Vdout0_21ck79 = 0 time = 400
.meas tran vdout0_21ck79 FIND v(dout0_21) AT=400.025n

* CHECK dout0_22 Vdout0_22ck79 = 0 time = 400
.meas tran vdout0_22ck79 FIND v(dout0_22) AT=400.025n

* CHECK dout0_23 Vdout0_23ck79 = 0.9 time = 400
.meas tran vdout0_23ck79 FIND v(dout0_23) AT=400.025n

* CHECK dout0_24 Vdout0_24ck79 = 0.9 time = 400
.meas tran vdout0_24ck79 FIND v(dout0_24) AT=400.025n

* CHECK dout0_25 Vdout0_25ck79 = 0 time = 400
.meas tran vdout0_25ck79 FIND v(dout0_25) AT=400.025n

* CHECK dout0_26 Vdout0_26ck79 = 0.9 time = 400
.meas tran vdout0_26ck79 FIND v(dout0_26) AT=400.025n

* CHECK dout0_27 Vdout0_27ck79 = 0.9 time = 400
.meas tran vdout0_27ck79 FIND v(dout0_27) AT=400.025n

* CHECK dout0_28 Vdout0_28ck79 = 0.9 time = 400
.meas tran vdout0_28ck79 FIND v(dout0_28) AT=400.025n

* CHECK dout0_29 Vdout0_29ck79 = 0 time = 400
.meas tran vdout0_29ck79 FIND v(dout0_29) AT=400.025n

* CHECK dout0_30 Vdout0_30ck79 = 0.9 time = 400
.meas tran vdout0_30ck79 FIND v(dout0_30) AT=400.025n

* CHECK dout0_31 Vdout0_31ck79 = 0 time = 400
.meas tran vdout0_31ck79 FIND v(dout0_31) AT=400.025n

* CHECK dout0_32 Vdout0_32ck79 = 0.9 time = 400
.meas tran vdout0_32ck79 FIND v(dout0_32) AT=400.025n

* CHECK dout0_33 Vdout0_33ck79 = 0.9 time = 400
.meas tran vdout0_33ck79 FIND v(dout0_33) AT=400.025n

* CHECK dout0_34 Vdout0_34ck79 = 0.9 time = 400
.meas tran vdout0_34ck79 FIND v(dout0_34) AT=400.025n

* CHECK dout0_35 Vdout0_35ck79 = 0.9 time = 400
.meas tran vdout0_35ck79 FIND v(dout0_35) AT=400.025n

* CHECK dout0_36 Vdout0_36ck79 = 0.9 time = 400
.meas tran vdout0_36ck79 FIND v(dout0_36) AT=400.025n

* CHECK dout0_37 Vdout0_37ck79 = 0 time = 400
.meas tran vdout0_37ck79 FIND v(dout0_37) AT=400.025n

* CHECK dout0_38 Vdout0_38ck79 = 0.9 time = 400
.meas tran vdout0_38ck79 FIND v(dout0_38) AT=400.025n

* CHECK dout0_39 Vdout0_39ck79 = 0.9 time = 400
.meas tran vdout0_39ck79 FIND v(dout0_39) AT=400.025n

* CHECK dout0_40 Vdout0_40ck79 = 0.9 time = 400
.meas tran vdout0_40ck79 FIND v(dout0_40) AT=400.025n

* CHECK dout0_41 Vdout0_41ck79 = 0 time = 400
.meas tran vdout0_41ck79 FIND v(dout0_41) AT=400.025n

* CHECK dout0_42 Vdout0_42ck79 = 0 time = 400
.meas tran vdout0_42ck79 FIND v(dout0_42) AT=400.025n

* CHECK dout0_43 Vdout0_43ck79 = 0 time = 400
.meas tran vdout0_43ck79 FIND v(dout0_43) AT=400.025n

* CHECK dout0_44 Vdout0_44ck79 = 0.9 time = 400
.meas tran vdout0_44ck79 FIND v(dout0_44) AT=400.025n

* CHECK dout0_45 Vdout0_45ck79 = 0 time = 400
.meas tran vdout0_45ck79 FIND v(dout0_45) AT=400.025n

* CHECK dout0_46 Vdout0_46ck79 = 0.9 time = 400
.meas tran vdout0_46ck79 FIND v(dout0_46) AT=400.025n

* CHECK dout0_47 Vdout0_47ck79 = 0 time = 400
.meas tran vdout0_47ck79 FIND v(dout0_47) AT=400.025n

* CHECK dout0_48 Vdout0_48ck79 = 0.9 time = 400
.meas tran vdout0_48ck79 FIND v(dout0_48) AT=400.025n

* CHECK dout0_49 Vdout0_49ck79 = 0.9 time = 400
.meas tran vdout0_49ck79 FIND v(dout0_49) AT=400.025n

* CHECK dout0_50 Vdout0_50ck79 = 0 time = 400
.meas tran vdout0_50ck79 FIND v(dout0_50) AT=400.025n

* CHECK dout0_51 Vdout0_51ck79 = 0.9 time = 400
.meas tran vdout0_51ck79 FIND v(dout0_51) AT=400.025n

* CHECK dout0_52 Vdout0_52ck79 = 0 time = 400
.meas tran vdout0_52ck79 FIND v(dout0_52) AT=400.025n

* CHECK dout0_53 Vdout0_53ck79 = 0 time = 400
.meas tran vdout0_53ck79 FIND v(dout0_53) AT=400.025n

* CHECK dout0_54 Vdout0_54ck79 = 0.9 time = 400
.meas tran vdout0_54ck79 FIND v(dout0_54) AT=400.025n

* CHECK dout0_55 Vdout0_55ck79 = 0.9 time = 400
.meas tran vdout0_55ck79 FIND v(dout0_55) AT=400.025n

* CHECK dout0_56 Vdout0_56ck79 = 0.9 time = 400
.meas tran vdout0_56ck79 FIND v(dout0_56) AT=400.025n

* CHECK dout0_57 Vdout0_57ck79 = 0 time = 400
.meas tran vdout0_57ck79 FIND v(dout0_57) AT=400.025n

* CHECK dout0_58 Vdout0_58ck79 = 0.9 time = 400
.meas tran vdout0_58ck79 FIND v(dout0_58) AT=400.025n

* CHECK dout0_59 Vdout0_59ck79 = 0.9 time = 400
.meas tran vdout0_59ck79 FIND v(dout0_59) AT=400.025n

* CHECK dout0_60 Vdout0_60ck79 = 0.9 time = 400
.meas tran vdout0_60ck79 FIND v(dout0_60) AT=400.025n

* CHECK dout0_61 Vdout0_61ck79 = 0 time = 400
.meas tran vdout0_61ck79 FIND v(dout0_61) AT=400.025n

* CHECK dout0_62 Vdout0_62ck79 = 0 time = 400
.meas tran vdout0_62ck79 FIND v(dout0_62) AT=400.025n

* CHECK dout0_63 Vdout0_63ck79 = 0 time = 400
.meas tran vdout0_63ck79 FIND v(dout0_63) AT=400.025n

* CHECK dout0_64 Vdout0_64ck79 = 0.9 time = 400
.meas tran vdout0_64ck79 FIND v(dout0_64) AT=400.025n

* CHECK dout0_65 Vdout0_65ck79 = 0 time = 400
.meas tran vdout0_65ck79 FIND v(dout0_65) AT=400.025n

* CHECK dout0_66 Vdout0_66ck79 = 0 time = 400
.meas tran vdout0_66ck79 FIND v(dout0_66) AT=400.025n

* CHECK dout0_67 Vdout0_67ck79 = 0 time = 400
.meas tran vdout0_67ck79 FIND v(dout0_67) AT=400.025n

* CHECK dout0_68 Vdout0_68ck79 = 0 time = 400
.meas tran vdout0_68ck79 FIND v(dout0_68) AT=400.025n

* CHECK dout0_69 Vdout0_69ck79 = 0 time = 400
.meas tran vdout0_69ck79 FIND v(dout0_69) AT=400.025n

* CHECK dout0_70 Vdout0_70ck79 = 0.9 time = 400
.meas tran vdout0_70ck79 FIND v(dout0_70) AT=400.025n

* CHECK dout0_71 Vdout0_71ck79 = 0.9 time = 400
.meas tran vdout0_71ck79 FIND v(dout0_71) AT=400.025n

* CHECK dout0_72 Vdout0_72ck79 = 0 time = 400
.meas tran vdout0_72ck79 FIND v(dout0_72) AT=400.025n

* CHECK dout0_73 Vdout0_73ck79 = 0 time = 400
.meas tran vdout0_73ck79 FIND v(dout0_73) AT=400.025n

* CHECK dout0_74 Vdout0_74ck79 = 0.9 time = 400
.meas tran vdout0_74ck79 FIND v(dout0_74) AT=400.025n

* CHECK dout0_75 Vdout0_75ck79 = 0.9 time = 400
.meas tran vdout0_75ck79 FIND v(dout0_75) AT=400.025n

* CHECK dout0_76 Vdout0_76ck79 = 0.9 time = 400
.meas tran vdout0_76ck79 FIND v(dout0_76) AT=400.025n

* CHECK dout0_77 Vdout0_77ck79 = 0 time = 400
.meas tran vdout0_77ck79 FIND v(dout0_77) AT=400.025n

* CHECK dout0_78 Vdout0_78ck79 = 0.9 time = 400
.meas tran vdout0_78ck79 FIND v(dout0_78) AT=400.025n

* CHECK dout0_79 Vdout0_79ck79 = 0 time = 400
.meas tran vdout0_79ck79 FIND v(dout0_79) AT=400.025n

* CHECK dout0_80 Vdout0_80ck79 = 0.9 time = 400
.meas tran vdout0_80ck79 FIND v(dout0_80) AT=400.025n

* CHECK dout0_81 Vdout0_81ck79 = 0 time = 400
.meas tran vdout0_81ck79 FIND v(dout0_81) AT=400.025n

* CHECK dout0_82 Vdout0_82ck79 = 0 time = 400
.meas tran vdout0_82ck79 FIND v(dout0_82) AT=400.025n

* CHECK dout0_83 Vdout0_83ck79 = 0 time = 400
.meas tran vdout0_83ck79 FIND v(dout0_83) AT=400.025n

* CHECK dout0_84 Vdout0_84ck79 = 0 time = 400
.meas tran vdout0_84ck79 FIND v(dout0_84) AT=400.025n

* CHECK dout0_85 Vdout0_85ck79 = 0 time = 400
.meas tran vdout0_85ck79 FIND v(dout0_85) AT=400.025n

* CHECK dout0_86 Vdout0_86ck79 = 0 time = 400
.meas tran vdout0_86ck79 FIND v(dout0_86) AT=400.025n

* CHECK dout0_87 Vdout0_87ck79 = 0.9 time = 400
.meas tran vdout0_87ck79 FIND v(dout0_87) AT=400.025n

* CHECK dout0_0 Vdout0_0ck83 = 0 time = 420
.meas tran vdout0_0ck83 FIND v(dout0_0) AT=420.025n

* CHECK dout0_1 Vdout0_1ck83 = 0.9 time = 420
.meas tran vdout0_1ck83 FIND v(dout0_1) AT=420.025n

* CHECK dout0_2 Vdout0_2ck83 = 0.9 time = 420
.meas tran vdout0_2ck83 FIND v(dout0_2) AT=420.025n

* CHECK dout0_3 Vdout0_3ck83 = 0 time = 420
.meas tran vdout0_3ck83 FIND v(dout0_3) AT=420.025n

* CHECK dout0_4 Vdout0_4ck83 = 0 time = 420
.meas tran vdout0_4ck83 FIND v(dout0_4) AT=420.025n

* CHECK dout0_5 Vdout0_5ck83 = 0 time = 420
.meas tran vdout0_5ck83 FIND v(dout0_5) AT=420.025n

* CHECK dout0_6 Vdout0_6ck83 = 0.9 time = 420
.meas tran vdout0_6ck83 FIND v(dout0_6) AT=420.025n

* CHECK dout0_7 Vdout0_7ck83 = 0 time = 420
.meas tran vdout0_7ck83 FIND v(dout0_7) AT=420.025n

* CHECK dout0_8 Vdout0_8ck83 = 0 time = 420
.meas tran vdout0_8ck83 FIND v(dout0_8) AT=420.025n

* CHECK dout0_9 Vdout0_9ck83 = 0 time = 420
.meas tran vdout0_9ck83 FIND v(dout0_9) AT=420.025n

* CHECK dout0_10 Vdout0_10ck83 = 0 time = 420
.meas tran vdout0_10ck83 FIND v(dout0_10) AT=420.025n

* CHECK dout0_11 Vdout0_11ck83 = 0 time = 420
.meas tran vdout0_11ck83 FIND v(dout0_11) AT=420.025n

* CHECK dout0_12 Vdout0_12ck83 = 0.9 time = 420
.meas tran vdout0_12ck83 FIND v(dout0_12) AT=420.025n

* CHECK dout0_13 Vdout0_13ck83 = 0.9 time = 420
.meas tran vdout0_13ck83 FIND v(dout0_13) AT=420.025n

* CHECK dout0_14 Vdout0_14ck83 = 0.9 time = 420
.meas tran vdout0_14ck83 FIND v(dout0_14) AT=420.025n

* CHECK dout0_15 Vdout0_15ck83 = 0.9 time = 420
.meas tran vdout0_15ck83 FIND v(dout0_15) AT=420.025n

* CHECK dout0_16 Vdout0_16ck83 = 0 time = 420
.meas tran vdout0_16ck83 FIND v(dout0_16) AT=420.025n

* CHECK dout0_17 Vdout0_17ck83 = 0 time = 420
.meas tran vdout0_17ck83 FIND v(dout0_17) AT=420.025n

* CHECK dout0_18 Vdout0_18ck83 = 0 time = 420
.meas tran vdout0_18ck83 FIND v(dout0_18) AT=420.025n

* CHECK dout0_19 Vdout0_19ck83 = 0 time = 420
.meas tran vdout0_19ck83 FIND v(dout0_19) AT=420.025n

* CHECK dout0_20 Vdout0_20ck83 = 0 time = 420
.meas tran vdout0_20ck83 FIND v(dout0_20) AT=420.025n

* CHECK dout0_21 Vdout0_21ck83 = 0 time = 420
.meas tran vdout0_21ck83 FIND v(dout0_21) AT=420.025n

* CHECK dout0_22 Vdout0_22ck83 = 0 time = 420
.meas tran vdout0_22ck83 FIND v(dout0_22) AT=420.025n

* CHECK dout0_23 Vdout0_23ck83 = 0.9 time = 420
.meas tran vdout0_23ck83 FIND v(dout0_23) AT=420.025n

* CHECK dout0_24 Vdout0_24ck83 = 0.9 time = 420
.meas tran vdout0_24ck83 FIND v(dout0_24) AT=420.025n

* CHECK dout0_25 Vdout0_25ck83 = 0 time = 420
.meas tran vdout0_25ck83 FIND v(dout0_25) AT=420.025n

* CHECK dout0_26 Vdout0_26ck83 = 0.9 time = 420
.meas tran vdout0_26ck83 FIND v(dout0_26) AT=420.025n

* CHECK dout0_27 Vdout0_27ck83 = 0.9 time = 420
.meas tran vdout0_27ck83 FIND v(dout0_27) AT=420.025n

* CHECK dout0_28 Vdout0_28ck83 = 0.9 time = 420
.meas tran vdout0_28ck83 FIND v(dout0_28) AT=420.025n

* CHECK dout0_29 Vdout0_29ck83 = 0 time = 420
.meas tran vdout0_29ck83 FIND v(dout0_29) AT=420.025n

* CHECK dout0_30 Vdout0_30ck83 = 0.9 time = 420
.meas tran vdout0_30ck83 FIND v(dout0_30) AT=420.025n

* CHECK dout0_31 Vdout0_31ck83 = 0 time = 420
.meas tran vdout0_31ck83 FIND v(dout0_31) AT=420.025n

* CHECK dout0_32 Vdout0_32ck83 = 0.9 time = 420
.meas tran vdout0_32ck83 FIND v(dout0_32) AT=420.025n

* CHECK dout0_33 Vdout0_33ck83 = 0.9 time = 420
.meas tran vdout0_33ck83 FIND v(dout0_33) AT=420.025n

* CHECK dout0_34 Vdout0_34ck83 = 0.9 time = 420
.meas tran vdout0_34ck83 FIND v(dout0_34) AT=420.025n

* CHECK dout0_35 Vdout0_35ck83 = 0.9 time = 420
.meas tran vdout0_35ck83 FIND v(dout0_35) AT=420.025n

* CHECK dout0_36 Vdout0_36ck83 = 0.9 time = 420
.meas tran vdout0_36ck83 FIND v(dout0_36) AT=420.025n

* CHECK dout0_37 Vdout0_37ck83 = 0 time = 420
.meas tran vdout0_37ck83 FIND v(dout0_37) AT=420.025n

* CHECK dout0_38 Vdout0_38ck83 = 0.9 time = 420
.meas tran vdout0_38ck83 FIND v(dout0_38) AT=420.025n

* CHECK dout0_39 Vdout0_39ck83 = 0.9 time = 420
.meas tran vdout0_39ck83 FIND v(dout0_39) AT=420.025n

* CHECK dout0_40 Vdout0_40ck83 = 0.9 time = 420
.meas tran vdout0_40ck83 FIND v(dout0_40) AT=420.025n

* CHECK dout0_41 Vdout0_41ck83 = 0 time = 420
.meas tran vdout0_41ck83 FIND v(dout0_41) AT=420.025n

* CHECK dout0_42 Vdout0_42ck83 = 0 time = 420
.meas tran vdout0_42ck83 FIND v(dout0_42) AT=420.025n

* CHECK dout0_43 Vdout0_43ck83 = 0 time = 420
.meas tran vdout0_43ck83 FIND v(dout0_43) AT=420.025n

* CHECK dout0_44 Vdout0_44ck83 = 0.9 time = 420
.meas tran vdout0_44ck83 FIND v(dout0_44) AT=420.025n

* CHECK dout0_45 Vdout0_45ck83 = 0 time = 420
.meas tran vdout0_45ck83 FIND v(dout0_45) AT=420.025n

* CHECK dout0_46 Vdout0_46ck83 = 0.9 time = 420
.meas tran vdout0_46ck83 FIND v(dout0_46) AT=420.025n

* CHECK dout0_47 Vdout0_47ck83 = 0 time = 420
.meas tran vdout0_47ck83 FIND v(dout0_47) AT=420.025n

* CHECK dout0_48 Vdout0_48ck83 = 0.9 time = 420
.meas tran vdout0_48ck83 FIND v(dout0_48) AT=420.025n

* CHECK dout0_49 Vdout0_49ck83 = 0.9 time = 420
.meas tran vdout0_49ck83 FIND v(dout0_49) AT=420.025n

* CHECK dout0_50 Vdout0_50ck83 = 0 time = 420
.meas tran vdout0_50ck83 FIND v(dout0_50) AT=420.025n

* CHECK dout0_51 Vdout0_51ck83 = 0.9 time = 420
.meas tran vdout0_51ck83 FIND v(dout0_51) AT=420.025n

* CHECK dout0_52 Vdout0_52ck83 = 0 time = 420
.meas tran vdout0_52ck83 FIND v(dout0_52) AT=420.025n

* CHECK dout0_53 Vdout0_53ck83 = 0 time = 420
.meas tran vdout0_53ck83 FIND v(dout0_53) AT=420.025n

* CHECK dout0_54 Vdout0_54ck83 = 0.9 time = 420
.meas tran vdout0_54ck83 FIND v(dout0_54) AT=420.025n

* CHECK dout0_55 Vdout0_55ck83 = 0.9 time = 420
.meas tran vdout0_55ck83 FIND v(dout0_55) AT=420.025n

* CHECK dout0_56 Vdout0_56ck83 = 0.9 time = 420
.meas tran vdout0_56ck83 FIND v(dout0_56) AT=420.025n

* CHECK dout0_57 Vdout0_57ck83 = 0 time = 420
.meas tran vdout0_57ck83 FIND v(dout0_57) AT=420.025n

* CHECK dout0_58 Vdout0_58ck83 = 0.9 time = 420
.meas tran vdout0_58ck83 FIND v(dout0_58) AT=420.025n

* CHECK dout0_59 Vdout0_59ck83 = 0.9 time = 420
.meas tran vdout0_59ck83 FIND v(dout0_59) AT=420.025n

* CHECK dout0_60 Vdout0_60ck83 = 0.9 time = 420
.meas tran vdout0_60ck83 FIND v(dout0_60) AT=420.025n

* CHECK dout0_61 Vdout0_61ck83 = 0 time = 420
.meas tran vdout0_61ck83 FIND v(dout0_61) AT=420.025n

* CHECK dout0_62 Vdout0_62ck83 = 0 time = 420
.meas tran vdout0_62ck83 FIND v(dout0_62) AT=420.025n

* CHECK dout0_63 Vdout0_63ck83 = 0 time = 420
.meas tran vdout0_63ck83 FIND v(dout0_63) AT=420.025n

* CHECK dout0_64 Vdout0_64ck83 = 0.9 time = 420
.meas tran vdout0_64ck83 FIND v(dout0_64) AT=420.025n

* CHECK dout0_65 Vdout0_65ck83 = 0 time = 420
.meas tran vdout0_65ck83 FIND v(dout0_65) AT=420.025n

* CHECK dout0_66 Vdout0_66ck83 = 0 time = 420
.meas tran vdout0_66ck83 FIND v(dout0_66) AT=420.025n

* CHECK dout0_67 Vdout0_67ck83 = 0 time = 420
.meas tran vdout0_67ck83 FIND v(dout0_67) AT=420.025n

* CHECK dout0_68 Vdout0_68ck83 = 0 time = 420
.meas tran vdout0_68ck83 FIND v(dout0_68) AT=420.025n

* CHECK dout0_69 Vdout0_69ck83 = 0 time = 420
.meas tran vdout0_69ck83 FIND v(dout0_69) AT=420.025n

* CHECK dout0_70 Vdout0_70ck83 = 0.9 time = 420
.meas tran vdout0_70ck83 FIND v(dout0_70) AT=420.025n

* CHECK dout0_71 Vdout0_71ck83 = 0.9 time = 420
.meas tran vdout0_71ck83 FIND v(dout0_71) AT=420.025n

* CHECK dout0_72 Vdout0_72ck83 = 0 time = 420
.meas tran vdout0_72ck83 FIND v(dout0_72) AT=420.025n

* CHECK dout0_73 Vdout0_73ck83 = 0 time = 420
.meas tran vdout0_73ck83 FIND v(dout0_73) AT=420.025n

* CHECK dout0_74 Vdout0_74ck83 = 0.9 time = 420
.meas tran vdout0_74ck83 FIND v(dout0_74) AT=420.025n

* CHECK dout0_75 Vdout0_75ck83 = 0.9 time = 420
.meas tran vdout0_75ck83 FIND v(dout0_75) AT=420.025n

* CHECK dout0_76 Vdout0_76ck83 = 0.9 time = 420
.meas tran vdout0_76ck83 FIND v(dout0_76) AT=420.025n

* CHECK dout0_77 Vdout0_77ck83 = 0 time = 420
.meas tran vdout0_77ck83 FIND v(dout0_77) AT=420.025n

* CHECK dout0_78 Vdout0_78ck83 = 0.9 time = 420
.meas tran vdout0_78ck83 FIND v(dout0_78) AT=420.025n

* CHECK dout0_79 Vdout0_79ck83 = 0 time = 420
.meas tran vdout0_79ck83 FIND v(dout0_79) AT=420.025n

* CHECK dout0_80 Vdout0_80ck83 = 0.9 time = 420
.meas tran vdout0_80ck83 FIND v(dout0_80) AT=420.025n

* CHECK dout0_81 Vdout0_81ck83 = 0 time = 420
.meas tran vdout0_81ck83 FIND v(dout0_81) AT=420.025n

* CHECK dout0_82 Vdout0_82ck83 = 0 time = 420
.meas tran vdout0_82ck83 FIND v(dout0_82) AT=420.025n

* CHECK dout0_83 Vdout0_83ck83 = 0 time = 420
.meas tran vdout0_83ck83 FIND v(dout0_83) AT=420.025n

* CHECK dout0_84 Vdout0_84ck83 = 0 time = 420
.meas tran vdout0_84ck83 FIND v(dout0_84) AT=420.025n

* CHECK dout0_85 Vdout0_85ck83 = 0 time = 420
.meas tran vdout0_85ck83 FIND v(dout0_85) AT=420.025n

* CHECK dout0_86 Vdout0_86ck83 = 0 time = 420
.meas tran vdout0_86ck83 FIND v(dout0_86) AT=420.025n

* CHECK dout0_87 Vdout0_87ck83 = 0.9 time = 420
.meas tran vdout0_87ck83 FIND v(dout0_87) AT=420.025n

* CHECK dout0_0 Vdout0_0ck84 = 0.9 time = 425
.meas tran vdout0_0ck84 FIND v(dout0_0) AT=425.025n

* CHECK dout0_1 Vdout0_1ck84 = 0.9 time = 425
.meas tran vdout0_1ck84 FIND v(dout0_1) AT=425.025n

* CHECK dout0_2 Vdout0_2ck84 = 0 time = 425
.meas tran vdout0_2ck84 FIND v(dout0_2) AT=425.025n

* CHECK dout0_3 Vdout0_3ck84 = 0.9 time = 425
.meas tran vdout0_3ck84 FIND v(dout0_3) AT=425.025n

* CHECK dout0_4 Vdout0_4ck84 = 0 time = 425
.meas tran vdout0_4ck84 FIND v(dout0_4) AT=425.025n

* CHECK dout0_5 Vdout0_5ck84 = 0 time = 425
.meas tran vdout0_5ck84 FIND v(dout0_5) AT=425.025n

* CHECK dout0_6 Vdout0_6ck84 = 0.9 time = 425
.meas tran vdout0_6ck84 FIND v(dout0_6) AT=425.025n

* CHECK dout0_7 Vdout0_7ck84 = 0 time = 425
.meas tran vdout0_7ck84 FIND v(dout0_7) AT=425.025n

* CHECK dout0_8 Vdout0_8ck84 = 0 time = 425
.meas tran vdout0_8ck84 FIND v(dout0_8) AT=425.025n

* CHECK dout0_9 Vdout0_9ck84 = 0.9 time = 425
.meas tran vdout0_9ck84 FIND v(dout0_9) AT=425.025n

* CHECK dout0_10 Vdout0_10ck84 = 0 time = 425
.meas tran vdout0_10ck84 FIND v(dout0_10) AT=425.025n

* CHECK dout0_11 Vdout0_11ck84 = 0.9 time = 425
.meas tran vdout0_11ck84 FIND v(dout0_11) AT=425.025n

* CHECK dout0_12 Vdout0_12ck84 = 0 time = 425
.meas tran vdout0_12ck84 FIND v(dout0_12) AT=425.025n

* CHECK dout0_13 Vdout0_13ck84 = 0 time = 425
.meas tran vdout0_13ck84 FIND v(dout0_13) AT=425.025n

* CHECK dout0_14 Vdout0_14ck84 = 0.9 time = 425
.meas tran vdout0_14ck84 FIND v(dout0_14) AT=425.025n

* CHECK dout0_15 Vdout0_15ck84 = 0 time = 425
.meas tran vdout0_15ck84 FIND v(dout0_15) AT=425.025n

* CHECK dout0_16 Vdout0_16ck84 = 0 time = 425
.meas tran vdout0_16ck84 FIND v(dout0_16) AT=425.025n

* CHECK dout0_17 Vdout0_17ck84 = 0 time = 425
.meas tran vdout0_17ck84 FIND v(dout0_17) AT=425.025n

* CHECK dout0_18 Vdout0_18ck84 = 0.9 time = 425
.meas tran vdout0_18ck84 FIND v(dout0_18) AT=425.025n

* CHECK dout0_19 Vdout0_19ck84 = 0.9 time = 425
.meas tran vdout0_19ck84 FIND v(dout0_19) AT=425.025n

* CHECK dout0_20 Vdout0_20ck84 = 0.9 time = 425
.meas tran vdout0_20ck84 FIND v(dout0_20) AT=425.025n

* CHECK dout0_21 Vdout0_21ck84 = 0.9 time = 425
.meas tran vdout0_21ck84 FIND v(dout0_21) AT=425.025n

* CHECK dout0_22 Vdout0_22ck84 = 0.9 time = 425
.meas tran vdout0_22ck84 FIND v(dout0_22) AT=425.025n

* CHECK dout0_23 Vdout0_23ck84 = 0.9 time = 425
.meas tran vdout0_23ck84 FIND v(dout0_23) AT=425.025n

* CHECK dout0_24 Vdout0_24ck84 = 0.9 time = 425
.meas tran vdout0_24ck84 FIND v(dout0_24) AT=425.025n

* CHECK dout0_25 Vdout0_25ck84 = 0 time = 425
.meas tran vdout0_25ck84 FIND v(dout0_25) AT=425.025n

* CHECK dout0_26 Vdout0_26ck84 = 0.9 time = 425
.meas tran vdout0_26ck84 FIND v(dout0_26) AT=425.025n

* CHECK dout0_27 Vdout0_27ck84 = 0 time = 425
.meas tran vdout0_27ck84 FIND v(dout0_27) AT=425.025n

* CHECK dout0_28 Vdout0_28ck84 = 0 time = 425
.meas tran vdout0_28ck84 FIND v(dout0_28) AT=425.025n

* CHECK dout0_29 Vdout0_29ck84 = 0.9 time = 425
.meas tran vdout0_29ck84 FIND v(dout0_29) AT=425.025n

* CHECK dout0_30 Vdout0_30ck84 = 0 time = 425
.meas tran vdout0_30ck84 FIND v(dout0_30) AT=425.025n

* CHECK dout0_31 Vdout0_31ck84 = 0 time = 425
.meas tran vdout0_31ck84 FIND v(dout0_31) AT=425.025n

* CHECK dout0_32 Vdout0_32ck84 = 0 time = 425
.meas tran vdout0_32ck84 FIND v(dout0_32) AT=425.025n

* CHECK dout0_33 Vdout0_33ck84 = 0.9 time = 425
.meas tran vdout0_33ck84 FIND v(dout0_33) AT=425.025n

* CHECK dout0_34 Vdout0_34ck84 = 0 time = 425
.meas tran vdout0_34ck84 FIND v(dout0_34) AT=425.025n

* CHECK dout0_35 Vdout0_35ck84 = 0 time = 425
.meas tran vdout0_35ck84 FIND v(dout0_35) AT=425.025n

* CHECK dout0_36 Vdout0_36ck84 = 0.9 time = 425
.meas tran vdout0_36ck84 FIND v(dout0_36) AT=425.025n

* CHECK dout0_37 Vdout0_37ck84 = 0.9 time = 425
.meas tran vdout0_37ck84 FIND v(dout0_37) AT=425.025n

* CHECK dout0_38 Vdout0_38ck84 = 0 time = 425
.meas tran vdout0_38ck84 FIND v(dout0_38) AT=425.025n

* CHECK dout0_39 Vdout0_39ck84 = 0 time = 425
.meas tran vdout0_39ck84 FIND v(dout0_39) AT=425.025n

* CHECK dout0_40 Vdout0_40ck84 = 0.9 time = 425
.meas tran vdout0_40ck84 FIND v(dout0_40) AT=425.025n

* CHECK dout0_41 Vdout0_41ck84 = 0 time = 425
.meas tran vdout0_41ck84 FIND v(dout0_41) AT=425.025n

* CHECK dout0_42 Vdout0_42ck84 = 0 time = 425
.meas tran vdout0_42ck84 FIND v(dout0_42) AT=425.025n

* CHECK dout0_43 Vdout0_43ck84 = 0 time = 425
.meas tran vdout0_43ck84 FIND v(dout0_43) AT=425.025n

* CHECK dout0_44 Vdout0_44ck84 = 0 time = 425
.meas tran vdout0_44ck84 FIND v(dout0_44) AT=425.025n

* CHECK dout0_45 Vdout0_45ck84 = 0 time = 425
.meas tran vdout0_45ck84 FIND v(dout0_45) AT=425.025n

* CHECK dout0_46 Vdout0_46ck84 = 0.9 time = 425
.meas tran vdout0_46ck84 FIND v(dout0_46) AT=425.025n

* CHECK dout0_47 Vdout0_47ck84 = 0.9 time = 425
.meas tran vdout0_47ck84 FIND v(dout0_47) AT=425.025n

* CHECK dout0_48 Vdout0_48ck84 = 0 time = 425
.meas tran vdout0_48ck84 FIND v(dout0_48) AT=425.025n

* CHECK dout0_49 Vdout0_49ck84 = 0.9 time = 425
.meas tran vdout0_49ck84 FIND v(dout0_49) AT=425.025n

* CHECK dout0_50 Vdout0_50ck84 = 0.9 time = 425
.meas tran vdout0_50ck84 FIND v(dout0_50) AT=425.025n

* CHECK dout0_51 Vdout0_51ck84 = 0.9 time = 425
.meas tran vdout0_51ck84 FIND v(dout0_51) AT=425.025n

* CHECK dout0_52 Vdout0_52ck84 = 0.9 time = 425
.meas tran vdout0_52ck84 FIND v(dout0_52) AT=425.025n

* CHECK dout0_53 Vdout0_53ck84 = 0.9 time = 425
.meas tran vdout0_53ck84 FIND v(dout0_53) AT=425.025n

* CHECK dout0_54 Vdout0_54ck84 = 0 time = 425
.meas tran vdout0_54ck84 FIND v(dout0_54) AT=425.025n

* CHECK dout0_55 Vdout0_55ck84 = 0 time = 425
.meas tran vdout0_55ck84 FIND v(dout0_55) AT=425.025n

* CHECK dout0_56 Vdout0_56ck84 = 0 time = 425
.meas tran vdout0_56ck84 FIND v(dout0_56) AT=425.025n

* CHECK dout0_57 Vdout0_57ck84 = 0.9 time = 425
.meas tran vdout0_57ck84 FIND v(dout0_57) AT=425.025n

* CHECK dout0_58 Vdout0_58ck84 = 0.9 time = 425
.meas tran vdout0_58ck84 FIND v(dout0_58) AT=425.025n

* CHECK dout0_59 Vdout0_59ck84 = 0 time = 425
.meas tran vdout0_59ck84 FIND v(dout0_59) AT=425.025n

* CHECK dout0_60 Vdout0_60ck84 = 0.9 time = 425
.meas tran vdout0_60ck84 FIND v(dout0_60) AT=425.025n

* CHECK dout0_61 Vdout0_61ck84 = 0 time = 425
.meas tran vdout0_61ck84 FIND v(dout0_61) AT=425.025n

* CHECK dout0_62 Vdout0_62ck84 = 0 time = 425
.meas tran vdout0_62ck84 FIND v(dout0_62) AT=425.025n

* CHECK dout0_63 Vdout0_63ck84 = 0 time = 425
.meas tran vdout0_63ck84 FIND v(dout0_63) AT=425.025n

* CHECK dout0_64 Vdout0_64ck84 = 0 time = 425
.meas tran vdout0_64ck84 FIND v(dout0_64) AT=425.025n

* CHECK dout0_65 Vdout0_65ck84 = 0.9 time = 425
.meas tran vdout0_65ck84 FIND v(dout0_65) AT=425.025n

* CHECK dout0_66 Vdout0_66ck84 = 0.9 time = 425
.meas tran vdout0_66ck84 FIND v(dout0_66) AT=425.025n

* CHECK dout0_67 Vdout0_67ck84 = 0.9 time = 425
.meas tran vdout0_67ck84 FIND v(dout0_67) AT=425.025n

* CHECK dout0_68 Vdout0_68ck84 = 0.9 time = 425
.meas tran vdout0_68ck84 FIND v(dout0_68) AT=425.025n

* CHECK dout0_69 Vdout0_69ck84 = 0 time = 425
.meas tran vdout0_69ck84 FIND v(dout0_69) AT=425.025n

* CHECK dout0_70 Vdout0_70ck84 = 0 time = 425
.meas tran vdout0_70ck84 FIND v(dout0_70) AT=425.025n

* CHECK dout0_71 Vdout0_71ck84 = 0 time = 425
.meas tran vdout0_71ck84 FIND v(dout0_71) AT=425.025n

* CHECK dout0_72 Vdout0_72ck84 = 0 time = 425
.meas tran vdout0_72ck84 FIND v(dout0_72) AT=425.025n

* CHECK dout0_73 Vdout0_73ck84 = 0.9 time = 425
.meas tran vdout0_73ck84 FIND v(dout0_73) AT=425.025n

* CHECK dout0_74 Vdout0_74ck84 = 0 time = 425
.meas tran vdout0_74ck84 FIND v(dout0_74) AT=425.025n

* CHECK dout0_75 Vdout0_75ck84 = 0.9 time = 425
.meas tran vdout0_75ck84 FIND v(dout0_75) AT=425.025n

* CHECK dout0_76 Vdout0_76ck84 = 0.9 time = 425
.meas tran vdout0_76ck84 FIND v(dout0_76) AT=425.025n

* CHECK dout0_77 Vdout0_77ck84 = 0 time = 425
.meas tran vdout0_77ck84 FIND v(dout0_77) AT=425.025n

* CHECK dout0_78 Vdout0_78ck84 = 0 time = 425
.meas tran vdout0_78ck84 FIND v(dout0_78) AT=425.025n

* CHECK dout0_79 Vdout0_79ck84 = 0 time = 425
.meas tran vdout0_79ck84 FIND v(dout0_79) AT=425.025n

* CHECK dout0_80 Vdout0_80ck84 = 0.9 time = 425
.meas tran vdout0_80ck84 FIND v(dout0_80) AT=425.025n

* CHECK dout0_81 Vdout0_81ck84 = 0 time = 425
.meas tran vdout0_81ck84 FIND v(dout0_81) AT=425.025n

* CHECK dout0_82 Vdout0_82ck84 = 0 time = 425
.meas tran vdout0_82ck84 FIND v(dout0_82) AT=425.025n

* CHECK dout0_83 Vdout0_83ck84 = 0.9 time = 425
.meas tran vdout0_83ck84 FIND v(dout0_83) AT=425.025n

* CHECK dout0_84 Vdout0_84ck84 = 0.9 time = 425
.meas tran vdout0_84ck84 FIND v(dout0_84) AT=425.025n

* CHECK dout0_85 Vdout0_85ck84 = 0.9 time = 425
.meas tran vdout0_85ck84 FIND v(dout0_85) AT=425.025n

* CHECK dout0_86 Vdout0_86ck84 = 0.9 time = 425
.meas tran vdout0_86ck84 FIND v(dout0_86) AT=425.025n

* CHECK dout0_87 Vdout0_87ck84 = 0.9 time = 425
.meas tran vdout0_87ck84 FIND v(dout0_87) AT=425.025n

* CHECK dout0_0 Vdout0_0ck86 = 0 time = 435
.meas tran vdout0_0ck86 FIND v(dout0_0) AT=435.025n

* CHECK dout0_1 Vdout0_1ck86 = 0.9 time = 435
.meas tran vdout0_1ck86 FIND v(dout0_1) AT=435.025n

* CHECK dout0_2 Vdout0_2ck86 = 0.9 time = 435
.meas tran vdout0_2ck86 FIND v(dout0_2) AT=435.025n

* CHECK dout0_3 Vdout0_3ck86 = 0 time = 435
.meas tran vdout0_3ck86 FIND v(dout0_3) AT=435.025n

* CHECK dout0_4 Vdout0_4ck86 = 0 time = 435
.meas tran vdout0_4ck86 FIND v(dout0_4) AT=435.025n

* CHECK dout0_5 Vdout0_5ck86 = 0 time = 435
.meas tran vdout0_5ck86 FIND v(dout0_5) AT=435.025n

* CHECK dout0_6 Vdout0_6ck86 = 0.9 time = 435
.meas tran vdout0_6ck86 FIND v(dout0_6) AT=435.025n

* CHECK dout0_7 Vdout0_7ck86 = 0 time = 435
.meas tran vdout0_7ck86 FIND v(dout0_7) AT=435.025n

* CHECK dout0_8 Vdout0_8ck86 = 0 time = 435
.meas tran vdout0_8ck86 FIND v(dout0_8) AT=435.025n

* CHECK dout0_9 Vdout0_9ck86 = 0 time = 435
.meas tran vdout0_9ck86 FIND v(dout0_9) AT=435.025n

* CHECK dout0_10 Vdout0_10ck86 = 0 time = 435
.meas tran vdout0_10ck86 FIND v(dout0_10) AT=435.025n

* CHECK dout0_11 Vdout0_11ck86 = 0 time = 435
.meas tran vdout0_11ck86 FIND v(dout0_11) AT=435.025n

* CHECK dout0_12 Vdout0_12ck86 = 0.9 time = 435
.meas tran vdout0_12ck86 FIND v(dout0_12) AT=435.025n

* CHECK dout0_13 Vdout0_13ck86 = 0.9 time = 435
.meas tran vdout0_13ck86 FIND v(dout0_13) AT=435.025n

* CHECK dout0_14 Vdout0_14ck86 = 0.9 time = 435
.meas tran vdout0_14ck86 FIND v(dout0_14) AT=435.025n

* CHECK dout0_15 Vdout0_15ck86 = 0.9 time = 435
.meas tran vdout0_15ck86 FIND v(dout0_15) AT=435.025n

* CHECK dout0_16 Vdout0_16ck86 = 0 time = 435
.meas tran vdout0_16ck86 FIND v(dout0_16) AT=435.025n

* CHECK dout0_17 Vdout0_17ck86 = 0 time = 435
.meas tran vdout0_17ck86 FIND v(dout0_17) AT=435.025n

* CHECK dout0_18 Vdout0_18ck86 = 0 time = 435
.meas tran vdout0_18ck86 FIND v(dout0_18) AT=435.025n

* CHECK dout0_19 Vdout0_19ck86 = 0 time = 435
.meas tran vdout0_19ck86 FIND v(dout0_19) AT=435.025n

* CHECK dout0_20 Vdout0_20ck86 = 0 time = 435
.meas tran vdout0_20ck86 FIND v(dout0_20) AT=435.025n

* CHECK dout0_21 Vdout0_21ck86 = 0 time = 435
.meas tran vdout0_21ck86 FIND v(dout0_21) AT=435.025n

* CHECK dout0_22 Vdout0_22ck86 = 0 time = 435
.meas tran vdout0_22ck86 FIND v(dout0_22) AT=435.025n

* CHECK dout0_23 Vdout0_23ck86 = 0.9 time = 435
.meas tran vdout0_23ck86 FIND v(dout0_23) AT=435.025n

* CHECK dout0_24 Vdout0_24ck86 = 0.9 time = 435
.meas tran vdout0_24ck86 FIND v(dout0_24) AT=435.025n

* CHECK dout0_25 Vdout0_25ck86 = 0 time = 435
.meas tran vdout0_25ck86 FIND v(dout0_25) AT=435.025n

* CHECK dout0_26 Vdout0_26ck86 = 0.9 time = 435
.meas tran vdout0_26ck86 FIND v(dout0_26) AT=435.025n

* CHECK dout0_27 Vdout0_27ck86 = 0.9 time = 435
.meas tran vdout0_27ck86 FIND v(dout0_27) AT=435.025n

* CHECK dout0_28 Vdout0_28ck86 = 0.9 time = 435
.meas tran vdout0_28ck86 FIND v(dout0_28) AT=435.025n

* CHECK dout0_29 Vdout0_29ck86 = 0 time = 435
.meas tran vdout0_29ck86 FIND v(dout0_29) AT=435.025n

* CHECK dout0_30 Vdout0_30ck86 = 0.9 time = 435
.meas tran vdout0_30ck86 FIND v(dout0_30) AT=435.025n

* CHECK dout0_31 Vdout0_31ck86 = 0 time = 435
.meas tran vdout0_31ck86 FIND v(dout0_31) AT=435.025n

* CHECK dout0_32 Vdout0_32ck86 = 0.9 time = 435
.meas tran vdout0_32ck86 FIND v(dout0_32) AT=435.025n

* CHECK dout0_33 Vdout0_33ck86 = 0.9 time = 435
.meas tran vdout0_33ck86 FIND v(dout0_33) AT=435.025n

* CHECK dout0_34 Vdout0_34ck86 = 0.9 time = 435
.meas tran vdout0_34ck86 FIND v(dout0_34) AT=435.025n

* CHECK dout0_35 Vdout0_35ck86 = 0.9 time = 435
.meas tran vdout0_35ck86 FIND v(dout0_35) AT=435.025n

* CHECK dout0_36 Vdout0_36ck86 = 0.9 time = 435
.meas tran vdout0_36ck86 FIND v(dout0_36) AT=435.025n

* CHECK dout0_37 Vdout0_37ck86 = 0 time = 435
.meas tran vdout0_37ck86 FIND v(dout0_37) AT=435.025n

* CHECK dout0_38 Vdout0_38ck86 = 0.9 time = 435
.meas tran vdout0_38ck86 FIND v(dout0_38) AT=435.025n

* CHECK dout0_39 Vdout0_39ck86 = 0.9 time = 435
.meas tran vdout0_39ck86 FIND v(dout0_39) AT=435.025n

* CHECK dout0_40 Vdout0_40ck86 = 0.9 time = 435
.meas tran vdout0_40ck86 FIND v(dout0_40) AT=435.025n

* CHECK dout0_41 Vdout0_41ck86 = 0 time = 435
.meas tran vdout0_41ck86 FIND v(dout0_41) AT=435.025n

* CHECK dout0_42 Vdout0_42ck86 = 0 time = 435
.meas tran vdout0_42ck86 FIND v(dout0_42) AT=435.025n

* CHECK dout0_43 Vdout0_43ck86 = 0 time = 435
.meas tran vdout0_43ck86 FIND v(dout0_43) AT=435.025n

* CHECK dout0_44 Vdout0_44ck86 = 0.9 time = 435
.meas tran vdout0_44ck86 FIND v(dout0_44) AT=435.025n

* CHECK dout0_45 Vdout0_45ck86 = 0 time = 435
.meas tran vdout0_45ck86 FIND v(dout0_45) AT=435.025n

* CHECK dout0_46 Vdout0_46ck86 = 0.9 time = 435
.meas tran vdout0_46ck86 FIND v(dout0_46) AT=435.025n

* CHECK dout0_47 Vdout0_47ck86 = 0 time = 435
.meas tran vdout0_47ck86 FIND v(dout0_47) AT=435.025n

* CHECK dout0_48 Vdout0_48ck86 = 0.9 time = 435
.meas tran vdout0_48ck86 FIND v(dout0_48) AT=435.025n

* CHECK dout0_49 Vdout0_49ck86 = 0.9 time = 435
.meas tran vdout0_49ck86 FIND v(dout0_49) AT=435.025n

* CHECK dout0_50 Vdout0_50ck86 = 0 time = 435
.meas tran vdout0_50ck86 FIND v(dout0_50) AT=435.025n

* CHECK dout0_51 Vdout0_51ck86 = 0.9 time = 435
.meas tran vdout0_51ck86 FIND v(dout0_51) AT=435.025n

* CHECK dout0_52 Vdout0_52ck86 = 0 time = 435
.meas tran vdout0_52ck86 FIND v(dout0_52) AT=435.025n

* CHECK dout0_53 Vdout0_53ck86 = 0 time = 435
.meas tran vdout0_53ck86 FIND v(dout0_53) AT=435.025n

* CHECK dout0_54 Vdout0_54ck86 = 0.9 time = 435
.meas tran vdout0_54ck86 FIND v(dout0_54) AT=435.025n

* CHECK dout0_55 Vdout0_55ck86 = 0.9 time = 435
.meas tran vdout0_55ck86 FIND v(dout0_55) AT=435.025n

* CHECK dout0_56 Vdout0_56ck86 = 0.9 time = 435
.meas tran vdout0_56ck86 FIND v(dout0_56) AT=435.025n

* CHECK dout0_57 Vdout0_57ck86 = 0 time = 435
.meas tran vdout0_57ck86 FIND v(dout0_57) AT=435.025n

* CHECK dout0_58 Vdout0_58ck86 = 0.9 time = 435
.meas tran vdout0_58ck86 FIND v(dout0_58) AT=435.025n

* CHECK dout0_59 Vdout0_59ck86 = 0.9 time = 435
.meas tran vdout0_59ck86 FIND v(dout0_59) AT=435.025n

* CHECK dout0_60 Vdout0_60ck86 = 0.9 time = 435
.meas tran vdout0_60ck86 FIND v(dout0_60) AT=435.025n

* CHECK dout0_61 Vdout0_61ck86 = 0 time = 435
.meas tran vdout0_61ck86 FIND v(dout0_61) AT=435.025n

* CHECK dout0_62 Vdout0_62ck86 = 0 time = 435
.meas tran vdout0_62ck86 FIND v(dout0_62) AT=435.025n

* CHECK dout0_63 Vdout0_63ck86 = 0 time = 435
.meas tran vdout0_63ck86 FIND v(dout0_63) AT=435.025n

* CHECK dout0_64 Vdout0_64ck86 = 0.9 time = 435
.meas tran vdout0_64ck86 FIND v(dout0_64) AT=435.025n

* CHECK dout0_65 Vdout0_65ck86 = 0 time = 435
.meas tran vdout0_65ck86 FIND v(dout0_65) AT=435.025n

* CHECK dout0_66 Vdout0_66ck86 = 0 time = 435
.meas tran vdout0_66ck86 FIND v(dout0_66) AT=435.025n

* CHECK dout0_67 Vdout0_67ck86 = 0 time = 435
.meas tran vdout0_67ck86 FIND v(dout0_67) AT=435.025n

* CHECK dout0_68 Vdout0_68ck86 = 0 time = 435
.meas tran vdout0_68ck86 FIND v(dout0_68) AT=435.025n

* CHECK dout0_69 Vdout0_69ck86 = 0 time = 435
.meas tran vdout0_69ck86 FIND v(dout0_69) AT=435.025n

* CHECK dout0_70 Vdout0_70ck86 = 0.9 time = 435
.meas tran vdout0_70ck86 FIND v(dout0_70) AT=435.025n

* CHECK dout0_71 Vdout0_71ck86 = 0.9 time = 435
.meas tran vdout0_71ck86 FIND v(dout0_71) AT=435.025n

* CHECK dout0_72 Vdout0_72ck86 = 0 time = 435
.meas tran vdout0_72ck86 FIND v(dout0_72) AT=435.025n

* CHECK dout0_73 Vdout0_73ck86 = 0 time = 435
.meas tran vdout0_73ck86 FIND v(dout0_73) AT=435.025n

* CHECK dout0_74 Vdout0_74ck86 = 0.9 time = 435
.meas tran vdout0_74ck86 FIND v(dout0_74) AT=435.025n

* CHECK dout0_75 Vdout0_75ck86 = 0.9 time = 435
.meas tran vdout0_75ck86 FIND v(dout0_75) AT=435.025n

* CHECK dout0_76 Vdout0_76ck86 = 0.9 time = 435
.meas tran vdout0_76ck86 FIND v(dout0_76) AT=435.025n

* CHECK dout0_77 Vdout0_77ck86 = 0 time = 435
.meas tran vdout0_77ck86 FIND v(dout0_77) AT=435.025n

* CHECK dout0_78 Vdout0_78ck86 = 0.9 time = 435
.meas tran vdout0_78ck86 FIND v(dout0_78) AT=435.025n

* CHECK dout0_79 Vdout0_79ck86 = 0 time = 435
.meas tran vdout0_79ck86 FIND v(dout0_79) AT=435.025n

* CHECK dout0_80 Vdout0_80ck86 = 0.9 time = 435
.meas tran vdout0_80ck86 FIND v(dout0_80) AT=435.025n

* CHECK dout0_81 Vdout0_81ck86 = 0 time = 435
.meas tran vdout0_81ck86 FIND v(dout0_81) AT=435.025n

* CHECK dout0_82 Vdout0_82ck86 = 0 time = 435
.meas tran vdout0_82ck86 FIND v(dout0_82) AT=435.025n

* CHECK dout0_83 Vdout0_83ck86 = 0 time = 435
.meas tran vdout0_83ck86 FIND v(dout0_83) AT=435.025n

* CHECK dout0_84 Vdout0_84ck86 = 0 time = 435
.meas tran vdout0_84ck86 FIND v(dout0_84) AT=435.025n

* CHECK dout0_85 Vdout0_85ck86 = 0 time = 435
.meas tran vdout0_85ck86 FIND v(dout0_85) AT=435.025n

* CHECK dout0_86 Vdout0_86ck86 = 0 time = 435
.meas tran vdout0_86ck86 FIND v(dout0_86) AT=435.025n

* CHECK dout0_87 Vdout0_87ck86 = 0.9 time = 435
.meas tran vdout0_87ck86 FIND v(dout0_87) AT=435.025n

* CHECK dout0_0 Vdout0_0ck88 = 0 time = 445
.meas tran vdout0_0ck88 FIND v(dout0_0) AT=445.025n

* CHECK dout0_1 Vdout0_1ck88 = 0.9 time = 445
.meas tran vdout0_1ck88 FIND v(dout0_1) AT=445.025n

* CHECK dout0_2 Vdout0_2ck88 = 0.9 time = 445
.meas tran vdout0_2ck88 FIND v(dout0_2) AT=445.025n

* CHECK dout0_3 Vdout0_3ck88 = 0 time = 445
.meas tran vdout0_3ck88 FIND v(dout0_3) AT=445.025n

* CHECK dout0_4 Vdout0_4ck88 = 0 time = 445
.meas tran vdout0_4ck88 FIND v(dout0_4) AT=445.025n

* CHECK dout0_5 Vdout0_5ck88 = 0 time = 445
.meas tran vdout0_5ck88 FIND v(dout0_5) AT=445.025n

* CHECK dout0_6 Vdout0_6ck88 = 0.9 time = 445
.meas tran vdout0_6ck88 FIND v(dout0_6) AT=445.025n

* CHECK dout0_7 Vdout0_7ck88 = 0 time = 445
.meas tran vdout0_7ck88 FIND v(dout0_7) AT=445.025n

* CHECK dout0_8 Vdout0_8ck88 = 0 time = 445
.meas tran vdout0_8ck88 FIND v(dout0_8) AT=445.025n

* CHECK dout0_9 Vdout0_9ck88 = 0 time = 445
.meas tran vdout0_9ck88 FIND v(dout0_9) AT=445.025n

* CHECK dout0_10 Vdout0_10ck88 = 0 time = 445
.meas tran vdout0_10ck88 FIND v(dout0_10) AT=445.025n

* CHECK dout0_11 Vdout0_11ck88 = 0 time = 445
.meas tran vdout0_11ck88 FIND v(dout0_11) AT=445.025n

* CHECK dout0_12 Vdout0_12ck88 = 0.9 time = 445
.meas tran vdout0_12ck88 FIND v(dout0_12) AT=445.025n

* CHECK dout0_13 Vdout0_13ck88 = 0.9 time = 445
.meas tran vdout0_13ck88 FIND v(dout0_13) AT=445.025n

* CHECK dout0_14 Vdout0_14ck88 = 0.9 time = 445
.meas tran vdout0_14ck88 FIND v(dout0_14) AT=445.025n

* CHECK dout0_15 Vdout0_15ck88 = 0.9 time = 445
.meas tran vdout0_15ck88 FIND v(dout0_15) AT=445.025n

* CHECK dout0_16 Vdout0_16ck88 = 0 time = 445
.meas tran vdout0_16ck88 FIND v(dout0_16) AT=445.025n

* CHECK dout0_17 Vdout0_17ck88 = 0 time = 445
.meas tran vdout0_17ck88 FIND v(dout0_17) AT=445.025n

* CHECK dout0_18 Vdout0_18ck88 = 0 time = 445
.meas tran vdout0_18ck88 FIND v(dout0_18) AT=445.025n

* CHECK dout0_19 Vdout0_19ck88 = 0 time = 445
.meas tran vdout0_19ck88 FIND v(dout0_19) AT=445.025n

* CHECK dout0_20 Vdout0_20ck88 = 0 time = 445
.meas tran vdout0_20ck88 FIND v(dout0_20) AT=445.025n

* CHECK dout0_21 Vdout0_21ck88 = 0 time = 445
.meas tran vdout0_21ck88 FIND v(dout0_21) AT=445.025n

* CHECK dout0_22 Vdout0_22ck88 = 0 time = 445
.meas tran vdout0_22ck88 FIND v(dout0_22) AT=445.025n

* CHECK dout0_23 Vdout0_23ck88 = 0.9 time = 445
.meas tran vdout0_23ck88 FIND v(dout0_23) AT=445.025n

* CHECK dout0_24 Vdout0_24ck88 = 0.9 time = 445
.meas tran vdout0_24ck88 FIND v(dout0_24) AT=445.025n

* CHECK dout0_25 Vdout0_25ck88 = 0 time = 445
.meas tran vdout0_25ck88 FIND v(dout0_25) AT=445.025n

* CHECK dout0_26 Vdout0_26ck88 = 0.9 time = 445
.meas tran vdout0_26ck88 FIND v(dout0_26) AT=445.025n

* CHECK dout0_27 Vdout0_27ck88 = 0.9 time = 445
.meas tran vdout0_27ck88 FIND v(dout0_27) AT=445.025n

* CHECK dout0_28 Vdout0_28ck88 = 0.9 time = 445
.meas tran vdout0_28ck88 FIND v(dout0_28) AT=445.025n

* CHECK dout0_29 Vdout0_29ck88 = 0 time = 445
.meas tran vdout0_29ck88 FIND v(dout0_29) AT=445.025n

* CHECK dout0_30 Vdout0_30ck88 = 0.9 time = 445
.meas tran vdout0_30ck88 FIND v(dout0_30) AT=445.025n

* CHECK dout0_31 Vdout0_31ck88 = 0 time = 445
.meas tran vdout0_31ck88 FIND v(dout0_31) AT=445.025n

* CHECK dout0_32 Vdout0_32ck88 = 0.9 time = 445
.meas tran vdout0_32ck88 FIND v(dout0_32) AT=445.025n

* CHECK dout0_33 Vdout0_33ck88 = 0.9 time = 445
.meas tran vdout0_33ck88 FIND v(dout0_33) AT=445.025n

* CHECK dout0_34 Vdout0_34ck88 = 0.9 time = 445
.meas tran vdout0_34ck88 FIND v(dout0_34) AT=445.025n

* CHECK dout0_35 Vdout0_35ck88 = 0.9 time = 445
.meas tran vdout0_35ck88 FIND v(dout0_35) AT=445.025n

* CHECK dout0_36 Vdout0_36ck88 = 0.9 time = 445
.meas tran vdout0_36ck88 FIND v(dout0_36) AT=445.025n

* CHECK dout0_37 Vdout0_37ck88 = 0 time = 445
.meas tran vdout0_37ck88 FIND v(dout0_37) AT=445.025n

* CHECK dout0_38 Vdout0_38ck88 = 0.9 time = 445
.meas tran vdout0_38ck88 FIND v(dout0_38) AT=445.025n

* CHECK dout0_39 Vdout0_39ck88 = 0.9 time = 445
.meas tran vdout0_39ck88 FIND v(dout0_39) AT=445.025n

* CHECK dout0_40 Vdout0_40ck88 = 0.9 time = 445
.meas tran vdout0_40ck88 FIND v(dout0_40) AT=445.025n

* CHECK dout0_41 Vdout0_41ck88 = 0 time = 445
.meas tran vdout0_41ck88 FIND v(dout0_41) AT=445.025n

* CHECK dout0_42 Vdout0_42ck88 = 0 time = 445
.meas tran vdout0_42ck88 FIND v(dout0_42) AT=445.025n

* CHECK dout0_43 Vdout0_43ck88 = 0 time = 445
.meas tran vdout0_43ck88 FIND v(dout0_43) AT=445.025n

* CHECK dout0_44 Vdout0_44ck88 = 0.9 time = 445
.meas tran vdout0_44ck88 FIND v(dout0_44) AT=445.025n

* CHECK dout0_45 Vdout0_45ck88 = 0 time = 445
.meas tran vdout0_45ck88 FIND v(dout0_45) AT=445.025n

* CHECK dout0_46 Vdout0_46ck88 = 0.9 time = 445
.meas tran vdout0_46ck88 FIND v(dout0_46) AT=445.025n

* CHECK dout0_47 Vdout0_47ck88 = 0 time = 445
.meas tran vdout0_47ck88 FIND v(dout0_47) AT=445.025n

* CHECK dout0_48 Vdout0_48ck88 = 0.9 time = 445
.meas tran vdout0_48ck88 FIND v(dout0_48) AT=445.025n

* CHECK dout0_49 Vdout0_49ck88 = 0.9 time = 445
.meas tran vdout0_49ck88 FIND v(dout0_49) AT=445.025n

* CHECK dout0_50 Vdout0_50ck88 = 0 time = 445
.meas tran vdout0_50ck88 FIND v(dout0_50) AT=445.025n

* CHECK dout0_51 Vdout0_51ck88 = 0.9 time = 445
.meas tran vdout0_51ck88 FIND v(dout0_51) AT=445.025n

* CHECK dout0_52 Vdout0_52ck88 = 0 time = 445
.meas tran vdout0_52ck88 FIND v(dout0_52) AT=445.025n

* CHECK dout0_53 Vdout0_53ck88 = 0 time = 445
.meas tran vdout0_53ck88 FIND v(dout0_53) AT=445.025n

* CHECK dout0_54 Vdout0_54ck88 = 0.9 time = 445
.meas tran vdout0_54ck88 FIND v(dout0_54) AT=445.025n

* CHECK dout0_55 Vdout0_55ck88 = 0.9 time = 445
.meas tran vdout0_55ck88 FIND v(dout0_55) AT=445.025n

* CHECK dout0_56 Vdout0_56ck88 = 0.9 time = 445
.meas tran vdout0_56ck88 FIND v(dout0_56) AT=445.025n

* CHECK dout0_57 Vdout0_57ck88 = 0 time = 445
.meas tran vdout0_57ck88 FIND v(dout0_57) AT=445.025n

* CHECK dout0_58 Vdout0_58ck88 = 0.9 time = 445
.meas tran vdout0_58ck88 FIND v(dout0_58) AT=445.025n

* CHECK dout0_59 Vdout0_59ck88 = 0.9 time = 445
.meas tran vdout0_59ck88 FIND v(dout0_59) AT=445.025n

* CHECK dout0_60 Vdout0_60ck88 = 0.9 time = 445
.meas tran vdout0_60ck88 FIND v(dout0_60) AT=445.025n

* CHECK dout0_61 Vdout0_61ck88 = 0 time = 445
.meas tran vdout0_61ck88 FIND v(dout0_61) AT=445.025n

* CHECK dout0_62 Vdout0_62ck88 = 0 time = 445
.meas tran vdout0_62ck88 FIND v(dout0_62) AT=445.025n

* CHECK dout0_63 Vdout0_63ck88 = 0 time = 445
.meas tran vdout0_63ck88 FIND v(dout0_63) AT=445.025n

* CHECK dout0_64 Vdout0_64ck88 = 0.9 time = 445
.meas tran vdout0_64ck88 FIND v(dout0_64) AT=445.025n

* CHECK dout0_65 Vdout0_65ck88 = 0 time = 445
.meas tran vdout0_65ck88 FIND v(dout0_65) AT=445.025n

* CHECK dout0_66 Vdout0_66ck88 = 0 time = 445
.meas tran vdout0_66ck88 FIND v(dout0_66) AT=445.025n

* CHECK dout0_67 Vdout0_67ck88 = 0 time = 445
.meas tran vdout0_67ck88 FIND v(dout0_67) AT=445.025n

* CHECK dout0_68 Vdout0_68ck88 = 0 time = 445
.meas tran vdout0_68ck88 FIND v(dout0_68) AT=445.025n

* CHECK dout0_69 Vdout0_69ck88 = 0 time = 445
.meas tran vdout0_69ck88 FIND v(dout0_69) AT=445.025n

* CHECK dout0_70 Vdout0_70ck88 = 0.9 time = 445
.meas tran vdout0_70ck88 FIND v(dout0_70) AT=445.025n

* CHECK dout0_71 Vdout0_71ck88 = 0.9 time = 445
.meas tran vdout0_71ck88 FIND v(dout0_71) AT=445.025n

* CHECK dout0_72 Vdout0_72ck88 = 0 time = 445
.meas tran vdout0_72ck88 FIND v(dout0_72) AT=445.025n

* CHECK dout0_73 Vdout0_73ck88 = 0 time = 445
.meas tran vdout0_73ck88 FIND v(dout0_73) AT=445.025n

* CHECK dout0_74 Vdout0_74ck88 = 0.9 time = 445
.meas tran vdout0_74ck88 FIND v(dout0_74) AT=445.025n

* CHECK dout0_75 Vdout0_75ck88 = 0.9 time = 445
.meas tran vdout0_75ck88 FIND v(dout0_75) AT=445.025n

* CHECK dout0_76 Vdout0_76ck88 = 0.9 time = 445
.meas tran vdout0_76ck88 FIND v(dout0_76) AT=445.025n

* CHECK dout0_77 Vdout0_77ck88 = 0 time = 445
.meas tran vdout0_77ck88 FIND v(dout0_77) AT=445.025n

* CHECK dout0_78 Vdout0_78ck88 = 0.9 time = 445
.meas tran vdout0_78ck88 FIND v(dout0_78) AT=445.025n

* CHECK dout0_79 Vdout0_79ck88 = 0 time = 445
.meas tran vdout0_79ck88 FIND v(dout0_79) AT=445.025n

* CHECK dout0_80 Vdout0_80ck88 = 0.9 time = 445
.meas tran vdout0_80ck88 FIND v(dout0_80) AT=445.025n

* CHECK dout0_81 Vdout0_81ck88 = 0 time = 445
.meas tran vdout0_81ck88 FIND v(dout0_81) AT=445.025n

* CHECK dout0_82 Vdout0_82ck88 = 0 time = 445
.meas tran vdout0_82ck88 FIND v(dout0_82) AT=445.025n

* CHECK dout0_83 Vdout0_83ck88 = 0 time = 445
.meas tran vdout0_83ck88 FIND v(dout0_83) AT=445.025n

* CHECK dout0_84 Vdout0_84ck88 = 0 time = 445
.meas tran vdout0_84ck88 FIND v(dout0_84) AT=445.025n

* CHECK dout0_85 Vdout0_85ck88 = 0 time = 445
.meas tran vdout0_85ck88 FIND v(dout0_85) AT=445.025n

* CHECK dout0_86 Vdout0_86ck88 = 0 time = 445
.meas tran vdout0_86ck88 FIND v(dout0_86) AT=445.025n

* CHECK dout0_87 Vdout0_87ck88 = 0.9 time = 445
.meas tran vdout0_87ck88 FIND v(dout0_87) AT=445.025n

* CHECK dout0_0 Vdout0_0ck89 = 0.9 time = 450
.meas tran vdout0_0ck89 FIND v(dout0_0) AT=450.025n

* CHECK dout0_1 Vdout0_1ck89 = 0.9 time = 450
.meas tran vdout0_1ck89 FIND v(dout0_1) AT=450.025n

* CHECK dout0_2 Vdout0_2ck89 = 0 time = 450
.meas tran vdout0_2ck89 FIND v(dout0_2) AT=450.025n

* CHECK dout0_3 Vdout0_3ck89 = 0.9 time = 450
.meas tran vdout0_3ck89 FIND v(dout0_3) AT=450.025n

* CHECK dout0_4 Vdout0_4ck89 = 0 time = 450
.meas tran vdout0_4ck89 FIND v(dout0_4) AT=450.025n

* CHECK dout0_5 Vdout0_5ck89 = 0 time = 450
.meas tran vdout0_5ck89 FIND v(dout0_5) AT=450.025n

* CHECK dout0_6 Vdout0_6ck89 = 0.9 time = 450
.meas tran vdout0_6ck89 FIND v(dout0_6) AT=450.025n

* CHECK dout0_7 Vdout0_7ck89 = 0 time = 450
.meas tran vdout0_7ck89 FIND v(dout0_7) AT=450.025n

* CHECK dout0_8 Vdout0_8ck89 = 0 time = 450
.meas tran vdout0_8ck89 FIND v(dout0_8) AT=450.025n

* CHECK dout0_9 Vdout0_9ck89 = 0.9 time = 450
.meas tran vdout0_9ck89 FIND v(dout0_9) AT=450.025n

* CHECK dout0_10 Vdout0_10ck89 = 0 time = 450
.meas tran vdout0_10ck89 FIND v(dout0_10) AT=450.025n

* CHECK dout0_11 Vdout0_11ck89 = 0.9 time = 450
.meas tran vdout0_11ck89 FIND v(dout0_11) AT=450.025n

* CHECK dout0_12 Vdout0_12ck89 = 0 time = 450
.meas tran vdout0_12ck89 FIND v(dout0_12) AT=450.025n

* CHECK dout0_13 Vdout0_13ck89 = 0 time = 450
.meas tran vdout0_13ck89 FIND v(dout0_13) AT=450.025n

* CHECK dout0_14 Vdout0_14ck89 = 0.9 time = 450
.meas tran vdout0_14ck89 FIND v(dout0_14) AT=450.025n

* CHECK dout0_15 Vdout0_15ck89 = 0 time = 450
.meas tran vdout0_15ck89 FIND v(dout0_15) AT=450.025n

* CHECK dout0_16 Vdout0_16ck89 = 0 time = 450
.meas tran vdout0_16ck89 FIND v(dout0_16) AT=450.025n

* CHECK dout0_17 Vdout0_17ck89 = 0 time = 450
.meas tran vdout0_17ck89 FIND v(dout0_17) AT=450.025n

* CHECK dout0_18 Vdout0_18ck89 = 0.9 time = 450
.meas tran vdout0_18ck89 FIND v(dout0_18) AT=450.025n

* CHECK dout0_19 Vdout0_19ck89 = 0.9 time = 450
.meas tran vdout0_19ck89 FIND v(dout0_19) AT=450.025n

* CHECK dout0_20 Vdout0_20ck89 = 0.9 time = 450
.meas tran vdout0_20ck89 FIND v(dout0_20) AT=450.025n

* CHECK dout0_21 Vdout0_21ck89 = 0.9 time = 450
.meas tran vdout0_21ck89 FIND v(dout0_21) AT=450.025n

* CHECK dout0_22 Vdout0_22ck89 = 0.9 time = 450
.meas tran vdout0_22ck89 FIND v(dout0_22) AT=450.025n

* CHECK dout0_23 Vdout0_23ck89 = 0.9 time = 450
.meas tran vdout0_23ck89 FIND v(dout0_23) AT=450.025n

* CHECK dout0_24 Vdout0_24ck89 = 0.9 time = 450
.meas tran vdout0_24ck89 FIND v(dout0_24) AT=450.025n

* CHECK dout0_25 Vdout0_25ck89 = 0 time = 450
.meas tran vdout0_25ck89 FIND v(dout0_25) AT=450.025n

* CHECK dout0_26 Vdout0_26ck89 = 0.9 time = 450
.meas tran vdout0_26ck89 FIND v(dout0_26) AT=450.025n

* CHECK dout0_27 Vdout0_27ck89 = 0 time = 450
.meas tran vdout0_27ck89 FIND v(dout0_27) AT=450.025n

* CHECK dout0_28 Vdout0_28ck89 = 0 time = 450
.meas tran vdout0_28ck89 FIND v(dout0_28) AT=450.025n

* CHECK dout0_29 Vdout0_29ck89 = 0.9 time = 450
.meas tran vdout0_29ck89 FIND v(dout0_29) AT=450.025n

* CHECK dout0_30 Vdout0_30ck89 = 0 time = 450
.meas tran vdout0_30ck89 FIND v(dout0_30) AT=450.025n

* CHECK dout0_31 Vdout0_31ck89 = 0 time = 450
.meas tran vdout0_31ck89 FIND v(dout0_31) AT=450.025n

* CHECK dout0_32 Vdout0_32ck89 = 0 time = 450
.meas tran vdout0_32ck89 FIND v(dout0_32) AT=450.025n

* CHECK dout0_33 Vdout0_33ck89 = 0.9 time = 450
.meas tran vdout0_33ck89 FIND v(dout0_33) AT=450.025n

* CHECK dout0_34 Vdout0_34ck89 = 0 time = 450
.meas tran vdout0_34ck89 FIND v(dout0_34) AT=450.025n

* CHECK dout0_35 Vdout0_35ck89 = 0 time = 450
.meas tran vdout0_35ck89 FIND v(dout0_35) AT=450.025n

* CHECK dout0_36 Vdout0_36ck89 = 0.9 time = 450
.meas tran vdout0_36ck89 FIND v(dout0_36) AT=450.025n

* CHECK dout0_37 Vdout0_37ck89 = 0.9 time = 450
.meas tran vdout0_37ck89 FIND v(dout0_37) AT=450.025n

* CHECK dout0_38 Vdout0_38ck89 = 0 time = 450
.meas tran vdout0_38ck89 FIND v(dout0_38) AT=450.025n

* CHECK dout0_39 Vdout0_39ck89 = 0 time = 450
.meas tran vdout0_39ck89 FIND v(dout0_39) AT=450.025n

* CHECK dout0_40 Vdout0_40ck89 = 0.9 time = 450
.meas tran vdout0_40ck89 FIND v(dout0_40) AT=450.025n

* CHECK dout0_41 Vdout0_41ck89 = 0 time = 450
.meas tran vdout0_41ck89 FIND v(dout0_41) AT=450.025n

* CHECK dout0_42 Vdout0_42ck89 = 0 time = 450
.meas tran vdout0_42ck89 FIND v(dout0_42) AT=450.025n

* CHECK dout0_43 Vdout0_43ck89 = 0 time = 450
.meas tran vdout0_43ck89 FIND v(dout0_43) AT=450.025n

* CHECK dout0_44 Vdout0_44ck89 = 0 time = 450
.meas tran vdout0_44ck89 FIND v(dout0_44) AT=450.025n

* CHECK dout0_45 Vdout0_45ck89 = 0 time = 450
.meas tran vdout0_45ck89 FIND v(dout0_45) AT=450.025n

* CHECK dout0_46 Vdout0_46ck89 = 0.9 time = 450
.meas tran vdout0_46ck89 FIND v(dout0_46) AT=450.025n

* CHECK dout0_47 Vdout0_47ck89 = 0.9 time = 450
.meas tran vdout0_47ck89 FIND v(dout0_47) AT=450.025n

* CHECK dout0_48 Vdout0_48ck89 = 0 time = 450
.meas tran vdout0_48ck89 FIND v(dout0_48) AT=450.025n

* CHECK dout0_49 Vdout0_49ck89 = 0.9 time = 450
.meas tran vdout0_49ck89 FIND v(dout0_49) AT=450.025n

* CHECK dout0_50 Vdout0_50ck89 = 0.9 time = 450
.meas tran vdout0_50ck89 FIND v(dout0_50) AT=450.025n

* CHECK dout0_51 Vdout0_51ck89 = 0.9 time = 450
.meas tran vdout0_51ck89 FIND v(dout0_51) AT=450.025n

* CHECK dout0_52 Vdout0_52ck89 = 0.9 time = 450
.meas tran vdout0_52ck89 FIND v(dout0_52) AT=450.025n

* CHECK dout0_53 Vdout0_53ck89 = 0.9 time = 450
.meas tran vdout0_53ck89 FIND v(dout0_53) AT=450.025n

* CHECK dout0_54 Vdout0_54ck89 = 0 time = 450
.meas tran vdout0_54ck89 FIND v(dout0_54) AT=450.025n

* CHECK dout0_55 Vdout0_55ck89 = 0 time = 450
.meas tran vdout0_55ck89 FIND v(dout0_55) AT=450.025n

* CHECK dout0_56 Vdout0_56ck89 = 0 time = 450
.meas tran vdout0_56ck89 FIND v(dout0_56) AT=450.025n

* CHECK dout0_57 Vdout0_57ck89 = 0.9 time = 450
.meas tran vdout0_57ck89 FIND v(dout0_57) AT=450.025n

* CHECK dout0_58 Vdout0_58ck89 = 0.9 time = 450
.meas tran vdout0_58ck89 FIND v(dout0_58) AT=450.025n

* CHECK dout0_59 Vdout0_59ck89 = 0 time = 450
.meas tran vdout0_59ck89 FIND v(dout0_59) AT=450.025n

* CHECK dout0_60 Vdout0_60ck89 = 0.9 time = 450
.meas tran vdout0_60ck89 FIND v(dout0_60) AT=450.025n

* CHECK dout0_61 Vdout0_61ck89 = 0 time = 450
.meas tran vdout0_61ck89 FIND v(dout0_61) AT=450.025n

* CHECK dout0_62 Vdout0_62ck89 = 0 time = 450
.meas tran vdout0_62ck89 FIND v(dout0_62) AT=450.025n

* CHECK dout0_63 Vdout0_63ck89 = 0 time = 450
.meas tran vdout0_63ck89 FIND v(dout0_63) AT=450.025n

* CHECK dout0_64 Vdout0_64ck89 = 0 time = 450
.meas tran vdout0_64ck89 FIND v(dout0_64) AT=450.025n

* CHECK dout0_65 Vdout0_65ck89 = 0.9 time = 450
.meas tran vdout0_65ck89 FIND v(dout0_65) AT=450.025n

* CHECK dout0_66 Vdout0_66ck89 = 0.9 time = 450
.meas tran vdout0_66ck89 FIND v(dout0_66) AT=450.025n

* CHECK dout0_67 Vdout0_67ck89 = 0.9 time = 450
.meas tran vdout0_67ck89 FIND v(dout0_67) AT=450.025n

* CHECK dout0_68 Vdout0_68ck89 = 0.9 time = 450
.meas tran vdout0_68ck89 FIND v(dout0_68) AT=450.025n

* CHECK dout0_69 Vdout0_69ck89 = 0 time = 450
.meas tran vdout0_69ck89 FIND v(dout0_69) AT=450.025n

* CHECK dout0_70 Vdout0_70ck89 = 0 time = 450
.meas tran vdout0_70ck89 FIND v(dout0_70) AT=450.025n

* CHECK dout0_71 Vdout0_71ck89 = 0 time = 450
.meas tran vdout0_71ck89 FIND v(dout0_71) AT=450.025n

* CHECK dout0_72 Vdout0_72ck89 = 0 time = 450
.meas tran vdout0_72ck89 FIND v(dout0_72) AT=450.025n

* CHECK dout0_73 Vdout0_73ck89 = 0.9 time = 450
.meas tran vdout0_73ck89 FIND v(dout0_73) AT=450.025n

* CHECK dout0_74 Vdout0_74ck89 = 0 time = 450
.meas tran vdout0_74ck89 FIND v(dout0_74) AT=450.025n

* CHECK dout0_75 Vdout0_75ck89 = 0.9 time = 450
.meas tran vdout0_75ck89 FIND v(dout0_75) AT=450.025n

* CHECK dout0_76 Vdout0_76ck89 = 0.9 time = 450
.meas tran vdout0_76ck89 FIND v(dout0_76) AT=450.025n

* CHECK dout0_77 Vdout0_77ck89 = 0 time = 450
.meas tran vdout0_77ck89 FIND v(dout0_77) AT=450.025n

* CHECK dout0_78 Vdout0_78ck89 = 0 time = 450
.meas tran vdout0_78ck89 FIND v(dout0_78) AT=450.025n

* CHECK dout0_79 Vdout0_79ck89 = 0 time = 450
.meas tran vdout0_79ck89 FIND v(dout0_79) AT=450.025n

* CHECK dout0_80 Vdout0_80ck89 = 0.9 time = 450
.meas tran vdout0_80ck89 FIND v(dout0_80) AT=450.025n

* CHECK dout0_81 Vdout0_81ck89 = 0 time = 450
.meas tran vdout0_81ck89 FIND v(dout0_81) AT=450.025n

* CHECK dout0_82 Vdout0_82ck89 = 0 time = 450
.meas tran vdout0_82ck89 FIND v(dout0_82) AT=450.025n

* CHECK dout0_83 Vdout0_83ck89 = 0.9 time = 450
.meas tran vdout0_83ck89 FIND v(dout0_83) AT=450.025n

* CHECK dout0_84 Vdout0_84ck89 = 0.9 time = 450
.meas tran vdout0_84ck89 FIND v(dout0_84) AT=450.025n

* CHECK dout0_85 Vdout0_85ck89 = 0.9 time = 450
.meas tran vdout0_85ck89 FIND v(dout0_85) AT=450.025n

* CHECK dout0_86 Vdout0_86ck89 = 0.9 time = 450
.meas tran vdout0_86ck89 FIND v(dout0_86) AT=450.025n

* CHECK dout0_87 Vdout0_87ck89 = 0.9 time = 450
.meas tran vdout0_87ck89 FIND v(dout0_87) AT=450.025n

* CHECK dout0_0 Vdout0_0ck94 = 0.9 time = 475
.meas tran vdout0_0ck94 FIND v(dout0_0) AT=475.025n

* CHECK dout0_1 Vdout0_1ck94 = 0 time = 475
.meas tran vdout0_1ck94 FIND v(dout0_1) AT=475.025n

* CHECK dout0_2 Vdout0_2ck94 = 0.9 time = 475
.meas tran vdout0_2ck94 FIND v(dout0_2) AT=475.025n

* CHECK dout0_3 Vdout0_3ck94 = 0.9 time = 475
.meas tran vdout0_3ck94 FIND v(dout0_3) AT=475.025n

* CHECK dout0_4 Vdout0_4ck94 = 0.9 time = 475
.meas tran vdout0_4ck94 FIND v(dout0_4) AT=475.025n

* CHECK dout0_5 Vdout0_5ck94 = 0 time = 475
.meas tran vdout0_5ck94 FIND v(dout0_5) AT=475.025n

* CHECK dout0_6 Vdout0_6ck94 = 0 time = 475
.meas tran vdout0_6ck94 FIND v(dout0_6) AT=475.025n

* CHECK dout0_7 Vdout0_7ck94 = 0.9 time = 475
.meas tran vdout0_7ck94 FIND v(dout0_7) AT=475.025n

* CHECK dout0_8 Vdout0_8ck94 = 0 time = 475
.meas tran vdout0_8ck94 FIND v(dout0_8) AT=475.025n

* CHECK dout0_9 Vdout0_9ck94 = 0.9 time = 475
.meas tran vdout0_9ck94 FIND v(dout0_9) AT=475.025n

* CHECK dout0_10 Vdout0_10ck94 = 0.9 time = 475
.meas tran vdout0_10ck94 FIND v(dout0_10) AT=475.025n

* CHECK dout0_11 Vdout0_11ck94 = 0.9 time = 475
.meas tran vdout0_11ck94 FIND v(dout0_11) AT=475.025n

* CHECK dout0_12 Vdout0_12ck94 = 0 time = 475
.meas tran vdout0_12ck94 FIND v(dout0_12) AT=475.025n

* CHECK dout0_13 Vdout0_13ck94 = 0.9 time = 475
.meas tran vdout0_13ck94 FIND v(dout0_13) AT=475.025n

* CHECK dout0_14 Vdout0_14ck94 = 0.9 time = 475
.meas tran vdout0_14ck94 FIND v(dout0_14) AT=475.025n

* CHECK dout0_15 Vdout0_15ck94 = 0 time = 475
.meas tran vdout0_15ck94 FIND v(dout0_15) AT=475.025n

* CHECK dout0_16 Vdout0_16ck94 = 0 time = 475
.meas tran vdout0_16ck94 FIND v(dout0_16) AT=475.025n

* CHECK dout0_17 Vdout0_17ck94 = 0 time = 475
.meas tran vdout0_17ck94 FIND v(dout0_17) AT=475.025n

* CHECK dout0_18 Vdout0_18ck94 = 0 time = 475
.meas tran vdout0_18ck94 FIND v(dout0_18) AT=475.025n

* CHECK dout0_19 Vdout0_19ck94 = 0 time = 475
.meas tran vdout0_19ck94 FIND v(dout0_19) AT=475.025n

* CHECK dout0_20 Vdout0_20ck94 = 0.9 time = 475
.meas tran vdout0_20ck94 FIND v(dout0_20) AT=475.025n

* CHECK dout0_21 Vdout0_21ck94 = 0.9 time = 475
.meas tran vdout0_21ck94 FIND v(dout0_21) AT=475.025n

* CHECK dout0_22 Vdout0_22ck94 = 0 time = 475
.meas tran vdout0_22ck94 FIND v(dout0_22) AT=475.025n

* CHECK dout0_23 Vdout0_23ck94 = 0 time = 475
.meas tran vdout0_23ck94 FIND v(dout0_23) AT=475.025n

* CHECK dout0_24 Vdout0_24ck94 = 0.9 time = 475
.meas tran vdout0_24ck94 FIND v(dout0_24) AT=475.025n

* CHECK dout0_25 Vdout0_25ck94 = 0 time = 475
.meas tran vdout0_25ck94 FIND v(dout0_25) AT=475.025n

* CHECK dout0_26 Vdout0_26ck94 = 0 time = 475
.meas tran vdout0_26ck94 FIND v(dout0_26) AT=475.025n

* CHECK dout0_27 Vdout0_27ck94 = 0.9 time = 475
.meas tran vdout0_27ck94 FIND v(dout0_27) AT=475.025n

* CHECK dout0_28 Vdout0_28ck94 = 0.9 time = 475
.meas tran vdout0_28ck94 FIND v(dout0_28) AT=475.025n

* CHECK dout0_29 Vdout0_29ck94 = 0.9 time = 475
.meas tran vdout0_29ck94 FIND v(dout0_29) AT=475.025n

* CHECK dout0_30 Vdout0_30ck94 = 0 time = 475
.meas tran vdout0_30ck94 FIND v(dout0_30) AT=475.025n

* CHECK dout0_31 Vdout0_31ck94 = 0 time = 475
.meas tran vdout0_31ck94 FIND v(dout0_31) AT=475.025n

* CHECK dout0_32 Vdout0_32ck94 = 0.9 time = 475
.meas tran vdout0_32ck94 FIND v(dout0_32) AT=475.025n

* CHECK dout0_33 Vdout0_33ck94 = 0 time = 475
.meas tran vdout0_33ck94 FIND v(dout0_33) AT=475.025n

* CHECK dout0_34 Vdout0_34ck94 = 0 time = 475
.meas tran vdout0_34ck94 FIND v(dout0_34) AT=475.025n

* CHECK dout0_35 Vdout0_35ck94 = 0.9 time = 475
.meas tran vdout0_35ck94 FIND v(dout0_35) AT=475.025n

* CHECK dout0_36 Vdout0_36ck94 = 0 time = 475
.meas tran vdout0_36ck94 FIND v(dout0_36) AT=475.025n

* CHECK dout0_37 Vdout0_37ck94 = 0.9 time = 475
.meas tran vdout0_37ck94 FIND v(dout0_37) AT=475.025n

* CHECK dout0_38 Vdout0_38ck94 = 0.9 time = 475
.meas tran vdout0_38ck94 FIND v(dout0_38) AT=475.025n

* CHECK dout0_39 Vdout0_39ck94 = 0.9 time = 475
.meas tran vdout0_39ck94 FIND v(dout0_39) AT=475.025n

* CHECK dout0_40 Vdout0_40ck94 = 0 time = 475
.meas tran vdout0_40ck94 FIND v(dout0_40) AT=475.025n

* CHECK dout0_41 Vdout0_41ck94 = 0.9 time = 475
.meas tran vdout0_41ck94 FIND v(dout0_41) AT=475.025n

* CHECK dout0_42 Vdout0_42ck94 = 0 time = 475
.meas tran vdout0_42ck94 FIND v(dout0_42) AT=475.025n

* CHECK dout0_43 Vdout0_43ck94 = 0.9 time = 475
.meas tran vdout0_43ck94 FIND v(dout0_43) AT=475.025n

* CHECK dout0_44 Vdout0_44ck94 = 0 time = 475
.meas tran vdout0_44ck94 FIND v(dout0_44) AT=475.025n

* CHECK dout0_45 Vdout0_45ck94 = 0 time = 475
.meas tran vdout0_45ck94 FIND v(dout0_45) AT=475.025n

* CHECK dout0_46 Vdout0_46ck94 = 0.9 time = 475
.meas tran vdout0_46ck94 FIND v(dout0_46) AT=475.025n

* CHECK dout0_47 Vdout0_47ck94 = 0 time = 475
.meas tran vdout0_47ck94 FIND v(dout0_47) AT=475.025n

* CHECK dout0_48 Vdout0_48ck94 = 0.9 time = 475
.meas tran vdout0_48ck94 FIND v(dout0_48) AT=475.025n

* CHECK dout0_49 Vdout0_49ck94 = 0 time = 475
.meas tran vdout0_49ck94 FIND v(dout0_49) AT=475.025n

* CHECK dout0_50 Vdout0_50ck94 = 0.9 time = 475
.meas tran vdout0_50ck94 FIND v(dout0_50) AT=475.025n

* CHECK dout0_51 Vdout0_51ck94 = 0.9 time = 475
.meas tran vdout0_51ck94 FIND v(dout0_51) AT=475.025n

* CHECK dout0_52 Vdout0_52ck94 = 0 time = 475
.meas tran vdout0_52ck94 FIND v(dout0_52) AT=475.025n

* CHECK dout0_53 Vdout0_53ck94 = 0.9 time = 475
.meas tran vdout0_53ck94 FIND v(dout0_53) AT=475.025n

* CHECK dout0_54 Vdout0_54ck94 = 0 time = 475
.meas tran vdout0_54ck94 FIND v(dout0_54) AT=475.025n

* CHECK dout0_55 Vdout0_55ck94 = 0.9 time = 475
.meas tran vdout0_55ck94 FIND v(dout0_55) AT=475.025n

* CHECK dout0_56 Vdout0_56ck94 = 0 time = 475
.meas tran vdout0_56ck94 FIND v(dout0_56) AT=475.025n

* CHECK dout0_57 Vdout0_57ck94 = 0 time = 475
.meas tran vdout0_57ck94 FIND v(dout0_57) AT=475.025n

* CHECK dout0_58 Vdout0_58ck94 = 0.9 time = 475
.meas tran vdout0_58ck94 FIND v(dout0_58) AT=475.025n

* CHECK dout0_59 Vdout0_59ck94 = 0 time = 475
.meas tran vdout0_59ck94 FIND v(dout0_59) AT=475.025n

* CHECK dout0_60 Vdout0_60ck94 = 0 time = 475
.meas tran vdout0_60ck94 FIND v(dout0_60) AT=475.025n

* CHECK dout0_61 Vdout0_61ck94 = 0.9 time = 475
.meas tran vdout0_61ck94 FIND v(dout0_61) AT=475.025n

* CHECK dout0_62 Vdout0_62ck94 = 0.9 time = 475
.meas tran vdout0_62ck94 FIND v(dout0_62) AT=475.025n

* CHECK dout0_63 Vdout0_63ck94 = 0 time = 475
.meas tran vdout0_63ck94 FIND v(dout0_63) AT=475.025n

* CHECK dout0_64 Vdout0_64ck94 = 0.9 time = 475
.meas tran vdout0_64ck94 FIND v(dout0_64) AT=475.025n

* CHECK dout0_65 Vdout0_65ck94 = 0.9 time = 475
.meas tran vdout0_65ck94 FIND v(dout0_65) AT=475.025n

* CHECK dout0_66 Vdout0_66ck94 = 0 time = 475
.meas tran vdout0_66ck94 FIND v(dout0_66) AT=475.025n

* CHECK dout0_67 Vdout0_67ck94 = 0.9 time = 475
.meas tran vdout0_67ck94 FIND v(dout0_67) AT=475.025n

* CHECK dout0_68 Vdout0_68ck94 = 0.9 time = 475
.meas tran vdout0_68ck94 FIND v(dout0_68) AT=475.025n

* CHECK dout0_69 Vdout0_69ck94 = 0.9 time = 475
.meas tran vdout0_69ck94 FIND v(dout0_69) AT=475.025n

* CHECK dout0_70 Vdout0_70ck94 = 0 time = 475
.meas tran vdout0_70ck94 FIND v(dout0_70) AT=475.025n

* CHECK dout0_71 Vdout0_71ck94 = 0 time = 475
.meas tran vdout0_71ck94 FIND v(dout0_71) AT=475.025n

* CHECK dout0_72 Vdout0_72ck94 = 0.9 time = 475
.meas tran vdout0_72ck94 FIND v(dout0_72) AT=475.025n

* CHECK dout0_73 Vdout0_73ck94 = 0 time = 475
.meas tran vdout0_73ck94 FIND v(dout0_73) AT=475.025n

* CHECK dout0_74 Vdout0_74ck94 = 0.9 time = 475
.meas tran vdout0_74ck94 FIND v(dout0_74) AT=475.025n

* CHECK dout0_75 Vdout0_75ck94 = 0.9 time = 475
.meas tran vdout0_75ck94 FIND v(dout0_75) AT=475.025n

* CHECK dout0_76 Vdout0_76ck94 = 0 time = 475
.meas tran vdout0_76ck94 FIND v(dout0_76) AT=475.025n

* CHECK dout0_77 Vdout0_77ck94 = 0 time = 475
.meas tran vdout0_77ck94 FIND v(dout0_77) AT=475.025n

* CHECK dout0_78 Vdout0_78ck94 = 0.9 time = 475
.meas tran vdout0_78ck94 FIND v(dout0_78) AT=475.025n

* CHECK dout0_79 Vdout0_79ck94 = 0 time = 475
.meas tran vdout0_79ck94 FIND v(dout0_79) AT=475.025n

* CHECK dout0_80 Vdout0_80ck94 = 0.9 time = 475
.meas tran vdout0_80ck94 FIND v(dout0_80) AT=475.025n

* CHECK dout0_81 Vdout0_81ck94 = 0 time = 475
.meas tran vdout0_81ck94 FIND v(dout0_81) AT=475.025n

* CHECK dout0_82 Vdout0_82ck94 = 0 time = 475
.meas tran vdout0_82ck94 FIND v(dout0_82) AT=475.025n

* CHECK dout0_83 Vdout0_83ck94 = 0.9 time = 475
.meas tran vdout0_83ck94 FIND v(dout0_83) AT=475.025n

* CHECK dout0_84 Vdout0_84ck94 = 0.9 time = 475
.meas tran vdout0_84ck94 FIND v(dout0_84) AT=475.025n

* CHECK dout0_85 Vdout0_85ck94 = 0 time = 475
.meas tran vdout0_85ck94 FIND v(dout0_85) AT=475.025n

* CHECK dout0_86 Vdout0_86ck94 = 0.9 time = 475
.meas tran vdout0_86ck94 FIND v(dout0_86) AT=475.025n

* CHECK dout0_87 Vdout0_87ck94 = 0.9 time = 475
.meas tran vdout0_87ck94 FIND v(dout0_87) AT=475.025n

* CHECK dout0_0 Vdout0_0ck96 = 0.9 time = 485
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=485.025n

* CHECK dout0_1 Vdout0_1ck96 = 0.9 time = 485
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=485.025n

* CHECK dout0_2 Vdout0_2ck96 = 0.9 time = 485
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=485.025n

* CHECK dout0_3 Vdout0_3ck96 = 0 time = 485
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=485.025n

* CHECK dout0_4 Vdout0_4ck96 = 0.9 time = 485
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=485.025n

* CHECK dout0_5 Vdout0_5ck96 = 0 time = 485
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=485.025n

* CHECK dout0_6 Vdout0_6ck96 = 0 time = 485
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=485.025n

* CHECK dout0_7 Vdout0_7ck96 = 0.9 time = 485
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=485.025n

* CHECK dout0_8 Vdout0_8ck96 = 0 time = 485
.meas tran vdout0_8ck96 FIND v(dout0_8) AT=485.025n

* CHECK dout0_9 Vdout0_9ck96 = 0.9 time = 485
.meas tran vdout0_9ck96 FIND v(dout0_9) AT=485.025n

* CHECK dout0_10 Vdout0_10ck96 = 0.9 time = 485
.meas tran vdout0_10ck96 FIND v(dout0_10) AT=485.025n

* CHECK dout0_11 Vdout0_11ck96 = 0.9 time = 485
.meas tran vdout0_11ck96 FIND v(dout0_11) AT=485.025n

* CHECK dout0_12 Vdout0_12ck96 = 0 time = 485
.meas tran vdout0_12ck96 FIND v(dout0_12) AT=485.025n

* CHECK dout0_13 Vdout0_13ck96 = 0 time = 485
.meas tran vdout0_13ck96 FIND v(dout0_13) AT=485.025n

* CHECK dout0_14 Vdout0_14ck96 = 0.9 time = 485
.meas tran vdout0_14ck96 FIND v(dout0_14) AT=485.025n

* CHECK dout0_15 Vdout0_15ck96 = 0 time = 485
.meas tran vdout0_15ck96 FIND v(dout0_15) AT=485.025n

* CHECK dout0_16 Vdout0_16ck96 = 0.9 time = 485
.meas tran vdout0_16ck96 FIND v(dout0_16) AT=485.025n

* CHECK dout0_17 Vdout0_17ck96 = 0 time = 485
.meas tran vdout0_17ck96 FIND v(dout0_17) AT=485.025n

* CHECK dout0_18 Vdout0_18ck96 = 0 time = 485
.meas tran vdout0_18ck96 FIND v(dout0_18) AT=485.025n

* CHECK dout0_19 Vdout0_19ck96 = 0.9 time = 485
.meas tran vdout0_19ck96 FIND v(dout0_19) AT=485.025n

* CHECK dout0_20 Vdout0_20ck96 = 0 time = 485
.meas tran vdout0_20ck96 FIND v(dout0_20) AT=485.025n

* CHECK dout0_21 Vdout0_21ck96 = 0 time = 485
.meas tran vdout0_21ck96 FIND v(dout0_21) AT=485.025n

* CHECK dout0_22 Vdout0_22ck96 = 0 time = 485
.meas tran vdout0_22ck96 FIND v(dout0_22) AT=485.025n

* CHECK dout0_23 Vdout0_23ck96 = 0.9 time = 485
.meas tran vdout0_23ck96 FIND v(dout0_23) AT=485.025n

* CHECK dout0_24 Vdout0_24ck96 = 0.9 time = 485
.meas tran vdout0_24ck96 FIND v(dout0_24) AT=485.025n

* CHECK dout0_25 Vdout0_25ck96 = 0 time = 485
.meas tran vdout0_25ck96 FIND v(dout0_25) AT=485.025n

* CHECK dout0_26 Vdout0_26ck96 = 0.9 time = 485
.meas tran vdout0_26ck96 FIND v(dout0_26) AT=485.025n

* CHECK dout0_27 Vdout0_27ck96 = 0.9 time = 485
.meas tran vdout0_27ck96 FIND v(dout0_27) AT=485.025n

* CHECK dout0_28 Vdout0_28ck96 = 0.9 time = 485
.meas tran vdout0_28ck96 FIND v(dout0_28) AT=485.025n

* CHECK dout0_29 Vdout0_29ck96 = 0 time = 485
.meas tran vdout0_29ck96 FIND v(dout0_29) AT=485.025n

* CHECK dout0_30 Vdout0_30ck96 = 0.9 time = 485
.meas tran vdout0_30ck96 FIND v(dout0_30) AT=485.025n

* CHECK dout0_31 Vdout0_31ck96 = 0 time = 485
.meas tran vdout0_31ck96 FIND v(dout0_31) AT=485.025n

* CHECK dout0_32 Vdout0_32ck96 = 0.9 time = 485
.meas tran vdout0_32ck96 FIND v(dout0_32) AT=485.025n

* CHECK dout0_33 Vdout0_33ck96 = 0.9 time = 485
.meas tran vdout0_33ck96 FIND v(dout0_33) AT=485.025n

* CHECK dout0_34 Vdout0_34ck96 = 0.9 time = 485
.meas tran vdout0_34ck96 FIND v(dout0_34) AT=485.025n

* CHECK dout0_35 Vdout0_35ck96 = 0.9 time = 485
.meas tran vdout0_35ck96 FIND v(dout0_35) AT=485.025n

* CHECK dout0_36 Vdout0_36ck96 = 0.9 time = 485
.meas tran vdout0_36ck96 FIND v(dout0_36) AT=485.025n

* CHECK dout0_37 Vdout0_37ck96 = 0 time = 485
.meas tran vdout0_37ck96 FIND v(dout0_37) AT=485.025n

* CHECK dout0_38 Vdout0_38ck96 = 0.9 time = 485
.meas tran vdout0_38ck96 FIND v(dout0_38) AT=485.025n

* CHECK dout0_39 Vdout0_39ck96 = 0.9 time = 485
.meas tran vdout0_39ck96 FIND v(dout0_39) AT=485.025n

* CHECK dout0_40 Vdout0_40ck96 = 0.9 time = 485
.meas tran vdout0_40ck96 FIND v(dout0_40) AT=485.025n

* CHECK dout0_41 Vdout0_41ck96 = 0 time = 485
.meas tran vdout0_41ck96 FIND v(dout0_41) AT=485.025n

* CHECK dout0_42 Vdout0_42ck96 = 0 time = 485
.meas tran vdout0_42ck96 FIND v(dout0_42) AT=485.025n

* CHECK dout0_43 Vdout0_43ck96 = 0 time = 485
.meas tran vdout0_43ck96 FIND v(dout0_43) AT=485.025n

* CHECK dout0_44 Vdout0_44ck96 = 0 time = 485
.meas tran vdout0_44ck96 FIND v(dout0_44) AT=485.025n

* CHECK dout0_45 Vdout0_45ck96 = 0.9 time = 485
.meas tran vdout0_45ck96 FIND v(dout0_45) AT=485.025n

* CHECK dout0_46 Vdout0_46ck96 = 0.9 time = 485
.meas tran vdout0_46ck96 FIND v(dout0_46) AT=485.025n

* CHECK dout0_47 Vdout0_47ck96 = 0.9 time = 485
.meas tran vdout0_47ck96 FIND v(dout0_47) AT=485.025n

* CHECK dout0_48 Vdout0_48ck96 = 0 time = 485
.meas tran vdout0_48ck96 FIND v(dout0_48) AT=485.025n

* CHECK dout0_49 Vdout0_49ck96 = 0 time = 485
.meas tran vdout0_49ck96 FIND v(dout0_49) AT=485.025n

* CHECK dout0_50 Vdout0_50ck96 = 0.9 time = 485
.meas tran vdout0_50ck96 FIND v(dout0_50) AT=485.025n

* CHECK dout0_51 Vdout0_51ck96 = 0 time = 485
.meas tran vdout0_51ck96 FIND v(dout0_51) AT=485.025n

* CHECK dout0_52 Vdout0_52ck96 = 0.9 time = 485
.meas tran vdout0_52ck96 FIND v(dout0_52) AT=485.025n

* CHECK dout0_53 Vdout0_53ck96 = 0 time = 485
.meas tran vdout0_53ck96 FIND v(dout0_53) AT=485.025n

* CHECK dout0_54 Vdout0_54ck96 = 0 time = 485
.meas tran vdout0_54ck96 FIND v(dout0_54) AT=485.025n

* CHECK dout0_55 Vdout0_55ck96 = 0 time = 485
.meas tran vdout0_55ck96 FIND v(dout0_55) AT=485.025n

* CHECK dout0_56 Vdout0_56ck96 = 0.9 time = 485
.meas tran vdout0_56ck96 FIND v(dout0_56) AT=485.025n

* CHECK dout0_57 Vdout0_57ck96 = 0.9 time = 485
.meas tran vdout0_57ck96 FIND v(dout0_57) AT=485.025n

* CHECK dout0_58 Vdout0_58ck96 = 0 time = 485
.meas tran vdout0_58ck96 FIND v(dout0_58) AT=485.025n

* CHECK dout0_59 Vdout0_59ck96 = 0.9 time = 485
.meas tran vdout0_59ck96 FIND v(dout0_59) AT=485.025n

* CHECK dout0_60 Vdout0_60ck96 = 0.9 time = 485
.meas tran vdout0_60ck96 FIND v(dout0_60) AT=485.025n

* CHECK dout0_61 Vdout0_61ck96 = 0.9 time = 485
.meas tran vdout0_61ck96 FIND v(dout0_61) AT=485.025n

* CHECK dout0_62 Vdout0_62ck96 = 0.9 time = 485
.meas tran vdout0_62ck96 FIND v(dout0_62) AT=485.025n

* CHECK dout0_63 Vdout0_63ck96 = 0.9 time = 485
.meas tran vdout0_63ck96 FIND v(dout0_63) AT=485.025n

* CHECK dout0_64 Vdout0_64ck96 = 0 time = 485
.meas tran vdout0_64ck96 FIND v(dout0_64) AT=485.025n

* CHECK dout0_65 Vdout0_65ck96 = 0 time = 485
.meas tran vdout0_65ck96 FIND v(dout0_65) AT=485.025n

* CHECK dout0_66 Vdout0_66ck96 = 0.9 time = 485
.meas tran vdout0_66ck96 FIND v(dout0_66) AT=485.025n

* CHECK dout0_67 Vdout0_67ck96 = 0 time = 485
.meas tran vdout0_67ck96 FIND v(dout0_67) AT=485.025n

* CHECK dout0_68 Vdout0_68ck96 = 0 time = 485
.meas tran vdout0_68ck96 FIND v(dout0_68) AT=485.025n

* CHECK dout0_69 Vdout0_69ck96 = 0 time = 485
.meas tran vdout0_69ck96 FIND v(dout0_69) AT=485.025n

* CHECK dout0_70 Vdout0_70ck96 = 0.9 time = 485
.meas tran vdout0_70ck96 FIND v(dout0_70) AT=485.025n

* CHECK dout0_71 Vdout0_71ck96 = 0.9 time = 485
.meas tran vdout0_71ck96 FIND v(dout0_71) AT=485.025n

* CHECK dout0_72 Vdout0_72ck96 = 0.9 time = 485
.meas tran vdout0_72ck96 FIND v(dout0_72) AT=485.025n

* CHECK dout0_73 Vdout0_73ck96 = 0 time = 485
.meas tran vdout0_73ck96 FIND v(dout0_73) AT=485.025n

* CHECK dout0_74 Vdout0_74ck96 = 0.9 time = 485
.meas tran vdout0_74ck96 FIND v(dout0_74) AT=485.025n

* CHECK dout0_75 Vdout0_75ck96 = 0 time = 485
.meas tran vdout0_75ck96 FIND v(dout0_75) AT=485.025n

* CHECK dout0_76 Vdout0_76ck96 = 0 time = 485
.meas tran vdout0_76ck96 FIND v(dout0_76) AT=485.025n

* CHECK dout0_77 Vdout0_77ck96 = 0 time = 485
.meas tran vdout0_77ck96 FIND v(dout0_77) AT=485.025n

* CHECK dout0_78 Vdout0_78ck96 = 0 time = 485
.meas tran vdout0_78ck96 FIND v(dout0_78) AT=485.025n

* CHECK dout0_79 Vdout0_79ck96 = 0 time = 485
.meas tran vdout0_79ck96 FIND v(dout0_79) AT=485.025n

* CHECK dout0_80 Vdout0_80ck96 = 0 time = 485
.meas tran vdout0_80ck96 FIND v(dout0_80) AT=485.025n

* CHECK dout0_81 Vdout0_81ck96 = 0.9 time = 485
.meas tran vdout0_81ck96 FIND v(dout0_81) AT=485.025n

* CHECK dout0_82 Vdout0_82ck96 = 0 time = 485
.meas tran vdout0_82ck96 FIND v(dout0_82) AT=485.025n

* CHECK dout0_83 Vdout0_83ck96 = 0.9 time = 485
.meas tran vdout0_83ck96 FIND v(dout0_83) AT=485.025n

* CHECK dout0_84 Vdout0_84ck96 = 0.9 time = 485
.meas tran vdout0_84ck96 FIND v(dout0_84) AT=485.025n

* CHECK dout0_85 Vdout0_85ck96 = 0 time = 485
.meas tran vdout0_85ck96 FIND v(dout0_85) AT=485.025n

* CHECK dout0_86 Vdout0_86ck96 = 0 time = 485
.meas tran vdout0_86ck96 FIND v(dout0_86) AT=485.025n

* CHECK dout0_87 Vdout0_87ck96 = 0 time = 485
.meas tran vdout0_87ck96 FIND v(dout0_87) AT=485.025n

* CHECK dout0_0 Vdout0_0ck100 = 0.9 time = 505
.meas tran vdout0_0ck100 FIND v(dout0_0) AT=505.025n

* CHECK dout0_1 Vdout0_1ck100 = 0 time = 505
.meas tran vdout0_1ck100 FIND v(dout0_1) AT=505.025n

* CHECK dout0_2 Vdout0_2ck100 = 0 time = 505
.meas tran vdout0_2ck100 FIND v(dout0_2) AT=505.025n

* CHECK dout0_3 Vdout0_3ck100 = 0 time = 505
.meas tran vdout0_3ck100 FIND v(dout0_3) AT=505.025n

* CHECK dout0_4 Vdout0_4ck100 = 0.9 time = 505
.meas tran vdout0_4ck100 FIND v(dout0_4) AT=505.025n

* CHECK dout0_5 Vdout0_5ck100 = 0 time = 505
.meas tran vdout0_5ck100 FIND v(dout0_5) AT=505.025n

* CHECK dout0_6 Vdout0_6ck100 = 0 time = 505
.meas tran vdout0_6ck100 FIND v(dout0_6) AT=505.025n

* CHECK dout0_7 Vdout0_7ck100 = 0.9 time = 505
.meas tran vdout0_7ck100 FIND v(dout0_7) AT=505.025n

* CHECK dout0_8 Vdout0_8ck100 = 0 time = 505
.meas tran vdout0_8ck100 FIND v(dout0_8) AT=505.025n

* CHECK dout0_9 Vdout0_9ck100 = 0 time = 505
.meas tran vdout0_9ck100 FIND v(dout0_9) AT=505.025n

* CHECK dout0_10 Vdout0_10ck100 = 0.9 time = 505
.meas tran vdout0_10ck100 FIND v(dout0_10) AT=505.025n

* CHECK dout0_11 Vdout0_11ck100 = 0 time = 505
.meas tran vdout0_11ck100 FIND v(dout0_11) AT=505.025n

* CHECK dout0_12 Vdout0_12ck100 = 0 time = 505
.meas tran vdout0_12ck100 FIND v(dout0_12) AT=505.025n

* CHECK dout0_13 Vdout0_13ck100 = 0 time = 505
.meas tran vdout0_13ck100 FIND v(dout0_13) AT=505.025n

* CHECK dout0_14 Vdout0_14ck100 = 0 time = 505
.meas tran vdout0_14ck100 FIND v(dout0_14) AT=505.025n

* CHECK dout0_15 Vdout0_15ck100 = 0 time = 505
.meas tran vdout0_15ck100 FIND v(dout0_15) AT=505.025n

* CHECK dout0_16 Vdout0_16ck100 = 0.9 time = 505
.meas tran vdout0_16ck100 FIND v(dout0_16) AT=505.025n

* CHECK dout0_17 Vdout0_17ck100 = 0.9 time = 505
.meas tran vdout0_17ck100 FIND v(dout0_17) AT=505.025n

* CHECK dout0_18 Vdout0_18ck100 = 0 time = 505
.meas tran vdout0_18ck100 FIND v(dout0_18) AT=505.025n

* CHECK dout0_19 Vdout0_19ck100 = 0.9 time = 505
.meas tran vdout0_19ck100 FIND v(dout0_19) AT=505.025n

* CHECK dout0_20 Vdout0_20ck100 = 0 time = 505
.meas tran vdout0_20ck100 FIND v(dout0_20) AT=505.025n

* CHECK dout0_21 Vdout0_21ck100 = 0.9 time = 505
.meas tran vdout0_21ck100 FIND v(dout0_21) AT=505.025n

* CHECK dout0_22 Vdout0_22ck100 = 0.9 time = 505
.meas tran vdout0_22ck100 FIND v(dout0_22) AT=505.025n

* CHECK dout0_23 Vdout0_23ck100 = 0.9 time = 505
.meas tran vdout0_23ck100 FIND v(dout0_23) AT=505.025n

* CHECK dout0_24 Vdout0_24ck100 = 0.9 time = 505
.meas tran vdout0_24ck100 FIND v(dout0_24) AT=505.025n

* CHECK dout0_25 Vdout0_25ck100 = 0.9 time = 505
.meas tran vdout0_25ck100 FIND v(dout0_25) AT=505.025n

* CHECK dout0_26 Vdout0_26ck100 = 0 time = 505
.meas tran vdout0_26ck100 FIND v(dout0_26) AT=505.025n

* CHECK dout0_27 Vdout0_27ck100 = 0 time = 505
.meas tran vdout0_27ck100 FIND v(dout0_27) AT=505.025n

* CHECK dout0_28 Vdout0_28ck100 = 0 time = 505
.meas tran vdout0_28ck100 FIND v(dout0_28) AT=505.025n

* CHECK dout0_29 Vdout0_29ck100 = 0.9 time = 505
.meas tran vdout0_29ck100 FIND v(dout0_29) AT=505.025n

* CHECK dout0_30 Vdout0_30ck100 = 0.9 time = 505
.meas tran vdout0_30ck100 FIND v(dout0_30) AT=505.025n

* CHECK dout0_31 Vdout0_31ck100 = 0 time = 505
.meas tran vdout0_31ck100 FIND v(dout0_31) AT=505.025n

* CHECK dout0_32 Vdout0_32ck100 = 0.9 time = 505
.meas tran vdout0_32ck100 FIND v(dout0_32) AT=505.025n

* CHECK dout0_33 Vdout0_33ck100 = 0 time = 505
.meas tran vdout0_33ck100 FIND v(dout0_33) AT=505.025n

* CHECK dout0_34 Vdout0_34ck100 = 0 time = 505
.meas tran vdout0_34ck100 FIND v(dout0_34) AT=505.025n

* CHECK dout0_35 Vdout0_35ck100 = 0 time = 505
.meas tran vdout0_35ck100 FIND v(dout0_35) AT=505.025n

* CHECK dout0_36 Vdout0_36ck100 = 0.9 time = 505
.meas tran vdout0_36ck100 FIND v(dout0_36) AT=505.025n

* CHECK dout0_37 Vdout0_37ck100 = 0.9 time = 505
.meas tran vdout0_37ck100 FIND v(dout0_37) AT=505.025n

* CHECK dout0_38 Vdout0_38ck100 = 0 time = 505
.meas tran vdout0_38ck100 FIND v(dout0_38) AT=505.025n

* CHECK dout0_39 Vdout0_39ck100 = 0.9 time = 505
.meas tran vdout0_39ck100 FIND v(dout0_39) AT=505.025n

* CHECK dout0_40 Vdout0_40ck100 = 0 time = 505
.meas tran vdout0_40ck100 FIND v(dout0_40) AT=505.025n

* CHECK dout0_41 Vdout0_41ck100 = 0.9 time = 505
.meas tran vdout0_41ck100 FIND v(dout0_41) AT=505.025n

* CHECK dout0_42 Vdout0_42ck100 = 0 time = 505
.meas tran vdout0_42ck100 FIND v(dout0_42) AT=505.025n

* CHECK dout0_43 Vdout0_43ck100 = 0.9 time = 505
.meas tran vdout0_43ck100 FIND v(dout0_43) AT=505.025n

* CHECK dout0_44 Vdout0_44ck100 = 0.9 time = 505
.meas tran vdout0_44ck100 FIND v(dout0_44) AT=505.025n

* CHECK dout0_45 Vdout0_45ck100 = 0.9 time = 505
.meas tran vdout0_45ck100 FIND v(dout0_45) AT=505.025n

* CHECK dout0_46 Vdout0_46ck100 = 0 time = 505
.meas tran vdout0_46ck100 FIND v(dout0_46) AT=505.025n

* CHECK dout0_47 Vdout0_47ck100 = 0.9 time = 505
.meas tran vdout0_47ck100 FIND v(dout0_47) AT=505.025n

* CHECK dout0_48 Vdout0_48ck100 = 0 time = 505
.meas tran vdout0_48ck100 FIND v(dout0_48) AT=505.025n

* CHECK dout0_49 Vdout0_49ck100 = 0.9 time = 505
.meas tran vdout0_49ck100 FIND v(dout0_49) AT=505.025n

* CHECK dout0_50 Vdout0_50ck100 = 0 time = 505
.meas tran vdout0_50ck100 FIND v(dout0_50) AT=505.025n

* CHECK dout0_51 Vdout0_51ck100 = 0 time = 505
.meas tran vdout0_51ck100 FIND v(dout0_51) AT=505.025n

* CHECK dout0_52 Vdout0_52ck100 = 0.9 time = 505
.meas tran vdout0_52ck100 FIND v(dout0_52) AT=505.025n

* CHECK dout0_53 Vdout0_53ck100 = 0.9 time = 505
.meas tran vdout0_53ck100 FIND v(dout0_53) AT=505.025n

* CHECK dout0_54 Vdout0_54ck100 = 0.9 time = 505
.meas tran vdout0_54ck100 FIND v(dout0_54) AT=505.025n

* CHECK dout0_55 Vdout0_55ck100 = 0 time = 505
.meas tran vdout0_55ck100 FIND v(dout0_55) AT=505.025n

* CHECK dout0_56 Vdout0_56ck100 = 0.9 time = 505
.meas tran vdout0_56ck100 FIND v(dout0_56) AT=505.025n

* CHECK dout0_57 Vdout0_57ck100 = 0.9 time = 505
.meas tran vdout0_57ck100 FIND v(dout0_57) AT=505.025n

* CHECK dout0_58 Vdout0_58ck100 = 0.9 time = 505
.meas tran vdout0_58ck100 FIND v(dout0_58) AT=505.025n

* CHECK dout0_59 Vdout0_59ck100 = 0 time = 505
.meas tran vdout0_59ck100 FIND v(dout0_59) AT=505.025n

* CHECK dout0_60 Vdout0_60ck100 = 0 time = 505
.meas tran vdout0_60ck100 FIND v(dout0_60) AT=505.025n

* CHECK dout0_61 Vdout0_61ck100 = 0.9 time = 505
.meas tran vdout0_61ck100 FIND v(dout0_61) AT=505.025n

* CHECK dout0_62 Vdout0_62ck100 = 0.9 time = 505
.meas tran vdout0_62ck100 FIND v(dout0_62) AT=505.025n

* CHECK dout0_63 Vdout0_63ck100 = 0.9 time = 505
.meas tran vdout0_63ck100 FIND v(dout0_63) AT=505.025n

* CHECK dout0_64 Vdout0_64ck100 = 0 time = 505
.meas tran vdout0_64ck100 FIND v(dout0_64) AT=505.025n

* CHECK dout0_65 Vdout0_65ck100 = 0 time = 505
.meas tran vdout0_65ck100 FIND v(dout0_65) AT=505.025n

* CHECK dout0_66 Vdout0_66ck100 = 0.9 time = 505
.meas tran vdout0_66ck100 FIND v(dout0_66) AT=505.025n

* CHECK dout0_67 Vdout0_67ck100 = 0 time = 505
.meas tran vdout0_67ck100 FIND v(dout0_67) AT=505.025n

* CHECK dout0_68 Vdout0_68ck100 = 0 time = 505
.meas tran vdout0_68ck100 FIND v(dout0_68) AT=505.025n

* CHECK dout0_69 Vdout0_69ck100 = 0 time = 505
.meas tran vdout0_69ck100 FIND v(dout0_69) AT=505.025n

* CHECK dout0_70 Vdout0_70ck100 = 0 time = 505
.meas tran vdout0_70ck100 FIND v(dout0_70) AT=505.025n

* CHECK dout0_71 Vdout0_71ck100 = 0 time = 505
.meas tran vdout0_71ck100 FIND v(dout0_71) AT=505.025n

* CHECK dout0_72 Vdout0_72ck100 = 0.9 time = 505
.meas tran vdout0_72ck100 FIND v(dout0_72) AT=505.025n

* CHECK dout0_73 Vdout0_73ck100 = 0 time = 505
.meas tran vdout0_73ck100 FIND v(dout0_73) AT=505.025n

* CHECK dout0_74 Vdout0_74ck100 = 0 time = 505
.meas tran vdout0_74ck100 FIND v(dout0_74) AT=505.025n

* CHECK dout0_75 Vdout0_75ck100 = 0.9 time = 505
.meas tran vdout0_75ck100 FIND v(dout0_75) AT=505.025n

* CHECK dout0_76 Vdout0_76ck100 = 0.9 time = 505
.meas tran vdout0_76ck100 FIND v(dout0_76) AT=505.025n

* CHECK dout0_77 Vdout0_77ck100 = 0.9 time = 505
.meas tran vdout0_77ck100 FIND v(dout0_77) AT=505.025n

* CHECK dout0_78 Vdout0_78ck100 = 0.9 time = 505
.meas tran vdout0_78ck100 FIND v(dout0_78) AT=505.025n

* CHECK dout0_79 Vdout0_79ck100 = 0.9 time = 505
.meas tran vdout0_79ck100 FIND v(dout0_79) AT=505.025n

* CHECK dout0_80 Vdout0_80ck100 = 0 time = 505
.meas tran vdout0_80ck100 FIND v(dout0_80) AT=505.025n

* CHECK dout0_81 Vdout0_81ck100 = 0 time = 505
.meas tran vdout0_81ck100 FIND v(dout0_81) AT=505.025n

* CHECK dout0_82 Vdout0_82ck100 = 0 time = 505
.meas tran vdout0_82ck100 FIND v(dout0_82) AT=505.025n

* CHECK dout0_83 Vdout0_83ck100 = 0.9 time = 505
.meas tran vdout0_83ck100 FIND v(dout0_83) AT=505.025n

* CHECK dout0_84 Vdout0_84ck100 = 0 time = 505
.meas tran vdout0_84ck100 FIND v(dout0_84) AT=505.025n

* CHECK dout0_85 Vdout0_85ck100 = 0.9 time = 505
.meas tran vdout0_85ck100 FIND v(dout0_85) AT=505.025n

* CHECK dout0_86 Vdout0_86ck100 = 0.9 time = 505
.meas tran vdout0_86ck100 FIND v(dout0_86) AT=505.025n

* CHECK dout0_87 Vdout0_87ck100 = 0.9 time = 505
.meas tran vdout0_87ck100 FIND v(dout0_87) AT=505.025n

* CHECK dout0_0 Vdout0_0ck102 = 0 time = 515
.meas tran vdout0_0ck102 FIND v(dout0_0) AT=515.025n

* CHECK dout0_1 Vdout0_1ck102 = 0 time = 515
.meas tran vdout0_1ck102 FIND v(dout0_1) AT=515.025n

* CHECK dout0_2 Vdout0_2ck102 = 0.9 time = 515
.meas tran vdout0_2ck102 FIND v(dout0_2) AT=515.025n

* CHECK dout0_3 Vdout0_3ck102 = 0 time = 515
.meas tran vdout0_3ck102 FIND v(dout0_3) AT=515.025n

* CHECK dout0_4 Vdout0_4ck102 = 0.9 time = 515
.meas tran vdout0_4ck102 FIND v(dout0_4) AT=515.025n

* CHECK dout0_5 Vdout0_5ck102 = 0 time = 515
.meas tran vdout0_5ck102 FIND v(dout0_5) AT=515.025n

* CHECK dout0_6 Vdout0_6ck102 = 0 time = 515
.meas tran vdout0_6ck102 FIND v(dout0_6) AT=515.025n

* CHECK dout0_7 Vdout0_7ck102 = 0.9 time = 515
.meas tran vdout0_7ck102 FIND v(dout0_7) AT=515.025n

* CHECK dout0_8 Vdout0_8ck102 = 0.9 time = 515
.meas tran vdout0_8ck102 FIND v(dout0_8) AT=515.025n

* CHECK dout0_9 Vdout0_9ck102 = 0.9 time = 515
.meas tran vdout0_9ck102 FIND v(dout0_9) AT=515.025n

* CHECK dout0_10 Vdout0_10ck102 = 0 time = 515
.meas tran vdout0_10ck102 FIND v(dout0_10) AT=515.025n

* CHECK dout0_11 Vdout0_11ck102 = 0.9 time = 515
.meas tran vdout0_11ck102 FIND v(dout0_11) AT=515.025n

* CHECK dout0_12 Vdout0_12ck102 = 0 time = 515
.meas tran vdout0_12ck102 FIND v(dout0_12) AT=515.025n

* CHECK dout0_13 Vdout0_13ck102 = 0 time = 515
.meas tran vdout0_13ck102 FIND v(dout0_13) AT=515.025n

* CHECK dout0_14 Vdout0_14ck102 = 0 time = 515
.meas tran vdout0_14ck102 FIND v(dout0_14) AT=515.025n

* CHECK dout0_15 Vdout0_15ck102 = 0.9 time = 515
.meas tran vdout0_15ck102 FIND v(dout0_15) AT=515.025n

* CHECK dout0_16 Vdout0_16ck102 = 0 time = 515
.meas tran vdout0_16ck102 FIND v(dout0_16) AT=515.025n

* CHECK dout0_17 Vdout0_17ck102 = 0.9 time = 515
.meas tran vdout0_17ck102 FIND v(dout0_17) AT=515.025n

* CHECK dout0_18 Vdout0_18ck102 = 0 time = 515
.meas tran vdout0_18ck102 FIND v(dout0_18) AT=515.025n

* CHECK dout0_19 Vdout0_19ck102 = 0.9 time = 515
.meas tran vdout0_19ck102 FIND v(dout0_19) AT=515.025n

* CHECK dout0_20 Vdout0_20ck102 = 0 time = 515
.meas tran vdout0_20ck102 FIND v(dout0_20) AT=515.025n

* CHECK dout0_21 Vdout0_21ck102 = 0.9 time = 515
.meas tran vdout0_21ck102 FIND v(dout0_21) AT=515.025n

* CHECK dout0_22 Vdout0_22ck102 = 0 time = 515
.meas tran vdout0_22ck102 FIND v(dout0_22) AT=515.025n

* CHECK dout0_23 Vdout0_23ck102 = 0 time = 515
.meas tran vdout0_23ck102 FIND v(dout0_23) AT=515.025n

* CHECK dout0_24 Vdout0_24ck102 = 0 time = 515
.meas tran vdout0_24ck102 FIND v(dout0_24) AT=515.025n

* CHECK dout0_25 Vdout0_25ck102 = 0 time = 515
.meas tran vdout0_25ck102 FIND v(dout0_25) AT=515.025n

* CHECK dout0_26 Vdout0_26ck102 = 0 time = 515
.meas tran vdout0_26ck102 FIND v(dout0_26) AT=515.025n

* CHECK dout0_27 Vdout0_27ck102 = 0 time = 515
.meas tran vdout0_27ck102 FIND v(dout0_27) AT=515.025n

* CHECK dout0_28 Vdout0_28ck102 = 0.9 time = 515
.meas tran vdout0_28ck102 FIND v(dout0_28) AT=515.025n

* CHECK dout0_29 Vdout0_29ck102 = 0.9 time = 515
.meas tran vdout0_29ck102 FIND v(dout0_29) AT=515.025n

* CHECK dout0_30 Vdout0_30ck102 = 0 time = 515
.meas tran vdout0_30ck102 FIND v(dout0_30) AT=515.025n

* CHECK dout0_31 Vdout0_31ck102 = 0 time = 515
.meas tran vdout0_31ck102 FIND v(dout0_31) AT=515.025n

* CHECK dout0_32 Vdout0_32ck102 = 0 time = 515
.meas tran vdout0_32ck102 FIND v(dout0_32) AT=515.025n

* CHECK dout0_33 Vdout0_33ck102 = 0 time = 515
.meas tran vdout0_33ck102 FIND v(dout0_33) AT=515.025n

* CHECK dout0_34 Vdout0_34ck102 = 0.9 time = 515
.meas tran vdout0_34ck102 FIND v(dout0_34) AT=515.025n

* CHECK dout0_35 Vdout0_35ck102 = 0.9 time = 515
.meas tran vdout0_35ck102 FIND v(dout0_35) AT=515.025n

* CHECK dout0_36 Vdout0_36ck102 = 0 time = 515
.meas tran vdout0_36ck102 FIND v(dout0_36) AT=515.025n

* CHECK dout0_37 Vdout0_37ck102 = 0.9 time = 515
.meas tran vdout0_37ck102 FIND v(dout0_37) AT=515.025n

* CHECK dout0_38 Vdout0_38ck102 = 0.9 time = 515
.meas tran vdout0_38ck102 FIND v(dout0_38) AT=515.025n

* CHECK dout0_39 Vdout0_39ck102 = 0.9 time = 515
.meas tran vdout0_39ck102 FIND v(dout0_39) AT=515.025n

* CHECK dout0_40 Vdout0_40ck102 = 0.9 time = 515
.meas tran vdout0_40ck102 FIND v(dout0_40) AT=515.025n

* CHECK dout0_41 Vdout0_41ck102 = 0 time = 515
.meas tran vdout0_41ck102 FIND v(dout0_41) AT=515.025n

* CHECK dout0_42 Vdout0_42ck102 = 0.9 time = 515
.meas tran vdout0_42ck102 FIND v(dout0_42) AT=515.025n

* CHECK dout0_43 Vdout0_43ck102 = 0 time = 515
.meas tran vdout0_43ck102 FIND v(dout0_43) AT=515.025n

* CHECK dout0_44 Vdout0_44ck102 = 0 time = 515
.meas tran vdout0_44ck102 FIND v(dout0_44) AT=515.025n

* CHECK dout0_45 Vdout0_45ck102 = 0 time = 515
.meas tran vdout0_45ck102 FIND v(dout0_45) AT=515.025n

* CHECK dout0_46 Vdout0_46ck102 = 0 time = 515
.meas tran vdout0_46ck102 FIND v(dout0_46) AT=515.025n

* CHECK dout0_47 Vdout0_47ck102 = 0.9 time = 515
.meas tran vdout0_47ck102 FIND v(dout0_47) AT=515.025n

* CHECK dout0_48 Vdout0_48ck102 = 0.9 time = 515
.meas tran vdout0_48ck102 FIND v(dout0_48) AT=515.025n

* CHECK dout0_49 Vdout0_49ck102 = 0.9 time = 515
.meas tran vdout0_49ck102 FIND v(dout0_49) AT=515.025n

* CHECK dout0_50 Vdout0_50ck102 = 0.9 time = 515
.meas tran vdout0_50ck102 FIND v(dout0_50) AT=515.025n

* CHECK dout0_51 Vdout0_51ck102 = 0 time = 515
.meas tran vdout0_51ck102 FIND v(dout0_51) AT=515.025n

* CHECK dout0_52 Vdout0_52ck102 = 0 time = 515
.meas tran vdout0_52ck102 FIND v(dout0_52) AT=515.025n

* CHECK dout0_53 Vdout0_53ck102 = 0 time = 515
.meas tran vdout0_53ck102 FIND v(dout0_53) AT=515.025n

* CHECK dout0_54 Vdout0_54ck102 = 0.9 time = 515
.meas tran vdout0_54ck102 FIND v(dout0_54) AT=515.025n

* CHECK dout0_55 Vdout0_55ck102 = 0.9 time = 515
.meas tran vdout0_55ck102 FIND v(dout0_55) AT=515.025n

* CHECK dout0_56 Vdout0_56ck102 = 0.9 time = 515
.meas tran vdout0_56ck102 FIND v(dout0_56) AT=515.025n

* CHECK dout0_57 Vdout0_57ck102 = 0.9 time = 515
.meas tran vdout0_57ck102 FIND v(dout0_57) AT=515.025n

* CHECK dout0_58 Vdout0_58ck102 = 0.9 time = 515
.meas tran vdout0_58ck102 FIND v(dout0_58) AT=515.025n

* CHECK dout0_59 Vdout0_59ck102 = 0 time = 515
.meas tran vdout0_59ck102 FIND v(dout0_59) AT=515.025n

* CHECK dout0_60 Vdout0_60ck102 = 0.9 time = 515
.meas tran vdout0_60ck102 FIND v(dout0_60) AT=515.025n

* CHECK dout0_61 Vdout0_61ck102 = 0.9 time = 515
.meas tran vdout0_61ck102 FIND v(dout0_61) AT=515.025n

* CHECK dout0_62 Vdout0_62ck102 = 0.9 time = 515
.meas tran vdout0_62ck102 FIND v(dout0_62) AT=515.025n

* CHECK dout0_63 Vdout0_63ck102 = 0 time = 515
.meas tran vdout0_63ck102 FIND v(dout0_63) AT=515.025n

* CHECK dout0_64 Vdout0_64ck102 = 0.9 time = 515
.meas tran vdout0_64ck102 FIND v(dout0_64) AT=515.025n

* CHECK dout0_65 Vdout0_65ck102 = 0 time = 515
.meas tran vdout0_65ck102 FIND v(dout0_65) AT=515.025n

* CHECK dout0_66 Vdout0_66ck102 = 0 time = 515
.meas tran vdout0_66ck102 FIND v(dout0_66) AT=515.025n

* CHECK dout0_67 Vdout0_67ck102 = 0.9 time = 515
.meas tran vdout0_67ck102 FIND v(dout0_67) AT=515.025n

* CHECK dout0_68 Vdout0_68ck102 = 0.9 time = 515
.meas tran vdout0_68ck102 FIND v(dout0_68) AT=515.025n

* CHECK dout0_69 Vdout0_69ck102 = 0.9 time = 515
.meas tran vdout0_69ck102 FIND v(dout0_69) AT=515.025n

* CHECK dout0_70 Vdout0_70ck102 = 0 time = 515
.meas tran vdout0_70ck102 FIND v(dout0_70) AT=515.025n

* CHECK dout0_71 Vdout0_71ck102 = 0 time = 515
.meas tran vdout0_71ck102 FIND v(dout0_71) AT=515.025n

* CHECK dout0_72 Vdout0_72ck102 = 0.9 time = 515
.meas tran vdout0_72ck102 FIND v(dout0_72) AT=515.025n

* CHECK dout0_73 Vdout0_73ck102 = 0 time = 515
.meas tran vdout0_73ck102 FIND v(dout0_73) AT=515.025n

* CHECK dout0_74 Vdout0_74ck102 = 0.9 time = 515
.meas tran vdout0_74ck102 FIND v(dout0_74) AT=515.025n

* CHECK dout0_75 Vdout0_75ck102 = 0.9 time = 515
.meas tran vdout0_75ck102 FIND v(dout0_75) AT=515.025n

* CHECK dout0_76 Vdout0_76ck102 = 0 time = 515
.meas tran vdout0_76ck102 FIND v(dout0_76) AT=515.025n

* CHECK dout0_77 Vdout0_77ck102 = 0 time = 515
.meas tran vdout0_77ck102 FIND v(dout0_77) AT=515.025n

* CHECK dout0_78 Vdout0_78ck102 = 0.9 time = 515
.meas tran vdout0_78ck102 FIND v(dout0_78) AT=515.025n

* CHECK dout0_79 Vdout0_79ck102 = 0 time = 515
.meas tran vdout0_79ck102 FIND v(dout0_79) AT=515.025n

* CHECK dout0_80 Vdout0_80ck102 = 0.9 time = 515
.meas tran vdout0_80ck102 FIND v(dout0_80) AT=515.025n

* CHECK dout0_81 Vdout0_81ck102 = 0 time = 515
.meas tran vdout0_81ck102 FIND v(dout0_81) AT=515.025n

* CHECK dout0_82 Vdout0_82ck102 = 0 time = 515
.meas tran vdout0_82ck102 FIND v(dout0_82) AT=515.025n

* CHECK dout0_83 Vdout0_83ck102 = 0.9 time = 515
.meas tran vdout0_83ck102 FIND v(dout0_83) AT=515.025n

* CHECK dout0_84 Vdout0_84ck102 = 0.9 time = 515
.meas tran vdout0_84ck102 FIND v(dout0_84) AT=515.025n

* CHECK dout0_85 Vdout0_85ck102 = 0 time = 515
.meas tran vdout0_85ck102 FIND v(dout0_85) AT=515.025n

* CHECK dout0_86 Vdout0_86ck102 = 0.9 time = 515
.meas tran vdout0_86ck102 FIND v(dout0_86) AT=515.025n

* CHECK dout0_87 Vdout0_87ck102 = 0.9 time = 515
.meas tran vdout0_87ck102 FIND v(dout0_87) AT=515.025n

* CHECK dout0_0 Vdout0_0ck103 = 0 time = 520
.meas tran vdout0_0ck103 FIND v(dout0_0) AT=520.025n

* CHECK dout0_1 Vdout0_1ck103 = 0 time = 520
.meas tran vdout0_1ck103 FIND v(dout0_1) AT=520.025n

* CHECK dout0_2 Vdout0_2ck103 = 0.9 time = 520
.meas tran vdout0_2ck103 FIND v(dout0_2) AT=520.025n

* CHECK dout0_3 Vdout0_3ck103 = 0 time = 520
.meas tran vdout0_3ck103 FIND v(dout0_3) AT=520.025n

* CHECK dout0_4 Vdout0_4ck103 = 0.9 time = 520
.meas tran vdout0_4ck103 FIND v(dout0_4) AT=520.025n

* CHECK dout0_5 Vdout0_5ck103 = 0 time = 520
.meas tran vdout0_5ck103 FIND v(dout0_5) AT=520.025n

* CHECK dout0_6 Vdout0_6ck103 = 0 time = 520
.meas tran vdout0_6ck103 FIND v(dout0_6) AT=520.025n

* CHECK dout0_7 Vdout0_7ck103 = 0.9 time = 520
.meas tran vdout0_7ck103 FIND v(dout0_7) AT=520.025n

* CHECK dout0_8 Vdout0_8ck103 = 0.9 time = 520
.meas tran vdout0_8ck103 FIND v(dout0_8) AT=520.025n

* CHECK dout0_9 Vdout0_9ck103 = 0.9 time = 520
.meas tran vdout0_9ck103 FIND v(dout0_9) AT=520.025n

* CHECK dout0_10 Vdout0_10ck103 = 0 time = 520
.meas tran vdout0_10ck103 FIND v(dout0_10) AT=520.025n

* CHECK dout0_11 Vdout0_11ck103 = 0.9 time = 520
.meas tran vdout0_11ck103 FIND v(dout0_11) AT=520.025n

* CHECK dout0_12 Vdout0_12ck103 = 0 time = 520
.meas tran vdout0_12ck103 FIND v(dout0_12) AT=520.025n

* CHECK dout0_13 Vdout0_13ck103 = 0 time = 520
.meas tran vdout0_13ck103 FIND v(dout0_13) AT=520.025n

* CHECK dout0_14 Vdout0_14ck103 = 0 time = 520
.meas tran vdout0_14ck103 FIND v(dout0_14) AT=520.025n

* CHECK dout0_15 Vdout0_15ck103 = 0.9 time = 520
.meas tran vdout0_15ck103 FIND v(dout0_15) AT=520.025n

* CHECK dout0_16 Vdout0_16ck103 = 0 time = 520
.meas tran vdout0_16ck103 FIND v(dout0_16) AT=520.025n

* CHECK dout0_17 Vdout0_17ck103 = 0.9 time = 520
.meas tran vdout0_17ck103 FIND v(dout0_17) AT=520.025n

* CHECK dout0_18 Vdout0_18ck103 = 0 time = 520
.meas tran vdout0_18ck103 FIND v(dout0_18) AT=520.025n

* CHECK dout0_19 Vdout0_19ck103 = 0.9 time = 520
.meas tran vdout0_19ck103 FIND v(dout0_19) AT=520.025n

* CHECK dout0_20 Vdout0_20ck103 = 0 time = 520
.meas tran vdout0_20ck103 FIND v(dout0_20) AT=520.025n

* CHECK dout0_21 Vdout0_21ck103 = 0.9 time = 520
.meas tran vdout0_21ck103 FIND v(dout0_21) AT=520.025n

* CHECK dout0_22 Vdout0_22ck103 = 0 time = 520
.meas tran vdout0_22ck103 FIND v(dout0_22) AT=520.025n

* CHECK dout0_23 Vdout0_23ck103 = 0 time = 520
.meas tran vdout0_23ck103 FIND v(dout0_23) AT=520.025n

* CHECK dout0_24 Vdout0_24ck103 = 0 time = 520
.meas tran vdout0_24ck103 FIND v(dout0_24) AT=520.025n

* CHECK dout0_25 Vdout0_25ck103 = 0 time = 520
.meas tran vdout0_25ck103 FIND v(dout0_25) AT=520.025n

* CHECK dout0_26 Vdout0_26ck103 = 0 time = 520
.meas tran vdout0_26ck103 FIND v(dout0_26) AT=520.025n

* CHECK dout0_27 Vdout0_27ck103 = 0 time = 520
.meas tran vdout0_27ck103 FIND v(dout0_27) AT=520.025n

* CHECK dout0_28 Vdout0_28ck103 = 0.9 time = 520
.meas tran vdout0_28ck103 FIND v(dout0_28) AT=520.025n

* CHECK dout0_29 Vdout0_29ck103 = 0.9 time = 520
.meas tran vdout0_29ck103 FIND v(dout0_29) AT=520.025n

* CHECK dout0_30 Vdout0_30ck103 = 0 time = 520
.meas tran vdout0_30ck103 FIND v(dout0_30) AT=520.025n

* CHECK dout0_31 Vdout0_31ck103 = 0 time = 520
.meas tran vdout0_31ck103 FIND v(dout0_31) AT=520.025n

* CHECK dout0_32 Vdout0_32ck103 = 0 time = 520
.meas tran vdout0_32ck103 FIND v(dout0_32) AT=520.025n

* CHECK dout0_33 Vdout0_33ck103 = 0 time = 520
.meas tran vdout0_33ck103 FIND v(dout0_33) AT=520.025n

* CHECK dout0_34 Vdout0_34ck103 = 0.9 time = 520
.meas tran vdout0_34ck103 FIND v(dout0_34) AT=520.025n

* CHECK dout0_35 Vdout0_35ck103 = 0.9 time = 520
.meas tran vdout0_35ck103 FIND v(dout0_35) AT=520.025n

* CHECK dout0_36 Vdout0_36ck103 = 0 time = 520
.meas tran vdout0_36ck103 FIND v(dout0_36) AT=520.025n

* CHECK dout0_37 Vdout0_37ck103 = 0.9 time = 520
.meas tran vdout0_37ck103 FIND v(dout0_37) AT=520.025n

* CHECK dout0_38 Vdout0_38ck103 = 0.9 time = 520
.meas tran vdout0_38ck103 FIND v(dout0_38) AT=520.025n

* CHECK dout0_39 Vdout0_39ck103 = 0.9 time = 520
.meas tran vdout0_39ck103 FIND v(dout0_39) AT=520.025n

* CHECK dout0_40 Vdout0_40ck103 = 0.9 time = 520
.meas tran vdout0_40ck103 FIND v(dout0_40) AT=520.025n

* CHECK dout0_41 Vdout0_41ck103 = 0 time = 520
.meas tran vdout0_41ck103 FIND v(dout0_41) AT=520.025n

* CHECK dout0_42 Vdout0_42ck103 = 0.9 time = 520
.meas tran vdout0_42ck103 FIND v(dout0_42) AT=520.025n

* CHECK dout0_43 Vdout0_43ck103 = 0 time = 520
.meas tran vdout0_43ck103 FIND v(dout0_43) AT=520.025n

* CHECK dout0_44 Vdout0_44ck103 = 0 time = 520
.meas tran vdout0_44ck103 FIND v(dout0_44) AT=520.025n

* CHECK dout0_45 Vdout0_45ck103 = 0 time = 520
.meas tran vdout0_45ck103 FIND v(dout0_45) AT=520.025n

* CHECK dout0_46 Vdout0_46ck103 = 0 time = 520
.meas tran vdout0_46ck103 FIND v(dout0_46) AT=520.025n

* CHECK dout0_47 Vdout0_47ck103 = 0.9 time = 520
.meas tran vdout0_47ck103 FIND v(dout0_47) AT=520.025n

* CHECK dout0_48 Vdout0_48ck103 = 0.9 time = 520
.meas tran vdout0_48ck103 FIND v(dout0_48) AT=520.025n

* CHECK dout0_49 Vdout0_49ck103 = 0.9 time = 520
.meas tran vdout0_49ck103 FIND v(dout0_49) AT=520.025n

* CHECK dout0_50 Vdout0_50ck103 = 0.9 time = 520
.meas tran vdout0_50ck103 FIND v(dout0_50) AT=520.025n

* CHECK dout0_51 Vdout0_51ck103 = 0 time = 520
.meas tran vdout0_51ck103 FIND v(dout0_51) AT=520.025n

* CHECK dout0_52 Vdout0_52ck103 = 0 time = 520
.meas tran vdout0_52ck103 FIND v(dout0_52) AT=520.025n

* CHECK dout0_53 Vdout0_53ck103 = 0 time = 520
.meas tran vdout0_53ck103 FIND v(dout0_53) AT=520.025n

* CHECK dout0_54 Vdout0_54ck103 = 0.9 time = 520
.meas tran vdout0_54ck103 FIND v(dout0_54) AT=520.025n

* CHECK dout0_55 Vdout0_55ck103 = 0.9 time = 520
.meas tran vdout0_55ck103 FIND v(dout0_55) AT=520.025n

* CHECK dout0_56 Vdout0_56ck103 = 0.9 time = 520
.meas tran vdout0_56ck103 FIND v(dout0_56) AT=520.025n

* CHECK dout0_57 Vdout0_57ck103 = 0.9 time = 520
.meas tran vdout0_57ck103 FIND v(dout0_57) AT=520.025n

* CHECK dout0_58 Vdout0_58ck103 = 0.9 time = 520
.meas tran vdout0_58ck103 FIND v(dout0_58) AT=520.025n

* CHECK dout0_59 Vdout0_59ck103 = 0 time = 520
.meas tran vdout0_59ck103 FIND v(dout0_59) AT=520.025n

* CHECK dout0_60 Vdout0_60ck103 = 0.9 time = 520
.meas tran vdout0_60ck103 FIND v(dout0_60) AT=520.025n

* CHECK dout0_61 Vdout0_61ck103 = 0.9 time = 520
.meas tran vdout0_61ck103 FIND v(dout0_61) AT=520.025n

* CHECK dout0_62 Vdout0_62ck103 = 0.9 time = 520
.meas tran vdout0_62ck103 FIND v(dout0_62) AT=520.025n

* CHECK dout0_63 Vdout0_63ck103 = 0 time = 520
.meas tran vdout0_63ck103 FIND v(dout0_63) AT=520.025n

* CHECK dout0_64 Vdout0_64ck103 = 0.9 time = 520
.meas tran vdout0_64ck103 FIND v(dout0_64) AT=520.025n

* CHECK dout0_65 Vdout0_65ck103 = 0 time = 520
.meas tran vdout0_65ck103 FIND v(dout0_65) AT=520.025n

* CHECK dout0_66 Vdout0_66ck103 = 0 time = 520
.meas tran vdout0_66ck103 FIND v(dout0_66) AT=520.025n

* CHECK dout0_67 Vdout0_67ck103 = 0.9 time = 520
.meas tran vdout0_67ck103 FIND v(dout0_67) AT=520.025n

* CHECK dout0_68 Vdout0_68ck103 = 0.9 time = 520
.meas tran vdout0_68ck103 FIND v(dout0_68) AT=520.025n

* CHECK dout0_69 Vdout0_69ck103 = 0.9 time = 520
.meas tran vdout0_69ck103 FIND v(dout0_69) AT=520.025n

* CHECK dout0_70 Vdout0_70ck103 = 0 time = 520
.meas tran vdout0_70ck103 FIND v(dout0_70) AT=520.025n

* CHECK dout0_71 Vdout0_71ck103 = 0 time = 520
.meas tran vdout0_71ck103 FIND v(dout0_71) AT=520.025n

* CHECK dout0_72 Vdout0_72ck103 = 0.9 time = 520
.meas tran vdout0_72ck103 FIND v(dout0_72) AT=520.025n

* CHECK dout0_73 Vdout0_73ck103 = 0 time = 520
.meas tran vdout0_73ck103 FIND v(dout0_73) AT=520.025n

* CHECK dout0_74 Vdout0_74ck103 = 0.9 time = 520
.meas tran vdout0_74ck103 FIND v(dout0_74) AT=520.025n

* CHECK dout0_75 Vdout0_75ck103 = 0.9 time = 520
.meas tran vdout0_75ck103 FIND v(dout0_75) AT=520.025n

* CHECK dout0_76 Vdout0_76ck103 = 0 time = 520
.meas tran vdout0_76ck103 FIND v(dout0_76) AT=520.025n

* CHECK dout0_77 Vdout0_77ck103 = 0 time = 520
.meas tran vdout0_77ck103 FIND v(dout0_77) AT=520.025n

* CHECK dout0_78 Vdout0_78ck103 = 0.9 time = 520
.meas tran vdout0_78ck103 FIND v(dout0_78) AT=520.025n

* CHECK dout0_79 Vdout0_79ck103 = 0 time = 520
.meas tran vdout0_79ck103 FIND v(dout0_79) AT=520.025n

* CHECK dout0_80 Vdout0_80ck103 = 0.9 time = 520
.meas tran vdout0_80ck103 FIND v(dout0_80) AT=520.025n

* CHECK dout0_81 Vdout0_81ck103 = 0 time = 520
.meas tran vdout0_81ck103 FIND v(dout0_81) AT=520.025n

* CHECK dout0_82 Vdout0_82ck103 = 0 time = 520
.meas tran vdout0_82ck103 FIND v(dout0_82) AT=520.025n

* CHECK dout0_83 Vdout0_83ck103 = 0.9 time = 520
.meas tran vdout0_83ck103 FIND v(dout0_83) AT=520.025n

* CHECK dout0_84 Vdout0_84ck103 = 0.9 time = 520
.meas tran vdout0_84ck103 FIND v(dout0_84) AT=520.025n

* CHECK dout0_85 Vdout0_85ck103 = 0 time = 520
.meas tran vdout0_85ck103 FIND v(dout0_85) AT=520.025n

* CHECK dout0_86 Vdout0_86ck103 = 0.9 time = 520
.meas tran vdout0_86ck103 FIND v(dout0_86) AT=520.025n

* CHECK dout0_87 Vdout0_87ck103 = 0.9 time = 520
.meas tran vdout0_87ck103 FIND v(dout0_87) AT=520.025n

* CHECK dout0_0 Vdout0_0ck105 = 0.9 time = 530
.meas tran vdout0_0ck105 FIND v(dout0_0) AT=530.025n

* CHECK dout0_1 Vdout0_1ck105 = 0 time = 530
.meas tran vdout0_1ck105 FIND v(dout0_1) AT=530.025n

* CHECK dout0_2 Vdout0_2ck105 = 0.9 time = 530
.meas tran vdout0_2ck105 FIND v(dout0_2) AT=530.025n

* CHECK dout0_3 Vdout0_3ck105 = 0.9 time = 530
.meas tran vdout0_3ck105 FIND v(dout0_3) AT=530.025n

* CHECK dout0_4 Vdout0_4ck105 = 0 time = 530
.meas tran vdout0_4ck105 FIND v(dout0_4) AT=530.025n

* CHECK dout0_5 Vdout0_5ck105 = 0 time = 530
.meas tran vdout0_5ck105 FIND v(dout0_5) AT=530.025n

* CHECK dout0_6 Vdout0_6ck105 = 0.9 time = 530
.meas tran vdout0_6ck105 FIND v(dout0_6) AT=530.025n

* CHECK dout0_7 Vdout0_7ck105 = 0 time = 530
.meas tran vdout0_7ck105 FIND v(dout0_7) AT=530.025n

* CHECK dout0_8 Vdout0_8ck105 = 0.9 time = 530
.meas tran vdout0_8ck105 FIND v(dout0_8) AT=530.025n

* CHECK dout0_9 Vdout0_9ck105 = 0.9 time = 530
.meas tran vdout0_9ck105 FIND v(dout0_9) AT=530.025n

* CHECK dout0_10 Vdout0_10ck105 = 0 time = 530
.meas tran vdout0_10ck105 FIND v(dout0_10) AT=530.025n

* CHECK dout0_11 Vdout0_11ck105 = 0 time = 530
.meas tran vdout0_11ck105 FIND v(dout0_11) AT=530.025n

* CHECK dout0_12 Vdout0_12ck105 = 0 time = 530
.meas tran vdout0_12ck105 FIND v(dout0_12) AT=530.025n

* CHECK dout0_13 Vdout0_13ck105 = 0 time = 530
.meas tran vdout0_13ck105 FIND v(dout0_13) AT=530.025n

* CHECK dout0_14 Vdout0_14ck105 = 0.9 time = 530
.meas tran vdout0_14ck105 FIND v(dout0_14) AT=530.025n

* CHECK dout0_15 Vdout0_15ck105 = 0.9 time = 530
.meas tran vdout0_15ck105 FIND v(dout0_15) AT=530.025n

* CHECK dout0_16 Vdout0_16ck105 = 0.9 time = 530
.meas tran vdout0_16ck105 FIND v(dout0_16) AT=530.025n

* CHECK dout0_17 Vdout0_17ck105 = 0.9 time = 530
.meas tran vdout0_17ck105 FIND v(dout0_17) AT=530.025n

* CHECK dout0_18 Vdout0_18ck105 = 0.9 time = 530
.meas tran vdout0_18ck105 FIND v(dout0_18) AT=530.025n

* CHECK dout0_19 Vdout0_19ck105 = 0.9 time = 530
.meas tran vdout0_19ck105 FIND v(dout0_19) AT=530.025n

* CHECK dout0_20 Vdout0_20ck105 = 0 time = 530
.meas tran vdout0_20ck105 FIND v(dout0_20) AT=530.025n

* CHECK dout0_21 Vdout0_21ck105 = 0.9 time = 530
.meas tran vdout0_21ck105 FIND v(dout0_21) AT=530.025n

* CHECK dout0_22 Vdout0_22ck105 = 0 time = 530
.meas tran vdout0_22ck105 FIND v(dout0_22) AT=530.025n

* CHECK dout0_23 Vdout0_23ck105 = 0 time = 530
.meas tran vdout0_23ck105 FIND v(dout0_23) AT=530.025n

* CHECK dout0_24 Vdout0_24ck105 = 0 time = 530
.meas tran vdout0_24ck105 FIND v(dout0_24) AT=530.025n

* CHECK dout0_25 Vdout0_25ck105 = 0 time = 530
.meas tran vdout0_25ck105 FIND v(dout0_25) AT=530.025n

* CHECK dout0_26 Vdout0_26ck105 = 0.9 time = 530
.meas tran vdout0_26ck105 FIND v(dout0_26) AT=530.025n

* CHECK dout0_27 Vdout0_27ck105 = 0 time = 530
.meas tran vdout0_27ck105 FIND v(dout0_27) AT=530.025n

* CHECK dout0_28 Vdout0_28ck105 = 0.9 time = 530
.meas tran vdout0_28ck105 FIND v(dout0_28) AT=530.025n

* CHECK dout0_29 Vdout0_29ck105 = 0.9 time = 530
.meas tran vdout0_29ck105 FIND v(dout0_29) AT=530.025n

* CHECK dout0_30 Vdout0_30ck105 = 0 time = 530
.meas tran vdout0_30ck105 FIND v(dout0_30) AT=530.025n

* CHECK dout0_31 Vdout0_31ck105 = 0 time = 530
.meas tran vdout0_31ck105 FIND v(dout0_31) AT=530.025n

* CHECK dout0_32 Vdout0_32ck105 = 0 time = 530
.meas tran vdout0_32ck105 FIND v(dout0_32) AT=530.025n

* CHECK dout0_33 Vdout0_33ck105 = 0.9 time = 530
.meas tran vdout0_33ck105 FIND v(dout0_33) AT=530.025n

* CHECK dout0_34 Vdout0_34ck105 = 0.9 time = 530
.meas tran vdout0_34ck105 FIND v(dout0_34) AT=530.025n

* CHECK dout0_35 Vdout0_35ck105 = 0.9 time = 530
.meas tran vdout0_35ck105 FIND v(dout0_35) AT=530.025n

* CHECK dout0_36 Vdout0_36ck105 = 0.9 time = 530
.meas tran vdout0_36ck105 FIND v(dout0_36) AT=530.025n

* CHECK dout0_37 Vdout0_37ck105 = 0.9 time = 530
.meas tran vdout0_37ck105 FIND v(dout0_37) AT=530.025n

* CHECK dout0_38 Vdout0_38ck105 = 0.9 time = 530
.meas tran vdout0_38ck105 FIND v(dout0_38) AT=530.025n

* CHECK dout0_39 Vdout0_39ck105 = 0 time = 530
.meas tran vdout0_39ck105 FIND v(dout0_39) AT=530.025n

* CHECK dout0_40 Vdout0_40ck105 = 0.9 time = 530
.meas tran vdout0_40ck105 FIND v(dout0_40) AT=530.025n

* CHECK dout0_41 Vdout0_41ck105 = 0.9 time = 530
.meas tran vdout0_41ck105 FIND v(dout0_41) AT=530.025n

* CHECK dout0_42 Vdout0_42ck105 = 0 time = 530
.meas tran vdout0_42ck105 FIND v(dout0_42) AT=530.025n

* CHECK dout0_43 Vdout0_43ck105 = 0.9 time = 530
.meas tran vdout0_43ck105 FIND v(dout0_43) AT=530.025n

* CHECK dout0_44 Vdout0_44ck105 = 0.9 time = 530
.meas tran vdout0_44ck105 FIND v(dout0_44) AT=530.025n

* CHECK dout0_45 Vdout0_45ck105 = 0.9 time = 530
.meas tran vdout0_45ck105 FIND v(dout0_45) AT=530.025n

* CHECK dout0_46 Vdout0_46ck105 = 0 time = 530
.meas tran vdout0_46ck105 FIND v(dout0_46) AT=530.025n

* CHECK dout0_47 Vdout0_47ck105 = 0 time = 530
.meas tran vdout0_47ck105 FIND v(dout0_47) AT=530.025n

* CHECK dout0_48 Vdout0_48ck105 = 0 time = 530
.meas tran vdout0_48ck105 FIND v(dout0_48) AT=530.025n

* CHECK dout0_49 Vdout0_49ck105 = 0 time = 530
.meas tran vdout0_49ck105 FIND v(dout0_49) AT=530.025n

* CHECK dout0_50 Vdout0_50ck105 = 0.9 time = 530
.meas tran vdout0_50ck105 FIND v(dout0_50) AT=530.025n

* CHECK dout0_51 Vdout0_51ck105 = 0 time = 530
.meas tran vdout0_51ck105 FIND v(dout0_51) AT=530.025n

* CHECK dout0_52 Vdout0_52ck105 = 0.9 time = 530
.meas tran vdout0_52ck105 FIND v(dout0_52) AT=530.025n

* CHECK dout0_53 Vdout0_53ck105 = 0 time = 530
.meas tran vdout0_53ck105 FIND v(dout0_53) AT=530.025n

* CHECK dout0_54 Vdout0_54ck105 = 0 time = 530
.meas tran vdout0_54ck105 FIND v(dout0_54) AT=530.025n

* CHECK dout0_55 Vdout0_55ck105 = 0 time = 530
.meas tran vdout0_55ck105 FIND v(dout0_55) AT=530.025n

* CHECK dout0_56 Vdout0_56ck105 = 0.9 time = 530
.meas tran vdout0_56ck105 FIND v(dout0_56) AT=530.025n

* CHECK dout0_57 Vdout0_57ck105 = 0 time = 530
.meas tran vdout0_57ck105 FIND v(dout0_57) AT=530.025n

* CHECK dout0_58 Vdout0_58ck105 = 0 time = 530
.meas tran vdout0_58ck105 FIND v(dout0_58) AT=530.025n

* CHECK dout0_59 Vdout0_59ck105 = 0 time = 530
.meas tran vdout0_59ck105 FIND v(dout0_59) AT=530.025n

* CHECK dout0_60 Vdout0_60ck105 = 0.9 time = 530
.meas tran vdout0_60ck105 FIND v(dout0_60) AT=530.025n

* CHECK dout0_61 Vdout0_61ck105 = 0 time = 530
.meas tran vdout0_61ck105 FIND v(dout0_61) AT=530.025n

* CHECK dout0_62 Vdout0_62ck105 = 0.9 time = 530
.meas tran vdout0_62ck105 FIND v(dout0_62) AT=530.025n

* CHECK dout0_63 Vdout0_63ck105 = 0 time = 530
.meas tran vdout0_63ck105 FIND v(dout0_63) AT=530.025n

* CHECK dout0_64 Vdout0_64ck105 = 0 time = 530
.meas tran vdout0_64ck105 FIND v(dout0_64) AT=530.025n

* CHECK dout0_65 Vdout0_65ck105 = 0.9 time = 530
.meas tran vdout0_65ck105 FIND v(dout0_65) AT=530.025n

* CHECK dout0_66 Vdout0_66ck105 = 0 time = 530
.meas tran vdout0_66ck105 FIND v(dout0_66) AT=530.025n

* CHECK dout0_67 Vdout0_67ck105 = 0 time = 530
.meas tran vdout0_67ck105 FIND v(dout0_67) AT=530.025n

* CHECK dout0_68 Vdout0_68ck105 = 0 time = 530
.meas tran vdout0_68ck105 FIND v(dout0_68) AT=530.025n

* CHECK dout0_69 Vdout0_69ck105 = 0.9 time = 530
.meas tran vdout0_69ck105 FIND v(dout0_69) AT=530.025n

* CHECK dout0_70 Vdout0_70ck105 = 0 time = 530
.meas tran vdout0_70ck105 FIND v(dout0_70) AT=530.025n

* CHECK dout0_71 Vdout0_71ck105 = 0.9 time = 530
.meas tran vdout0_71ck105 FIND v(dout0_71) AT=530.025n

* CHECK dout0_72 Vdout0_72ck105 = 0 time = 530
.meas tran vdout0_72ck105 FIND v(dout0_72) AT=530.025n

* CHECK dout0_73 Vdout0_73ck105 = 0 time = 530
.meas tran vdout0_73ck105 FIND v(dout0_73) AT=530.025n

* CHECK dout0_74 Vdout0_74ck105 = 0.9 time = 530
.meas tran vdout0_74ck105 FIND v(dout0_74) AT=530.025n

* CHECK dout0_75 Vdout0_75ck105 = 0.9 time = 530
.meas tran vdout0_75ck105 FIND v(dout0_75) AT=530.025n

* CHECK dout0_76 Vdout0_76ck105 = 0 time = 530
.meas tran vdout0_76ck105 FIND v(dout0_76) AT=530.025n

* CHECK dout0_77 Vdout0_77ck105 = 0 time = 530
.meas tran vdout0_77ck105 FIND v(dout0_77) AT=530.025n

* CHECK dout0_78 Vdout0_78ck105 = 0 time = 530
.meas tran vdout0_78ck105 FIND v(dout0_78) AT=530.025n

* CHECK dout0_79 Vdout0_79ck105 = 0.9 time = 530
.meas tran vdout0_79ck105 FIND v(dout0_79) AT=530.025n

* CHECK dout0_80 Vdout0_80ck105 = 0.9 time = 530
.meas tran vdout0_80ck105 FIND v(dout0_80) AT=530.025n

* CHECK dout0_81 Vdout0_81ck105 = 0 time = 530
.meas tran vdout0_81ck105 FIND v(dout0_81) AT=530.025n

* CHECK dout0_82 Vdout0_82ck105 = 0.9 time = 530
.meas tran vdout0_82ck105 FIND v(dout0_82) AT=530.025n

* CHECK dout0_83 Vdout0_83ck105 = 0 time = 530
.meas tran vdout0_83ck105 FIND v(dout0_83) AT=530.025n

* CHECK dout0_84 Vdout0_84ck105 = 0 time = 530
.meas tran vdout0_84ck105 FIND v(dout0_84) AT=530.025n

* CHECK dout0_85 Vdout0_85ck105 = 0 time = 530
.meas tran vdout0_85ck105 FIND v(dout0_85) AT=530.025n

* CHECK dout0_86 Vdout0_86ck105 = 0.9 time = 530
.meas tran vdout0_86ck105 FIND v(dout0_86) AT=530.025n

* CHECK dout0_87 Vdout0_87ck105 = 0.9 time = 530
.meas tran vdout0_87ck105 FIND v(dout0_87) AT=530.025n

* CHECK dout0_0 Vdout0_0ck106 = 0.9 time = 535
.meas tran vdout0_0ck106 FIND v(dout0_0) AT=535.025n

* CHECK dout0_1 Vdout0_1ck106 = 0 time = 535
.meas tran vdout0_1ck106 FIND v(dout0_1) AT=535.025n

* CHECK dout0_2 Vdout0_2ck106 = 0.9 time = 535
.meas tran vdout0_2ck106 FIND v(dout0_2) AT=535.025n

* CHECK dout0_3 Vdout0_3ck106 = 0.9 time = 535
.meas tran vdout0_3ck106 FIND v(dout0_3) AT=535.025n

* CHECK dout0_4 Vdout0_4ck106 = 0 time = 535
.meas tran vdout0_4ck106 FIND v(dout0_4) AT=535.025n

* CHECK dout0_5 Vdout0_5ck106 = 0 time = 535
.meas tran vdout0_5ck106 FIND v(dout0_5) AT=535.025n

* CHECK dout0_6 Vdout0_6ck106 = 0.9 time = 535
.meas tran vdout0_6ck106 FIND v(dout0_6) AT=535.025n

* CHECK dout0_7 Vdout0_7ck106 = 0 time = 535
.meas tran vdout0_7ck106 FIND v(dout0_7) AT=535.025n

* CHECK dout0_8 Vdout0_8ck106 = 0.9 time = 535
.meas tran vdout0_8ck106 FIND v(dout0_8) AT=535.025n

* CHECK dout0_9 Vdout0_9ck106 = 0.9 time = 535
.meas tran vdout0_9ck106 FIND v(dout0_9) AT=535.025n

* CHECK dout0_10 Vdout0_10ck106 = 0 time = 535
.meas tran vdout0_10ck106 FIND v(dout0_10) AT=535.025n

* CHECK dout0_11 Vdout0_11ck106 = 0 time = 535
.meas tran vdout0_11ck106 FIND v(dout0_11) AT=535.025n

* CHECK dout0_12 Vdout0_12ck106 = 0 time = 535
.meas tran vdout0_12ck106 FIND v(dout0_12) AT=535.025n

* CHECK dout0_13 Vdout0_13ck106 = 0 time = 535
.meas tran vdout0_13ck106 FIND v(dout0_13) AT=535.025n

* CHECK dout0_14 Vdout0_14ck106 = 0.9 time = 535
.meas tran vdout0_14ck106 FIND v(dout0_14) AT=535.025n

* CHECK dout0_15 Vdout0_15ck106 = 0.9 time = 535
.meas tran vdout0_15ck106 FIND v(dout0_15) AT=535.025n

* CHECK dout0_16 Vdout0_16ck106 = 0.9 time = 535
.meas tran vdout0_16ck106 FIND v(dout0_16) AT=535.025n

* CHECK dout0_17 Vdout0_17ck106 = 0.9 time = 535
.meas tran vdout0_17ck106 FIND v(dout0_17) AT=535.025n

* CHECK dout0_18 Vdout0_18ck106 = 0.9 time = 535
.meas tran vdout0_18ck106 FIND v(dout0_18) AT=535.025n

* CHECK dout0_19 Vdout0_19ck106 = 0.9 time = 535
.meas tran vdout0_19ck106 FIND v(dout0_19) AT=535.025n

* CHECK dout0_20 Vdout0_20ck106 = 0 time = 535
.meas tran vdout0_20ck106 FIND v(dout0_20) AT=535.025n

* CHECK dout0_21 Vdout0_21ck106 = 0.9 time = 535
.meas tran vdout0_21ck106 FIND v(dout0_21) AT=535.025n

* CHECK dout0_22 Vdout0_22ck106 = 0 time = 535
.meas tran vdout0_22ck106 FIND v(dout0_22) AT=535.025n

* CHECK dout0_23 Vdout0_23ck106 = 0 time = 535
.meas tran vdout0_23ck106 FIND v(dout0_23) AT=535.025n

* CHECK dout0_24 Vdout0_24ck106 = 0 time = 535
.meas tran vdout0_24ck106 FIND v(dout0_24) AT=535.025n

* CHECK dout0_25 Vdout0_25ck106 = 0 time = 535
.meas tran vdout0_25ck106 FIND v(dout0_25) AT=535.025n

* CHECK dout0_26 Vdout0_26ck106 = 0.9 time = 535
.meas tran vdout0_26ck106 FIND v(dout0_26) AT=535.025n

* CHECK dout0_27 Vdout0_27ck106 = 0 time = 535
.meas tran vdout0_27ck106 FIND v(dout0_27) AT=535.025n

* CHECK dout0_28 Vdout0_28ck106 = 0.9 time = 535
.meas tran vdout0_28ck106 FIND v(dout0_28) AT=535.025n

* CHECK dout0_29 Vdout0_29ck106 = 0.9 time = 535
.meas tran vdout0_29ck106 FIND v(dout0_29) AT=535.025n

* CHECK dout0_30 Vdout0_30ck106 = 0 time = 535
.meas tran vdout0_30ck106 FIND v(dout0_30) AT=535.025n

* CHECK dout0_31 Vdout0_31ck106 = 0 time = 535
.meas tran vdout0_31ck106 FIND v(dout0_31) AT=535.025n

* CHECK dout0_32 Vdout0_32ck106 = 0 time = 535
.meas tran vdout0_32ck106 FIND v(dout0_32) AT=535.025n

* CHECK dout0_33 Vdout0_33ck106 = 0.9 time = 535
.meas tran vdout0_33ck106 FIND v(dout0_33) AT=535.025n

* CHECK dout0_34 Vdout0_34ck106 = 0.9 time = 535
.meas tran vdout0_34ck106 FIND v(dout0_34) AT=535.025n

* CHECK dout0_35 Vdout0_35ck106 = 0.9 time = 535
.meas tran vdout0_35ck106 FIND v(dout0_35) AT=535.025n

* CHECK dout0_36 Vdout0_36ck106 = 0.9 time = 535
.meas tran vdout0_36ck106 FIND v(dout0_36) AT=535.025n

* CHECK dout0_37 Vdout0_37ck106 = 0.9 time = 535
.meas tran vdout0_37ck106 FIND v(dout0_37) AT=535.025n

* CHECK dout0_38 Vdout0_38ck106 = 0.9 time = 535
.meas tran vdout0_38ck106 FIND v(dout0_38) AT=535.025n

* CHECK dout0_39 Vdout0_39ck106 = 0 time = 535
.meas tran vdout0_39ck106 FIND v(dout0_39) AT=535.025n

* CHECK dout0_40 Vdout0_40ck106 = 0.9 time = 535
.meas tran vdout0_40ck106 FIND v(dout0_40) AT=535.025n

* CHECK dout0_41 Vdout0_41ck106 = 0.9 time = 535
.meas tran vdout0_41ck106 FIND v(dout0_41) AT=535.025n

* CHECK dout0_42 Vdout0_42ck106 = 0 time = 535
.meas tran vdout0_42ck106 FIND v(dout0_42) AT=535.025n

* CHECK dout0_43 Vdout0_43ck106 = 0.9 time = 535
.meas tran vdout0_43ck106 FIND v(dout0_43) AT=535.025n

* CHECK dout0_44 Vdout0_44ck106 = 0.9 time = 535
.meas tran vdout0_44ck106 FIND v(dout0_44) AT=535.025n

* CHECK dout0_45 Vdout0_45ck106 = 0.9 time = 535
.meas tran vdout0_45ck106 FIND v(dout0_45) AT=535.025n

* CHECK dout0_46 Vdout0_46ck106 = 0 time = 535
.meas tran vdout0_46ck106 FIND v(dout0_46) AT=535.025n

* CHECK dout0_47 Vdout0_47ck106 = 0 time = 535
.meas tran vdout0_47ck106 FIND v(dout0_47) AT=535.025n

* CHECK dout0_48 Vdout0_48ck106 = 0 time = 535
.meas tran vdout0_48ck106 FIND v(dout0_48) AT=535.025n

* CHECK dout0_49 Vdout0_49ck106 = 0 time = 535
.meas tran vdout0_49ck106 FIND v(dout0_49) AT=535.025n

* CHECK dout0_50 Vdout0_50ck106 = 0.9 time = 535
.meas tran vdout0_50ck106 FIND v(dout0_50) AT=535.025n

* CHECK dout0_51 Vdout0_51ck106 = 0 time = 535
.meas tran vdout0_51ck106 FIND v(dout0_51) AT=535.025n

* CHECK dout0_52 Vdout0_52ck106 = 0.9 time = 535
.meas tran vdout0_52ck106 FIND v(dout0_52) AT=535.025n

* CHECK dout0_53 Vdout0_53ck106 = 0 time = 535
.meas tran vdout0_53ck106 FIND v(dout0_53) AT=535.025n

* CHECK dout0_54 Vdout0_54ck106 = 0 time = 535
.meas tran vdout0_54ck106 FIND v(dout0_54) AT=535.025n

* CHECK dout0_55 Vdout0_55ck106 = 0 time = 535
.meas tran vdout0_55ck106 FIND v(dout0_55) AT=535.025n

* CHECK dout0_56 Vdout0_56ck106 = 0.9 time = 535
.meas tran vdout0_56ck106 FIND v(dout0_56) AT=535.025n

* CHECK dout0_57 Vdout0_57ck106 = 0 time = 535
.meas tran vdout0_57ck106 FIND v(dout0_57) AT=535.025n

* CHECK dout0_58 Vdout0_58ck106 = 0 time = 535
.meas tran vdout0_58ck106 FIND v(dout0_58) AT=535.025n

* CHECK dout0_59 Vdout0_59ck106 = 0 time = 535
.meas tran vdout0_59ck106 FIND v(dout0_59) AT=535.025n

* CHECK dout0_60 Vdout0_60ck106 = 0.9 time = 535
.meas tran vdout0_60ck106 FIND v(dout0_60) AT=535.025n

* CHECK dout0_61 Vdout0_61ck106 = 0 time = 535
.meas tran vdout0_61ck106 FIND v(dout0_61) AT=535.025n

* CHECK dout0_62 Vdout0_62ck106 = 0.9 time = 535
.meas tran vdout0_62ck106 FIND v(dout0_62) AT=535.025n

* CHECK dout0_63 Vdout0_63ck106 = 0 time = 535
.meas tran vdout0_63ck106 FIND v(dout0_63) AT=535.025n

* CHECK dout0_64 Vdout0_64ck106 = 0 time = 535
.meas tran vdout0_64ck106 FIND v(dout0_64) AT=535.025n

* CHECK dout0_65 Vdout0_65ck106 = 0.9 time = 535
.meas tran vdout0_65ck106 FIND v(dout0_65) AT=535.025n

* CHECK dout0_66 Vdout0_66ck106 = 0 time = 535
.meas tran vdout0_66ck106 FIND v(dout0_66) AT=535.025n

* CHECK dout0_67 Vdout0_67ck106 = 0 time = 535
.meas tran vdout0_67ck106 FIND v(dout0_67) AT=535.025n

* CHECK dout0_68 Vdout0_68ck106 = 0 time = 535
.meas tran vdout0_68ck106 FIND v(dout0_68) AT=535.025n

* CHECK dout0_69 Vdout0_69ck106 = 0.9 time = 535
.meas tran vdout0_69ck106 FIND v(dout0_69) AT=535.025n

* CHECK dout0_70 Vdout0_70ck106 = 0 time = 535
.meas tran vdout0_70ck106 FIND v(dout0_70) AT=535.025n

* CHECK dout0_71 Vdout0_71ck106 = 0.9 time = 535
.meas tran vdout0_71ck106 FIND v(dout0_71) AT=535.025n

* CHECK dout0_72 Vdout0_72ck106 = 0 time = 535
.meas tran vdout0_72ck106 FIND v(dout0_72) AT=535.025n

* CHECK dout0_73 Vdout0_73ck106 = 0 time = 535
.meas tran vdout0_73ck106 FIND v(dout0_73) AT=535.025n

* CHECK dout0_74 Vdout0_74ck106 = 0.9 time = 535
.meas tran vdout0_74ck106 FIND v(dout0_74) AT=535.025n

* CHECK dout0_75 Vdout0_75ck106 = 0.9 time = 535
.meas tran vdout0_75ck106 FIND v(dout0_75) AT=535.025n

* CHECK dout0_76 Vdout0_76ck106 = 0 time = 535
.meas tran vdout0_76ck106 FIND v(dout0_76) AT=535.025n

* CHECK dout0_77 Vdout0_77ck106 = 0 time = 535
.meas tran vdout0_77ck106 FIND v(dout0_77) AT=535.025n

* CHECK dout0_78 Vdout0_78ck106 = 0 time = 535
.meas tran vdout0_78ck106 FIND v(dout0_78) AT=535.025n

* CHECK dout0_79 Vdout0_79ck106 = 0.9 time = 535
.meas tran vdout0_79ck106 FIND v(dout0_79) AT=535.025n

* CHECK dout0_80 Vdout0_80ck106 = 0.9 time = 535
.meas tran vdout0_80ck106 FIND v(dout0_80) AT=535.025n

* CHECK dout0_81 Vdout0_81ck106 = 0 time = 535
.meas tran vdout0_81ck106 FIND v(dout0_81) AT=535.025n

* CHECK dout0_82 Vdout0_82ck106 = 0.9 time = 535
.meas tran vdout0_82ck106 FIND v(dout0_82) AT=535.025n

* CHECK dout0_83 Vdout0_83ck106 = 0 time = 535
.meas tran vdout0_83ck106 FIND v(dout0_83) AT=535.025n

* CHECK dout0_84 Vdout0_84ck106 = 0 time = 535
.meas tran vdout0_84ck106 FIND v(dout0_84) AT=535.025n

* CHECK dout0_85 Vdout0_85ck106 = 0 time = 535
.meas tran vdout0_85ck106 FIND v(dout0_85) AT=535.025n

* CHECK dout0_86 Vdout0_86ck106 = 0.9 time = 535
.meas tran vdout0_86ck106 FIND v(dout0_86) AT=535.025n

* CHECK dout0_87 Vdout0_87ck106 = 0.9 time = 535
.meas tran vdout0_87ck106 FIND v(dout0_87) AT=535.025n

* CHECK dout0_0 Vdout0_0ck112 = 0.9 time = 565
.meas tran vdout0_0ck112 FIND v(dout0_0) AT=565.025n

* CHECK dout0_1 Vdout0_1ck112 = 0 time = 565
.meas tran vdout0_1ck112 FIND v(dout0_1) AT=565.025n

* CHECK dout0_2 Vdout0_2ck112 = 0.9 time = 565
.meas tran vdout0_2ck112 FIND v(dout0_2) AT=565.025n

* CHECK dout0_3 Vdout0_3ck112 = 0 time = 565
.meas tran vdout0_3ck112 FIND v(dout0_3) AT=565.025n

* CHECK dout0_4 Vdout0_4ck112 = 0 time = 565
.meas tran vdout0_4ck112 FIND v(dout0_4) AT=565.025n

* CHECK dout0_5 Vdout0_5ck112 = 0.9 time = 565
.meas tran vdout0_5ck112 FIND v(dout0_5) AT=565.025n

* CHECK dout0_6 Vdout0_6ck112 = 0.9 time = 565
.meas tran vdout0_6ck112 FIND v(dout0_6) AT=565.025n

* CHECK dout0_7 Vdout0_7ck112 = 0 time = 565
.meas tran vdout0_7ck112 FIND v(dout0_7) AT=565.025n

* CHECK dout0_8 Vdout0_8ck112 = 0 time = 565
.meas tran vdout0_8ck112 FIND v(dout0_8) AT=565.025n

* CHECK dout0_9 Vdout0_9ck112 = 0.9 time = 565
.meas tran vdout0_9ck112 FIND v(dout0_9) AT=565.025n

* CHECK dout0_10 Vdout0_10ck112 = 0.9 time = 565
.meas tran vdout0_10ck112 FIND v(dout0_10) AT=565.025n

* CHECK dout0_11 Vdout0_11ck112 = 0 time = 565
.meas tran vdout0_11ck112 FIND v(dout0_11) AT=565.025n

* CHECK dout0_12 Vdout0_12ck112 = 0 time = 565
.meas tran vdout0_12ck112 FIND v(dout0_12) AT=565.025n

* CHECK dout0_13 Vdout0_13ck112 = 0 time = 565
.meas tran vdout0_13ck112 FIND v(dout0_13) AT=565.025n

* CHECK dout0_14 Vdout0_14ck112 = 0.9 time = 565
.meas tran vdout0_14ck112 FIND v(dout0_14) AT=565.025n

* CHECK dout0_15 Vdout0_15ck112 = 0.9 time = 565
.meas tran vdout0_15ck112 FIND v(dout0_15) AT=565.025n

* CHECK dout0_16 Vdout0_16ck112 = 0 time = 565
.meas tran vdout0_16ck112 FIND v(dout0_16) AT=565.025n

* CHECK dout0_17 Vdout0_17ck112 = 0 time = 565
.meas tran vdout0_17ck112 FIND v(dout0_17) AT=565.025n

* CHECK dout0_18 Vdout0_18ck112 = 0.9 time = 565
.meas tran vdout0_18ck112 FIND v(dout0_18) AT=565.025n

* CHECK dout0_19 Vdout0_19ck112 = 0.9 time = 565
.meas tran vdout0_19ck112 FIND v(dout0_19) AT=565.025n

* CHECK dout0_20 Vdout0_20ck112 = 0.9 time = 565
.meas tran vdout0_20ck112 FIND v(dout0_20) AT=565.025n

* CHECK dout0_21 Vdout0_21ck112 = 0 time = 565
.meas tran vdout0_21ck112 FIND v(dout0_21) AT=565.025n

* CHECK dout0_22 Vdout0_22ck112 = 0 time = 565
.meas tran vdout0_22ck112 FIND v(dout0_22) AT=565.025n

* CHECK dout0_23 Vdout0_23ck112 = 0 time = 565
.meas tran vdout0_23ck112 FIND v(dout0_23) AT=565.025n

* CHECK dout0_24 Vdout0_24ck112 = 0.9 time = 565
.meas tran vdout0_24ck112 FIND v(dout0_24) AT=565.025n

* CHECK dout0_25 Vdout0_25ck112 = 0.9 time = 565
.meas tran vdout0_25ck112 FIND v(dout0_25) AT=565.025n

* CHECK dout0_26 Vdout0_26ck112 = 0.9 time = 565
.meas tran vdout0_26ck112 FIND v(dout0_26) AT=565.025n

* CHECK dout0_27 Vdout0_27ck112 = 0.9 time = 565
.meas tran vdout0_27ck112 FIND v(dout0_27) AT=565.025n

* CHECK dout0_28 Vdout0_28ck112 = 0 time = 565
.meas tran vdout0_28ck112 FIND v(dout0_28) AT=565.025n

* CHECK dout0_29 Vdout0_29ck112 = 0.9 time = 565
.meas tran vdout0_29ck112 FIND v(dout0_29) AT=565.025n

* CHECK dout0_30 Vdout0_30ck112 = 0 time = 565
.meas tran vdout0_30ck112 FIND v(dout0_30) AT=565.025n

* CHECK dout0_31 Vdout0_31ck112 = 0 time = 565
.meas tran vdout0_31ck112 FIND v(dout0_31) AT=565.025n

* CHECK dout0_32 Vdout0_32ck112 = 0 time = 565
.meas tran vdout0_32ck112 FIND v(dout0_32) AT=565.025n

* CHECK dout0_33 Vdout0_33ck112 = 0.9 time = 565
.meas tran vdout0_33ck112 FIND v(dout0_33) AT=565.025n

* CHECK dout0_34 Vdout0_34ck112 = 0 time = 565
.meas tran vdout0_34ck112 FIND v(dout0_34) AT=565.025n

* CHECK dout0_35 Vdout0_35ck112 = 0 time = 565
.meas tran vdout0_35ck112 FIND v(dout0_35) AT=565.025n

* CHECK dout0_36 Vdout0_36ck112 = 0.9 time = 565
.meas tran vdout0_36ck112 FIND v(dout0_36) AT=565.025n

* CHECK dout0_37 Vdout0_37ck112 = 0 time = 565
.meas tran vdout0_37ck112 FIND v(dout0_37) AT=565.025n

* CHECK dout0_38 Vdout0_38ck112 = 0.9 time = 565
.meas tran vdout0_38ck112 FIND v(dout0_38) AT=565.025n

* CHECK dout0_39 Vdout0_39ck112 = 0 time = 565
.meas tran vdout0_39ck112 FIND v(dout0_39) AT=565.025n

* CHECK dout0_40 Vdout0_40ck112 = 0 time = 565
.meas tran vdout0_40ck112 FIND v(dout0_40) AT=565.025n

* CHECK dout0_41 Vdout0_41ck112 = 0.9 time = 565
.meas tran vdout0_41ck112 FIND v(dout0_41) AT=565.025n

* CHECK dout0_42 Vdout0_42ck112 = 0 time = 565
.meas tran vdout0_42ck112 FIND v(dout0_42) AT=565.025n

* CHECK dout0_43 Vdout0_43ck112 = 0.9 time = 565
.meas tran vdout0_43ck112 FIND v(dout0_43) AT=565.025n

* CHECK dout0_44 Vdout0_44ck112 = 0 time = 565
.meas tran vdout0_44ck112 FIND v(dout0_44) AT=565.025n

* CHECK dout0_45 Vdout0_45ck112 = 0.9 time = 565
.meas tran vdout0_45ck112 FIND v(dout0_45) AT=565.025n

* CHECK dout0_46 Vdout0_46ck112 = 0 time = 565
.meas tran vdout0_46ck112 FIND v(dout0_46) AT=565.025n

* CHECK dout0_47 Vdout0_47ck112 = 0 time = 565
.meas tran vdout0_47ck112 FIND v(dout0_47) AT=565.025n

* CHECK dout0_48 Vdout0_48ck112 = 0 time = 565
.meas tran vdout0_48ck112 FIND v(dout0_48) AT=565.025n

* CHECK dout0_49 Vdout0_49ck112 = 0 time = 565
.meas tran vdout0_49ck112 FIND v(dout0_49) AT=565.025n

* CHECK dout0_50 Vdout0_50ck112 = 0 time = 565
.meas tran vdout0_50ck112 FIND v(dout0_50) AT=565.025n

* CHECK dout0_51 Vdout0_51ck112 = 0.9 time = 565
.meas tran vdout0_51ck112 FIND v(dout0_51) AT=565.025n

* CHECK dout0_52 Vdout0_52ck112 = 0 time = 565
.meas tran vdout0_52ck112 FIND v(dout0_52) AT=565.025n

* CHECK dout0_53 Vdout0_53ck112 = 0 time = 565
.meas tran vdout0_53ck112 FIND v(dout0_53) AT=565.025n

* CHECK dout0_54 Vdout0_54ck112 = 0 time = 565
.meas tran vdout0_54ck112 FIND v(dout0_54) AT=565.025n

* CHECK dout0_55 Vdout0_55ck112 = 0 time = 565
.meas tran vdout0_55ck112 FIND v(dout0_55) AT=565.025n

* CHECK dout0_56 Vdout0_56ck112 = 0.9 time = 565
.meas tran vdout0_56ck112 FIND v(dout0_56) AT=565.025n

* CHECK dout0_57 Vdout0_57ck112 = 0.9 time = 565
.meas tran vdout0_57ck112 FIND v(dout0_57) AT=565.025n

* CHECK dout0_58 Vdout0_58ck112 = 0 time = 565
.meas tran vdout0_58ck112 FIND v(dout0_58) AT=565.025n

* CHECK dout0_59 Vdout0_59ck112 = 0.9 time = 565
.meas tran vdout0_59ck112 FIND v(dout0_59) AT=565.025n

* CHECK dout0_60 Vdout0_60ck112 = 0 time = 565
.meas tran vdout0_60ck112 FIND v(dout0_60) AT=565.025n

* CHECK dout0_61 Vdout0_61ck112 = 0.9 time = 565
.meas tran vdout0_61ck112 FIND v(dout0_61) AT=565.025n

* CHECK dout0_62 Vdout0_62ck112 = 0.9 time = 565
.meas tran vdout0_62ck112 FIND v(dout0_62) AT=565.025n

* CHECK dout0_63 Vdout0_63ck112 = 0.9 time = 565
.meas tran vdout0_63ck112 FIND v(dout0_63) AT=565.025n

* CHECK dout0_64 Vdout0_64ck112 = 0.9 time = 565
.meas tran vdout0_64ck112 FIND v(dout0_64) AT=565.025n

* CHECK dout0_65 Vdout0_65ck112 = 0.9 time = 565
.meas tran vdout0_65ck112 FIND v(dout0_65) AT=565.025n

* CHECK dout0_66 Vdout0_66ck112 = 0.9 time = 565
.meas tran vdout0_66ck112 FIND v(dout0_66) AT=565.025n

* CHECK dout0_67 Vdout0_67ck112 = 0.9 time = 565
.meas tran vdout0_67ck112 FIND v(dout0_67) AT=565.025n

* CHECK dout0_68 Vdout0_68ck112 = 0 time = 565
.meas tran vdout0_68ck112 FIND v(dout0_68) AT=565.025n

* CHECK dout0_69 Vdout0_69ck112 = 0.9 time = 565
.meas tran vdout0_69ck112 FIND v(dout0_69) AT=565.025n

* CHECK dout0_70 Vdout0_70ck112 = 0.9 time = 565
.meas tran vdout0_70ck112 FIND v(dout0_70) AT=565.025n

* CHECK dout0_71 Vdout0_71ck112 = 0.9 time = 565
.meas tran vdout0_71ck112 FIND v(dout0_71) AT=565.025n

* CHECK dout0_72 Vdout0_72ck112 = 0.9 time = 565
.meas tran vdout0_72ck112 FIND v(dout0_72) AT=565.025n

* CHECK dout0_73 Vdout0_73ck112 = 0 time = 565
.meas tran vdout0_73ck112 FIND v(dout0_73) AT=565.025n

* CHECK dout0_74 Vdout0_74ck112 = 0 time = 565
.meas tran vdout0_74ck112 FIND v(dout0_74) AT=565.025n

* CHECK dout0_75 Vdout0_75ck112 = 0.9 time = 565
.meas tran vdout0_75ck112 FIND v(dout0_75) AT=565.025n

* CHECK dout0_76 Vdout0_76ck112 = 0 time = 565
.meas tran vdout0_76ck112 FIND v(dout0_76) AT=565.025n

* CHECK dout0_77 Vdout0_77ck112 = 0.9 time = 565
.meas tran vdout0_77ck112 FIND v(dout0_77) AT=565.025n

* CHECK dout0_78 Vdout0_78ck112 = 0.9 time = 565
.meas tran vdout0_78ck112 FIND v(dout0_78) AT=565.025n

* CHECK dout0_79 Vdout0_79ck112 = 0.9 time = 565
.meas tran vdout0_79ck112 FIND v(dout0_79) AT=565.025n

* CHECK dout0_80 Vdout0_80ck112 = 0 time = 565
.meas tran vdout0_80ck112 FIND v(dout0_80) AT=565.025n

* CHECK dout0_81 Vdout0_81ck112 = 0 time = 565
.meas tran vdout0_81ck112 FIND v(dout0_81) AT=565.025n

* CHECK dout0_82 Vdout0_82ck112 = 0 time = 565
.meas tran vdout0_82ck112 FIND v(dout0_82) AT=565.025n

* CHECK dout0_83 Vdout0_83ck112 = 0 time = 565
.meas tran vdout0_83ck112 FIND v(dout0_83) AT=565.025n

* CHECK dout0_84 Vdout0_84ck112 = 0.9 time = 565
.meas tran vdout0_84ck112 FIND v(dout0_84) AT=565.025n

* CHECK dout0_85 Vdout0_85ck112 = 0 time = 565
.meas tran vdout0_85ck112 FIND v(dout0_85) AT=565.025n

* CHECK dout0_86 Vdout0_86ck112 = 0.9 time = 565
.meas tran vdout0_86ck112 FIND v(dout0_86) AT=565.025n

* CHECK dout0_87 Vdout0_87ck112 = 0 time = 565
.meas tran vdout0_87ck112 FIND v(dout0_87) AT=565.025n

* CHECK dout0_0 Vdout0_0ck113 = 0.9 time = 570
.meas tran vdout0_0ck113 FIND v(dout0_0) AT=570.025n

* CHECK dout0_1 Vdout0_1ck113 = 0 time = 570
.meas tran vdout0_1ck113 FIND v(dout0_1) AT=570.025n

* CHECK dout0_2 Vdout0_2ck113 = 0.9 time = 570
.meas tran vdout0_2ck113 FIND v(dout0_2) AT=570.025n

* CHECK dout0_3 Vdout0_3ck113 = 0 time = 570
.meas tran vdout0_3ck113 FIND v(dout0_3) AT=570.025n

* CHECK dout0_4 Vdout0_4ck113 = 0 time = 570
.meas tran vdout0_4ck113 FIND v(dout0_4) AT=570.025n

* CHECK dout0_5 Vdout0_5ck113 = 0.9 time = 570
.meas tran vdout0_5ck113 FIND v(dout0_5) AT=570.025n

* CHECK dout0_6 Vdout0_6ck113 = 0.9 time = 570
.meas tran vdout0_6ck113 FIND v(dout0_6) AT=570.025n

* CHECK dout0_7 Vdout0_7ck113 = 0 time = 570
.meas tran vdout0_7ck113 FIND v(dout0_7) AT=570.025n

* CHECK dout0_8 Vdout0_8ck113 = 0 time = 570
.meas tran vdout0_8ck113 FIND v(dout0_8) AT=570.025n

* CHECK dout0_9 Vdout0_9ck113 = 0.9 time = 570
.meas tran vdout0_9ck113 FIND v(dout0_9) AT=570.025n

* CHECK dout0_10 Vdout0_10ck113 = 0.9 time = 570
.meas tran vdout0_10ck113 FIND v(dout0_10) AT=570.025n

* CHECK dout0_11 Vdout0_11ck113 = 0 time = 570
.meas tran vdout0_11ck113 FIND v(dout0_11) AT=570.025n

* CHECK dout0_12 Vdout0_12ck113 = 0 time = 570
.meas tran vdout0_12ck113 FIND v(dout0_12) AT=570.025n

* CHECK dout0_13 Vdout0_13ck113 = 0 time = 570
.meas tran vdout0_13ck113 FIND v(dout0_13) AT=570.025n

* CHECK dout0_14 Vdout0_14ck113 = 0.9 time = 570
.meas tran vdout0_14ck113 FIND v(dout0_14) AT=570.025n

* CHECK dout0_15 Vdout0_15ck113 = 0.9 time = 570
.meas tran vdout0_15ck113 FIND v(dout0_15) AT=570.025n

* CHECK dout0_16 Vdout0_16ck113 = 0 time = 570
.meas tran vdout0_16ck113 FIND v(dout0_16) AT=570.025n

* CHECK dout0_17 Vdout0_17ck113 = 0 time = 570
.meas tran vdout0_17ck113 FIND v(dout0_17) AT=570.025n

* CHECK dout0_18 Vdout0_18ck113 = 0.9 time = 570
.meas tran vdout0_18ck113 FIND v(dout0_18) AT=570.025n

* CHECK dout0_19 Vdout0_19ck113 = 0.9 time = 570
.meas tran vdout0_19ck113 FIND v(dout0_19) AT=570.025n

* CHECK dout0_20 Vdout0_20ck113 = 0.9 time = 570
.meas tran vdout0_20ck113 FIND v(dout0_20) AT=570.025n

* CHECK dout0_21 Vdout0_21ck113 = 0 time = 570
.meas tran vdout0_21ck113 FIND v(dout0_21) AT=570.025n

* CHECK dout0_22 Vdout0_22ck113 = 0 time = 570
.meas tran vdout0_22ck113 FIND v(dout0_22) AT=570.025n

* CHECK dout0_23 Vdout0_23ck113 = 0 time = 570
.meas tran vdout0_23ck113 FIND v(dout0_23) AT=570.025n

* CHECK dout0_24 Vdout0_24ck113 = 0.9 time = 570
.meas tran vdout0_24ck113 FIND v(dout0_24) AT=570.025n

* CHECK dout0_25 Vdout0_25ck113 = 0.9 time = 570
.meas tran vdout0_25ck113 FIND v(dout0_25) AT=570.025n

* CHECK dout0_26 Vdout0_26ck113 = 0.9 time = 570
.meas tran vdout0_26ck113 FIND v(dout0_26) AT=570.025n

* CHECK dout0_27 Vdout0_27ck113 = 0.9 time = 570
.meas tran vdout0_27ck113 FIND v(dout0_27) AT=570.025n

* CHECK dout0_28 Vdout0_28ck113 = 0 time = 570
.meas tran vdout0_28ck113 FIND v(dout0_28) AT=570.025n

* CHECK dout0_29 Vdout0_29ck113 = 0.9 time = 570
.meas tran vdout0_29ck113 FIND v(dout0_29) AT=570.025n

* CHECK dout0_30 Vdout0_30ck113 = 0 time = 570
.meas tran vdout0_30ck113 FIND v(dout0_30) AT=570.025n

* CHECK dout0_31 Vdout0_31ck113 = 0 time = 570
.meas tran vdout0_31ck113 FIND v(dout0_31) AT=570.025n

* CHECK dout0_32 Vdout0_32ck113 = 0 time = 570
.meas tran vdout0_32ck113 FIND v(dout0_32) AT=570.025n

* CHECK dout0_33 Vdout0_33ck113 = 0.9 time = 570
.meas tran vdout0_33ck113 FIND v(dout0_33) AT=570.025n

* CHECK dout0_34 Vdout0_34ck113 = 0 time = 570
.meas tran vdout0_34ck113 FIND v(dout0_34) AT=570.025n

* CHECK dout0_35 Vdout0_35ck113 = 0 time = 570
.meas tran vdout0_35ck113 FIND v(dout0_35) AT=570.025n

* CHECK dout0_36 Vdout0_36ck113 = 0.9 time = 570
.meas tran vdout0_36ck113 FIND v(dout0_36) AT=570.025n

* CHECK dout0_37 Vdout0_37ck113 = 0 time = 570
.meas tran vdout0_37ck113 FIND v(dout0_37) AT=570.025n

* CHECK dout0_38 Vdout0_38ck113 = 0.9 time = 570
.meas tran vdout0_38ck113 FIND v(dout0_38) AT=570.025n

* CHECK dout0_39 Vdout0_39ck113 = 0 time = 570
.meas tran vdout0_39ck113 FIND v(dout0_39) AT=570.025n

* CHECK dout0_40 Vdout0_40ck113 = 0 time = 570
.meas tran vdout0_40ck113 FIND v(dout0_40) AT=570.025n

* CHECK dout0_41 Vdout0_41ck113 = 0.9 time = 570
.meas tran vdout0_41ck113 FIND v(dout0_41) AT=570.025n

* CHECK dout0_42 Vdout0_42ck113 = 0 time = 570
.meas tran vdout0_42ck113 FIND v(dout0_42) AT=570.025n

* CHECK dout0_43 Vdout0_43ck113 = 0.9 time = 570
.meas tran vdout0_43ck113 FIND v(dout0_43) AT=570.025n

* CHECK dout0_44 Vdout0_44ck113 = 0 time = 570
.meas tran vdout0_44ck113 FIND v(dout0_44) AT=570.025n

* CHECK dout0_45 Vdout0_45ck113 = 0.9 time = 570
.meas tran vdout0_45ck113 FIND v(dout0_45) AT=570.025n

* CHECK dout0_46 Vdout0_46ck113 = 0 time = 570
.meas tran vdout0_46ck113 FIND v(dout0_46) AT=570.025n

* CHECK dout0_47 Vdout0_47ck113 = 0 time = 570
.meas tran vdout0_47ck113 FIND v(dout0_47) AT=570.025n

* CHECK dout0_48 Vdout0_48ck113 = 0 time = 570
.meas tran vdout0_48ck113 FIND v(dout0_48) AT=570.025n

* CHECK dout0_49 Vdout0_49ck113 = 0 time = 570
.meas tran vdout0_49ck113 FIND v(dout0_49) AT=570.025n

* CHECK dout0_50 Vdout0_50ck113 = 0 time = 570
.meas tran vdout0_50ck113 FIND v(dout0_50) AT=570.025n

* CHECK dout0_51 Vdout0_51ck113 = 0.9 time = 570
.meas tran vdout0_51ck113 FIND v(dout0_51) AT=570.025n

* CHECK dout0_52 Vdout0_52ck113 = 0 time = 570
.meas tran vdout0_52ck113 FIND v(dout0_52) AT=570.025n

* CHECK dout0_53 Vdout0_53ck113 = 0 time = 570
.meas tran vdout0_53ck113 FIND v(dout0_53) AT=570.025n

* CHECK dout0_54 Vdout0_54ck113 = 0 time = 570
.meas tran vdout0_54ck113 FIND v(dout0_54) AT=570.025n

* CHECK dout0_55 Vdout0_55ck113 = 0 time = 570
.meas tran vdout0_55ck113 FIND v(dout0_55) AT=570.025n

* CHECK dout0_56 Vdout0_56ck113 = 0.9 time = 570
.meas tran vdout0_56ck113 FIND v(dout0_56) AT=570.025n

* CHECK dout0_57 Vdout0_57ck113 = 0.9 time = 570
.meas tran vdout0_57ck113 FIND v(dout0_57) AT=570.025n

* CHECK dout0_58 Vdout0_58ck113 = 0 time = 570
.meas tran vdout0_58ck113 FIND v(dout0_58) AT=570.025n

* CHECK dout0_59 Vdout0_59ck113 = 0.9 time = 570
.meas tran vdout0_59ck113 FIND v(dout0_59) AT=570.025n

* CHECK dout0_60 Vdout0_60ck113 = 0 time = 570
.meas tran vdout0_60ck113 FIND v(dout0_60) AT=570.025n

* CHECK dout0_61 Vdout0_61ck113 = 0.9 time = 570
.meas tran vdout0_61ck113 FIND v(dout0_61) AT=570.025n

* CHECK dout0_62 Vdout0_62ck113 = 0.9 time = 570
.meas tran vdout0_62ck113 FIND v(dout0_62) AT=570.025n

* CHECK dout0_63 Vdout0_63ck113 = 0.9 time = 570
.meas tran vdout0_63ck113 FIND v(dout0_63) AT=570.025n

* CHECK dout0_64 Vdout0_64ck113 = 0.9 time = 570
.meas tran vdout0_64ck113 FIND v(dout0_64) AT=570.025n

* CHECK dout0_65 Vdout0_65ck113 = 0.9 time = 570
.meas tran vdout0_65ck113 FIND v(dout0_65) AT=570.025n

* CHECK dout0_66 Vdout0_66ck113 = 0.9 time = 570
.meas tran vdout0_66ck113 FIND v(dout0_66) AT=570.025n

* CHECK dout0_67 Vdout0_67ck113 = 0.9 time = 570
.meas tran vdout0_67ck113 FIND v(dout0_67) AT=570.025n

* CHECK dout0_68 Vdout0_68ck113 = 0 time = 570
.meas tran vdout0_68ck113 FIND v(dout0_68) AT=570.025n

* CHECK dout0_69 Vdout0_69ck113 = 0.9 time = 570
.meas tran vdout0_69ck113 FIND v(dout0_69) AT=570.025n

* CHECK dout0_70 Vdout0_70ck113 = 0.9 time = 570
.meas tran vdout0_70ck113 FIND v(dout0_70) AT=570.025n

* CHECK dout0_71 Vdout0_71ck113 = 0.9 time = 570
.meas tran vdout0_71ck113 FIND v(dout0_71) AT=570.025n

* CHECK dout0_72 Vdout0_72ck113 = 0.9 time = 570
.meas tran vdout0_72ck113 FIND v(dout0_72) AT=570.025n

* CHECK dout0_73 Vdout0_73ck113 = 0 time = 570
.meas tran vdout0_73ck113 FIND v(dout0_73) AT=570.025n

* CHECK dout0_74 Vdout0_74ck113 = 0 time = 570
.meas tran vdout0_74ck113 FIND v(dout0_74) AT=570.025n

* CHECK dout0_75 Vdout0_75ck113 = 0.9 time = 570
.meas tran vdout0_75ck113 FIND v(dout0_75) AT=570.025n

* CHECK dout0_76 Vdout0_76ck113 = 0 time = 570
.meas tran vdout0_76ck113 FIND v(dout0_76) AT=570.025n

* CHECK dout0_77 Vdout0_77ck113 = 0.9 time = 570
.meas tran vdout0_77ck113 FIND v(dout0_77) AT=570.025n

* CHECK dout0_78 Vdout0_78ck113 = 0.9 time = 570
.meas tran vdout0_78ck113 FIND v(dout0_78) AT=570.025n

* CHECK dout0_79 Vdout0_79ck113 = 0.9 time = 570
.meas tran vdout0_79ck113 FIND v(dout0_79) AT=570.025n

* CHECK dout0_80 Vdout0_80ck113 = 0 time = 570
.meas tran vdout0_80ck113 FIND v(dout0_80) AT=570.025n

* CHECK dout0_81 Vdout0_81ck113 = 0 time = 570
.meas tran vdout0_81ck113 FIND v(dout0_81) AT=570.025n

* CHECK dout0_82 Vdout0_82ck113 = 0 time = 570
.meas tran vdout0_82ck113 FIND v(dout0_82) AT=570.025n

* CHECK dout0_83 Vdout0_83ck113 = 0 time = 570
.meas tran vdout0_83ck113 FIND v(dout0_83) AT=570.025n

* CHECK dout0_84 Vdout0_84ck113 = 0.9 time = 570
.meas tran vdout0_84ck113 FIND v(dout0_84) AT=570.025n

* CHECK dout0_85 Vdout0_85ck113 = 0 time = 570
.meas tran vdout0_85ck113 FIND v(dout0_85) AT=570.025n

* CHECK dout0_86 Vdout0_86ck113 = 0.9 time = 570
.meas tran vdout0_86ck113 FIND v(dout0_86) AT=570.025n

* CHECK dout0_87 Vdout0_87ck113 = 0 time = 570
.meas tran vdout0_87ck113 FIND v(dout0_87) AT=570.025n

* CHECK dout0_0 Vdout0_0ck114 = 0.9 time = 575
.meas tran vdout0_0ck114 FIND v(dout0_0) AT=575.025n

* CHECK dout0_1 Vdout0_1ck114 = 0 time = 575
.meas tran vdout0_1ck114 FIND v(dout0_1) AT=575.025n

* CHECK dout0_2 Vdout0_2ck114 = 0.9 time = 575
.meas tran vdout0_2ck114 FIND v(dout0_2) AT=575.025n

* CHECK dout0_3 Vdout0_3ck114 = 0 time = 575
.meas tran vdout0_3ck114 FIND v(dout0_3) AT=575.025n

* CHECK dout0_4 Vdout0_4ck114 = 0 time = 575
.meas tran vdout0_4ck114 FIND v(dout0_4) AT=575.025n

* CHECK dout0_5 Vdout0_5ck114 = 0.9 time = 575
.meas tran vdout0_5ck114 FIND v(dout0_5) AT=575.025n

* CHECK dout0_6 Vdout0_6ck114 = 0.9 time = 575
.meas tran vdout0_6ck114 FIND v(dout0_6) AT=575.025n

* CHECK dout0_7 Vdout0_7ck114 = 0 time = 575
.meas tran vdout0_7ck114 FIND v(dout0_7) AT=575.025n

* CHECK dout0_8 Vdout0_8ck114 = 0 time = 575
.meas tran vdout0_8ck114 FIND v(dout0_8) AT=575.025n

* CHECK dout0_9 Vdout0_9ck114 = 0.9 time = 575
.meas tran vdout0_9ck114 FIND v(dout0_9) AT=575.025n

* CHECK dout0_10 Vdout0_10ck114 = 0.9 time = 575
.meas tran vdout0_10ck114 FIND v(dout0_10) AT=575.025n

* CHECK dout0_11 Vdout0_11ck114 = 0 time = 575
.meas tran vdout0_11ck114 FIND v(dout0_11) AT=575.025n

* CHECK dout0_12 Vdout0_12ck114 = 0 time = 575
.meas tran vdout0_12ck114 FIND v(dout0_12) AT=575.025n

* CHECK dout0_13 Vdout0_13ck114 = 0 time = 575
.meas tran vdout0_13ck114 FIND v(dout0_13) AT=575.025n

* CHECK dout0_14 Vdout0_14ck114 = 0.9 time = 575
.meas tran vdout0_14ck114 FIND v(dout0_14) AT=575.025n

* CHECK dout0_15 Vdout0_15ck114 = 0.9 time = 575
.meas tran vdout0_15ck114 FIND v(dout0_15) AT=575.025n

* CHECK dout0_16 Vdout0_16ck114 = 0 time = 575
.meas tran vdout0_16ck114 FIND v(dout0_16) AT=575.025n

* CHECK dout0_17 Vdout0_17ck114 = 0 time = 575
.meas tran vdout0_17ck114 FIND v(dout0_17) AT=575.025n

* CHECK dout0_18 Vdout0_18ck114 = 0.9 time = 575
.meas tran vdout0_18ck114 FIND v(dout0_18) AT=575.025n

* CHECK dout0_19 Vdout0_19ck114 = 0.9 time = 575
.meas tran vdout0_19ck114 FIND v(dout0_19) AT=575.025n

* CHECK dout0_20 Vdout0_20ck114 = 0.9 time = 575
.meas tran vdout0_20ck114 FIND v(dout0_20) AT=575.025n

* CHECK dout0_21 Vdout0_21ck114 = 0 time = 575
.meas tran vdout0_21ck114 FIND v(dout0_21) AT=575.025n

* CHECK dout0_22 Vdout0_22ck114 = 0 time = 575
.meas tran vdout0_22ck114 FIND v(dout0_22) AT=575.025n

* CHECK dout0_23 Vdout0_23ck114 = 0 time = 575
.meas tran vdout0_23ck114 FIND v(dout0_23) AT=575.025n

* CHECK dout0_24 Vdout0_24ck114 = 0.9 time = 575
.meas tran vdout0_24ck114 FIND v(dout0_24) AT=575.025n

* CHECK dout0_25 Vdout0_25ck114 = 0.9 time = 575
.meas tran vdout0_25ck114 FIND v(dout0_25) AT=575.025n

* CHECK dout0_26 Vdout0_26ck114 = 0.9 time = 575
.meas tran vdout0_26ck114 FIND v(dout0_26) AT=575.025n

* CHECK dout0_27 Vdout0_27ck114 = 0.9 time = 575
.meas tran vdout0_27ck114 FIND v(dout0_27) AT=575.025n

* CHECK dout0_28 Vdout0_28ck114 = 0 time = 575
.meas tran vdout0_28ck114 FIND v(dout0_28) AT=575.025n

* CHECK dout0_29 Vdout0_29ck114 = 0.9 time = 575
.meas tran vdout0_29ck114 FIND v(dout0_29) AT=575.025n

* CHECK dout0_30 Vdout0_30ck114 = 0 time = 575
.meas tran vdout0_30ck114 FIND v(dout0_30) AT=575.025n

* CHECK dout0_31 Vdout0_31ck114 = 0 time = 575
.meas tran vdout0_31ck114 FIND v(dout0_31) AT=575.025n

* CHECK dout0_32 Vdout0_32ck114 = 0 time = 575
.meas tran vdout0_32ck114 FIND v(dout0_32) AT=575.025n

* CHECK dout0_33 Vdout0_33ck114 = 0.9 time = 575
.meas tran vdout0_33ck114 FIND v(dout0_33) AT=575.025n

* CHECK dout0_34 Vdout0_34ck114 = 0 time = 575
.meas tran vdout0_34ck114 FIND v(dout0_34) AT=575.025n

* CHECK dout0_35 Vdout0_35ck114 = 0 time = 575
.meas tran vdout0_35ck114 FIND v(dout0_35) AT=575.025n

* CHECK dout0_36 Vdout0_36ck114 = 0.9 time = 575
.meas tran vdout0_36ck114 FIND v(dout0_36) AT=575.025n

* CHECK dout0_37 Vdout0_37ck114 = 0 time = 575
.meas tran vdout0_37ck114 FIND v(dout0_37) AT=575.025n

* CHECK dout0_38 Vdout0_38ck114 = 0.9 time = 575
.meas tran vdout0_38ck114 FIND v(dout0_38) AT=575.025n

* CHECK dout0_39 Vdout0_39ck114 = 0 time = 575
.meas tran vdout0_39ck114 FIND v(dout0_39) AT=575.025n

* CHECK dout0_40 Vdout0_40ck114 = 0 time = 575
.meas tran vdout0_40ck114 FIND v(dout0_40) AT=575.025n

* CHECK dout0_41 Vdout0_41ck114 = 0.9 time = 575
.meas tran vdout0_41ck114 FIND v(dout0_41) AT=575.025n

* CHECK dout0_42 Vdout0_42ck114 = 0 time = 575
.meas tran vdout0_42ck114 FIND v(dout0_42) AT=575.025n

* CHECK dout0_43 Vdout0_43ck114 = 0.9 time = 575
.meas tran vdout0_43ck114 FIND v(dout0_43) AT=575.025n

* CHECK dout0_44 Vdout0_44ck114 = 0 time = 575
.meas tran vdout0_44ck114 FIND v(dout0_44) AT=575.025n

* CHECK dout0_45 Vdout0_45ck114 = 0.9 time = 575
.meas tran vdout0_45ck114 FIND v(dout0_45) AT=575.025n

* CHECK dout0_46 Vdout0_46ck114 = 0 time = 575
.meas tran vdout0_46ck114 FIND v(dout0_46) AT=575.025n

* CHECK dout0_47 Vdout0_47ck114 = 0 time = 575
.meas tran vdout0_47ck114 FIND v(dout0_47) AT=575.025n

* CHECK dout0_48 Vdout0_48ck114 = 0 time = 575
.meas tran vdout0_48ck114 FIND v(dout0_48) AT=575.025n

* CHECK dout0_49 Vdout0_49ck114 = 0 time = 575
.meas tran vdout0_49ck114 FIND v(dout0_49) AT=575.025n

* CHECK dout0_50 Vdout0_50ck114 = 0 time = 575
.meas tran vdout0_50ck114 FIND v(dout0_50) AT=575.025n

* CHECK dout0_51 Vdout0_51ck114 = 0.9 time = 575
.meas tran vdout0_51ck114 FIND v(dout0_51) AT=575.025n

* CHECK dout0_52 Vdout0_52ck114 = 0 time = 575
.meas tran vdout0_52ck114 FIND v(dout0_52) AT=575.025n

* CHECK dout0_53 Vdout0_53ck114 = 0 time = 575
.meas tran vdout0_53ck114 FIND v(dout0_53) AT=575.025n

* CHECK dout0_54 Vdout0_54ck114 = 0 time = 575
.meas tran vdout0_54ck114 FIND v(dout0_54) AT=575.025n

* CHECK dout0_55 Vdout0_55ck114 = 0 time = 575
.meas tran vdout0_55ck114 FIND v(dout0_55) AT=575.025n

* CHECK dout0_56 Vdout0_56ck114 = 0.9 time = 575
.meas tran vdout0_56ck114 FIND v(dout0_56) AT=575.025n

* CHECK dout0_57 Vdout0_57ck114 = 0.9 time = 575
.meas tran vdout0_57ck114 FIND v(dout0_57) AT=575.025n

* CHECK dout0_58 Vdout0_58ck114 = 0 time = 575
.meas tran vdout0_58ck114 FIND v(dout0_58) AT=575.025n

* CHECK dout0_59 Vdout0_59ck114 = 0.9 time = 575
.meas tran vdout0_59ck114 FIND v(dout0_59) AT=575.025n

* CHECK dout0_60 Vdout0_60ck114 = 0 time = 575
.meas tran vdout0_60ck114 FIND v(dout0_60) AT=575.025n

* CHECK dout0_61 Vdout0_61ck114 = 0.9 time = 575
.meas tran vdout0_61ck114 FIND v(dout0_61) AT=575.025n

* CHECK dout0_62 Vdout0_62ck114 = 0.9 time = 575
.meas tran vdout0_62ck114 FIND v(dout0_62) AT=575.025n

* CHECK dout0_63 Vdout0_63ck114 = 0.9 time = 575
.meas tran vdout0_63ck114 FIND v(dout0_63) AT=575.025n

* CHECK dout0_64 Vdout0_64ck114 = 0.9 time = 575
.meas tran vdout0_64ck114 FIND v(dout0_64) AT=575.025n

* CHECK dout0_65 Vdout0_65ck114 = 0.9 time = 575
.meas tran vdout0_65ck114 FIND v(dout0_65) AT=575.025n

* CHECK dout0_66 Vdout0_66ck114 = 0.9 time = 575
.meas tran vdout0_66ck114 FIND v(dout0_66) AT=575.025n

* CHECK dout0_67 Vdout0_67ck114 = 0.9 time = 575
.meas tran vdout0_67ck114 FIND v(dout0_67) AT=575.025n

* CHECK dout0_68 Vdout0_68ck114 = 0 time = 575
.meas tran vdout0_68ck114 FIND v(dout0_68) AT=575.025n

* CHECK dout0_69 Vdout0_69ck114 = 0.9 time = 575
.meas tran vdout0_69ck114 FIND v(dout0_69) AT=575.025n

* CHECK dout0_70 Vdout0_70ck114 = 0.9 time = 575
.meas tran vdout0_70ck114 FIND v(dout0_70) AT=575.025n

* CHECK dout0_71 Vdout0_71ck114 = 0.9 time = 575
.meas tran vdout0_71ck114 FIND v(dout0_71) AT=575.025n

* CHECK dout0_72 Vdout0_72ck114 = 0.9 time = 575
.meas tran vdout0_72ck114 FIND v(dout0_72) AT=575.025n

* CHECK dout0_73 Vdout0_73ck114 = 0 time = 575
.meas tran vdout0_73ck114 FIND v(dout0_73) AT=575.025n

* CHECK dout0_74 Vdout0_74ck114 = 0 time = 575
.meas tran vdout0_74ck114 FIND v(dout0_74) AT=575.025n

* CHECK dout0_75 Vdout0_75ck114 = 0.9 time = 575
.meas tran vdout0_75ck114 FIND v(dout0_75) AT=575.025n

* CHECK dout0_76 Vdout0_76ck114 = 0 time = 575
.meas tran vdout0_76ck114 FIND v(dout0_76) AT=575.025n

* CHECK dout0_77 Vdout0_77ck114 = 0.9 time = 575
.meas tran vdout0_77ck114 FIND v(dout0_77) AT=575.025n

* CHECK dout0_78 Vdout0_78ck114 = 0.9 time = 575
.meas tran vdout0_78ck114 FIND v(dout0_78) AT=575.025n

* CHECK dout0_79 Vdout0_79ck114 = 0.9 time = 575
.meas tran vdout0_79ck114 FIND v(dout0_79) AT=575.025n

* CHECK dout0_80 Vdout0_80ck114 = 0 time = 575
.meas tran vdout0_80ck114 FIND v(dout0_80) AT=575.025n

* CHECK dout0_81 Vdout0_81ck114 = 0 time = 575
.meas tran vdout0_81ck114 FIND v(dout0_81) AT=575.025n

* CHECK dout0_82 Vdout0_82ck114 = 0 time = 575
.meas tran vdout0_82ck114 FIND v(dout0_82) AT=575.025n

* CHECK dout0_83 Vdout0_83ck114 = 0 time = 575
.meas tran vdout0_83ck114 FIND v(dout0_83) AT=575.025n

* CHECK dout0_84 Vdout0_84ck114 = 0.9 time = 575
.meas tran vdout0_84ck114 FIND v(dout0_84) AT=575.025n

* CHECK dout0_85 Vdout0_85ck114 = 0 time = 575
.meas tran vdout0_85ck114 FIND v(dout0_85) AT=575.025n

* CHECK dout0_86 Vdout0_86ck114 = 0.9 time = 575
.meas tran vdout0_86ck114 FIND v(dout0_86) AT=575.025n

* CHECK dout0_87 Vdout0_87ck114 = 0 time = 575
.meas tran vdout0_87ck114 FIND v(dout0_87) AT=575.025n

* CHECK dout0_0 Vdout0_0ck118 = 0 time = 595
.meas tran vdout0_0ck118 FIND v(dout0_0) AT=595.025n

* CHECK dout0_1 Vdout0_1ck118 = 0.9 time = 595
.meas tran vdout0_1ck118 FIND v(dout0_1) AT=595.025n

* CHECK dout0_2 Vdout0_2ck118 = 0.9 time = 595
.meas tran vdout0_2ck118 FIND v(dout0_2) AT=595.025n

* CHECK dout0_3 Vdout0_3ck118 = 0 time = 595
.meas tran vdout0_3ck118 FIND v(dout0_3) AT=595.025n

* CHECK dout0_4 Vdout0_4ck118 = 0 time = 595
.meas tran vdout0_4ck118 FIND v(dout0_4) AT=595.025n

* CHECK dout0_5 Vdout0_5ck118 = 0 time = 595
.meas tran vdout0_5ck118 FIND v(dout0_5) AT=595.025n

* CHECK dout0_6 Vdout0_6ck118 = 0 time = 595
.meas tran vdout0_6ck118 FIND v(dout0_6) AT=595.025n

* CHECK dout0_7 Vdout0_7ck118 = 0 time = 595
.meas tran vdout0_7ck118 FIND v(dout0_7) AT=595.025n

* CHECK dout0_8 Vdout0_8ck118 = 0.9 time = 595
.meas tran vdout0_8ck118 FIND v(dout0_8) AT=595.025n

* CHECK dout0_9 Vdout0_9ck118 = 0.9 time = 595
.meas tran vdout0_9ck118 FIND v(dout0_9) AT=595.025n

* CHECK dout0_10 Vdout0_10ck118 = 0.9 time = 595
.meas tran vdout0_10ck118 FIND v(dout0_10) AT=595.025n

* CHECK dout0_11 Vdout0_11ck118 = 0 time = 595
.meas tran vdout0_11ck118 FIND v(dout0_11) AT=595.025n

* CHECK dout0_12 Vdout0_12ck118 = 0.9 time = 595
.meas tran vdout0_12ck118 FIND v(dout0_12) AT=595.025n

* CHECK dout0_13 Vdout0_13ck118 = 0.9 time = 595
.meas tran vdout0_13ck118 FIND v(dout0_13) AT=595.025n

* CHECK dout0_14 Vdout0_14ck118 = 0 time = 595
.meas tran vdout0_14ck118 FIND v(dout0_14) AT=595.025n

* CHECK dout0_15 Vdout0_15ck118 = 0.9 time = 595
.meas tran vdout0_15ck118 FIND v(dout0_15) AT=595.025n

* CHECK dout0_16 Vdout0_16ck118 = 0 time = 595
.meas tran vdout0_16ck118 FIND v(dout0_16) AT=595.025n

* CHECK dout0_17 Vdout0_17ck118 = 0 time = 595
.meas tran vdout0_17ck118 FIND v(dout0_17) AT=595.025n

* CHECK dout0_18 Vdout0_18ck118 = 0 time = 595
.meas tran vdout0_18ck118 FIND v(dout0_18) AT=595.025n

* CHECK dout0_19 Vdout0_19ck118 = 0.9 time = 595
.meas tran vdout0_19ck118 FIND v(dout0_19) AT=595.025n

* CHECK dout0_20 Vdout0_20ck118 = 0 time = 595
.meas tran vdout0_20ck118 FIND v(dout0_20) AT=595.025n

* CHECK dout0_21 Vdout0_21ck118 = 0.9 time = 595
.meas tran vdout0_21ck118 FIND v(dout0_21) AT=595.025n

* CHECK dout0_22 Vdout0_22ck118 = 0.9 time = 595
.meas tran vdout0_22ck118 FIND v(dout0_22) AT=595.025n

* CHECK dout0_23 Vdout0_23ck118 = 0.9 time = 595
.meas tran vdout0_23ck118 FIND v(dout0_23) AT=595.025n

* CHECK dout0_24 Vdout0_24ck118 = 0.9 time = 595
.meas tran vdout0_24ck118 FIND v(dout0_24) AT=595.025n

* CHECK dout0_25 Vdout0_25ck118 = 0 time = 595
.meas tran vdout0_25ck118 FIND v(dout0_25) AT=595.025n

* CHECK dout0_26 Vdout0_26ck118 = 0.9 time = 595
.meas tran vdout0_26ck118 FIND v(dout0_26) AT=595.025n

* CHECK dout0_27 Vdout0_27ck118 = 0 time = 595
.meas tran vdout0_27ck118 FIND v(dout0_27) AT=595.025n

* CHECK dout0_28 Vdout0_28ck118 = 0.9 time = 595
.meas tran vdout0_28ck118 FIND v(dout0_28) AT=595.025n

* CHECK dout0_29 Vdout0_29ck118 = 0.9 time = 595
.meas tran vdout0_29ck118 FIND v(dout0_29) AT=595.025n

* CHECK dout0_30 Vdout0_30ck118 = 0.9 time = 595
.meas tran vdout0_30ck118 FIND v(dout0_30) AT=595.025n

* CHECK dout0_31 Vdout0_31ck118 = 0.9 time = 595
.meas tran vdout0_31ck118 FIND v(dout0_31) AT=595.025n

* CHECK dout0_32 Vdout0_32ck118 = 0.9 time = 595
.meas tran vdout0_32ck118 FIND v(dout0_32) AT=595.025n

* CHECK dout0_33 Vdout0_33ck118 = 0.9 time = 595
.meas tran vdout0_33ck118 FIND v(dout0_33) AT=595.025n

* CHECK dout0_34 Vdout0_34ck118 = 0 time = 595
.meas tran vdout0_34ck118 FIND v(dout0_34) AT=595.025n

* CHECK dout0_35 Vdout0_35ck118 = 0.9 time = 595
.meas tran vdout0_35ck118 FIND v(dout0_35) AT=595.025n

* CHECK dout0_36 Vdout0_36ck118 = 0.9 time = 595
.meas tran vdout0_36ck118 FIND v(dout0_36) AT=595.025n

* CHECK dout0_37 Vdout0_37ck118 = 0 time = 595
.meas tran vdout0_37ck118 FIND v(dout0_37) AT=595.025n

* CHECK dout0_38 Vdout0_38ck118 = 0.9 time = 595
.meas tran vdout0_38ck118 FIND v(dout0_38) AT=595.025n

* CHECK dout0_39 Vdout0_39ck118 = 0.9 time = 595
.meas tran vdout0_39ck118 FIND v(dout0_39) AT=595.025n

* CHECK dout0_40 Vdout0_40ck118 = 0.9 time = 595
.meas tran vdout0_40ck118 FIND v(dout0_40) AT=595.025n

* CHECK dout0_41 Vdout0_41ck118 = 0 time = 595
.meas tran vdout0_41ck118 FIND v(dout0_41) AT=595.025n

* CHECK dout0_42 Vdout0_42ck118 = 0 time = 595
.meas tran vdout0_42ck118 FIND v(dout0_42) AT=595.025n

* CHECK dout0_43 Vdout0_43ck118 = 0.9 time = 595
.meas tran vdout0_43ck118 FIND v(dout0_43) AT=595.025n

* CHECK dout0_44 Vdout0_44ck118 = 0 time = 595
.meas tran vdout0_44ck118 FIND v(dout0_44) AT=595.025n

* CHECK dout0_45 Vdout0_45ck118 = 0.9 time = 595
.meas tran vdout0_45ck118 FIND v(dout0_45) AT=595.025n

* CHECK dout0_46 Vdout0_46ck118 = 0.9 time = 595
.meas tran vdout0_46ck118 FIND v(dout0_46) AT=595.025n

* CHECK dout0_47 Vdout0_47ck118 = 0 time = 595
.meas tran vdout0_47ck118 FIND v(dout0_47) AT=595.025n

* CHECK dout0_48 Vdout0_48ck118 = 0.9 time = 595
.meas tran vdout0_48ck118 FIND v(dout0_48) AT=595.025n

* CHECK dout0_49 Vdout0_49ck118 = 0 time = 595
.meas tran vdout0_49ck118 FIND v(dout0_49) AT=595.025n

* CHECK dout0_50 Vdout0_50ck118 = 0.9 time = 595
.meas tran vdout0_50ck118 FIND v(dout0_50) AT=595.025n

* CHECK dout0_51 Vdout0_51ck118 = 0 time = 595
.meas tran vdout0_51ck118 FIND v(dout0_51) AT=595.025n

* CHECK dout0_52 Vdout0_52ck118 = 0.9 time = 595
.meas tran vdout0_52ck118 FIND v(dout0_52) AT=595.025n

* CHECK dout0_53 Vdout0_53ck118 = 0 time = 595
.meas tran vdout0_53ck118 FIND v(dout0_53) AT=595.025n

* CHECK dout0_54 Vdout0_54ck118 = 0 time = 595
.meas tran vdout0_54ck118 FIND v(dout0_54) AT=595.025n

* CHECK dout0_55 Vdout0_55ck118 = 0.9 time = 595
.meas tran vdout0_55ck118 FIND v(dout0_55) AT=595.025n

* CHECK dout0_56 Vdout0_56ck118 = 0 time = 595
.meas tran vdout0_56ck118 FIND v(dout0_56) AT=595.025n

* CHECK dout0_57 Vdout0_57ck118 = 0 time = 595
.meas tran vdout0_57ck118 FIND v(dout0_57) AT=595.025n

* CHECK dout0_58 Vdout0_58ck118 = 0 time = 595
.meas tran vdout0_58ck118 FIND v(dout0_58) AT=595.025n

* CHECK dout0_59 Vdout0_59ck118 = 0 time = 595
.meas tran vdout0_59ck118 FIND v(dout0_59) AT=595.025n

* CHECK dout0_60 Vdout0_60ck118 = 0.9 time = 595
.meas tran vdout0_60ck118 FIND v(dout0_60) AT=595.025n

* CHECK dout0_61 Vdout0_61ck118 = 0.9 time = 595
.meas tran vdout0_61ck118 FIND v(dout0_61) AT=595.025n

* CHECK dout0_62 Vdout0_62ck118 = 0 time = 595
.meas tran vdout0_62ck118 FIND v(dout0_62) AT=595.025n

* CHECK dout0_63 Vdout0_63ck118 = 0.9 time = 595
.meas tran vdout0_63ck118 FIND v(dout0_63) AT=595.025n

* CHECK dout0_64 Vdout0_64ck118 = 0.9 time = 595
.meas tran vdout0_64ck118 FIND v(dout0_64) AT=595.025n

* CHECK dout0_65 Vdout0_65ck118 = 0 time = 595
.meas tran vdout0_65ck118 FIND v(dout0_65) AT=595.025n

* CHECK dout0_66 Vdout0_66ck118 = 0.9 time = 595
.meas tran vdout0_66ck118 FIND v(dout0_66) AT=595.025n

* CHECK dout0_67 Vdout0_67ck118 = 0 time = 595
.meas tran vdout0_67ck118 FIND v(dout0_67) AT=595.025n

* CHECK dout0_68 Vdout0_68ck118 = 0 time = 595
.meas tran vdout0_68ck118 FIND v(dout0_68) AT=595.025n

* CHECK dout0_69 Vdout0_69ck118 = 0.9 time = 595
.meas tran vdout0_69ck118 FIND v(dout0_69) AT=595.025n

* CHECK dout0_70 Vdout0_70ck118 = 0.9 time = 595
.meas tran vdout0_70ck118 FIND v(dout0_70) AT=595.025n

* CHECK dout0_71 Vdout0_71ck118 = 0.9 time = 595
.meas tran vdout0_71ck118 FIND v(dout0_71) AT=595.025n

* CHECK dout0_72 Vdout0_72ck118 = 0 time = 595
.meas tran vdout0_72ck118 FIND v(dout0_72) AT=595.025n

* CHECK dout0_73 Vdout0_73ck118 = 0 time = 595
.meas tran vdout0_73ck118 FIND v(dout0_73) AT=595.025n

* CHECK dout0_74 Vdout0_74ck118 = 0.9 time = 595
.meas tran vdout0_74ck118 FIND v(dout0_74) AT=595.025n

* CHECK dout0_75 Vdout0_75ck118 = 0 time = 595
.meas tran vdout0_75ck118 FIND v(dout0_75) AT=595.025n

* CHECK dout0_76 Vdout0_76ck118 = 0 time = 595
.meas tran vdout0_76ck118 FIND v(dout0_76) AT=595.025n

* CHECK dout0_77 Vdout0_77ck118 = 0 time = 595
.meas tran vdout0_77ck118 FIND v(dout0_77) AT=595.025n

* CHECK dout0_78 Vdout0_78ck118 = 0 time = 595
.meas tran vdout0_78ck118 FIND v(dout0_78) AT=595.025n

* CHECK dout0_79 Vdout0_79ck118 = 0 time = 595
.meas tran vdout0_79ck118 FIND v(dout0_79) AT=595.025n

* CHECK dout0_80 Vdout0_80ck118 = 0.9 time = 595
.meas tran vdout0_80ck118 FIND v(dout0_80) AT=595.025n

* CHECK dout0_81 Vdout0_81ck118 = 0.9 time = 595
.meas tran vdout0_81ck118 FIND v(dout0_81) AT=595.025n

* CHECK dout0_82 Vdout0_82ck118 = 0.9 time = 595
.meas tran vdout0_82ck118 FIND v(dout0_82) AT=595.025n

* CHECK dout0_83 Vdout0_83ck118 = 0.9 time = 595
.meas tran vdout0_83ck118 FIND v(dout0_83) AT=595.025n

* CHECK dout0_84 Vdout0_84ck118 = 0 time = 595
.meas tran vdout0_84ck118 FIND v(dout0_84) AT=595.025n

* CHECK dout0_85 Vdout0_85ck118 = 0.9 time = 595
.meas tran vdout0_85ck118 FIND v(dout0_85) AT=595.025n

* CHECK dout0_86 Vdout0_86ck118 = 0 time = 595
.meas tran vdout0_86ck118 FIND v(dout0_86) AT=595.025n

* CHECK dout0_87 Vdout0_87ck118 = 0 time = 595
.meas tran vdout0_87ck118 FIND v(dout0_87) AT=595.025n

* CHECK dout0_0 Vdout0_0ck119 = 0.9 time = 600
.meas tran vdout0_0ck119 FIND v(dout0_0) AT=600.025n

* CHECK dout0_1 Vdout0_1ck119 = 0 time = 600
.meas tran vdout0_1ck119 FIND v(dout0_1) AT=600.025n

* CHECK dout0_2 Vdout0_2ck119 = 0.9 time = 600
.meas tran vdout0_2ck119 FIND v(dout0_2) AT=600.025n

* CHECK dout0_3 Vdout0_3ck119 = 0.9 time = 600
.meas tran vdout0_3ck119 FIND v(dout0_3) AT=600.025n

* CHECK dout0_4 Vdout0_4ck119 = 0 time = 600
.meas tran vdout0_4ck119 FIND v(dout0_4) AT=600.025n

* CHECK dout0_5 Vdout0_5ck119 = 0 time = 600
.meas tran vdout0_5ck119 FIND v(dout0_5) AT=600.025n

* CHECK dout0_6 Vdout0_6ck119 = 0.9 time = 600
.meas tran vdout0_6ck119 FIND v(dout0_6) AT=600.025n

* CHECK dout0_7 Vdout0_7ck119 = 0 time = 600
.meas tran vdout0_7ck119 FIND v(dout0_7) AT=600.025n

* CHECK dout0_8 Vdout0_8ck119 = 0.9 time = 600
.meas tran vdout0_8ck119 FIND v(dout0_8) AT=600.025n

* CHECK dout0_9 Vdout0_9ck119 = 0.9 time = 600
.meas tran vdout0_9ck119 FIND v(dout0_9) AT=600.025n

* CHECK dout0_10 Vdout0_10ck119 = 0 time = 600
.meas tran vdout0_10ck119 FIND v(dout0_10) AT=600.025n

* CHECK dout0_11 Vdout0_11ck119 = 0 time = 600
.meas tran vdout0_11ck119 FIND v(dout0_11) AT=600.025n

* CHECK dout0_12 Vdout0_12ck119 = 0 time = 600
.meas tran vdout0_12ck119 FIND v(dout0_12) AT=600.025n

* CHECK dout0_13 Vdout0_13ck119 = 0 time = 600
.meas tran vdout0_13ck119 FIND v(dout0_13) AT=600.025n

* CHECK dout0_14 Vdout0_14ck119 = 0.9 time = 600
.meas tran vdout0_14ck119 FIND v(dout0_14) AT=600.025n

* CHECK dout0_15 Vdout0_15ck119 = 0.9 time = 600
.meas tran vdout0_15ck119 FIND v(dout0_15) AT=600.025n

* CHECK dout0_16 Vdout0_16ck119 = 0.9 time = 600
.meas tran vdout0_16ck119 FIND v(dout0_16) AT=600.025n

* CHECK dout0_17 Vdout0_17ck119 = 0.9 time = 600
.meas tran vdout0_17ck119 FIND v(dout0_17) AT=600.025n

* CHECK dout0_18 Vdout0_18ck119 = 0.9 time = 600
.meas tran vdout0_18ck119 FIND v(dout0_18) AT=600.025n

* CHECK dout0_19 Vdout0_19ck119 = 0.9 time = 600
.meas tran vdout0_19ck119 FIND v(dout0_19) AT=600.025n

* CHECK dout0_20 Vdout0_20ck119 = 0 time = 600
.meas tran vdout0_20ck119 FIND v(dout0_20) AT=600.025n

* CHECK dout0_21 Vdout0_21ck119 = 0.9 time = 600
.meas tran vdout0_21ck119 FIND v(dout0_21) AT=600.025n

* CHECK dout0_22 Vdout0_22ck119 = 0 time = 600
.meas tran vdout0_22ck119 FIND v(dout0_22) AT=600.025n

* CHECK dout0_23 Vdout0_23ck119 = 0 time = 600
.meas tran vdout0_23ck119 FIND v(dout0_23) AT=600.025n

* CHECK dout0_24 Vdout0_24ck119 = 0 time = 600
.meas tran vdout0_24ck119 FIND v(dout0_24) AT=600.025n

* CHECK dout0_25 Vdout0_25ck119 = 0 time = 600
.meas tran vdout0_25ck119 FIND v(dout0_25) AT=600.025n

* CHECK dout0_26 Vdout0_26ck119 = 0.9 time = 600
.meas tran vdout0_26ck119 FIND v(dout0_26) AT=600.025n

* CHECK dout0_27 Vdout0_27ck119 = 0 time = 600
.meas tran vdout0_27ck119 FIND v(dout0_27) AT=600.025n

* CHECK dout0_28 Vdout0_28ck119 = 0.9 time = 600
.meas tran vdout0_28ck119 FIND v(dout0_28) AT=600.025n

* CHECK dout0_29 Vdout0_29ck119 = 0.9 time = 600
.meas tran vdout0_29ck119 FIND v(dout0_29) AT=600.025n

* CHECK dout0_30 Vdout0_30ck119 = 0 time = 600
.meas tran vdout0_30ck119 FIND v(dout0_30) AT=600.025n

* CHECK dout0_31 Vdout0_31ck119 = 0 time = 600
.meas tran vdout0_31ck119 FIND v(dout0_31) AT=600.025n

* CHECK dout0_32 Vdout0_32ck119 = 0 time = 600
.meas tran vdout0_32ck119 FIND v(dout0_32) AT=600.025n

* CHECK dout0_33 Vdout0_33ck119 = 0.9 time = 600
.meas tran vdout0_33ck119 FIND v(dout0_33) AT=600.025n

* CHECK dout0_34 Vdout0_34ck119 = 0.9 time = 600
.meas tran vdout0_34ck119 FIND v(dout0_34) AT=600.025n

* CHECK dout0_35 Vdout0_35ck119 = 0.9 time = 600
.meas tran vdout0_35ck119 FIND v(dout0_35) AT=600.025n

* CHECK dout0_36 Vdout0_36ck119 = 0.9 time = 600
.meas tran vdout0_36ck119 FIND v(dout0_36) AT=600.025n

* CHECK dout0_37 Vdout0_37ck119 = 0.9 time = 600
.meas tran vdout0_37ck119 FIND v(dout0_37) AT=600.025n

* CHECK dout0_38 Vdout0_38ck119 = 0.9 time = 600
.meas tran vdout0_38ck119 FIND v(dout0_38) AT=600.025n

* CHECK dout0_39 Vdout0_39ck119 = 0 time = 600
.meas tran vdout0_39ck119 FIND v(dout0_39) AT=600.025n

* CHECK dout0_40 Vdout0_40ck119 = 0.9 time = 600
.meas tran vdout0_40ck119 FIND v(dout0_40) AT=600.025n

* CHECK dout0_41 Vdout0_41ck119 = 0.9 time = 600
.meas tran vdout0_41ck119 FIND v(dout0_41) AT=600.025n

* CHECK dout0_42 Vdout0_42ck119 = 0 time = 600
.meas tran vdout0_42ck119 FIND v(dout0_42) AT=600.025n

* CHECK dout0_43 Vdout0_43ck119 = 0.9 time = 600
.meas tran vdout0_43ck119 FIND v(dout0_43) AT=600.025n

* CHECK dout0_44 Vdout0_44ck119 = 0 time = 600
.meas tran vdout0_44ck119 FIND v(dout0_44) AT=600.025n

* CHECK dout0_45 Vdout0_45ck119 = 0 time = 600
.meas tran vdout0_45ck119 FIND v(dout0_45) AT=600.025n

* CHECK dout0_46 Vdout0_46ck119 = 0 time = 600
.meas tran vdout0_46ck119 FIND v(dout0_46) AT=600.025n

* CHECK dout0_47 Vdout0_47ck119 = 0 time = 600
.meas tran vdout0_47ck119 FIND v(dout0_47) AT=600.025n

* CHECK dout0_48 Vdout0_48ck119 = 0.9 time = 600
.meas tran vdout0_48ck119 FIND v(dout0_48) AT=600.025n

* CHECK dout0_49 Vdout0_49ck119 = 0.9 time = 600
.meas tran vdout0_49ck119 FIND v(dout0_49) AT=600.025n

* CHECK dout0_50 Vdout0_50ck119 = 0 time = 600
.meas tran vdout0_50ck119 FIND v(dout0_50) AT=600.025n

* CHECK dout0_51 Vdout0_51ck119 = 0 time = 600
.meas tran vdout0_51ck119 FIND v(dout0_51) AT=600.025n

* CHECK dout0_52 Vdout0_52ck119 = 0.9 time = 600
.meas tran vdout0_52ck119 FIND v(dout0_52) AT=600.025n

* CHECK dout0_53 Vdout0_53ck119 = 0 time = 600
.meas tran vdout0_53ck119 FIND v(dout0_53) AT=600.025n

* CHECK dout0_54 Vdout0_54ck119 = 0 time = 600
.meas tran vdout0_54ck119 FIND v(dout0_54) AT=600.025n

* CHECK dout0_55 Vdout0_55ck119 = 0 time = 600
.meas tran vdout0_55ck119 FIND v(dout0_55) AT=600.025n

* CHECK dout0_56 Vdout0_56ck119 = 0 time = 600
.meas tran vdout0_56ck119 FIND v(dout0_56) AT=600.025n

* CHECK dout0_57 Vdout0_57ck119 = 0.9 time = 600
.meas tran vdout0_57ck119 FIND v(dout0_57) AT=600.025n

* CHECK dout0_58 Vdout0_58ck119 = 0 time = 600
.meas tran vdout0_58ck119 FIND v(dout0_58) AT=600.025n

* CHECK dout0_59 Vdout0_59ck119 = 0 time = 600
.meas tran vdout0_59ck119 FIND v(dout0_59) AT=600.025n

* CHECK dout0_60 Vdout0_60ck119 = 0 time = 600
.meas tran vdout0_60ck119 FIND v(dout0_60) AT=600.025n

* CHECK dout0_61 Vdout0_61ck119 = 0.9 time = 600
.meas tran vdout0_61ck119 FIND v(dout0_61) AT=600.025n

* CHECK dout0_62 Vdout0_62ck119 = 0.9 time = 600
.meas tran vdout0_62ck119 FIND v(dout0_62) AT=600.025n

* CHECK dout0_63 Vdout0_63ck119 = 0 time = 600
.meas tran vdout0_63ck119 FIND v(dout0_63) AT=600.025n

* CHECK dout0_64 Vdout0_64ck119 = 0.9 time = 600
.meas tran vdout0_64ck119 FIND v(dout0_64) AT=600.025n

* CHECK dout0_65 Vdout0_65ck119 = 0 time = 600
.meas tran vdout0_65ck119 FIND v(dout0_65) AT=600.025n

* CHECK dout0_66 Vdout0_66ck119 = 0.9 time = 600
.meas tran vdout0_66ck119 FIND v(dout0_66) AT=600.025n

* CHECK dout0_67 Vdout0_67ck119 = 0 time = 600
.meas tran vdout0_67ck119 FIND v(dout0_67) AT=600.025n

* CHECK dout0_68 Vdout0_68ck119 = 0.9 time = 600
.meas tran vdout0_68ck119 FIND v(dout0_68) AT=600.025n

* CHECK dout0_69 Vdout0_69ck119 = 0.9 time = 600
.meas tran vdout0_69ck119 FIND v(dout0_69) AT=600.025n

* CHECK dout0_70 Vdout0_70ck119 = 0 time = 600
.meas tran vdout0_70ck119 FIND v(dout0_70) AT=600.025n

* CHECK dout0_71 Vdout0_71ck119 = 0.9 time = 600
.meas tran vdout0_71ck119 FIND v(dout0_71) AT=600.025n

* CHECK dout0_72 Vdout0_72ck119 = 0.9 time = 600
.meas tran vdout0_72ck119 FIND v(dout0_72) AT=600.025n

* CHECK dout0_73 Vdout0_73ck119 = 0.9 time = 600
.meas tran vdout0_73ck119 FIND v(dout0_73) AT=600.025n

* CHECK dout0_74 Vdout0_74ck119 = 0 time = 600
.meas tran vdout0_74ck119 FIND v(dout0_74) AT=600.025n

* CHECK dout0_75 Vdout0_75ck119 = 0 time = 600
.meas tran vdout0_75ck119 FIND v(dout0_75) AT=600.025n

* CHECK dout0_76 Vdout0_76ck119 = 0.9 time = 600
.meas tran vdout0_76ck119 FIND v(dout0_76) AT=600.025n

* CHECK dout0_77 Vdout0_77ck119 = 0 time = 600
.meas tran vdout0_77ck119 FIND v(dout0_77) AT=600.025n

* CHECK dout0_78 Vdout0_78ck119 = 0.9 time = 600
.meas tran vdout0_78ck119 FIND v(dout0_78) AT=600.025n

* CHECK dout0_79 Vdout0_79ck119 = 0.9 time = 600
.meas tran vdout0_79ck119 FIND v(dout0_79) AT=600.025n

* CHECK dout0_80 Vdout0_80ck119 = 0 time = 600
.meas tran vdout0_80ck119 FIND v(dout0_80) AT=600.025n

* CHECK dout0_81 Vdout0_81ck119 = 0.9 time = 600
.meas tran vdout0_81ck119 FIND v(dout0_81) AT=600.025n

* CHECK dout0_82 Vdout0_82ck119 = 0 time = 600
.meas tran vdout0_82ck119 FIND v(dout0_82) AT=600.025n

* CHECK dout0_83 Vdout0_83ck119 = 0 time = 600
.meas tran vdout0_83ck119 FIND v(dout0_83) AT=600.025n

* CHECK dout0_84 Vdout0_84ck119 = 0.9 time = 600
.meas tran vdout0_84ck119 FIND v(dout0_84) AT=600.025n

* CHECK dout0_85 Vdout0_85ck119 = 0 time = 600
.meas tran vdout0_85ck119 FIND v(dout0_85) AT=600.025n

* CHECK dout0_86 Vdout0_86ck119 = 0.9 time = 600
.meas tran vdout0_86ck119 FIND v(dout0_86) AT=600.025n

* CHECK dout0_87 Vdout0_87ck119 = 0.9 time = 600
.meas tran vdout0_87ck119 FIND v(dout0_87) AT=600.025n

* CHECK dout0_0 Vdout0_0ck122 = 0 time = 615
.meas tran vdout0_0ck122 FIND v(dout0_0) AT=615.025n

* CHECK dout0_1 Vdout0_1ck122 = 0.9 time = 615
.meas tran vdout0_1ck122 FIND v(dout0_1) AT=615.025n

* CHECK dout0_2 Vdout0_2ck122 = 0.9 time = 615
.meas tran vdout0_2ck122 FIND v(dout0_2) AT=615.025n

* CHECK dout0_3 Vdout0_3ck122 = 0 time = 615
.meas tran vdout0_3ck122 FIND v(dout0_3) AT=615.025n

* CHECK dout0_4 Vdout0_4ck122 = 0 time = 615
.meas tran vdout0_4ck122 FIND v(dout0_4) AT=615.025n

* CHECK dout0_5 Vdout0_5ck122 = 0 time = 615
.meas tran vdout0_5ck122 FIND v(dout0_5) AT=615.025n

* CHECK dout0_6 Vdout0_6ck122 = 0 time = 615
.meas tran vdout0_6ck122 FIND v(dout0_6) AT=615.025n

* CHECK dout0_7 Vdout0_7ck122 = 0 time = 615
.meas tran vdout0_7ck122 FIND v(dout0_7) AT=615.025n

* CHECK dout0_8 Vdout0_8ck122 = 0.9 time = 615
.meas tran vdout0_8ck122 FIND v(dout0_8) AT=615.025n

* CHECK dout0_9 Vdout0_9ck122 = 0.9 time = 615
.meas tran vdout0_9ck122 FIND v(dout0_9) AT=615.025n

* CHECK dout0_10 Vdout0_10ck122 = 0.9 time = 615
.meas tran vdout0_10ck122 FIND v(dout0_10) AT=615.025n

* CHECK dout0_11 Vdout0_11ck122 = 0 time = 615
.meas tran vdout0_11ck122 FIND v(dout0_11) AT=615.025n

* CHECK dout0_12 Vdout0_12ck122 = 0.9 time = 615
.meas tran vdout0_12ck122 FIND v(dout0_12) AT=615.025n

* CHECK dout0_13 Vdout0_13ck122 = 0.9 time = 615
.meas tran vdout0_13ck122 FIND v(dout0_13) AT=615.025n

* CHECK dout0_14 Vdout0_14ck122 = 0 time = 615
.meas tran vdout0_14ck122 FIND v(dout0_14) AT=615.025n

* CHECK dout0_15 Vdout0_15ck122 = 0.9 time = 615
.meas tran vdout0_15ck122 FIND v(dout0_15) AT=615.025n

* CHECK dout0_16 Vdout0_16ck122 = 0 time = 615
.meas tran vdout0_16ck122 FIND v(dout0_16) AT=615.025n

* CHECK dout0_17 Vdout0_17ck122 = 0 time = 615
.meas tran vdout0_17ck122 FIND v(dout0_17) AT=615.025n

* CHECK dout0_18 Vdout0_18ck122 = 0 time = 615
.meas tran vdout0_18ck122 FIND v(dout0_18) AT=615.025n

* CHECK dout0_19 Vdout0_19ck122 = 0.9 time = 615
.meas tran vdout0_19ck122 FIND v(dout0_19) AT=615.025n

* CHECK dout0_20 Vdout0_20ck122 = 0 time = 615
.meas tran vdout0_20ck122 FIND v(dout0_20) AT=615.025n

* CHECK dout0_21 Vdout0_21ck122 = 0.9 time = 615
.meas tran vdout0_21ck122 FIND v(dout0_21) AT=615.025n

* CHECK dout0_22 Vdout0_22ck122 = 0.9 time = 615
.meas tran vdout0_22ck122 FIND v(dout0_22) AT=615.025n

* CHECK dout0_23 Vdout0_23ck122 = 0.9 time = 615
.meas tran vdout0_23ck122 FIND v(dout0_23) AT=615.025n

* CHECK dout0_24 Vdout0_24ck122 = 0.9 time = 615
.meas tran vdout0_24ck122 FIND v(dout0_24) AT=615.025n

* CHECK dout0_25 Vdout0_25ck122 = 0 time = 615
.meas tran vdout0_25ck122 FIND v(dout0_25) AT=615.025n

* CHECK dout0_26 Vdout0_26ck122 = 0.9 time = 615
.meas tran vdout0_26ck122 FIND v(dout0_26) AT=615.025n

* CHECK dout0_27 Vdout0_27ck122 = 0 time = 615
.meas tran vdout0_27ck122 FIND v(dout0_27) AT=615.025n

* CHECK dout0_28 Vdout0_28ck122 = 0.9 time = 615
.meas tran vdout0_28ck122 FIND v(dout0_28) AT=615.025n

* CHECK dout0_29 Vdout0_29ck122 = 0.9 time = 615
.meas tran vdout0_29ck122 FIND v(dout0_29) AT=615.025n

* CHECK dout0_30 Vdout0_30ck122 = 0.9 time = 615
.meas tran vdout0_30ck122 FIND v(dout0_30) AT=615.025n

* CHECK dout0_31 Vdout0_31ck122 = 0.9 time = 615
.meas tran vdout0_31ck122 FIND v(dout0_31) AT=615.025n

* CHECK dout0_32 Vdout0_32ck122 = 0.9 time = 615
.meas tran vdout0_32ck122 FIND v(dout0_32) AT=615.025n

* CHECK dout0_33 Vdout0_33ck122 = 0.9 time = 615
.meas tran vdout0_33ck122 FIND v(dout0_33) AT=615.025n

* CHECK dout0_34 Vdout0_34ck122 = 0 time = 615
.meas tran vdout0_34ck122 FIND v(dout0_34) AT=615.025n

* CHECK dout0_35 Vdout0_35ck122 = 0.9 time = 615
.meas tran vdout0_35ck122 FIND v(dout0_35) AT=615.025n

* CHECK dout0_36 Vdout0_36ck122 = 0.9 time = 615
.meas tran vdout0_36ck122 FIND v(dout0_36) AT=615.025n

* CHECK dout0_37 Vdout0_37ck122 = 0 time = 615
.meas tran vdout0_37ck122 FIND v(dout0_37) AT=615.025n

* CHECK dout0_38 Vdout0_38ck122 = 0.9 time = 615
.meas tran vdout0_38ck122 FIND v(dout0_38) AT=615.025n

* CHECK dout0_39 Vdout0_39ck122 = 0.9 time = 615
.meas tran vdout0_39ck122 FIND v(dout0_39) AT=615.025n

* CHECK dout0_40 Vdout0_40ck122 = 0.9 time = 615
.meas tran vdout0_40ck122 FIND v(dout0_40) AT=615.025n

* CHECK dout0_41 Vdout0_41ck122 = 0 time = 615
.meas tran vdout0_41ck122 FIND v(dout0_41) AT=615.025n

* CHECK dout0_42 Vdout0_42ck122 = 0 time = 615
.meas tran vdout0_42ck122 FIND v(dout0_42) AT=615.025n

* CHECK dout0_43 Vdout0_43ck122 = 0.9 time = 615
.meas tran vdout0_43ck122 FIND v(dout0_43) AT=615.025n

* CHECK dout0_44 Vdout0_44ck122 = 0 time = 615
.meas tran vdout0_44ck122 FIND v(dout0_44) AT=615.025n

* CHECK dout0_45 Vdout0_45ck122 = 0.9 time = 615
.meas tran vdout0_45ck122 FIND v(dout0_45) AT=615.025n

* CHECK dout0_46 Vdout0_46ck122 = 0.9 time = 615
.meas tran vdout0_46ck122 FIND v(dout0_46) AT=615.025n

* CHECK dout0_47 Vdout0_47ck122 = 0 time = 615
.meas tran vdout0_47ck122 FIND v(dout0_47) AT=615.025n

* CHECK dout0_48 Vdout0_48ck122 = 0.9 time = 615
.meas tran vdout0_48ck122 FIND v(dout0_48) AT=615.025n

* CHECK dout0_49 Vdout0_49ck122 = 0 time = 615
.meas tran vdout0_49ck122 FIND v(dout0_49) AT=615.025n

* CHECK dout0_50 Vdout0_50ck122 = 0.9 time = 615
.meas tran vdout0_50ck122 FIND v(dout0_50) AT=615.025n

* CHECK dout0_51 Vdout0_51ck122 = 0 time = 615
.meas tran vdout0_51ck122 FIND v(dout0_51) AT=615.025n

* CHECK dout0_52 Vdout0_52ck122 = 0.9 time = 615
.meas tran vdout0_52ck122 FIND v(dout0_52) AT=615.025n

* CHECK dout0_53 Vdout0_53ck122 = 0 time = 615
.meas tran vdout0_53ck122 FIND v(dout0_53) AT=615.025n

* CHECK dout0_54 Vdout0_54ck122 = 0 time = 615
.meas tran vdout0_54ck122 FIND v(dout0_54) AT=615.025n

* CHECK dout0_55 Vdout0_55ck122 = 0.9 time = 615
.meas tran vdout0_55ck122 FIND v(dout0_55) AT=615.025n

* CHECK dout0_56 Vdout0_56ck122 = 0 time = 615
.meas tran vdout0_56ck122 FIND v(dout0_56) AT=615.025n

* CHECK dout0_57 Vdout0_57ck122 = 0 time = 615
.meas tran vdout0_57ck122 FIND v(dout0_57) AT=615.025n

* CHECK dout0_58 Vdout0_58ck122 = 0 time = 615
.meas tran vdout0_58ck122 FIND v(dout0_58) AT=615.025n

* CHECK dout0_59 Vdout0_59ck122 = 0 time = 615
.meas tran vdout0_59ck122 FIND v(dout0_59) AT=615.025n

* CHECK dout0_60 Vdout0_60ck122 = 0.9 time = 615
.meas tran vdout0_60ck122 FIND v(dout0_60) AT=615.025n

* CHECK dout0_61 Vdout0_61ck122 = 0.9 time = 615
.meas tran vdout0_61ck122 FIND v(dout0_61) AT=615.025n

* CHECK dout0_62 Vdout0_62ck122 = 0 time = 615
.meas tran vdout0_62ck122 FIND v(dout0_62) AT=615.025n

* CHECK dout0_63 Vdout0_63ck122 = 0.9 time = 615
.meas tran vdout0_63ck122 FIND v(dout0_63) AT=615.025n

* CHECK dout0_64 Vdout0_64ck122 = 0.9 time = 615
.meas tran vdout0_64ck122 FIND v(dout0_64) AT=615.025n

* CHECK dout0_65 Vdout0_65ck122 = 0 time = 615
.meas tran vdout0_65ck122 FIND v(dout0_65) AT=615.025n

* CHECK dout0_66 Vdout0_66ck122 = 0.9 time = 615
.meas tran vdout0_66ck122 FIND v(dout0_66) AT=615.025n

* CHECK dout0_67 Vdout0_67ck122 = 0 time = 615
.meas tran vdout0_67ck122 FIND v(dout0_67) AT=615.025n

* CHECK dout0_68 Vdout0_68ck122 = 0 time = 615
.meas tran vdout0_68ck122 FIND v(dout0_68) AT=615.025n

* CHECK dout0_69 Vdout0_69ck122 = 0.9 time = 615
.meas tran vdout0_69ck122 FIND v(dout0_69) AT=615.025n

* CHECK dout0_70 Vdout0_70ck122 = 0.9 time = 615
.meas tran vdout0_70ck122 FIND v(dout0_70) AT=615.025n

* CHECK dout0_71 Vdout0_71ck122 = 0.9 time = 615
.meas tran vdout0_71ck122 FIND v(dout0_71) AT=615.025n

* CHECK dout0_72 Vdout0_72ck122 = 0 time = 615
.meas tran vdout0_72ck122 FIND v(dout0_72) AT=615.025n

* CHECK dout0_73 Vdout0_73ck122 = 0 time = 615
.meas tran vdout0_73ck122 FIND v(dout0_73) AT=615.025n

* CHECK dout0_74 Vdout0_74ck122 = 0.9 time = 615
.meas tran vdout0_74ck122 FIND v(dout0_74) AT=615.025n

* CHECK dout0_75 Vdout0_75ck122 = 0 time = 615
.meas tran vdout0_75ck122 FIND v(dout0_75) AT=615.025n

* CHECK dout0_76 Vdout0_76ck122 = 0 time = 615
.meas tran vdout0_76ck122 FIND v(dout0_76) AT=615.025n

* CHECK dout0_77 Vdout0_77ck122 = 0 time = 615
.meas tran vdout0_77ck122 FIND v(dout0_77) AT=615.025n

* CHECK dout0_78 Vdout0_78ck122 = 0 time = 615
.meas tran vdout0_78ck122 FIND v(dout0_78) AT=615.025n

* CHECK dout0_79 Vdout0_79ck122 = 0 time = 615
.meas tran vdout0_79ck122 FIND v(dout0_79) AT=615.025n

* CHECK dout0_80 Vdout0_80ck122 = 0.9 time = 615
.meas tran vdout0_80ck122 FIND v(dout0_80) AT=615.025n

* CHECK dout0_81 Vdout0_81ck122 = 0.9 time = 615
.meas tran vdout0_81ck122 FIND v(dout0_81) AT=615.025n

* CHECK dout0_82 Vdout0_82ck122 = 0.9 time = 615
.meas tran vdout0_82ck122 FIND v(dout0_82) AT=615.025n

* CHECK dout0_83 Vdout0_83ck122 = 0.9 time = 615
.meas tran vdout0_83ck122 FIND v(dout0_83) AT=615.025n

* CHECK dout0_84 Vdout0_84ck122 = 0 time = 615
.meas tran vdout0_84ck122 FIND v(dout0_84) AT=615.025n

* CHECK dout0_85 Vdout0_85ck122 = 0.9 time = 615
.meas tran vdout0_85ck122 FIND v(dout0_85) AT=615.025n

* CHECK dout0_86 Vdout0_86ck122 = 0 time = 615
.meas tran vdout0_86ck122 FIND v(dout0_86) AT=615.025n

* CHECK dout0_87 Vdout0_87ck122 = 0 time = 615
.meas tran vdout0_87ck122 FIND v(dout0_87) AT=615.025n

* CHECK dout0_0 Vdout0_0ck126 = 0.9 time = 635
.meas tran vdout0_0ck126 FIND v(dout0_0) AT=635.025n

* CHECK dout0_1 Vdout0_1ck126 = 0 time = 635
.meas tran vdout0_1ck126 FIND v(dout0_1) AT=635.025n

* CHECK dout0_2 Vdout0_2ck126 = 0.9 time = 635
.meas tran vdout0_2ck126 FIND v(dout0_2) AT=635.025n

* CHECK dout0_3 Vdout0_3ck126 = 0.9 time = 635
.meas tran vdout0_3ck126 FIND v(dout0_3) AT=635.025n

* CHECK dout0_4 Vdout0_4ck126 = 0 time = 635
.meas tran vdout0_4ck126 FIND v(dout0_4) AT=635.025n

* CHECK dout0_5 Vdout0_5ck126 = 0 time = 635
.meas tran vdout0_5ck126 FIND v(dout0_5) AT=635.025n

* CHECK dout0_6 Vdout0_6ck126 = 0.9 time = 635
.meas tran vdout0_6ck126 FIND v(dout0_6) AT=635.025n

* CHECK dout0_7 Vdout0_7ck126 = 0 time = 635
.meas tran vdout0_7ck126 FIND v(dout0_7) AT=635.025n

* CHECK dout0_8 Vdout0_8ck126 = 0.9 time = 635
.meas tran vdout0_8ck126 FIND v(dout0_8) AT=635.025n

* CHECK dout0_9 Vdout0_9ck126 = 0.9 time = 635
.meas tran vdout0_9ck126 FIND v(dout0_9) AT=635.025n

* CHECK dout0_10 Vdout0_10ck126 = 0 time = 635
.meas tran vdout0_10ck126 FIND v(dout0_10) AT=635.025n

* CHECK dout0_11 Vdout0_11ck126 = 0 time = 635
.meas tran vdout0_11ck126 FIND v(dout0_11) AT=635.025n

* CHECK dout0_12 Vdout0_12ck126 = 0 time = 635
.meas tran vdout0_12ck126 FIND v(dout0_12) AT=635.025n

* CHECK dout0_13 Vdout0_13ck126 = 0 time = 635
.meas tran vdout0_13ck126 FIND v(dout0_13) AT=635.025n

* CHECK dout0_14 Vdout0_14ck126 = 0.9 time = 635
.meas tran vdout0_14ck126 FIND v(dout0_14) AT=635.025n

* CHECK dout0_15 Vdout0_15ck126 = 0.9 time = 635
.meas tran vdout0_15ck126 FIND v(dout0_15) AT=635.025n

* CHECK dout0_16 Vdout0_16ck126 = 0.9 time = 635
.meas tran vdout0_16ck126 FIND v(dout0_16) AT=635.025n

* CHECK dout0_17 Vdout0_17ck126 = 0.9 time = 635
.meas tran vdout0_17ck126 FIND v(dout0_17) AT=635.025n

* CHECK dout0_18 Vdout0_18ck126 = 0.9 time = 635
.meas tran vdout0_18ck126 FIND v(dout0_18) AT=635.025n

* CHECK dout0_19 Vdout0_19ck126 = 0.9 time = 635
.meas tran vdout0_19ck126 FIND v(dout0_19) AT=635.025n

* CHECK dout0_20 Vdout0_20ck126 = 0 time = 635
.meas tran vdout0_20ck126 FIND v(dout0_20) AT=635.025n

* CHECK dout0_21 Vdout0_21ck126 = 0.9 time = 635
.meas tran vdout0_21ck126 FIND v(dout0_21) AT=635.025n

* CHECK dout0_22 Vdout0_22ck126 = 0.9 time = 635
.meas tran vdout0_22ck126 FIND v(dout0_22) AT=635.025n

* CHECK dout0_23 Vdout0_23ck126 = 0.9 time = 635
.meas tran vdout0_23ck126 FIND v(dout0_23) AT=635.025n

* CHECK dout0_24 Vdout0_24ck126 = 0 time = 635
.meas tran vdout0_24ck126 FIND v(dout0_24) AT=635.025n

* CHECK dout0_25 Vdout0_25ck126 = 0 time = 635
.meas tran vdout0_25ck126 FIND v(dout0_25) AT=635.025n

* CHECK dout0_26 Vdout0_26ck126 = 0.9 time = 635
.meas tran vdout0_26ck126 FIND v(dout0_26) AT=635.025n

* CHECK dout0_27 Vdout0_27ck126 = 0 time = 635
.meas tran vdout0_27ck126 FIND v(dout0_27) AT=635.025n

* CHECK dout0_28 Vdout0_28ck126 = 0.9 time = 635
.meas tran vdout0_28ck126 FIND v(dout0_28) AT=635.025n

* CHECK dout0_29 Vdout0_29ck126 = 0.9 time = 635
.meas tran vdout0_29ck126 FIND v(dout0_29) AT=635.025n

* CHECK dout0_30 Vdout0_30ck126 = 0.9 time = 635
.meas tran vdout0_30ck126 FIND v(dout0_30) AT=635.025n

* CHECK dout0_31 Vdout0_31ck126 = 0 time = 635
.meas tran vdout0_31ck126 FIND v(dout0_31) AT=635.025n

* CHECK dout0_32 Vdout0_32ck126 = 0.9 time = 635
.meas tran vdout0_32ck126 FIND v(dout0_32) AT=635.025n

* CHECK dout0_33 Vdout0_33ck126 = 0 time = 635
.meas tran vdout0_33ck126 FIND v(dout0_33) AT=635.025n

* CHECK dout0_34 Vdout0_34ck126 = 0 time = 635
.meas tran vdout0_34ck126 FIND v(dout0_34) AT=635.025n

* CHECK dout0_35 Vdout0_35ck126 = 0.9 time = 635
.meas tran vdout0_35ck126 FIND v(dout0_35) AT=635.025n

* CHECK dout0_36 Vdout0_36ck126 = 0 time = 635
.meas tran vdout0_36ck126 FIND v(dout0_36) AT=635.025n

* CHECK dout0_37 Vdout0_37ck126 = 0.9 time = 635
.meas tran vdout0_37ck126 FIND v(dout0_37) AT=635.025n

* CHECK dout0_38 Vdout0_38ck126 = 0 time = 635
.meas tran vdout0_38ck126 FIND v(dout0_38) AT=635.025n

* CHECK dout0_39 Vdout0_39ck126 = 0 time = 635
.meas tran vdout0_39ck126 FIND v(dout0_39) AT=635.025n

* CHECK dout0_40 Vdout0_40ck126 = 0.9 time = 635
.meas tran vdout0_40ck126 FIND v(dout0_40) AT=635.025n

* CHECK dout0_41 Vdout0_41ck126 = 0.9 time = 635
.meas tran vdout0_41ck126 FIND v(dout0_41) AT=635.025n

* CHECK dout0_42 Vdout0_42ck126 = 0 time = 635
.meas tran vdout0_42ck126 FIND v(dout0_42) AT=635.025n

* CHECK dout0_43 Vdout0_43ck126 = 0 time = 635
.meas tran vdout0_43ck126 FIND v(dout0_43) AT=635.025n

* CHECK dout0_44 Vdout0_44ck126 = 0.9 time = 635
.meas tran vdout0_44ck126 FIND v(dout0_44) AT=635.025n

* CHECK dout0_45 Vdout0_45ck126 = 0.9 time = 635
.meas tran vdout0_45ck126 FIND v(dout0_45) AT=635.025n

* CHECK dout0_46 Vdout0_46ck126 = 0 time = 635
.meas tran vdout0_46ck126 FIND v(dout0_46) AT=635.025n

* CHECK dout0_47 Vdout0_47ck126 = 0 time = 635
.meas tran vdout0_47ck126 FIND v(dout0_47) AT=635.025n

* CHECK dout0_48 Vdout0_48ck126 = 0 time = 635
.meas tran vdout0_48ck126 FIND v(dout0_48) AT=635.025n

* CHECK dout0_49 Vdout0_49ck126 = 0.9 time = 635
.meas tran vdout0_49ck126 FIND v(dout0_49) AT=635.025n

* CHECK dout0_50 Vdout0_50ck126 = 0.9 time = 635
.meas tran vdout0_50ck126 FIND v(dout0_50) AT=635.025n

* CHECK dout0_51 Vdout0_51ck126 = 0.9 time = 635
.meas tran vdout0_51ck126 FIND v(dout0_51) AT=635.025n

* CHECK dout0_52 Vdout0_52ck126 = 0.9 time = 635
.meas tran vdout0_52ck126 FIND v(dout0_52) AT=635.025n

* CHECK dout0_53 Vdout0_53ck126 = 0.9 time = 635
.meas tran vdout0_53ck126 FIND v(dout0_53) AT=635.025n

* CHECK dout0_54 Vdout0_54ck126 = 0 time = 635
.meas tran vdout0_54ck126 FIND v(dout0_54) AT=635.025n

* CHECK dout0_55 Vdout0_55ck126 = 0.9 time = 635
.meas tran vdout0_55ck126 FIND v(dout0_55) AT=635.025n

* CHECK dout0_56 Vdout0_56ck126 = 0 time = 635
.meas tran vdout0_56ck126 FIND v(dout0_56) AT=635.025n

* CHECK dout0_57 Vdout0_57ck126 = 0.9 time = 635
.meas tran vdout0_57ck126 FIND v(dout0_57) AT=635.025n

* CHECK dout0_58 Vdout0_58ck126 = 0 time = 635
.meas tran vdout0_58ck126 FIND v(dout0_58) AT=635.025n

* CHECK dout0_59 Vdout0_59ck126 = 0 time = 635
.meas tran vdout0_59ck126 FIND v(dout0_59) AT=635.025n

* CHECK dout0_60 Vdout0_60ck126 = 0 time = 635
.meas tran vdout0_60ck126 FIND v(dout0_60) AT=635.025n

* CHECK dout0_61 Vdout0_61ck126 = 0.9 time = 635
.meas tran vdout0_61ck126 FIND v(dout0_61) AT=635.025n

* CHECK dout0_62 Vdout0_62ck126 = 0 time = 635
.meas tran vdout0_62ck126 FIND v(dout0_62) AT=635.025n

* CHECK dout0_63 Vdout0_63ck126 = 0.9 time = 635
.meas tran vdout0_63ck126 FIND v(dout0_63) AT=635.025n

* CHECK dout0_64 Vdout0_64ck126 = 0.9 time = 635
.meas tran vdout0_64ck126 FIND v(dout0_64) AT=635.025n

* CHECK dout0_65 Vdout0_65ck126 = 0.9 time = 635
.meas tran vdout0_65ck126 FIND v(dout0_65) AT=635.025n

* CHECK dout0_66 Vdout0_66ck126 = 0 time = 635
.meas tran vdout0_66ck126 FIND v(dout0_66) AT=635.025n

* CHECK dout0_67 Vdout0_67ck126 = 0 time = 635
.meas tran vdout0_67ck126 FIND v(dout0_67) AT=635.025n

* CHECK dout0_68 Vdout0_68ck126 = 0.9 time = 635
.meas tran vdout0_68ck126 FIND v(dout0_68) AT=635.025n

* CHECK dout0_69 Vdout0_69ck126 = 0.9 time = 635
.meas tran vdout0_69ck126 FIND v(dout0_69) AT=635.025n

* CHECK dout0_70 Vdout0_70ck126 = 0.9 time = 635
.meas tran vdout0_70ck126 FIND v(dout0_70) AT=635.025n

* CHECK dout0_71 Vdout0_71ck126 = 0 time = 635
.meas tran vdout0_71ck126 FIND v(dout0_71) AT=635.025n

* CHECK dout0_72 Vdout0_72ck126 = 0.9 time = 635
.meas tran vdout0_72ck126 FIND v(dout0_72) AT=635.025n

* CHECK dout0_73 Vdout0_73ck126 = 0 time = 635
.meas tran vdout0_73ck126 FIND v(dout0_73) AT=635.025n

* CHECK dout0_74 Vdout0_74ck126 = 0.9 time = 635
.meas tran vdout0_74ck126 FIND v(dout0_74) AT=635.025n

* CHECK dout0_75 Vdout0_75ck126 = 0.9 time = 635
.meas tran vdout0_75ck126 FIND v(dout0_75) AT=635.025n

* CHECK dout0_76 Vdout0_76ck126 = 0.9 time = 635
.meas tran vdout0_76ck126 FIND v(dout0_76) AT=635.025n

* CHECK dout0_77 Vdout0_77ck126 = 0 time = 635
.meas tran vdout0_77ck126 FIND v(dout0_77) AT=635.025n

* CHECK dout0_78 Vdout0_78ck126 = 0.9 time = 635
.meas tran vdout0_78ck126 FIND v(dout0_78) AT=635.025n

* CHECK dout0_79 Vdout0_79ck126 = 0 time = 635
.meas tran vdout0_79ck126 FIND v(dout0_79) AT=635.025n

* CHECK dout0_80 Vdout0_80ck126 = 0 time = 635
.meas tran vdout0_80ck126 FIND v(dout0_80) AT=635.025n

* CHECK dout0_81 Vdout0_81ck126 = 0.9 time = 635
.meas tran vdout0_81ck126 FIND v(dout0_81) AT=635.025n

* CHECK dout0_82 Vdout0_82ck126 = 0.9 time = 635
.meas tran vdout0_82ck126 FIND v(dout0_82) AT=635.025n

* CHECK dout0_83 Vdout0_83ck126 = 0 time = 635
.meas tran vdout0_83ck126 FIND v(dout0_83) AT=635.025n

* CHECK dout0_84 Vdout0_84ck126 = 0.9 time = 635
.meas tran vdout0_84ck126 FIND v(dout0_84) AT=635.025n

* CHECK dout0_85 Vdout0_85ck126 = 0.9 time = 635
.meas tran vdout0_85ck126 FIND v(dout0_85) AT=635.025n

* CHECK dout0_86 Vdout0_86ck126 = 0 time = 635
.meas tran vdout0_86ck126 FIND v(dout0_86) AT=635.025n

* CHECK dout0_87 Vdout0_87ck126 = 0.9 time = 635
.meas tran vdout0_87ck126 FIND v(dout0_87) AT=635.025n

* CHECK dout0_0 Vdout0_0ck127 = 0 time = 640
.meas tran vdout0_0ck127 FIND v(dout0_0) AT=640.025n

* CHECK dout0_1 Vdout0_1ck127 = 0 time = 640
.meas tran vdout0_1ck127 FIND v(dout0_1) AT=640.025n

* CHECK dout0_2 Vdout0_2ck127 = 0.9 time = 640
.meas tran vdout0_2ck127 FIND v(dout0_2) AT=640.025n

* CHECK dout0_3 Vdout0_3ck127 = 0.9 time = 640
.meas tran vdout0_3ck127 FIND v(dout0_3) AT=640.025n

* CHECK dout0_4 Vdout0_4ck127 = 0.9 time = 640
.meas tran vdout0_4ck127 FIND v(dout0_4) AT=640.025n

* CHECK dout0_5 Vdout0_5ck127 = 0.9 time = 640
.meas tran vdout0_5ck127 FIND v(dout0_5) AT=640.025n

* CHECK dout0_6 Vdout0_6ck127 = 0 time = 640
.meas tran vdout0_6ck127 FIND v(dout0_6) AT=640.025n

* CHECK dout0_7 Vdout0_7ck127 = 0.9 time = 640
.meas tran vdout0_7ck127 FIND v(dout0_7) AT=640.025n

* CHECK dout0_8 Vdout0_8ck127 = 0.9 time = 640
.meas tran vdout0_8ck127 FIND v(dout0_8) AT=640.025n

* CHECK dout0_9 Vdout0_9ck127 = 0 time = 640
.meas tran vdout0_9ck127 FIND v(dout0_9) AT=640.025n

* CHECK dout0_10 Vdout0_10ck127 = 0.9 time = 640
.meas tran vdout0_10ck127 FIND v(dout0_10) AT=640.025n

* CHECK dout0_11 Vdout0_11ck127 = 0 time = 640
.meas tran vdout0_11ck127 FIND v(dout0_11) AT=640.025n

* CHECK dout0_12 Vdout0_12ck127 = 0 time = 640
.meas tran vdout0_12ck127 FIND v(dout0_12) AT=640.025n

* CHECK dout0_13 Vdout0_13ck127 = 0.9 time = 640
.meas tran vdout0_13ck127 FIND v(dout0_13) AT=640.025n

* CHECK dout0_14 Vdout0_14ck127 = 0 time = 640
.meas tran vdout0_14ck127 FIND v(dout0_14) AT=640.025n

* CHECK dout0_15 Vdout0_15ck127 = 0.9 time = 640
.meas tran vdout0_15ck127 FIND v(dout0_15) AT=640.025n

* CHECK dout0_16 Vdout0_16ck127 = 0 time = 640
.meas tran vdout0_16ck127 FIND v(dout0_16) AT=640.025n

* CHECK dout0_17 Vdout0_17ck127 = 0 time = 640
.meas tran vdout0_17ck127 FIND v(dout0_17) AT=640.025n

* CHECK dout0_18 Vdout0_18ck127 = 0 time = 640
.meas tran vdout0_18ck127 FIND v(dout0_18) AT=640.025n

* CHECK dout0_19 Vdout0_19ck127 = 0.9 time = 640
.meas tran vdout0_19ck127 FIND v(dout0_19) AT=640.025n

* CHECK dout0_20 Vdout0_20ck127 = 0.9 time = 640
.meas tran vdout0_20ck127 FIND v(dout0_20) AT=640.025n

* CHECK dout0_21 Vdout0_21ck127 = 0.9 time = 640
.meas tran vdout0_21ck127 FIND v(dout0_21) AT=640.025n

* CHECK dout0_22 Vdout0_22ck127 = 0.9 time = 640
.meas tran vdout0_22ck127 FIND v(dout0_22) AT=640.025n

* CHECK dout0_23 Vdout0_23ck127 = 0.9 time = 640
.meas tran vdout0_23ck127 FIND v(dout0_23) AT=640.025n

* CHECK dout0_24 Vdout0_24ck127 = 0 time = 640
.meas tran vdout0_24ck127 FIND v(dout0_24) AT=640.025n

* CHECK dout0_25 Vdout0_25ck127 = 0 time = 640
.meas tran vdout0_25ck127 FIND v(dout0_25) AT=640.025n

* CHECK dout0_26 Vdout0_26ck127 = 0 time = 640
.meas tran vdout0_26ck127 FIND v(dout0_26) AT=640.025n

* CHECK dout0_27 Vdout0_27ck127 = 0.9 time = 640
.meas tran vdout0_27ck127 FIND v(dout0_27) AT=640.025n

* CHECK dout0_28 Vdout0_28ck127 = 0 time = 640
.meas tran vdout0_28ck127 FIND v(dout0_28) AT=640.025n

* CHECK dout0_29 Vdout0_29ck127 = 0 time = 640
.meas tran vdout0_29ck127 FIND v(dout0_29) AT=640.025n

* CHECK dout0_30 Vdout0_30ck127 = 0 time = 640
.meas tran vdout0_30ck127 FIND v(dout0_30) AT=640.025n

* CHECK dout0_31 Vdout0_31ck127 = 0.9 time = 640
.meas tran vdout0_31ck127 FIND v(dout0_31) AT=640.025n

* CHECK dout0_32 Vdout0_32ck127 = 0 time = 640
.meas tran vdout0_32ck127 FIND v(dout0_32) AT=640.025n

* CHECK dout0_33 Vdout0_33ck127 = 0.9 time = 640
.meas tran vdout0_33ck127 FIND v(dout0_33) AT=640.025n

* CHECK dout0_34 Vdout0_34ck127 = 0.9 time = 640
.meas tran vdout0_34ck127 FIND v(dout0_34) AT=640.025n

* CHECK dout0_35 Vdout0_35ck127 = 0 time = 640
.meas tran vdout0_35ck127 FIND v(dout0_35) AT=640.025n

* CHECK dout0_36 Vdout0_36ck127 = 0 time = 640
.meas tran vdout0_36ck127 FIND v(dout0_36) AT=640.025n

* CHECK dout0_37 Vdout0_37ck127 = 0 time = 640
.meas tran vdout0_37ck127 FIND v(dout0_37) AT=640.025n

* CHECK dout0_38 Vdout0_38ck127 = 0.9 time = 640
.meas tran vdout0_38ck127 FIND v(dout0_38) AT=640.025n

* CHECK dout0_39 Vdout0_39ck127 = 0.9 time = 640
.meas tran vdout0_39ck127 FIND v(dout0_39) AT=640.025n

* CHECK dout0_40 Vdout0_40ck127 = 0.9 time = 640
.meas tran vdout0_40ck127 FIND v(dout0_40) AT=640.025n

* CHECK dout0_41 Vdout0_41ck127 = 0.9 time = 640
.meas tran vdout0_41ck127 FIND v(dout0_41) AT=640.025n

* CHECK dout0_42 Vdout0_42ck127 = 0.9 time = 640
.meas tran vdout0_42ck127 FIND v(dout0_42) AT=640.025n

* CHECK dout0_43 Vdout0_43ck127 = 0 time = 640
.meas tran vdout0_43ck127 FIND v(dout0_43) AT=640.025n

* CHECK dout0_44 Vdout0_44ck127 = 0 time = 640
.meas tran vdout0_44ck127 FIND v(dout0_44) AT=640.025n

* CHECK dout0_45 Vdout0_45ck127 = 0 time = 640
.meas tran vdout0_45ck127 FIND v(dout0_45) AT=640.025n

* CHECK dout0_46 Vdout0_46ck127 = 0 time = 640
.meas tran vdout0_46ck127 FIND v(dout0_46) AT=640.025n

* CHECK dout0_47 Vdout0_47ck127 = 0.9 time = 640
.meas tran vdout0_47ck127 FIND v(dout0_47) AT=640.025n

* CHECK dout0_48 Vdout0_48ck127 = 0.9 time = 640
.meas tran vdout0_48ck127 FIND v(dout0_48) AT=640.025n

* CHECK dout0_49 Vdout0_49ck127 = 0.9 time = 640
.meas tran vdout0_49ck127 FIND v(dout0_49) AT=640.025n

* CHECK dout0_50 Vdout0_50ck127 = 0 time = 640
.meas tran vdout0_50ck127 FIND v(dout0_50) AT=640.025n

* CHECK dout0_51 Vdout0_51ck127 = 0 time = 640
.meas tran vdout0_51ck127 FIND v(dout0_51) AT=640.025n

* CHECK dout0_52 Vdout0_52ck127 = 0.9 time = 640
.meas tran vdout0_52ck127 FIND v(dout0_52) AT=640.025n

* CHECK dout0_53 Vdout0_53ck127 = 0.9 time = 640
.meas tran vdout0_53ck127 FIND v(dout0_53) AT=640.025n

* CHECK dout0_54 Vdout0_54ck127 = 0.9 time = 640
.meas tran vdout0_54ck127 FIND v(dout0_54) AT=640.025n

* CHECK dout0_55 Vdout0_55ck127 = 0.9 time = 640
.meas tran vdout0_55ck127 FIND v(dout0_55) AT=640.025n

* CHECK dout0_56 Vdout0_56ck127 = 0.9 time = 640
.meas tran vdout0_56ck127 FIND v(dout0_56) AT=640.025n

* CHECK dout0_57 Vdout0_57ck127 = 0 time = 640
.meas tran vdout0_57ck127 FIND v(dout0_57) AT=640.025n

* CHECK dout0_58 Vdout0_58ck127 = 0 time = 640
.meas tran vdout0_58ck127 FIND v(dout0_58) AT=640.025n

* CHECK dout0_59 Vdout0_59ck127 = 0.9 time = 640
.meas tran vdout0_59ck127 FIND v(dout0_59) AT=640.025n

* CHECK dout0_60 Vdout0_60ck127 = 0 time = 640
.meas tran vdout0_60ck127 FIND v(dout0_60) AT=640.025n

* CHECK dout0_61 Vdout0_61ck127 = 0.9 time = 640
.meas tran vdout0_61ck127 FIND v(dout0_61) AT=640.025n

* CHECK dout0_62 Vdout0_62ck127 = 0 time = 640
.meas tran vdout0_62ck127 FIND v(dout0_62) AT=640.025n

* CHECK dout0_63 Vdout0_63ck127 = 0.9 time = 640
.meas tran vdout0_63ck127 FIND v(dout0_63) AT=640.025n

* CHECK dout0_64 Vdout0_64ck127 = 0.9 time = 640
.meas tran vdout0_64ck127 FIND v(dout0_64) AT=640.025n

* CHECK dout0_65 Vdout0_65ck127 = 0 time = 640
.meas tran vdout0_65ck127 FIND v(dout0_65) AT=640.025n

* CHECK dout0_66 Vdout0_66ck127 = 0 time = 640
.meas tran vdout0_66ck127 FIND v(dout0_66) AT=640.025n

* CHECK dout0_67 Vdout0_67ck127 = 0 time = 640
.meas tran vdout0_67ck127 FIND v(dout0_67) AT=640.025n

* CHECK dout0_68 Vdout0_68ck127 = 0.9 time = 640
.meas tran vdout0_68ck127 FIND v(dout0_68) AT=640.025n

* CHECK dout0_69 Vdout0_69ck127 = 0 time = 640
.meas tran vdout0_69ck127 FIND v(dout0_69) AT=640.025n

* CHECK dout0_70 Vdout0_70ck127 = 0 time = 640
.meas tran vdout0_70ck127 FIND v(dout0_70) AT=640.025n

* CHECK dout0_71 Vdout0_71ck127 = 0.9 time = 640
.meas tran vdout0_71ck127 FIND v(dout0_71) AT=640.025n

* CHECK dout0_72 Vdout0_72ck127 = 0.9 time = 640
.meas tran vdout0_72ck127 FIND v(dout0_72) AT=640.025n

* CHECK dout0_73 Vdout0_73ck127 = 0.9 time = 640
.meas tran vdout0_73ck127 FIND v(dout0_73) AT=640.025n

* CHECK dout0_74 Vdout0_74ck127 = 0.9 time = 640
.meas tran vdout0_74ck127 FIND v(dout0_74) AT=640.025n

* CHECK dout0_75 Vdout0_75ck127 = 0.9 time = 640
.meas tran vdout0_75ck127 FIND v(dout0_75) AT=640.025n

* CHECK dout0_76 Vdout0_76ck127 = 0 time = 640
.meas tran vdout0_76ck127 FIND v(dout0_76) AT=640.025n

* CHECK dout0_77 Vdout0_77ck127 = 0.9 time = 640
.meas tran vdout0_77ck127 FIND v(dout0_77) AT=640.025n

* CHECK dout0_78 Vdout0_78ck127 = 0 time = 640
.meas tran vdout0_78ck127 FIND v(dout0_78) AT=640.025n

* CHECK dout0_79 Vdout0_79ck127 = 0 time = 640
.meas tran vdout0_79ck127 FIND v(dout0_79) AT=640.025n

* CHECK dout0_80 Vdout0_80ck127 = 0 time = 640
.meas tran vdout0_80ck127 FIND v(dout0_80) AT=640.025n

* CHECK dout0_81 Vdout0_81ck127 = 0 time = 640
.meas tran vdout0_81ck127 FIND v(dout0_81) AT=640.025n

* CHECK dout0_82 Vdout0_82ck127 = 0.9 time = 640
.meas tran vdout0_82ck127 FIND v(dout0_82) AT=640.025n

* CHECK dout0_83 Vdout0_83ck127 = 0.9 time = 640
.meas tran vdout0_83ck127 FIND v(dout0_83) AT=640.025n

* CHECK dout0_84 Vdout0_84ck127 = 0 time = 640
.meas tran vdout0_84ck127 FIND v(dout0_84) AT=640.025n

* CHECK dout0_85 Vdout0_85ck127 = 0 time = 640
.meas tran vdout0_85ck127 FIND v(dout0_85) AT=640.025n

* CHECK dout0_86 Vdout0_86ck127 = 0 time = 640
.meas tran vdout0_86ck127 FIND v(dout0_86) AT=640.025n

* CHECK dout0_87 Vdout0_87ck127 = 0.9 time = 640
.meas tran vdout0_87ck127 FIND v(dout0_87) AT=640.025n

* CHECK dout0_0 Vdout0_0ck129 = 0.9 time = 650
.meas tran vdout0_0ck129 FIND v(dout0_0) AT=650.025n

* CHECK dout0_1 Vdout0_1ck129 = 0 time = 650
.meas tran vdout0_1ck129 FIND v(dout0_1) AT=650.025n

* CHECK dout0_2 Vdout0_2ck129 = 0.9 time = 650
.meas tran vdout0_2ck129 FIND v(dout0_2) AT=650.025n

* CHECK dout0_3 Vdout0_3ck129 = 0.9 time = 650
.meas tran vdout0_3ck129 FIND v(dout0_3) AT=650.025n

* CHECK dout0_4 Vdout0_4ck129 = 0 time = 650
.meas tran vdout0_4ck129 FIND v(dout0_4) AT=650.025n

* CHECK dout0_5 Vdout0_5ck129 = 0 time = 650
.meas tran vdout0_5ck129 FIND v(dout0_5) AT=650.025n

* CHECK dout0_6 Vdout0_6ck129 = 0.9 time = 650
.meas tran vdout0_6ck129 FIND v(dout0_6) AT=650.025n

* CHECK dout0_7 Vdout0_7ck129 = 0 time = 650
.meas tran vdout0_7ck129 FIND v(dout0_7) AT=650.025n

* CHECK dout0_8 Vdout0_8ck129 = 0.9 time = 650
.meas tran vdout0_8ck129 FIND v(dout0_8) AT=650.025n

* CHECK dout0_9 Vdout0_9ck129 = 0.9 time = 650
.meas tran vdout0_9ck129 FIND v(dout0_9) AT=650.025n

* CHECK dout0_10 Vdout0_10ck129 = 0 time = 650
.meas tran vdout0_10ck129 FIND v(dout0_10) AT=650.025n

* CHECK dout0_11 Vdout0_11ck129 = 0 time = 650
.meas tran vdout0_11ck129 FIND v(dout0_11) AT=650.025n

* CHECK dout0_12 Vdout0_12ck129 = 0 time = 650
.meas tran vdout0_12ck129 FIND v(dout0_12) AT=650.025n

* CHECK dout0_13 Vdout0_13ck129 = 0 time = 650
.meas tran vdout0_13ck129 FIND v(dout0_13) AT=650.025n

* CHECK dout0_14 Vdout0_14ck129 = 0.9 time = 650
.meas tran vdout0_14ck129 FIND v(dout0_14) AT=650.025n

* CHECK dout0_15 Vdout0_15ck129 = 0.9 time = 650
.meas tran vdout0_15ck129 FIND v(dout0_15) AT=650.025n

* CHECK dout0_16 Vdout0_16ck129 = 0.9 time = 650
.meas tran vdout0_16ck129 FIND v(dout0_16) AT=650.025n

* CHECK dout0_17 Vdout0_17ck129 = 0.9 time = 650
.meas tran vdout0_17ck129 FIND v(dout0_17) AT=650.025n

* CHECK dout0_18 Vdout0_18ck129 = 0.9 time = 650
.meas tran vdout0_18ck129 FIND v(dout0_18) AT=650.025n

* CHECK dout0_19 Vdout0_19ck129 = 0.9 time = 650
.meas tran vdout0_19ck129 FIND v(dout0_19) AT=650.025n

* CHECK dout0_20 Vdout0_20ck129 = 0 time = 650
.meas tran vdout0_20ck129 FIND v(dout0_20) AT=650.025n

* CHECK dout0_21 Vdout0_21ck129 = 0.9 time = 650
.meas tran vdout0_21ck129 FIND v(dout0_21) AT=650.025n

* CHECK dout0_22 Vdout0_22ck129 = 0.9 time = 650
.meas tran vdout0_22ck129 FIND v(dout0_22) AT=650.025n

* CHECK dout0_23 Vdout0_23ck129 = 0.9 time = 650
.meas tran vdout0_23ck129 FIND v(dout0_23) AT=650.025n

* CHECK dout0_24 Vdout0_24ck129 = 0 time = 650
.meas tran vdout0_24ck129 FIND v(dout0_24) AT=650.025n

* CHECK dout0_25 Vdout0_25ck129 = 0 time = 650
.meas tran vdout0_25ck129 FIND v(dout0_25) AT=650.025n

* CHECK dout0_26 Vdout0_26ck129 = 0.9 time = 650
.meas tran vdout0_26ck129 FIND v(dout0_26) AT=650.025n

* CHECK dout0_27 Vdout0_27ck129 = 0 time = 650
.meas tran vdout0_27ck129 FIND v(dout0_27) AT=650.025n

* CHECK dout0_28 Vdout0_28ck129 = 0.9 time = 650
.meas tran vdout0_28ck129 FIND v(dout0_28) AT=650.025n

* CHECK dout0_29 Vdout0_29ck129 = 0.9 time = 650
.meas tran vdout0_29ck129 FIND v(dout0_29) AT=650.025n

* CHECK dout0_30 Vdout0_30ck129 = 0.9 time = 650
.meas tran vdout0_30ck129 FIND v(dout0_30) AT=650.025n

* CHECK dout0_31 Vdout0_31ck129 = 0 time = 650
.meas tran vdout0_31ck129 FIND v(dout0_31) AT=650.025n

* CHECK dout0_32 Vdout0_32ck129 = 0.9 time = 650
.meas tran vdout0_32ck129 FIND v(dout0_32) AT=650.025n

* CHECK dout0_33 Vdout0_33ck129 = 0 time = 650
.meas tran vdout0_33ck129 FIND v(dout0_33) AT=650.025n

* CHECK dout0_34 Vdout0_34ck129 = 0 time = 650
.meas tran vdout0_34ck129 FIND v(dout0_34) AT=650.025n

* CHECK dout0_35 Vdout0_35ck129 = 0.9 time = 650
.meas tran vdout0_35ck129 FIND v(dout0_35) AT=650.025n

* CHECK dout0_36 Vdout0_36ck129 = 0 time = 650
.meas tran vdout0_36ck129 FIND v(dout0_36) AT=650.025n

* CHECK dout0_37 Vdout0_37ck129 = 0.9 time = 650
.meas tran vdout0_37ck129 FIND v(dout0_37) AT=650.025n

* CHECK dout0_38 Vdout0_38ck129 = 0 time = 650
.meas tran vdout0_38ck129 FIND v(dout0_38) AT=650.025n

* CHECK dout0_39 Vdout0_39ck129 = 0 time = 650
.meas tran vdout0_39ck129 FIND v(dout0_39) AT=650.025n

* CHECK dout0_40 Vdout0_40ck129 = 0.9 time = 650
.meas tran vdout0_40ck129 FIND v(dout0_40) AT=650.025n

* CHECK dout0_41 Vdout0_41ck129 = 0.9 time = 650
.meas tran vdout0_41ck129 FIND v(dout0_41) AT=650.025n

* CHECK dout0_42 Vdout0_42ck129 = 0 time = 650
.meas tran vdout0_42ck129 FIND v(dout0_42) AT=650.025n

* CHECK dout0_43 Vdout0_43ck129 = 0 time = 650
.meas tran vdout0_43ck129 FIND v(dout0_43) AT=650.025n

* CHECK dout0_44 Vdout0_44ck129 = 0.9 time = 650
.meas tran vdout0_44ck129 FIND v(dout0_44) AT=650.025n

* CHECK dout0_45 Vdout0_45ck129 = 0.9 time = 650
.meas tran vdout0_45ck129 FIND v(dout0_45) AT=650.025n

* CHECK dout0_46 Vdout0_46ck129 = 0 time = 650
.meas tran vdout0_46ck129 FIND v(dout0_46) AT=650.025n

* CHECK dout0_47 Vdout0_47ck129 = 0 time = 650
.meas tran vdout0_47ck129 FIND v(dout0_47) AT=650.025n

* CHECK dout0_48 Vdout0_48ck129 = 0 time = 650
.meas tran vdout0_48ck129 FIND v(dout0_48) AT=650.025n

* CHECK dout0_49 Vdout0_49ck129 = 0.9 time = 650
.meas tran vdout0_49ck129 FIND v(dout0_49) AT=650.025n

* CHECK dout0_50 Vdout0_50ck129 = 0.9 time = 650
.meas tran vdout0_50ck129 FIND v(dout0_50) AT=650.025n

* CHECK dout0_51 Vdout0_51ck129 = 0.9 time = 650
.meas tran vdout0_51ck129 FIND v(dout0_51) AT=650.025n

* CHECK dout0_52 Vdout0_52ck129 = 0.9 time = 650
.meas tran vdout0_52ck129 FIND v(dout0_52) AT=650.025n

* CHECK dout0_53 Vdout0_53ck129 = 0.9 time = 650
.meas tran vdout0_53ck129 FIND v(dout0_53) AT=650.025n

* CHECK dout0_54 Vdout0_54ck129 = 0 time = 650
.meas tran vdout0_54ck129 FIND v(dout0_54) AT=650.025n

* CHECK dout0_55 Vdout0_55ck129 = 0.9 time = 650
.meas tran vdout0_55ck129 FIND v(dout0_55) AT=650.025n

* CHECK dout0_56 Vdout0_56ck129 = 0 time = 650
.meas tran vdout0_56ck129 FIND v(dout0_56) AT=650.025n

* CHECK dout0_57 Vdout0_57ck129 = 0.9 time = 650
.meas tran vdout0_57ck129 FIND v(dout0_57) AT=650.025n

* CHECK dout0_58 Vdout0_58ck129 = 0 time = 650
.meas tran vdout0_58ck129 FIND v(dout0_58) AT=650.025n

* CHECK dout0_59 Vdout0_59ck129 = 0 time = 650
.meas tran vdout0_59ck129 FIND v(dout0_59) AT=650.025n

* CHECK dout0_60 Vdout0_60ck129 = 0 time = 650
.meas tran vdout0_60ck129 FIND v(dout0_60) AT=650.025n

* CHECK dout0_61 Vdout0_61ck129 = 0.9 time = 650
.meas tran vdout0_61ck129 FIND v(dout0_61) AT=650.025n

* CHECK dout0_62 Vdout0_62ck129 = 0 time = 650
.meas tran vdout0_62ck129 FIND v(dout0_62) AT=650.025n

* CHECK dout0_63 Vdout0_63ck129 = 0.9 time = 650
.meas tran vdout0_63ck129 FIND v(dout0_63) AT=650.025n

* CHECK dout0_64 Vdout0_64ck129 = 0.9 time = 650
.meas tran vdout0_64ck129 FIND v(dout0_64) AT=650.025n

* CHECK dout0_65 Vdout0_65ck129 = 0.9 time = 650
.meas tran vdout0_65ck129 FIND v(dout0_65) AT=650.025n

* CHECK dout0_66 Vdout0_66ck129 = 0 time = 650
.meas tran vdout0_66ck129 FIND v(dout0_66) AT=650.025n

* CHECK dout0_67 Vdout0_67ck129 = 0 time = 650
.meas tran vdout0_67ck129 FIND v(dout0_67) AT=650.025n

* CHECK dout0_68 Vdout0_68ck129 = 0.9 time = 650
.meas tran vdout0_68ck129 FIND v(dout0_68) AT=650.025n

* CHECK dout0_69 Vdout0_69ck129 = 0.9 time = 650
.meas tran vdout0_69ck129 FIND v(dout0_69) AT=650.025n

* CHECK dout0_70 Vdout0_70ck129 = 0.9 time = 650
.meas tran vdout0_70ck129 FIND v(dout0_70) AT=650.025n

* CHECK dout0_71 Vdout0_71ck129 = 0 time = 650
.meas tran vdout0_71ck129 FIND v(dout0_71) AT=650.025n

* CHECK dout0_72 Vdout0_72ck129 = 0.9 time = 650
.meas tran vdout0_72ck129 FIND v(dout0_72) AT=650.025n

* CHECK dout0_73 Vdout0_73ck129 = 0 time = 650
.meas tran vdout0_73ck129 FIND v(dout0_73) AT=650.025n

* CHECK dout0_74 Vdout0_74ck129 = 0.9 time = 650
.meas tran vdout0_74ck129 FIND v(dout0_74) AT=650.025n

* CHECK dout0_75 Vdout0_75ck129 = 0.9 time = 650
.meas tran vdout0_75ck129 FIND v(dout0_75) AT=650.025n

* CHECK dout0_76 Vdout0_76ck129 = 0.9 time = 650
.meas tran vdout0_76ck129 FIND v(dout0_76) AT=650.025n

* CHECK dout0_77 Vdout0_77ck129 = 0 time = 650
.meas tran vdout0_77ck129 FIND v(dout0_77) AT=650.025n

* CHECK dout0_78 Vdout0_78ck129 = 0.9 time = 650
.meas tran vdout0_78ck129 FIND v(dout0_78) AT=650.025n

* CHECK dout0_79 Vdout0_79ck129 = 0 time = 650
.meas tran vdout0_79ck129 FIND v(dout0_79) AT=650.025n

* CHECK dout0_80 Vdout0_80ck129 = 0 time = 650
.meas tran vdout0_80ck129 FIND v(dout0_80) AT=650.025n

* CHECK dout0_81 Vdout0_81ck129 = 0.9 time = 650
.meas tran vdout0_81ck129 FIND v(dout0_81) AT=650.025n

* CHECK dout0_82 Vdout0_82ck129 = 0.9 time = 650
.meas tran vdout0_82ck129 FIND v(dout0_82) AT=650.025n

* CHECK dout0_83 Vdout0_83ck129 = 0 time = 650
.meas tran vdout0_83ck129 FIND v(dout0_83) AT=650.025n

* CHECK dout0_84 Vdout0_84ck129 = 0.9 time = 650
.meas tran vdout0_84ck129 FIND v(dout0_84) AT=650.025n

* CHECK dout0_85 Vdout0_85ck129 = 0.9 time = 650
.meas tran vdout0_85ck129 FIND v(dout0_85) AT=650.025n

* CHECK dout0_86 Vdout0_86ck129 = 0 time = 650
.meas tran vdout0_86ck129 FIND v(dout0_86) AT=650.025n

* CHECK dout0_87 Vdout0_87ck129 = 0.9 time = 650
.meas tran vdout0_87ck129 FIND v(dout0_87) AT=650.025n

* CHECK dout0_0 Vdout0_0ck134 = 0 time = 675
.meas tran vdout0_0ck134 FIND v(dout0_0) AT=675.025n

* CHECK dout0_1 Vdout0_1ck134 = 0.9 time = 675
.meas tran vdout0_1ck134 FIND v(dout0_1) AT=675.025n

* CHECK dout0_2 Vdout0_2ck134 = 0 time = 675
.meas tran vdout0_2ck134 FIND v(dout0_2) AT=675.025n

* CHECK dout0_3 Vdout0_3ck134 = 0.9 time = 675
.meas tran vdout0_3ck134 FIND v(dout0_3) AT=675.025n

* CHECK dout0_4 Vdout0_4ck134 = 0.9 time = 675
.meas tran vdout0_4ck134 FIND v(dout0_4) AT=675.025n

* CHECK dout0_5 Vdout0_5ck134 = 0 time = 675
.meas tran vdout0_5ck134 FIND v(dout0_5) AT=675.025n

* CHECK dout0_6 Vdout0_6ck134 = 0 time = 675
.meas tran vdout0_6ck134 FIND v(dout0_6) AT=675.025n

* CHECK dout0_7 Vdout0_7ck134 = 0 time = 675
.meas tran vdout0_7ck134 FIND v(dout0_7) AT=675.025n

* CHECK dout0_8 Vdout0_8ck134 = 0 time = 675
.meas tran vdout0_8ck134 FIND v(dout0_8) AT=675.025n

* CHECK dout0_9 Vdout0_9ck134 = 0 time = 675
.meas tran vdout0_9ck134 FIND v(dout0_9) AT=675.025n

* CHECK dout0_10 Vdout0_10ck134 = 0.9 time = 675
.meas tran vdout0_10ck134 FIND v(dout0_10) AT=675.025n

* CHECK dout0_11 Vdout0_11ck134 = 0 time = 675
.meas tran vdout0_11ck134 FIND v(dout0_11) AT=675.025n

* CHECK dout0_12 Vdout0_12ck134 = 0.9 time = 675
.meas tran vdout0_12ck134 FIND v(dout0_12) AT=675.025n

* CHECK dout0_13 Vdout0_13ck134 = 0 time = 675
.meas tran vdout0_13ck134 FIND v(dout0_13) AT=675.025n

* CHECK dout0_14 Vdout0_14ck134 = 0 time = 675
.meas tran vdout0_14ck134 FIND v(dout0_14) AT=675.025n

* CHECK dout0_15 Vdout0_15ck134 = 0 time = 675
.meas tran vdout0_15ck134 FIND v(dout0_15) AT=675.025n

* CHECK dout0_16 Vdout0_16ck134 = 0 time = 675
.meas tran vdout0_16ck134 FIND v(dout0_16) AT=675.025n

* CHECK dout0_17 Vdout0_17ck134 = 0 time = 675
.meas tran vdout0_17ck134 FIND v(dout0_17) AT=675.025n

* CHECK dout0_18 Vdout0_18ck134 = 0.9 time = 675
.meas tran vdout0_18ck134 FIND v(dout0_18) AT=675.025n

* CHECK dout0_19 Vdout0_19ck134 = 0.9 time = 675
.meas tran vdout0_19ck134 FIND v(dout0_19) AT=675.025n

* CHECK dout0_20 Vdout0_20ck134 = 0.9 time = 675
.meas tran vdout0_20ck134 FIND v(dout0_20) AT=675.025n

* CHECK dout0_21 Vdout0_21ck134 = 0.9 time = 675
.meas tran vdout0_21ck134 FIND v(dout0_21) AT=675.025n

* CHECK dout0_22 Vdout0_22ck134 = 0.9 time = 675
.meas tran vdout0_22ck134 FIND v(dout0_22) AT=675.025n

* CHECK dout0_23 Vdout0_23ck134 = 0.9 time = 675
.meas tran vdout0_23ck134 FIND v(dout0_23) AT=675.025n

* CHECK dout0_24 Vdout0_24ck134 = 0 time = 675
.meas tran vdout0_24ck134 FIND v(dout0_24) AT=675.025n

* CHECK dout0_25 Vdout0_25ck134 = 0 time = 675
.meas tran vdout0_25ck134 FIND v(dout0_25) AT=675.025n

* CHECK dout0_26 Vdout0_26ck134 = 0 time = 675
.meas tran vdout0_26ck134 FIND v(dout0_26) AT=675.025n

* CHECK dout0_27 Vdout0_27ck134 = 0.9 time = 675
.meas tran vdout0_27ck134 FIND v(dout0_27) AT=675.025n

* CHECK dout0_28 Vdout0_28ck134 = 0 time = 675
.meas tran vdout0_28ck134 FIND v(dout0_28) AT=675.025n

* CHECK dout0_29 Vdout0_29ck134 = 0 time = 675
.meas tran vdout0_29ck134 FIND v(dout0_29) AT=675.025n

* CHECK dout0_30 Vdout0_30ck134 = 0 time = 675
.meas tran vdout0_30ck134 FIND v(dout0_30) AT=675.025n

* CHECK dout0_31 Vdout0_31ck134 = 0.9 time = 675
.meas tran vdout0_31ck134 FIND v(dout0_31) AT=675.025n

* CHECK dout0_32 Vdout0_32ck134 = 0 time = 675
.meas tran vdout0_32ck134 FIND v(dout0_32) AT=675.025n

* CHECK dout0_33 Vdout0_33ck134 = 0.9 time = 675
.meas tran vdout0_33ck134 FIND v(dout0_33) AT=675.025n

* CHECK dout0_34 Vdout0_34ck134 = 0.9 time = 675
.meas tran vdout0_34ck134 FIND v(dout0_34) AT=675.025n

* CHECK dout0_35 Vdout0_35ck134 = 0 time = 675
.meas tran vdout0_35ck134 FIND v(dout0_35) AT=675.025n

* CHECK dout0_36 Vdout0_36ck134 = 0 time = 675
.meas tran vdout0_36ck134 FIND v(dout0_36) AT=675.025n

* CHECK dout0_37 Vdout0_37ck134 = 0 time = 675
.meas tran vdout0_37ck134 FIND v(dout0_37) AT=675.025n

* CHECK dout0_38 Vdout0_38ck134 = 0.9 time = 675
.meas tran vdout0_38ck134 FIND v(dout0_38) AT=675.025n

* CHECK dout0_39 Vdout0_39ck134 = 0.9 time = 675
.meas tran vdout0_39ck134 FIND v(dout0_39) AT=675.025n

* CHECK dout0_40 Vdout0_40ck134 = 0.9 time = 675
.meas tran vdout0_40ck134 FIND v(dout0_40) AT=675.025n

* CHECK dout0_41 Vdout0_41ck134 = 0.9 time = 675
.meas tran vdout0_41ck134 FIND v(dout0_41) AT=675.025n

* CHECK dout0_42 Vdout0_42ck134 = 0.9 time = 675
.meas tran vdout0_42ck134 FIND v(dout0_42) AT=675.025n

* CHECK dout0_43 Vdout0_43ck134 = 0 time = 675
.meas tran vdout0_43ck134 FIND v(dout0_43) AT=675.025n

* CHECK dout0_44 Vdout0_44ck134 = 0.9 time = 675
.meas tran vdout0_44ck134 FIND v(dout0_44) AT=675.025n

* CHECK dout0_45 Vdout0_45ck134 = 0 time = 675
.meas tran vdout0_45ck134 FIND v(dout0_45) AT=675.025n

* CHECK dout0_46 Vdout0_46ck134 = 0 time = 675
.meas tran vdout0_46ck134 FIND v(dout0_46) AT=675.025n

* CHECK dout0_47 Vdout0_47ck134 = 0 time = 675
.meas tran vdout0_47ck134 FIND v(dout0_47) AT=675.025n

* CHECK dout0_48 Vdout0_48ck134 = 0.9 time = 675
.meas tran vdout0_48ck134 FIND v(dout0_48) AT=675.025n

* CHECK dout0_49 Vdout0_49ck134 = 0 time = 675
.meas tran vdout0_49ck134 FIND v(dout0_49) AT=675.025n

* CHECK dout0_50 Vdout0_50ck134 = 0 time = 675
.meas tran vdout0_50ck134 FIND v(dout0_50) AT=675.025n

* CHECK dout0_51 Vdout0_51ck134 = 0.9 time = 675
.meas tran vdout0_51ck134 FIND v(dout0_51) AT=675.025n

* CHECK dout0_52 Vdout0_52ck134 = 0.9 time = 675
.meas tran vdout0_52ck134 FIND v(dout0_52) AT=675.025n

* CHECK dout0_53 Vdout0_53ck134 = 0.9 time = 675
.meas tran vdout0_53ck134 FIND v(dout0_53) AT=675.025n

* CHECK dout0_54 Vdout0_54ck134 = 0.9 time = 675
.meas tran vdout0_54ck134 FIND v(dout0_54) AT=675.025n

* CHECK dout0_55 Vdout0_55ck134 = 0.9 time = 675
.meas tran vdout0_55ck134 FIND v(dout0_55) AT=675.025n

* CHECK dout0_56 Vdout0_56ck134 = 0 time = 675
.meas tran vdout0_56ck134 FIND v(dout0_56) AT=675.025n

* CHECK dout0_57 Vdout0_57ck134 = 0 time = 675
.meas tran vdout0_57ck134 FIND v(dout0_57) AT=675.025n

* CHECK dout0_58 Vdout0_58ck134 = 0.9 time = 675
.meas tran vdout0_58ck134 FIND v(dout0_58) AT=675.025n

* CHECK dout0_59 Vdout0_59ck134 = 0 time = 675
.meas tran vdout0_59ck134 FIND v(dout0_59) AT=675.025n

* CHECK dout0_60 Vdout0_60ck134 = 0 time = 675
.meas tran vdout0_60ck134 FIND v(dout0_60) AT=675.025n

* CHECK dout0_61 Vdout0_61ck134 = 0 time = 675
.meas tran vdout0_61ck134 FIND v(dout0_61) AT=675.025n

* CHECK dout0_62 Vdout0_62ck134 = 0.9 time = 675
.meas tran vdout0_62ck134 FIND v(dout0_62) AT=675.025n

* CHECK dout0_63 Vdout0_63ck134 = 0.9 time = 675
.meas tran vdout0_63ck134 FIND v(dout0_63) AT=675.025n

* CHECK dout0_64 Vdout0_64ck134 = 0.9 time = 675
.meas tran vdout0_64ck134 FIND v(dout0_64) AT=675.025n

* CHECK dout0_65 Vdout0_65ck134 = 0.9 time = 675
.meas tran vdout0_65ck134 FIND v(dout0_65) AT=675.025n

* CHECK dout0_66 Vdout0_66ck134 = 0 time = 675
.meas tran vdout0_66ck134 FIND v(dout0_66) AT=675.025n

* CHECK dout0_67 Vdout0_67ck134 = 0 time = 675
.meas tran vdout0_67ck134 FIND v(dout0_67) AT=675.025n

* CHECK dout0_68 Vdout0_68ck134 = 0 time = 675
.meas tran vdout0_68ck134 FIND v(dout0_68) AT=675.025n

* CHECK dout0_69 Vdout0_69ck134 = 0.9 time = 675
.meas tran vdout0_69ck134 FIND v(dout0_69) AT=675.025n

* CHECK dout0_70 Vdout0_70ck134 = 0 time = 675
.meas tran vdout0_70ck134 FIND v(dout0_70) AT=675.025n

* CHECK dout0_71 Vdout0_71ck134 = 0 time = 675
.meas tran vdout0_71ck134 FIND v(dout0_71) AT=675.025n

* CHECK dout0_72 Vdout0_72ck134 = 0.9 time = 675
.meas tran vdout0_72ck134 FIND v(dout0_72) AT=675.025n

* CHECK dout0_73 Vdout0_73ck134 = 0.9 time = 675
.meas tran vdout0_73ck134 FIND v(dout0_73) AT=675.025n

* CHECK dout0_74 Vdout0_74ck134 = 0 time = 675
.meas tran vdout0_74ck134 FIND v(dout0_74) AT=675.025n

* CHECK dout0_75 Vdout0_75ck134 = 0 time = 675
.meas tran vdout0_75ck134 FIND v(dout0_75) AT=675.025n

* CHECK dout0_76 Vdout0_76ck134 = 0.9 time = 675
.meas tran vdout0_76ck134 FIND v(dout0_76) AT=675.025n

* CHECK dout0_77 Vdout0_77ck134 = 0 time = 675
.meas tran vdout0_77ck134 FIND v(dout0_77) AT=675.025n

* CHECK dout0_78 Vdout0_78ck134 = 0 time = 675
.meas tran vdout0_78ck134 FIND v(dout0_78) AT=675.025n

* CHECK dout0_79 Vdout0_79ck134 = 0 time = 675
.meas tran vdout0_79ck134 FIND v(dout0_79) AT=675.025n

* CHECK dout0_80 Vdout0_80ck134 = 0 time = 675
.meas tran vdout0_80ck134 FIND v(dout0_80) AT=675.025n

* CHECK dout0_81 Vdout0_81ck134 = 0.9 time = 675
.meas tran vdout0_81ck134 FIND v(dout0_81) AT=675.025n

* CHECK dout0_82 Vdout0_82ck134 = 0 time = 675
.meas tran vdout0_82ck134 FIND v(dout0_82) AT=675.025n

* CHECK dout0_83 Vdout0_83ck134 = 0 time = 675
.meas tran vdout0_83ck134 FIND v(dout0_83) AT=675.025n

* CHECK dout0_84 Vdout0_84ck134 = 0.9 time = 675
.meas tran vdout0_84ck134 FIND v(dout0_84) AT=675.025n

* CHECK dout0_85 Vdout0_85ck134 = 0.9 time = 675
.meas tran vdout0_85ck134 FIND v(dout0_85) AT=675.025n

* CHECK dout0_86 Vdout0_86ck134 = 0.9 time = 675
.meas tran vdout0_86ck134 FIND v(dout0_86) AT=675.025n

* CHECK dout0_87 Vdout0_87ck134 = 0.9 time = 675
.meas tran vdout0_87ck134 FIND v(dout0_87) AT=675.025n

* CHECK dout0_0 Vdout0_0ck136 = 0 time = 685
.meas tran vdout0_0ck136 FIND v(dout0_0) AT=685.025n

* CHECK dout0_1 Vdout0_1ck136 = 0.9 time = 685
.meas tran vdout0_1ck136 FIND v(dout0_1) AT=685.025n

* CHECK dout0_2 Vdout0_2ck136 = 0 time = 685
.meas tran vdout0_2ck136 FIND v(dout0_2) AT=685.025n

* CHECK dout0_3 Vdout0_3ck136 = 0.9 time = 685
.meas tran vdout0_3ck136 FIND v(dout0_3) AT=685.025n

* CHECK dout0_4 Vdout0_4ck136 = 0.9 time = 685
.meas tran vdout0_4ck136 FIND v(dout0_4) AT=685.025n

* CHECK dout0_5 Vdout0_5ck136 = 0 time = 685
.meas tran vdout0_5ck136 FIND v(dout0_5) AT=685.025n

* CHECK dout0_6 Vdout0_6ck136 = 0 time = 685
.meas tran vdout0_6ck136 FIND v(dout0_6) AT=685.025n

* CHECK dout0_7 Vdout0_7ck136 = 0 time = 685
.meas tran vdout0_7ck136 FIND v(dout0_7) AT=685.025n

* CHECK dout0_8 Vdout0_8ck136 = 0 time = 685
.meas tran vdout0_8ck136 FIND v(dout0_8) AT=685.025n

* CHECK dout0_9 Vdout0_9ck136 = 0 time = 685
.meas tran vdout0_9ck136 FIND v(dout0_9) AT=685.025n

* CHECK dout0_10 Vdout0_10ck136 = 0.9 time = 685
.meas tran vdout0_10ck136 FIND v(dout0_10) AT=685.025n

* CHECK dout0_11 Vdout0_11ck136 = 0 time = 685
.meas tran vdout0_11ck136 FIND v(dout0_11) AT=685.025n

* CHECK dout0_12 Vdout0_12ck136 = 0.9 time = 685
.meas tran vdout0_12ck136 FIND v(dout0_12) AT=685.025n

* CHECK dout0_13 Vdout0_13ck136 = 0 time = 685
.meas tran vdout0_13ck136 FIND v(dout0_13) AT=685.025n

* CHECK dout0_14 Vdout0_14ck136 = 0 time = 685
.meas tran vdout0_14ck136 FIND v(dout0_14) AT=685.025n

* CHECK dout0_15 Vdout0_15ck136 = 0 time = 685
.meas tran vdout0_15ck136 FIND v(dout0_15) AT=685.025n

* CHECK dout0_16 Vdout0_16ck136 = 0 time = 685
.meas tran vdout0_16ck136 FIND v(dout0_16) AT=685.025n

* CHECK dout0_17 Vdout0_17ck136 = 0 time = 685
.meas tran vdout0_17ck136 FIND v(dout0_17) AT=685.025n

* CHECK dout0_18 Vdout0_18ck136 = 0.9 time = 685
.meas tran vdout0_18ck136 FIND v(dout0_18) AT=685.025n

* CHECK dout0_19 Vdout0_19ck136 = 0.9 time = 685
.meas tran vdout0_19ck136 FIND v(dout0_19) AT=685.025n

* CHECK dout0_20 Vdout0_20ck136 = 0.9 time = 685
.meas tran vdout0_20ck136 FIND v(dout0_20) AT=685.025n

* CHECK dout0_21 Vdout0_21ck136 = 0.9 time = 685
.meas tran vdout0_21ck136 FIND v(dout0_21) AT=685.025n

* CHECK dout0_22 Vdout0_22ck136 = 0.9 time = 685
.meas tran vdout0_22ck136 FIND v(dout0_22) AT=685.025n

* CHECK dout0_23 Vdout0_23ck136 = 0.9 time = 685
.meas tran vdout0_23ck136 FIND v(dout0_23) AT=685.025n

* CHECK dout0_24 Vdout0_24ck136 = 0 time = 685
.meas tran vdout0_24ck136 FIND v(dout0_24) AT=685.025n

* CHECK dout0_25 Vdout0_25ck136 = 0 time = 685
.meas tran vdout0_25ck136 FIND v(dout0_25) AT=685.025n

* CHECK dout0_26 Vdout0_26ck136 = 0 time = 685
.meas tran vdout0_26ck136 FIND v(dout0_26) AT=685.025n

* CHECK dout0_27 Vdout0_27ck136 = 0.9 time = 685
.meas tran vdout0_27ck136 FIND v(dout0_27) AT=685.025n

* CHECK dout0_28 Vdout0_28ck136 = 0 time = 685
.meas tran vdout0_28ck136 FIND v(dout0_28) AT=685.025n

* CHECK dout0_29 Vdout0_29ck136 = 0 time = 685
.meas tran vdout0_29ck136 FIND v(dout0_29) AT=685.025n

* CHECK dout0_30 Vdout0_30ck136 = 0 time = 685
.meas tran vdout0_30ck136 FIND v(dout0_30) AT=685.025n

* CHECK dout0_31 Vdout0_31ck136 = 0.9 time = 685
.meas tran vdout0_31ck136 FIND v(dout0_31) AT=685.025n

* CHECK dout0_32 Vdout0_32ck136 = 0 time = 685
.meas tran vdout0_32ck136 FIND v(dout0_32) AT=685.025n

* CHECK dout0_33 Vdout0_33ck136 = 0.9 time = 685
.meas tran vdout0_33ck136 FIND v(dout0_33) AT=685.025n

* CHECK dout0_34 Vdout0_34ck136 = 0.9 time = 685
.meas tran vdout0_34ck136 FIND v(dout0_34) AT=685.025n

* CHECK dout0_35 Vdout0_35ck136 = 0 time = 685
.meas tran vdout0_35ck136 FIND v(dout0_35) AT=685.025n

* CHECK dout0_36 Vdout0_36ck136 = 0 time = 685
.meas tran vdout0_36ck136 FIND v(dout0_36) AT=685.025n

* CHECK dout0_37 Vdout0_37ck136 = 0 time = 685
.meas tran vdout0_37ck136 FIND v(dout0_37) AT=685.025n

* CHECK dout0_38 Vdout0_38ck136 = 0.9 time = 685
.meas tran vdout0_38ck136 FIND v(dout0_38) AT=685.025n

* CHECK dout0_39 Vdout0_39ck136 = 0.9 time = 685
.meas tran vdout0_39ck136 FIND v(dout0_39) AT=685.025n

* CHECK dout0_40 Vdout0_40ck136 = 0.9 time = 685
.meas tran vdout0_40ck136 FIND v(dout0_40) AT=685.025n

* CHECK dout0_41 Vdout0_41ck136 = 0.9 time = 685
.meas tran vdout0_41ck136 FIND v(dout0_41) AT=685.025n

* CHECK dout0_42 Vdout0_42ck136 = 0.9 time = 685
.meas tran vdout0_42ck136 FIND v(dout0_42) AT=685.025n

* CHECK dout0_43 Vdout0_43ck136 = 0 time = 685
.meas tran vdout0_43ck136 FIND v(dout0_43) AT=685.025n

* CHECK dout0_44 Vdout0_44ck136 = 0.9 time = 685
.meas tran vdout0_44ck136 FIND v(dout0_44) AT=685.025n

* CHECK dout0_45 Vdout0_45ck136 = 0 time = 685
.meas tran vdout0_45ck136 FIND v(dout0_45) AT=685.025n

* CHECK dout0_46 Vdout0_46ck136 = 0 time = 685
.meas tran vdout0_46ck136 FIND v(dout0_46) AT=685.025n

* CHECK dout0_47 Vdout0_47ck136 = 0 time = 685
.meas tran vdout0_47ck136 FIND v(dout0_47) AT=685.025n

* CHECK dout0_48 Vdout0_48ck136 = 0.9 time = 685
.meas tran vdout0_48ck136 FIND v(dout0_48) AT=685.025n

* CHECK dout0_49 Vdout0_49ck136 = 0 time = 685
.meas tran vdout0_49ck136 FIND v(dout0_49) AT=685.025n

* CHECK dout0_50 Vdout0_50ck136 = 0 time = 685
.meas tran vdout0_50ck136 FIND v(dout0_50) AT=685.025n

* CHECK dout0_51 Vdout0_51ck136 = 0.9 time = 685
.meas tran vdout0_51ck136 FIND v(dout0_51) AT=685.025n

* CHECK dout0_52 Vdout0_52ck136 = 0.9 time = 685
.meas tran vdout0_52ck136 FIND v(dout0_52) AT=685.025n

* CHECK dout0_53 Vdout0_53ck136 = 0.9 time = 685
.meas tran vdout0_53ck136 FIND v(dout0_53) AT=685.025n

* CHECK dout0_54 Vdout0_54ck136 = 0.9 time = 685
.meas tran vdout0_54ck136 FIND v(dout0_54) AT=685.025n

* CHECK dout0_55 Vdout0_55ck136 = 0.9 time = 685
.meas tran vdout0_55ck136 FIND v(dout0_55) AT=685.025n

* CHECK dout0_56 Vdout0_56ck136 = 0 time = 685
.meas tran vdout0_56ck136 FIND v(dout0_56) AT=685.025n

* CHECK dout0_57 Vdout0_57ck136 = 0 time = 685
.meas tran vdout0_57ck136 FIND v(dout0_57) AT=685.025n

* CHECK dout0_58 Vdout0_58ck136 = 0.9 time = 685
.meas tran vdout0_58ck136 FIND v(dout0_58) AT=685.025n

* CHECK dout0_59 Vdout0_59ck136 = 0 time = 685
.meas tran vdout0_59ck136 FIND v(dout0_59) AT=685.025n

* CHECK dout0_60 Vdout0_60ck136 = 0 time = 685
.meas tran vdout0_60ck136 FIND v(dout0_60) AT=685.025n

* CHECK dout0_61 Vdout0_61ck136 = 0 time = 685
.meas tran vdout0_61ck136 FIND v(dout0_61) AT=685.025n

* CHECK dout0_62 Vdout0_62ck136 = 0.9 time = 685
.meas tran vdout0_62ck136 FIND v(dout0_62) AT=685.025n

* CHECK dout0_63 Vdout0_63ck136 = 0.9 time = 685
.meas tran vdout0_63ck136 FIND v(dout0_63) AT=685.025n

* CHECK dout0_64 Vdout0_64ck136 = 0.9 time = 685
.meas tran vdout0_64ck136 FIND v(dout0_64) AT=685.025n

* CHECK dout0_65 Vdout0_65ck136 = 0.9 time = 685
.meas tran vdout0_65ck136 FIND v(dout0_65) AT=685.025n

* CHECK dout0_66 Vdout0_66ck136 = 0 time = 685
.meas tran vdout0_66ck136 FIND v(dout0_66) AT=685.025n

* CHECK dout0_67 Vdout0_67ck136 = 0 time = 685
.meas tran vdout0_67ck136 FIND v(dout0_67) AT=685.025n

* CHECK dout0_68 Vdout0_68ck136 = 0 time = 685
.meas tran vdout0_68ck136 FIND v(dout0_68) AT=685.025n

* CHECK dout0_69 Vdout0_69ck136 = 0.9 time = 685
.meas tran vdout0_69ck136 FIND v(dout0_69) AT=685.025n

* CHECK dout0_70 Vdout0_70ck136 = 0 time = 685
.meas tran vdout0_70ck136 FIND v(dout0_70) AT=685.025n

* CHECK dout0_71 Vdout0_71ck136 = 0 time = 685
.meas tran vdout0_71ck136 FIND v(dout0_71) AT=685.025n

* CHECK dout0_72 Vdout0_72ck136 = 0.9 time = 685
.meas tran vdout0_72ck136 FIND v(dout0_72) AT=685.025n

* CHECK dout0_73 Vdout0_73ck136 = 0.9 time = 685
.meas tran vdout0_73ck136 FIND v(dout0_73) AT=685.025n

* CHECK dout0_74 Vdout0_74ck136 = 0 time = 685
.meas tran vdout0_74ck136 FIND v(dout0_74) AT=685.025n

* CHECK dout0_75 Vdout0_75ck136 = 0 time = 685
.meas tran vdout0_75ck136 FIND v(dout0_75) AT=685.025n

* CHECK dout0_76 Vdout0_76ck136 = 0.9 time = 685
.meas tran vdout0_76ck136 FIND v(dout0_76) AT=685.025n

* CHECK dout0_77 Vdout0_77ck136 = 0 time = 685
.meas tran vdout0_77ck136 FIND v(dout0_77) AT=685.025n

* CHECK dout0_78 Vdout0_78ck136 = 0 time = 685
.meas tran vdout0_78ck136 FIND v(dout0_78) AT=685.025n

* CHECK dout0_79 Vdout0_79ck136 = 0 time = 685
.meas tran vdout0_79ck136 FIND v(dout0_79) AT=685.025n

* CHECK dout0_80 Vdout0_80ck136 = 0 time = 685
.meas tran vdout0_80ck136 FIND v(dout0_80) AT=685.025n

* CHECK dout0_81 Vdout0_81ck136 = 0.9 time = 685
.meas tran vdout0_81ck136 FIND v(dout0_81) AT=685.025n

* CHECK dout0_82 Vdout0_82ck136 = 0 time = 685
.meas tran vdout0_82ck136 FIND v(dout0_82) AT=685.025n

* CHECK dout0_83 Vdout0_83ck136 = 0 time = 685
.meas tran vdout0_83ck136 FIND v(dout0_83) AT=685.025n

* CHECK dout0_84 Vdout0_84ck136 = 0.9 time = 685
.meas tran vdout0_84ck136 FIND v(dout0_84) AT=685.025n

* CHECK dout0_85 Vdout0_85ck136 = 0.9 time = 685
.meas tran vdout0_85ck136 FIND v(dout0_85) AT=685.025n

* CHECK dout0_86 Vdout0_86ck136 = 0.9 time = 685
.meas tran vdout0_86ck136 FIND v(dout0_86) AT=685.025n

* CHECK dout0_87 Vdout0_87ck136 = 0.9 time = 685
.meas tran vdout0_87ck136 FIND v(dout0_87) AT=685.025n

* CHECK dout0_0 Vdout0_0ck137 = 0 time = 690
.meas tran vdout0_0ck137 FIND v(dout0_0) AT=690.025n

* CHECK dout0_1 Vdout0_1ck137 = 0.9 time = 690
.meas tran vdout0_1ck137 FIND v(dout0_1) AT=690.025n

* CHECK dout0_2 Vdout0_2ck137 = 0 time = 690
.meas tran vdout0_2ck137 FIND v(dout0_2) AT=690.025n

* CHECK dout0_3 Vdout0_3ck137 = 0.9 time = 690
.meas tran vdout0_3ck137 FIND v(dout0_3) AT=690.025n

* CHECK dout0_4 Vdout0_4ck137 = 0.9 time = 690
.meas tran vdout0_4ck137 FIND v(dout0_4) AT=690.025n

* CHECK dout0_5 Vdout0_5ck137 = 0 time = 690
.meas tran vdout0_5ck137 FIND v(dout0_5) AT=690.025n

* CHECK dout0_6 Vdout0_6ck137 = 0 time = 690
.meas tran vdout0_6ck137 FIND v(dout0_6) AT=690.025n

* CHECK dout0_7 Vdout0_7ck137 = 0 time = 690
.meas tran vdout0_7ck137 FIND v(dout0_7) AT=690.025n

* CHECK dout0_8 Vdout0_8ck137 = 0 time = 690
.meas tran vdout0_8ck137 FIND v(dout0_8) AT=690.025n

* CHECK dout0_9 Vdout0_9ck137 = 0 time = 690
.meas tran vdout0_9ck137 FIND v(dout0_9) AT=690.025n

* CHECK dout0_10 Vdout0_10ck137 = 0.9 time = 690
.meas tran vdout0_10ck137 FIND v(dout0_10) AT=690.025n

* CHECK dout0_11 Vdout0_11ck137 = 0 time = 690
.meas tran vdout0_11ck137 FIND v(dout0_11) AT=690.025n

* CHECK dout0_12 Vdout0_12ck137 = 0.9 time = 690
.meas tran vdout0_12ck137 FIND v(dout0_12) AT=690.025n

* CHECK dout0_13 Vdout0_13ck137 = 0 time = 690
.meas tran vdout0_13ck137 FIND v(dout0_13) AT=690.025n

* CHECK dout0_14 Vdout0_14ck137 = 0 time = 690
.meas tran vdout0_14ck137 FIND v(dout0_14) AT=690.025n

* CHECK dout0_15 Vdout0_15ck137 = 0 time = 690
.meas tran vdout0_15ck137 FIND v(dout0_15) AT=690.025n

* CHECK dout0_16 Vdout0_16ck137 = 0 time = 690
.meas tran vdout0_16ck137 FIND v(dout0_16) AT=690.025n

* CHECK dout0_17 Vdout0_17ck137 = 0 time = 690
.meas tran vdout0_17ck137 FIND v(dout0_17) AT=690.025n

* CHECK dout0_18 Vdout0_18ck137 = 0.9 time = 690
.meas tran vdout0_18ck137 FIND v(dout0_18) AT=690.025n

* CHECK dout0_19 Vdout0_19ck137 = 0.9 time = 690
.meas tran vdout0_19ck137 FIND v(dout0_19) AT=690.025n

* CHECK dout0_20 Vdout0_20ck137 = 0.9 time = 690
.meas tran vdout0_20ck137 FIND v(dout0_20) AT=690.025n

* CHECK dout0_21 Vdout0_21ck137 = 0.9 time = 690
.meas tran vdout0_21ck137 FIND v(dout0_21) AT=690.025n

* CHECK dout0_22 Vdout0_22ck137 = 0.9 time = 690
.meas tran vdout0_22ck137 FIND v(dout0_22) AT=690.025n

* CHECK dout0_23 Vdout0_23ck137 = 0.9 time = 690
.meas tran vdout0_23ck137 FIND v(dout0_23) AT=690.025n

* CHECK dout0_24 Vdout0_24ck137 = 0 time = 690
.meas tran vdout0_24ck137 FIND v(dout0_24) AT=690.025n

* CHECK dout0_25 Vdout0_25ck137 = 0 time = 690
.meas tran vdout0_25ck137 FIND v(dout0_25) AT=690.025n

* CHECK dout0_26 Vdout0_26ck137 = 0 time = 690
.meas tran vdout0_26ck137 FIND v(dout0_26) AT=690.025n

* CHECK dout0_27 Vdout0_27ck137 = 0.9 time = 690
.meas tran vdout0_27ck137 FIND v(dout0_27) AT=690.025n

* CHECK dout0_28 Vdout0_28ck137 = 0 time = 690
.meas tran vdout0_28ck137 FIND v(dout0_28) AT=690.025n

* CHECK dout0_29 Vdout0_29ck137 = 0 time = 690
.meas tran vdout0_29ck137 FIND v(dout0_29) AT=690.025n

* CHECK dout0_30 Vdout0_30ck137 = 0 time = 690
.meas tran vdout0_30ck137 FIND v(dout0_30) AT=690.025n

* CHECK dout0_31 Vdout0_31ck137 = 0.9 time = 690
.meas tran vdout0_31ck137 FIND v(dout0_31) AT=690.025n

* CHECK dout0_32 Vdout0_32ck137 = 0 time = 690
.meas tran vdout0_32ck137 FIND v(dout0_32) AT=690.025n

* CHECK dout0_33 Vdout0_33ck137 = 0.9 time = 690
.meas tran vdout0_33ck137 FIND v(dout0_33) AT=690.025n

* CHECK dout0_34 Vdout0_34ck137 = 0.9 time = 690
.meas tran vdout0_34ck137 FIND v(dout0_34) AT=690.025n

* CHECK dout0_35 Vdout0_35ck137 = 0 time = 690
.meas tran vdout0_35ck137 FIND v(dout0_35) AT=690.025n

* CHECK dout0_36 Vdout0_36ck137 = 0 time = 690
.meas tran vdout0_36ck137 FIND v(dout0_36) AT=690.025n

* CHECK dout0_37 Vdout0_37ck137 = 0 time = 690
.meas tran vdout0_37ck137 FIND v(dout0_37) AT=690.025n

* CHECK dout0_38 Vdout0_38ck137 = 0.9 time = 690
.meas tran vdout0_38ck137 FIND v(dout0_38) AT=690.025n

* CHECK dout0_39 Vdout0_39ck137 = 0.9 time = 690
.meas tran vdout0_39ck137 FIND v(dout0_39) AT=690.025n

* CHECK dout0_40 Vdout0_40ck137 = 0.9 time = 690
.meas tran vdout0_40ck137 FIND v(dout0_40) AT=690.025n

* CHECK dout0_41 Vdout0_41ck137 = 0.9 time = 690
.meas tran vdout0_41ck137 FIND v(dout0_41) AT=690.025n

* CHECK dout0_42 Vdout0_42ck137 = 0.9 time = 690
.meas tran vdout0_42ck137 FIND v(dout0_42) AT=690.025n

* CHECK dout0_43 Vdout0_43ck137 = 0 time = 690
.meas tran vdout0_43ck137 FIND v(dout0_43) AT=690.025n

* CHECK dout0_44 Vdout0_44ck137 = 0.9 time = 690
.meas tran vdout0_44ck137 FIND v(dout0_44) AT=690.025n

* CHECK dout0_45 Vdout0_45ck137 = 0 time = 690
.meas tran vdout0_45ck137 FIND v(dout0_45) AT=690.025n

* CHECK dout0_46 Vdout0_46ck137 = 0 time = 690
.meas tran vdout0_46ck137 FIND v(dout0_46) AT=690.025n

* CHECK dout0_47 Vdout0_47ck137 = 0 time = 690
.meas tran vdout0_47ck137 FIND v(dout0_47) AT=690.025n

* CHECK dout0_48 Vdout0_48ck137 = 0.9 time = 690
.meas tran vdout0_48ck137 FIND v(dout0_48) AT=690.025n

* CHECK dout0_49 Vdout0_49ck137 = 0 time = 690
.meas tran vdout0_49ck137 FIND v(dout0_49) AT=690.025n

* CHECK dout0_50 Vdout0_50ck137 = 0 time = 690
.meas tran vdout0_50ck137 FIND v(dout0_50) AT=690.025n

* CHECK dout0_51 Vdout0_51ck137 = 0.9 time = 690
.meas tran vdout0_51ck137 FIND v(dout0_51) AT=690.025n

* CHECK dout0_52 Vdout0_52ck137 = 0.9 time = 690
.meas tran vdout0_52ck137 FIND v(dout0_52) AT=690.025n

* CHECK dout0_53 Vdout0_53ck137 = 0.9 time = 690
.meas tran vdout0_53ck137 FIND v(dout0_53) AT=690.025n

* CHECK dout0_54 Vdout0_54ck137 = 0.9 time = 690
.meas tran vdout0_54ck137 FIND v(dout0_54) AT=690.025n

* CHECK dout0_55 Vdout0_55ck137 = 0.9 time = 690
.meas tran vdout0_55ck137 FIND v(dout0_55) AT=690.025n

* CHECK dout0_56 Vdout0_56ck137 = 0 time = 690
.meas tran vdout0_56ck137 FIND v(dout0_56) AT=690.025n

* CHECK dout0_57 Vdout0_57ck137 = 0 time = 690
.meas tran vdout0_57ck137 FIND v(dout0_57) AT=690.025n

* CHECK dout0_58 Vdout0_58ck137 = 0.9 time = 690
.meas tran vdout0_58ck137 FIND v(dout0_58) AT=690.025n

* CHECK dout0_59 Vdout0_59ck137 = 0 time = 690
.meas tran vdout0_59ck137 FIND v(dout0_59) AT=690.025n

* CHECK dout0_60 Vdout0_60ck137 = 0 time = 690
.meas tran vdout0_60ck137 FIND v(dout0_60) AT=690.025n

* CHECK dout0_61 Vdout0_61ck137 = 0 time = 690
.meas tran vdout0_61ck137 FIND v(dout0_61) AT=690.025n

* CHECK dout0_62 Vdout0_62ck137 = 0.9 time = 690
.meas tran vdout0_62ck137 FIND v(dout0_62) AT=690.025n

* CHECK dout0_63 Vdout0_63ck137 = 0.9 time = 690
.meas tran vdout0_63ck137 FIND v(dout0_63) AT=690.025n

* CHECK dout0_64 Vdout0_64ck137 = 0.9 time = 690
.meas tran vdout0_64ck137 FIND v(dout0_64) AT=690.025n

* CHECK dout0_65 Vdout0_65ck137 = 0.9 time = 690
.meas tran vdout0_65ck137 FIND v(dout0_65) AT=690.025n

* CHECK dout0_66 Vdout0_66ck137 = 0 time = 690
.meas tran vdout0_66ck137 FIND v(dout0_66) AT=690.025n

* CHECK dout0_67 Vdout0_67ck137 = 0 time = 690
.meas tran vdout0_67ck137 FIND v(dout0_67) AT=690.025n

* CHECK dout0_68 Vdout0_68ck137 = 0 time = 690
.meas tran vdout0_68ck137 FIND v(dout0_68) AT=690.025n

* CHECK dout0_69 Vdout0_69ck137 = 0.9 time = 690
.meas tran vdout0_69ck137 FIND v(dout0_69) AT=690.025n

* CHECK dout0_70 Vdout0_70ck137 = 0 time = 690
.meas tran vdout0_70ck137 FIND v(dout0_70) AT=690.025n

* CHECK dout0_71 Vdout0_71ck137 = 0 time = 690
.meas tran vdout0_71ck137 FIND v(dout0_71) AT=690.025n

* CHECK dout0_72 Vdout0_72ck137 = 0.9 time = 690
.meas tran vdout0_72ck137 FIND v(dout0_72) AT=690.025n

* CHECK dout0_73 Vdout0_73ck137 = 0.9 time = 690
.meas tran vdout0_73ck137 FIND v(dout0_73) AT=690.025n

* CHECK dout0_74 Vdout0_74ck137 = 0 time = 690
.meas tran vdout0_74ck137 FIND v(dout0_74) AT=690.025n

* CHECK dout0_75 Vdout0_75ck137 = 0 time = 690
.meas tran vdout0_75ck137 FIND v(dout0_75) AT=690.025n

* CHECK dout0_76 Vdout0_76ck137 = 0.9 time = 690
.meas tran vdout0_76ck137 FIND v(dout0_76) AT=690.025n

* CHECK dout0_77 Vdout0_77ck137 = 0 time = 690
.meas tran vdout0_77ck137 FIND v(dout0_77) AT=690.025n

* CHECK dout0_78 Vdout0_78ck137 = 0 time = 690
.meas tran vdout0_78ck137 FIND v(dout0_78) AT=690.025n

* CHECK dout0_79 Vdout0_79ck137 = 0 time = 690
.meas tran vdout0_79ck137 FIND v(dout0_79) AT=690.025n

* CHECK dout0_80 Vdout0_80ck137 = 0 time = 690
.meas tran vdout0_80ck137 FIND v(dout0_80) AT=690.025n

* CHECK dout0_81 Vdout0_81ck137 = 0.9 time = 690
.meas tran vdout0_81ck137 FIND v(dout0_81) AT=690.025n

* CHECK dout0_82 Vdout0_82ck137 = 0 time = 690
.meas tran vdout0_82ck137 FIND v(dout0_82) AT=690.025n

* CHECK dout0_83 Vdout0_83ck137 = 0 time = 690
.meas tran vdout0_83ck137 FIND v(dout0_83) AT=690.025n

* CHECK dout0_84 Vdout0_84ck137 = 0.9 time = 690
.meas tran vdout0_84ck137 FIND v(dout0_84) AT=690.025n

* CHECK dout0_85 Vdout0_85ck137 = 0.9 time = 690
.meas tran vdout0_85ck137 FIND v(dout0_85) AT=690.025n

* CHECK dout0_86 Vdout0_86ck137 = 0.9 time = 690
.meas tran vdout0_86ck137 FIND v(dout0_86) AT=690.025n

* CHECK dout0_87 Vdout0_87ck137 = 0.9 time = 690
.meas tran vdout0_87ck137 FIND v(dout0_87) AT=690.025n

* CHECK dout0_0 Vdout0_0ck138 = 0.9 time = 695
.meas tran vdout0_0ck138 FIND v(dout0_0) AT=695.025n

* CHECK dout0_1 Vdout0_1ck138 = 0 time = 695
.meas tran vdout0_1ck138 FIND v(dout0_1) AT=695.025n

* CHECK dout0_2 Vdout0_2ck138 = 0.9 time = 695
.meas tran vdout0_2ck138 FIND v(dout0_2) AT=695.025n

* CHECK dout0_3 Vdout0_3ck138 = 0.9 time = 695
.meas tran vdout0_3ck138 FIND v(dout0_3) AT=695.025n

* CHECK dout0_4 Vdout0_4ck138 = 0 time = 695
.meas tran vdout0_4ck138 FIND v(dout0_4) AT=695.025n

* CHECK dout0_5 Vdout0_5ck138 = 0 time = 695
.meas tran vdout0_5ck138 FIND v(dout0_5) AT=695.025n

* CHECK dout0_6 Vdout0_6ck138 = 0.9 time = 695
.meas tran vdout0_6ck138 FIND v(dout0_6) AT=695.025n

* CHECK dout0_7 Vdout0_7ck138 = 0 time = 695
.meas tran vdout0_7ck138 FIND v(dout0_7) AT=695.025n

* CHECK dout0_8 Vdout0_8ck138 = 0.9 time = 695
.meas tran vdout0_8ck138 FIND v(dout0_8) AT=695.025n

* CHECK dout0_9 Vdout0_9ck138 = 0.9 time = 695
.meas tran vdout0_9ck138 FIND v(dout0_9) AT=695.025n

* CHECK dout0_10 Vdout0_10ck138 = 0 time = 695
.meas tran vdout0_10ck138 FIND v(dout0_10) AT=695.025n

* CHECK dout0_11 Vdout0_11ck138 = 0 time = 695
.meas tran vdout0_11ck138 FIND v(dout0_11) AT=695.025n

* CHECK dout0_12 Vdout0_12ck138 = 0 time = 695
.meas tran vdout0_12ck138 FIND v(dout0_12) AT=695.025n

* CHECK dout0_13 Vdout0_13ck138 = 0 time = 695
.meas tran vdout0_13ck138 FIND v(dout0_13) AT=695.025n

* CHECK dout0_14 Vdout0_14ck138 = 0.9 time = 695
.meas tran vdout0_14ck138 FIND v(dout0_14) AT=695.025n

* CHECK dout0_15 Vdout0_15ck138 = 0.9 time = 695
.meas tran vdout0_15ck138 FIND v(dout0_15) AT=695.025n

* CHECK dout0_16 Vdout0_16ck138 = 0.9 time = 695
.meas tran vdout0_16ck138 FIND v(dout0_16) AT=695.025n

* CHECK dout0_17 Vdout0_17ck138 = 0.9 time = 695
.meas tran vdout0_17ck138 FIND v(dout0_17) AT=695.025n

* CHECK dout0_18 Vdout0_18ck138 = 0.9 time = 695
.meas tran vdout0_18ck138 FIND v(dout0_18) AT=695.025n

* CHECK dout0_19 Vdout0_19ck138 = 0.9 time = 695
.meas tran vdout0_19ck138 FIND v(dout0_19) AT=695.025n

* CHECK dout0_20 Vdout0_20ck138 = 0 time = 695
.meas tran vdout0_20ck138 FIND v(dout0_20) AT=695.025n

* CHECK dout0_21 Vdout0_21ck138 = 0.9 time = 695
.meas tran vdout0_21ck138 FIND v(dout0_21) AT=695.025n

* CHECK dout0_22 Vdout0_22ck138 = 0.9 time = 695
.meas tran vdout0_22ck138 FIND v(dout0_22) AT=695.025n

* CHECK dout0_23 Vdout0_23ck138 = 0.9 time = 695
.meas tran vdout0_23ck138 FIND v(dout0_23) AT=695.025n

* CHECK dout0_24 Vdout0_24ck138 = 0 time = 695
.meas tran vdout0_24ck138 FIND v(dout0_24) AT=695.025n

* CHECK dout0_25 Vdout0_25ck138 = 0 time = 695
.meas tran vdout0_25ck138 FIND v(dout0_25) AT=695.025n

* CHECK dout0_26 Vdout0_26ck138 = 0.9 time = 695
.meas tran vdout0_26ck138 FIND v(dout0_26) AT=695.025n

* CHECK dout0_27 Vdout0_27ck138 = 0 time = 695
.meas tran vdout0_27ck138 FIND v(dout0_27) AT=695.025n

* CHECK dout0_28 Vdout0_28ck138 = 0.9 time = 695
.meas tran vdout0_28ck138 FIND v(dout0_28) AT=695.025n

* CHECK dout0_29 Vdout0_29ck138 = 0.9 time = 695
.meas tran vdout0_29ck138 FIND v(dout0_29) AT=695.025n

* CHECK dout0_30 Vdout0_30ck138 = 0.9 time = 695
.meas tran vdout0_30ck138 FIND v(dout0_30) AT=695.025n

* CHECK dout0_31 Vdout0_31ck138 = 0 time = 695
.meas tran vdout0_31ck138 FIND v(dout0_31) AT=695.025n

* CHECK dout0_32 Vdout0_32ck138 = 0.9 time = 695
.meas tran vdout0_32ck138 FIND v(dout0_32) AT=695.025n

* CHECK dout0_33 Vdout0_33ck138 = 0 time = 695
.meas tran vdout0_33ck138 FIND v(dout0_33) AT=695.025n

* CHECK dout0_34 Vdout0_34ck138 = 0 time = 695
.meas tran vdout0_34ck138 FIND v(dout0_34) AT=695.025n

* CHECK dout0_35 Vdout0_35ck138 = 0.9 time = 695
.meas tran vdout0_35ck138 FIND v(dout0_35) AT=695.025n

* CHECK dout0_36 Vdout0_36ck138 = 0 time = 695
.meas tran vdout0_36ck138 FIND v(dout0_36) AT=695.025n

* CHECK dout0_37 Vdout0_37ck138 = 0.9 time = 695
.meas tran vdout0_37ck138 FIND v(dout0_37) AT=695.025n

* CHECK dout0_38 Vdout0_38ck138 = 0 time = 695
.meas tran vdout0_38ck138 FIND v(dout0_38) AT=695.025n

* CHECK dout0_39 Vdout0_39ck138 = 0 time = 695
.meas tran vdout0_39ck138 FIND v(dout0_39) AT=695.025n

* CHECK dout0_40 Vdout0_40ck138 = 0.9 time = 695
.meas tran vdout0_40ck138 FIND v(dout0_40) AT=695.025n

* CHECK dout0_41 Vdout0_41ck138 = 0.9 time = 695
.meas tran vdout0_41ck138 FIND v(dout0_41) AT=695.025n

* CHECK dout0_42 Vdout0_42ck138 = 0 time = 695
.meas tran vdout0_42ck138 FIND v(dout0_42) AT=695.025n

* CHECK dout0_43 Vdout0_43ck138 = 0 time = 695
.meas tran vdout0_43ck138 FIND v(dout0_43) AT=695.025n

* CHECK dout0_44 Vdout0_44ck138 = 0.9 time = 695
.meas tran vdout0_44ck138 FIND v(dout0_44) AT=695.025n

* CHECK dout0_45 Vdout0_45ck138 = 0.9 time = 695
.meas tran vdout0_45ck138 FIND v(dout0_45) AT=695.025n

* CHECK dout0_46 Vdout0_46ck138 = 0 time = 695
.meas tran vdout0_46ck138 FIND v(dout0_46) AT=695.025n

* CHECK dout0_47 Vdout0_47ck138 = 0 time = 695
.meas tran vdout0_47ck138 FIND v(dout0_47) AT=695.025n

* CHECK dout0_48 Vdout0_48ck138 = 0 time = 695
.meas tran vdout0_48ck138 FIND v(dout0_48) AT=695.025n

* CHECK dout0_49 Vdout0_49ck138 = 0.9 time = 695
.meas tran vdout0_49ck138 FIND v(dout0_49) AT=695.025n

* CHECK dout0_50 Vdout0_50ck138 = 0.9 time = 695
.meas tran vdout0_50ck138 FIND v(dout0_50) AT=695.025n

* CHECK dout0_51 Vdout0_51ck138 = 0.9 time = 695
.meas tran vdout0_51ck138 FIND v(dout0_51) AT=695.025n

* CHECK dout0_52 Vdout0_52ck138 = 0.9 time = 695
.meas tran vdout0_52ck138 FIND v(dout0_52) AT=695.025n

* CHECK dout0_53 Vdout0_53ck138 = 0.9 time = 695
.meas tran vdout0_53ck138 FIND v(dout0_53) AT=695.025n

* CHECK dout0_54 Vdout0_54ck138 = 0 time = 695
.meas tran vdout0_54ck138 FIND v(dout0_54) AT=695.025n

* CHECK dout0_55 Vdout0_55ck138 = 0.9 time = 695
.meas tran vdout0_55ck138 FIND v(dout0_55) AT=695.025n

* CHECK dout0_56 Vdout0_56ck138 = 0 time = 695
.meas tran vdout0_56ck138 FIND v(dout0_56) AT=695.025n

* CHECK dout0_57 Vdout0_57ck138 = 0.9 time = 695
.meas tran vdout0_57ck138 FIND v(dout0_57) AT=695.025n

* CHECK dout0_58 Vdout0_58ck138 = 0 time = 695
.meas tran vdout0_58ck138 FIND v(dout0_58) AT=695.025n

* CHECK dout0_59 Vdout0_59ck138 = 0 time = 695
.meas tran vdout0_59ck138 FIND v(dout0_59) AT=695.025n

* CHECK dout0_60 Vdout0_60ck138 = 0 time = 695
.meas tran vdout0_60ck138 FIND v(dout0_60) AT=695.025n

* CHECK dout0_61 Vdout0_61ck138 = 0.9 time = 695
.meas tran vdout0_61ck138 FIND v(dout0_61) AT=695.025n

* CHECK dout0_62 Vdout0_62ck138 = 0 time = 695
.meas tran vdout0_62ck138 FIND v(dout0_62) AT=695.025n

* CHECK dout0_63 Vdout0_63ck138 = 0.9 time = 695
.meas tran vdout0_63ck138 FIND v(dout0_63) AT=695.025n

* CHECK dout0_64 Vdout0_64ck138 = 0.9 time = 695
.meas tran vdout0_64ck138 FIND v(dout0_64) AT=695.025n

* CHECK dout0_65 Vdout0_65ck138 = 0.9 time = 695
.meas tran vdout0_65ck138 FIND v(dout0_65) AT=695.025n

* CHECK dout0_66 Vdout0_66ck138 = 0 time = 695
.meas tran vdout0_66ck138 FIND v(dout0_66) AT=695.025n

* CHECK dout0_67 Vdout0_67ck138 = 0 time = 695
.meas tran vdout0_67ck138 FIND v(dout0_67) AT=695.025n

* CHECK dout0_68 Vdout0_68ck138 = 0.9 time = 695
.meas tran vdout0_68ck138 FIND v(dout0_68) AT=695.025n

* CHECK dout0_69 Vdout0_69ck138 = 0.9 time = 695
.meas tran vdout0_69ck138 FIND v(dout0_69) AT=695.025n

* CHECK dout0_70 Vdout0_70ck138 = 0.9 time = 695
.meas tran vdout0_70ck138 FIND v(dout0_70) AT=695.025n

* CHECK dout0_71 Vdout0_71ck138 = 0 time = 695
.meas tran vdout0_71ck138 FIND v(dout0_71) AT=695.025n

* CHECK dout0_72 Vdout0_72ck138 = 0.9 time = 695
.meas tran vdout0_72ck138 FIND v(dout0_72) AT=695.025n

* CHECK dout0_73 Vdout0_73ck138 = 0 time = 695
.meas tran vdout0_73ck138 FIND v(dout0_73) AT=695.025n

* CHECK dout0_74 Vdout0_74ck138 = 0.9 time = 695
.meas tran vdout0_74ck138 FIND v(dout0_74) AT=695.025n

* CHECK dout0_75 Vdout0_75ck138 = 0.9 time = 695
.meas tran vdout0_75ck138 FIND v(dout0_75) AT=695.025n

* CHECK dout0_76 Vdout0_76ck138 = 0.9 time = 695
.meas tran vdout0_76ck138 FIND v(dout0_76) AT=695.025n

* CHECK dout0_77 Vdout0_77ck138 = 0 time = 695
.meas tran vdout0_77ck138 FIND v(dout0_77) AT=695.025n

* CHECK dout0_78 Vdout0_78ck138 = 0.9 time = 695
.meas tran vdout0_78ck138 FIND v(dout0_78) AT=695.025n

* CHECK dout0_79 Vdout0_79ck138 = 0 time = 695
.meas tran vdout0_79ck138 FIND v(dout0_79) AT=695.025n

* CHECK dout0_80 Vdout0_80ck138 = 0 time = 695
.meas tran vdout0_80ck138 FIND v(dout0_80) AT=695.025n

* CHECK dout0_81 Vdout0_81ck138 = 0.9 time = 695
.meas tran vdout0_81ck138 FIND v(dout0_81) AT=695.025n

* CHECK dout0_82 Vdout0_82ck138 = 0.9 time = 695
.meas tran vdout0_82ck138 FIND v(dout0_82) AT=695.025n

* CHECK dout0_83 Vdout0_83ck138 = 0 time = 695
.meas tran vdout0_83ck138 FIND v(dout0_83) AT=695.025n

* CHECK dout0_84 Vdout0_84ck138 = 0.9 time = 695
.meas tran vdout0_84ck138 FIND v(dout0_84) AT=695.025n

* CHECK dout0_85 Vdout0_85ck138 = 0.9 time = 695
.meas tran vdout0_85ck138 FIND v(dout0_85) AT=695.025n

* CHECK dout0_86 Vdout0_86ck138 = 0 time = 695
.meas tran vdout0_86ck138 FIND v(dout0_86) AT=695.025n

* CHECK dout0_87 Vdout0_87ck138 = 0.9 time = 695
.meas tran vdout0_87ck138 FIND v(dout0_87) AT=695.025n

* CHECK dout0_0 Vdout0_0ck139 = 0.9 time = 700
.meas tran vdout0_0ck139 FIND v(dout0_0) AT=700.025n

* CHECK dout0_1 Vdout0_1ck139 = 0 time = 700
.meas tran vdout0_1ck139 FIND v(dout0_1) AT=700.025n

* CHECK dout0_2 Vdout0_2ck139 = 0.9 time = 700
.meas tran vdout0_2ck139 FIND v(dout0_2) AT=700.025n

* CHECK dout0_3 Vdout0_3ck139 = 0.9 time = 700
.meas tran vdout0_3ck139 FIND v(dout0_3) AT=700.025n

* CHECK dout0_4 Vdout0_4ck139 = 0 time = 700
.meas tran vdout0_4ck139 FIND v(dout0_4) AT=700.025n

* CHECK dout0_5 Vdout0_5ck139 = 0 time = 700
.meas tran vdout0_5ck139 FIND v(dout0_5) AT=700.025n

* CHECK dout0_6 Vdout0_6ck139 = 0.9 time = 700
.meas tran vdout0_6ck139 FIND v(dout0_6) AT=700.025n

* CHECK dout0_7 Vdout0_7ck139 = 0 time = 700
.meas tran vdout0_7ck139 FIND v(dout0_7) AT=700.025n

* CHECK dout0_8 Vdout0_8ck139 = 0.9 time = 700
.meas tran vdout0_8ck139 FIND v(dout0_8) AT=700.025n

* CHECK dout0_9 Vdout0_9ck139 = 0.9 time = 700
.meas tran vdout0_9ck139 FIND v(dout0_9) AT=700.025n

* CHECK dout0_10 Vdout0_10ck139 = 0 time = 700
.meas tran vdout0_10ck139 FIND v(dout0_10) AT=700.025n

* CHECK dout0_11 Vdout0_11ck139 = 0 time = 700
.meas tran vdout0_11ck139 FIND v(dout0_11) AT=700.025n

* CHECK dout0_12 Vdout0_12ck139 = 0 time = 700
.meas tran vdout0_12ck139 FIND v(dout0_12) AT=700.025n

* CHECK dout0_13 Vdout0_13ck139 = 0 time = 700
.meas tran vdout0_13ck139 FIND v(dout0_13) AT=700.025n

* CHECK dout0_14 Vdout0_14ck139 = 0.9 time = 700
.meas tran vdout0_14ck139 FIND v(dout0_14) AT=700.025n

* CHECK dout0_15 Vdout0_15ck139 = 0.9 time = 700
.meas tran vdout0_15ck139 FIND v(dout0_15) AT=700.025n

* CHECK dout0_16 Vdout0_16ck139 = 0.9 time = 700
.meas tran vdout0_16ck139 FIND v(dout0_16) AT=700.025n

* CHECK dout0_17 Vdout0_17ck139 = 0.9 time = 700
.meas tran vdout0_17ck139 FIND v(dout0_17) AT=700.025n

* CHECK dout0_18 Vdout0_18ck139 = 0.9 time = 700
.meas tran vdout0_18ck139 FIND v(dout0_18) AT=700.025n

* CHECK dout0_19 Vdout0_19ck139 = 0.9 time = 700
.meas tran vdout0_19ck139 FIND v(dout0_19) AT=700.025n

* CHECK dout0_20 Vdout0_20ck139 = 0 time = 700
.meas tran vdout0_20ck139 FIND v(dout0_20) AT=700.025n

* CHECK dout0_21 Vdout0_21ck139 = 0.9 time = 700
.meas tran vdout0_21ck139 FIND v(dout0_21) AT=700.025n

* CHECK dout0_22 Vdout0_22ck139 = 0.9 time = 700
.meas tran vdout0_22ck139 FIND v(dout0_22) AT=700.025n

* CHECK dout0_23 Vdout0_23ck139 = 0.9 time = 700
.meas tran vdout0_23ck139 FIND v(dout0_23) AT=700.025n

* CHECK dout0_24 Vdout0_24ck139 = 0 time = 700
.meas tran vdout0_24ck139 FIND v(dout0_24) AT=700.025n

* CHECK dout0_25 Vdout0_25ck139 = 0 time = 700
.meas tran vdout0_25ck139 FIND v(dout0_25) AT=700.025n

* CHECK dout0_26 Vdout0_26ck139 = 0.9 time = 700
.meas tran vdout0_26ck139 FIND v(dout0_26) AT=700.025n

* CHECK dout0_27 Vdout0_27ck139 = 0 time = 700
.meas tran vdout0_27ck139 FIND v(dout0_27) AT=700.025n

* CHECK dout0_28 Vdout0_28ck139 = 0.9 time = 700
.meas tran vdout0_28ck139 FIND v(dout0_28) AT=700.025n

* CHECK dout0_29 Vdout0_29ck139 = 0.9 time = 700
.meas tran vdout0_29ck139 FIND v(dout0_29) AT=700.025n

* CHECK dout0_30 Vdout0_30ck139 = 0.9 time = 700
.meas tran vdout0_30ck139 FIND v(dout0_30) AT=700.025n

* CHECK dout0_31 Vdout0_31ck139 = 0 time = 700
.meas tran vdout0_31ck139 FIND v(dout0_31) AT=700.025n

* CHECK dout0_32 Vdout0_32ck139 = 0.9 time = 700
.meas tran vdout0_32ck139 FIND v(dout0_32) AT=700.025n

* CHECK dout0_33 Vdout0_33ck139 = 0 time = 700
.meas tran vdout0_33ck139 FIND v(dout0_33) AT=700.025n

* CHECK dout0_34 Vdout0_34ck139 = 0 time = 700
.meas tran vdout0_34ck139 FIND v(dout0_34) AT=700.025n

* CHECK dout0_35 Vdout0_35ck139 = 0.9 time = 700
.meas tran vdout0_35ck139 FIND v(dout0_35) AT=700.025n

* CHECK dout0_36 Vdout0_36ck139 = 0 time = 700
.meas tran vdout0_36ck139 FIND v(dout0_36) AT=700.025n

* CHECK dout0_37 Vdout0_37ck139 = 0.9 time = 700
.meas tran vdout0_37ck139 FIND v(dout0_37) AT=700.025n

* CHECK dout0_38 Vdout0_38ck139 = 0 time = 700
.meas tran vdout0_38ck139 FIND v(dout0_38) AT=700.025n

* CHECK dout0_39 Vdout0_39ck139 = 0 time = 700
.meas tran vdout0_39ck139 FIND v(dout0_39) AT=700.025n

* CHECK dout0_40 Vdout0_40ck139 = 0.9 time = 700
.meas tran vdout0_40ck139 FIND v(dout0_40) AT=700.025n

* CHECK dout0_41 Vdout0_41ck139 = 0.9 time = 700
.meas tran vdout0_41ck139 FIND v(dout0_41) AT=700.025n

* CHECK dout0_42 Vdout0_42ck139 = 0 time = 700
.meas tran vdout0_42ck139 FIND v(dout0_42) AT=700.025n

* CHECK dout0_43 Vdout0_43ck139 = 0 time = 700
.meas tran vdout0_43ck139 FIND v(dout0_43) AT=700.025n

* CHECK dout0_44 Vdout0_44ck139 = 0.9 time = 700
.meas tran vdout0_44ck139 FIND v(dout0_44) AT=700.025n

* CHECK dout0_45 Vdout0_45ck139 = 0.9 time = 700
.meas tran vdout0_45ck139 FIND v(dout0_45) AT=700.025n

* CHECK dout0_46 Vdout0_46ck139 = 0 time = 700
.meas tran vdout0_46ck139 FIND v(dout0_46) AT=700.025n

* CHECK dout0_47 Vdout0_47ck139 = 0 time = 700
.meas tran vdout0_47ck139 FIND v(dout0_47) AT=700.025n

* CHECK dout0_48 Vdout0_48ck139 = 0 time = 700
.meas tran vdout0_48ck139 FIND v(dout0_48) AT=700.025n

* CHECK dout0_49 Vdout0_49ck139 = 0.9 time = 700
.meas tran vdout0_49ck139 FIND v(dout0_49) AT=700.025n

* CHECK dout0_50 Vdout0_50ck139 = 0.9 time = 700
.meas tran vdout0_50ck139 FIND v(dout0_50) AT=700.025n

* CHECK dout0_51 Vdout0_51ck139 = 0.9 time = 700
.meas tran vdout0_51ck139 FIND v(dout0_51) AT=700.025n

* CHECK dout0_52 Vdout0_52ck139 = 0.9 time = 700
.meas tran vdout0_52ck139 FIND v(dout0_52) AT=700.025n

* CHECK dout0_53 Vdout0_53ck139 = 0.9 time = 700
.meas tran vdout0_53ck139 FIND v(dout0_53) AT=700.025n

* CHECK dout0_54 Vdout0_54ck139 = 0 time = 700
.meas tran vdout0_54ck139 FIND v(dout0_54) AT=700.025n

* CHECK dout0_55 Vdout0_55ck139 = 0.9 time = 700
.meas tran vdout0_55ck139 FIND v(dout0_55) AT=700.025n

* CHECK dout0_56 Vdout0_56ck139 = 0 time = 700
.meas tran vdout0_56ck139 FIND v(dout0_56) AT=700.025n

* CHECK dout0_57 Vdout0_57ck139 = 0.9 time = 700
.meas tran vdout0_57ck139 FIND v(dout0_57) AT=700.025n

* CHECK dout0_58 Vdout0_58ck139 = 0 time = 700
.meas tran vdout0_58ck139 FIND v(dout0_58) AT=700.025n

* CHECK dout0_59 Vdout0_59ck139 = 0 time = 700
.meas tran vdout0_59ck139 FIND v(dout0_59) AT=700.025n

* CHECK dout0_60 Vdout0_60ck139 = 0 time = 700
.meas tran vdout0_60ck139 FIND v(dout0_60) AT=700.025n

* CHECK dout0_61 Vdout0_61ck139 = 0.9 time = 700
.meas tran vdout0_61ck139 FIND v(dout0_61) AT=700.025n

* CHECK dout0_62 Vdout0_62ck139 = 0 time = 700
.meas tran vdout0_62ck139 FIND v(dout0_62) AT=700.025n

* CHECK dout0_63 Vdout0_63ck139 = 0.9 time = 700
.meas tran vdout0_63ck139 FIND v(dout0_63) AT=700.025n

* CHECK dout0_64 Vdout0_64ck139 = 0.9 time = 700
.meas tran vdout0_64ck139 FIND v(dout0_64) AT=700.025n

* CHECK dout0_65 Vdout0_65ck139 = 0.9 time = 700
.meas tran vdout0_65ck139 FIND v(dout0_65) AT=700.025n

* CHECK dout0_66 Vdout0_66ck139 = 0 time = 700
.meas tran vdout0_66ck139 FIND v(dout0_66) AT=700.025n

* CHECK dout0_67 Vdout0_67ck139 = 0 time = 700
.meas tran vdout0_67ck139 FIND v(dout0_67) AT=700.025n

* CHECK dout0_68 Vdout0_68ck139 = 0.9 time = 700
.meas tran vdout0_68ck139 FIND v(dout0_68) AT=700.025n

* CHECK dout0_69 Vdout0_69ck139 = 0.9 time = 700
.meas tran vdout0_69ck139 FIND v(dout0_69) AT=700.025n

* CHECK dout0_70 Vdout0_70ck139 = 0.9 time = 700
.meas tran vdout0_70ck139 FIND v(dout0_70) AT=700.025n

* CHECK dout0_71 Vdout0_71ck139 = 0 time = 700
.meas tran vdout0_71ck139 FIND v(dout0_71) AT=700.025n

* CHECK dout0_72 Vdout0_72ck139 = 0.9 time = 700
.meas tran vdout0_72ck139 FIND v(dout0_72) AT=700.025n

* CHECK dout0_73 Vdout0_73ck139 = 0 time = 700
.meas tran vdout0_73ck139 FIND v(dout0_73) AT=700.025n

* CHECK dout0_74 Vdout0_74ck139 = 0.9 time = 700
.meas tran vdout0_74ck139 FIND v(dout0_74) AT=700.025n

* CHECK dout0_75 Vdout0_75ck139 = 0.9 time = 700
.meas tran vdout0_75ck139 FIND v(dout0_75) AT=700.025n

* CHECK dout0_76 Vdout0_76ck139 = 0.9 time = 700
.meas tran vdout0_76ck139 FIND v(dout0_76) AT=700.025n

* CHECK dout0_77 Vdout0_77ck139 = 0 time = 700
.meas tran vdout0_77ck139 FIND v(dout0_77) AT=700.025n

* CHECK dout0_78 Vdout0_78ck139 = 0.9 time = 700
.meas tran vdout0_78ck139 FIND v(dout0_78) AT=700.025n

* CHECK dout0_79 Vdout0_79ck139 = 0 time = 700
.meas tran vdout0_79ck139 FIND v(dout0_79) AT=700.025n

* CHECK dout0_80 Vdout0_80ck139 = 0 time = 700
.meas tran vdout0_80ck139 FIND v(dout0_80) AT=700.025n

* CHECK dout0_81 Vdout0_81ck139 = 0.9 time = 700
.meas tran vdout0_81ck139 FIND v(dout0_81) AT=700.025n

* CHECK dout0_82 Vdout0_82ck139 = 0.9 time = 700
.meas tran vdout0_82ck139 FIND v(dout0_82) AT=700.025n

* CHECK dout0_83 Vdout0_83ck139 = 0 time = 700
.meas tran vdout0_83ck139 FIND v(dout0_83) AT=700.025n

* CHECK dout0_84 Vdout0_84ck139 = 0.9 time = 700
.meas tran vdout0_84ck139 FIND v(dout0_84) AT=700.025n

* CHECK dout0_85 Vdout0_85ck139 = 0.9 time = 700
.meas tran vdout0_85ck139 FIND v(dout0_85) AT=700.025n

* CHECK dout0_86 Vdout0_86ck139 = 0 time = 700
.meas tran vdout0_86ck139 FIND v(dout0_86) AT=700.025n

* CHECK dout0_87 Vdout0_87ck139 = 0.9 time = 700
.meas tran vdout0_87ck139 FIND v(dout0_87) AT=700.025n

* CHECK dout0_0 Vdout0_0ck141 = 0.9 time = 710
.meas tran vdout0_0ck141 FIND v(dout0_0) AT=710.025n

* CHECK dout0_1 Vdout0_1ck141 = 0.9 time = 710
.meas tran vdout0_1ck141 FIND v(dout0_1) AT=710.025n

* CHECK dout0_2 Vdout0_2ck141 = 0.9 time = 710
.meas tran vdout0_2ck141 FIND v(dout0_2) AT=710.025n

* CHECK dout0_3 Vdout0_3ck141 = 0 time = 710
.meas tran vdout0_3ck141 FIND v(dout0_3) AT=710.025n

* CHECK dout0_4 Vdout0_4ck141 = 0.9 time = 710
.meas tran vdout0_4ck141 FIND v(dout0_4) AT=710.025n

* CHECK dout0_5 Vdout0_5ck141 = 0.9 time = 710
.meas tran vdout0_5ck141 FIND v(dout0_5) AT=710.025n

* CHECK dout0_6 Vdout0_6ck141 = 0 time = 710
.meas tran vdout0_6ck141 FIND v(dout0_6) AT=710.025n

* CHECK dout0_7 Vdout0_7ck141 = 0 time = 710
.meas tran vdout0_7ck141 FIND v(dout0_7) AT=710.025n

* CHECK dout0_8 Vdout0_8ck141 = 0.9 time = 710
.meas tran vdout0_8ck141 FIND v(dout0_8) AT=710.025n

* CHECK dout0_9 Vdout0_9ck141 = 0.9 time = 710
.meas tran vdout0_9ck141 FIND v(dout0_9) AT=710.025n

* CHECK dout0_10 Vdout0_10ck141 = 0 time = 710
.meas tran vdout0_10ck141 FIND v(dout0_10) AT=710.025n

* CHECK dout0_11 Vdout0_11ck141 = 0.9 time = 710
.meas tran vdout0_11ck141 FIND v(dout0_11) AT=710.025n

* CHECK dout0_12 Vdout0_12ck141 = 0 time = 710
.meas tran vdout0_12ck141 FIND v(dout0_12) AT=710.025n

* CHECK dout0_13 Vdout0_13ck141 = 0 time = 710
.meas tran vdout0_13ck141 FIND v(dout0_13) AT=710.025n

* CHECK dout0_14 Vdout0_14ck141 = 0.9 time = 710
.meas tran vdout0_14ck141 FIND v(dout0_14) AT=710.025n

* CHECK dout0_15 Vdout0_15ck141 = 0 time = 710
.meas tran vdout0_15ck141 FIND v(dout0_15) AT=710.025n

* CHECK dout0_16 Vdout0_16ck141 = 0.9 time = 710
.meas tran vdout0_16ck141 FIND v(dout0_16) AT=710.025n

* CHECK dout0_17 Vdout0_17ck141 = 0 time = 710
.meas tran vdout0_17ck141 FIND v(dout0_17) AT=710.025n

* CHECK dout0_18 Vdout0_18ck141 = 0 time = 710
.meas tran vdout0_18ck141 FIND v(dout0_18) AT=710.025n

* CHECK dout0_19 Vdout0_19ck141 = 0 time = 710
.meas tran vdout0_19ck141 FIND v(dout0_19) AT=710.025n

* CHECK dout0_20 Vdout0_20ck141 = 0 time = 710
.meas tran vdout0_20ck141 FIND v(dout0_20) AT=710.025n

* CHECK dout0_21 Vdout0_21ck141 = 0 time = 710
.meas tran vdout0_21ck141 FIND v(dout0_21) AT=710.025n

* CHECK dout0_22 Vdout0_22ck141 = 0.9 time = 710
.meas tran vdout0_22ck141 FIND v(dout0_22) AT=710.025n

* CHECK dout0_23 Vdout0_23ck141 = 0.9 time = 710
.meas tran vdout0_23ck141 FIND v(dout0_23) AT=710.025n

* CHECK dout0_24 Vdout0_24ck141 = 0 time = 710
.meas tran vdout0_24ck141 FIND v(dout0_24) AT=710.025n

* CHECK dout0_25 Vdout0_25ck141 = 0.9 time = 710
.meas tran vdout0_25ck141 FIND v(dout0_25) AT=710.025n

* CHECK dout0_26 Vdout0_26ck141 = 0.9 time = 710
.meas tran vdout0_26ck141 FIND v(dout0_26) AT=710.025n

* CHECK dout0_27 Vdout0_27ck141 = 0.9 time = 710
.meas tran vdout0_27ck141 FIND v(dout0_27) AT=710.025n

* CHECK dout0_28 Vdout0_28ck141 = 0 time = 710
.meas tran vdout0_28ck141 FIND v(dout0_28) AT=710.025n

* CHECK dout0_29 Vdout0_29ck141 = 0 time = 710
.meas tran vdout0_29ck141 FIND v(dout0_29) AT=710.025n

* CHECK dout0_30 Vdout0_30ck141 = 0.9 time = 710
.meas tran vdout0_30ck141 FIND v(dout0_30) AT=710.025n

* CHECK dout0_31 Vdout0_31ck141 = 0 time = 710
.meas tran vdout0_31ck141 FIND v(dout0_31) AT=710.025n

* CHECK dout0_32 Vdout0_32ck141 = 0 time = 710
.meas tran vdout0_32ck141 FIND v(dout0_32) AT=710.025n

* CHECK dout0_33 Vdout0_33ck141 = 0 time = 710
.meas tran vdout0_33ck141 FIND v(dout0_33) AT=710.025n

* CHECK dout0_34 Vdout0_34ck141 = 0.9 time = 710
.meas tran vdout0_34ck141 FIND v(dout0_34) AT=710.025n

* CHECK dout0_35 Vdout0_35ck141 = 0 time = 710
.meas tran vdout0_35ck141 FIND v(dout0_35) AT=710.025n

* CHECK dout0_36 Vdout0_36ck141 = 0 time = 710
.meas tran vdout0_36ck141 FIND v(dout0_36) AT=710.025n

* CHECK dout0_37 Vdout0_37ck141 = 0.9 time = 710
.meas tran vdout0_37ck141 FIND v(dout0_37) AT=710.025n

* CHECK dout0_38 Vdout0_38ck141 = 0 time = 710
.meas tran vdout0_38ck141 FIND v(dout0_38) AT=710.025n

* CHECK dout0_39 Vdout0_39ck141 = 0.9 time = 710
.meas tran vdout0_39ck141 FIND v(dout0_39) AT=710.025n

* CHECK dout0_40 Vdout0_40ck141 = 0.9 time = 710
.meas tran vdout0_40ck141 FIND v(dout0_40) AT=710.025n

* CHECK dout0_41 Vdout0_41ck141 = 0 time = 710
.meas tran vdout0_41ck141 FIND v(dout0_41) AT=710.025n

* CHECK dout0_42 Vdout0_42ck141 = 0 time = 710
.meas tran vdout0_42ck141 FIND v(dout0_42) AT=710.025n

* CHECK dout0_43 Vdout0_43ck141 = 0.9 time = 710
.meas tran vdout0_43ck141 FIND v(dout0_43) AT=710.025n

* CHECK dout0_44 Vdout0_44ck141 = 0 time = 710
.meas tran vdout0_44ck141 FIND v(dout0_44) AT=710.025n

* CHECK dout0_45 Vdout0_45ck141 = 0.9 time = 710
.meas tran vdout0_45ck141 FIND v(dout0_45) AT=710.025n

* CHECK dout0_46 Vdout0_46ck141 = 0 time = 710
.meas tran vdout0_46ck141 FIND v(dout0_46) AT=710.025n

* CHECK dout0_47 Vdout0_47ck141 = 0.9 time = 710
.meas tran vdout0_47ck141 FIND v(dout0_47) AT=710.025n

* CHECK dout0_48 Vdout0_48ck141 = 0.9 time = 710
.meas tran vdout0_48ck141 FIND v(dout0_48) AT=710.025n

* CHECK dout0_49 Vdout0_49ck141 = 0.9 time = 710
.meas tran vdout0_49ck141 FIND v(dout0_49) AT=710.025n

* CHECK dout0_50 Vdout0_50ck141 = 0.9 time = 710
.meas tran vdout0_50ck141 FIND v(dout0_50) AT=710.025n

* CHECK dout0_51 Vdout0_51ck141 = 0.9 time = 710
.meas tran vdout0_51ck141 FIND v(dout0_51) AT=710.025n

* CHECK dout0_52 Vdout0_52ck141 = 0 time = 710
.meas tran vdout0_52ck141 FIND v(dout0_52) AT=710.025n

* CHECK dout0_53 Vdout0_53ck141 = 0 time = 710
.meas tran vdout0_53ck141 FIND v(dout0_53) AT=710.025n

* CHECK dout0_54 Vdout0_54ck141 = 0.9 time = 710
.meas tran vdout0_54ck141 FIND v(dout0_54) AT=710.025n

* CHECK dout0_55 Vdout0_55ck141 = 0 time = 710
.meas tran vdout0_55ck141 FIND v(dout0_55) AT=710.025n

* CHECK dout0_56 Vdout0_56ck141 = 0 time = 710
.meas tran vdout0_56ck141 FIND v(dout0_56) AT=710.025n

* CHECK dout0_57 Vdout0_57ck141 = 0.9 time = 710
.meas tran vdout0_57ck141 FIND v(dout0_57) AT=710.025n

* CHECK dout0_58 Vdout0_58ck141 = 0 time = 710
.meas tran vdout0_58ck141 FIND v(dout0_58) AT=710.025n

* CHECK dout0_59 Vdout0_59ck141 = 0 time = 710
.meas tran vdout0_59ck141 FIND v(dout0_59) AT=710.025n

* CHECK dout0_60 Vdout0_60ck141 = 0 time = 710
.meas tran vdout0_60ck141 FIND v(dout0_60) AT=710.025n

* CHECK dout0_61 Vdout0_61ck141 = 0.9 time = 710
.meas tran vdout0_61ck141 FIND v(dout0_61) AT=710.025n

* CHECK dout0_62 Vdout0_62ck141 = 0.9 time = 710
.meas tran vdout0_62ck141 FIND v(dout0_62) AT=710.025n

* CHECK dout0_63 Vdout0_63ck141 = 0.9 time = 710
.meas tran vdout0_63ck141 FIND v(dout0_63) AT=710.025n

* CHECK dout0_64 Vdout0_64ck141 = 0.9 time = 710
.meas tran vdout0_64ck141 FIND v(dout0_64) AT=710.025n

* CHECK dout0_65 Vdout0_65ck141 = 0.9 time = 710
.meas tran vdout0_65ck141 FIND v(dout0_65) AT=710.025n

* CHECK dout0_66 Vdout0_66ck141 = 0 time = 710
.meas tran vdout0_66ck141 FIND v(dout0_66) AT=710.025n

* CHECK dout0_67 Vdout0_67ck141 = 0.9 time = 710
.meas tran vdout0_67ck141 FIND v(dout0_67) AT=710.025n

* CHECK dout0_68 Vdout0_68ck141 = 0 time = 710
.meas tran vdout0_68ck141 FIND v(dout0_68) AT=710.025n

* CHECK dout0_69 Vdout0_69ck141 = 0.9 time = 710
.meas tran vdout0_69ck141 FIND v(dout0_69) AT=710.025n

* CHECK dout0_70 Vdout0_70ck141 = 0 time = 710
.meas tran vdout0_70ck141 FIND v(dout0_70) AT=710.025n

* CHECK dout0_71 Vdout0_71ck141 = 0 time = 710
.meas tran vdout0_71ck141 FIND v(dout0_71) AT=710.025n

* CHECK dout0_72 Vdout0_72ck141 = 0 time = 710
.meas tran vdout0_72ck141 FIND v(dout0_72) AT=710.025n

* CHECK dout0_73 Vdout0_73ck141 = 0.9 time = 710
.meas tran vdout0_73ck141 FIND v(dout0_73) AT=710.025n

* CHECK dout0_74 Vdout0_74ck141 = 0 time = 710
.meas tran vdout0_74ck141 FIND v(dout0_74) AT=710.025n

* CHECK dout0_75 Vdout0_75ck141 = 0.9 time = 710
.meas tran vdout0_75ck141 FIND v(dout0_75) AT=710.025n

* CHECK dout0_76 Vdout0_76ck141 = 0 time = 710
.meas tran vdout0_76ck141 FIND v(dout0_76) AT=710.025n

* CHECK dout0_77 Vdout0_77ck141 = 0.9 time = 710
.meas tran vdout0_77ck141 FIND v(dout0_77) AT=710.025n

* CHECK dout0_78 Vdout0_78ck141 = 0.9 time = 710
.meas tran vdout0_78ck141 FIND v(dout0_78) AT=710.025n

* CHECK dout0_79 Vdout0_79ck141 = 0 time = 710
.meas tran vdout0_79ck141 FIND v(dout0_79) AT=710.025n

* CHECK dout0_80 Vdout0_80ck141 = 0 time = 710
.meas tran vdout0_80ck141 FIND v(dout0_80) AT=710.025n

* CHECK dout0_81 Vdout0_81ck141 = 0 time = 710
.meas tran vdout0_81ck141 FIND v(dout0_81) AT=710.025n

* CHECK dout0_82 Vdout0_82ck141 = 0 time = 710
.meas tran vdout0_82ck141 FIND v(dout0_82) AT=710.025n

* CHECK dout0_83 Vdout0_83ck141 = 0.9 time = 710
.meas tran vdout0_83ck141 FIND v(dout0_83) AT=710.025n

* CHECK dout0_84 Vdout0_84ck141 = 0.9 time = 710
.meas tran vdout0_84ck141 FIND v(dout0_84) AT=710.025n

* CHECK dout0_85 Vdout0_85ck141 = 0 time = 710
.meas tran vdout0_85ck141 FIND v(dout0_85) AT=710.025n

* CHECK dout0_86 Vdout0_86ck141 = 0.9 time = 710
.meas tran vdout0_86ck141 FIND v(dout0_86) AT=710.025n

* CHECK dout0_87 Vdout0_87ck141 = 0 time = 710
.meas tran vdout0_87ck141 FIND v(dout0_87) AT=710.025n

* CHECK dout0_0 Vdout0_0ck143 = 0.9 time = 720
.meas tran vdout0_0ck143 FIND v(dout0_0) AT=720.025n

* CHECK dout0_1 Vdout0_1ck143 = 0 time = 720
.meas tran vdout0_1ck143 FIND v(dout0_1) AT=720.025n

* CHECK dout0_2 Vdout0_2ck143 = 0 time = 720
.meas tran vdout0_2ck143 FIND v(dout0_2) AT=720.025n

* CHECK dout0_3 Vdout0_3ck143 = 0 time = 720
.meas tran vdout0_3ck143 FIND v(dout0_3) AT=720.025n

* CHECK dout0_4 Vdout0_4ck143 = 0 time = 720
.meas tran vdout0_4ck143 FIND v(dout0_4) AT=720.025n

* CHECK dout0_5 Vdout0_5ck143 = 0 time = 720
.meas tran vdout0_5ck143 FIND v(dout0_5) AT=720.025n

* CHECK dout0_6 Vdout0_6ck143 = 0.9 time = 720
.meas tran vdout0_6ck143 FIND v(dout0_6) AT=720.025n

* CHECK dout0_7 Vdout0_7ck143 = 0.9 time = 720
.meas tran vdout0_7ck143 FIND v(dout0_7) AT=720.025n

* CHECK dout0_8 Vdout0_8ck143 = 0.9 time = 720
.meas tran vdout0_8ck143 FIND v(dout0_8) AT=720.025n

* CHECK dout0_9 Vdout0_9ck143 = 0 time = 720
.meas tran vdout0_9ck143 FIND v(dout0_9) AT=720.025n

* CHECK dout0_10 Vdout0_10ck143 = 0 time = 720
.meas tran vdout0_10ck143 FIND v(dout0_10) AT=720.025n

* CHECK dout0_11 Vdout0_11ck143 = 0 time = 720
.meas tran vdout0_11ck143 FIND v(dout0_11) AT=720.025n

* CHECK dout0_12 Vdout0_12ck143 = 0.9 time = 720
.meas tran vdout0_12ck143 FIND v(dout0_12) AT=720.025n

* CHECK dout0_13 Vdout0_13ck143 = 0.9 time = 720
.meas tran vdout0_13ck143 FIND v(dout0_13) AT=720.025n

* CHECK dout0_14 Vdout0_14ck143 = 0 time = 720
.meas tran vdout0_14ck143 FIND v(dout0_14) AT=720.025n

* CHECK dout0_15 Vdout0_15ck143 = 0.9 time = 720
.meas tran vdout0_15ck143 FIND v(dout0_15) AT=720.025n

* CHECK dout0_16 Vdout0_16ck143 = 0 time = 720
.meas tran vdout0_16ck143 FIND v(dout0_16) AT=720.025n

* CHECK dout0_17 Vdout0_17ck143 = 0 time = 720
.meas tran vdout0_17ck143 FIND v(dout0_17) AT=720.025n

* CHECK dout0_18 Vdout0_18ck143 = 0 time = 720
.meas tran vdout0_18ck143 FIND v(dout0_18) AT=720.025n

* CHECK dout0_19 Vdout0_19ck143 = 0 time = 720
.meas tran vdout0_19ck143 FIND v(dout0_19) AT=720.025n

* CHECK dout0_20 Vdout0_20ck143 = 0 time = 720
.meas tran vdout0_20ck143 FIND v(dout0_20) AT=720.025n

* CHECK dout0_21 Vdout0_21ck143 = 0 time = 720
.meas tran vdout0_21ck143 FIND v(dout0_21) AT=720.025n

* CHECK dout0_22 Vdout0_22ck143 = 0 time = 720
.meas tran vdout0_22ck143 FIND v(dout0_22) AT=720.025n

* CHECK dout0_23 Vdout0_23ck143 = 0.9 time = 720
.meas tran vdout0_23ck143 FIND v(dout0_23) AT=720.025n

* CHECK dout0_24 Vdout0_24ck143 = 0.9 time = 720
.meas tran vdout0_24ck143 FIND v(dout0_24) AT=720.025n

* CHECK dout0_25 Vdout0_25ck143 = 0.9 time = 720
.meas tran vdout0_25ck143 FIND v(dout0_25) AT=720.025n

* CHECK dout0_26 Vdout0_26ck143 = 0 time = 720
.meas tran vdout0_26ck143 FIND v(dout0_26) AT=720.025n

* CHECK dout0_27 Vdout0_27ck143 = 0.9 time = 720
.meas tran vdout0_27ck143 FIND v(dout0_27) AT=720.025n

* CHECK dout0_28 Vdout0_28ck143 = 0 time = 720
.meas tran vdout0_28ck143 FIND v(dout0_28) AT=720.025n

* CHECK dout0_29 Vdout0_29ck143 = 0 time = 720
.meas tran vdout0_29ck143 FIND v(dout0_29) AT=720.025n

* CHECK dout0_30 Vdout0_30ck143 = 0.9 time = 720
.meas tran vdout0_30ck143 FIND v(dout0_30) AT=720.025n

* CHECK dout0_31 Vdout0_31ck143 = 0 time = 720
.meas tran vdout0_31ck143 FIND v(dout0_31) AT=720.025n

* CHECK dout0_32 Vdout0_32ck143 = 0 time = 720
.meas tran vdout0_32ck143 FIND v(dout0_32) AT=720.025n

* CHECK dout0_33 Vdout0_33ck143 = 0.9 time = 720
.meas tran vdout0_33ck143 FIND v(dout0_33) AT=720.025n

* CHECK dout0_34 Vdout0_34ck143 = 0.9 time = 720
.meas tran vdout0_34ck143 FIND v(dout0_34) AT=720.025n

* CHECK dout0_35 Vdout0_35ck143 = 0.9 time = 720
.meas tran vdout0_35ck143 FIND v(dout0_35) AT=720.025n

* CHECK dout0_36 Vdout0_36ck143 = 0 time = 720
.meas tran vdout0_36ck143 FIND v(dout0_36) AT=720.025n

* CHECK dout0_37 Vdout0_37ck143 = 0.9 time = 720
.meas tran vdout0_37ck143 FIND v(dout0_37) AT=720.025n

* CHECK dout0_38 Vdout0_38ck143 = 0 time = 720
.meas tran vdout0_38ck143 FIND v(dout0_38) AT=720.025n

* CHECK dout0_39 Vdout0_39ck143 = 0 time = 720
.meas tran vdout0_39ck143 FIND v(dout0_39) AT=720.025n

* CHECK dout0_40 Vdout0_40ck143 = 0.9 time = 720
.meas tran vdout0_40ck143 FIND v(dout0_40) AT=720.025n

* CHECK dout0_41 Vdout0_41ck143 = 0 time = 720
.meas tran vdout0_41ck143 FIND v(dout0_41) AT=720.025n

* CHECK dout0_42 Vdout0_42ck143 = 0.9 time = 720
.meas tran vdout0_42ck143 FIND v(dout0_42) AT=720.025n

* CHECK dout0_43 Vdout0_43ck143 = 0 time = 720
.meas tran vdout0_43ck143 FIND v(dout0_43) AT=720.025n

* CHECK dout0_44 Vdout0_44ck143 = 0 time = 720
.meas tran vdout0_44ck143 FIND v(dout0_44) AT=720.025n

* CHECK dout0_45 Vdout0_45ck143 = 0 time = 720
.meas tran vdout0_45ck143 FIND v(dout0_45) AT=720.025n

* CHECK dout0_46 Vdout0_46ck143 = 0 time = 720
.meas tran vdout0_46ck143 FIND v(dout0_46) AT=720.025n

* CHECK dout0_47 Vdout0_47ck143 = 0 time = 720
.meas tran vdout0_47ck143 FIND v(dout0_47) AT=720.025n

* CHECK dout0_48 Vdout0_48ck143 = 0 time = 720
.meas tran vdout0_48ck143 FIND v(dout0_48) AT=720.025n

* CHECK dout0_49 Vdout0_49ck143 = 0 time = 720
.meas tran vdout0_49ck143 FIND v(dout0_49) AT=720.025n

* CHECK dout0_50 Vdout0_50ck143 = 0 time = 720
.meas tran vdout0_50ck143 FIND v(dout0_50) AT=720.025n

* CHECK dout0_51 Vdout0_51ck143 = 0.9 time = 720
.meas tran vdout0_51ck143 FIND v(dout0_51) AT=720.025n

* CHECK dout0_52 Vdout0_52ck143 = 0 time = 720
.meas tran vdout0_52ck143 FIND v(dout0_52) AT=720.025n

* CHECK dout0_53 Vdout0_53ck143 = 0.9 time = 720
.meas tran vdout0_53ck143 FIND v(dout0_53) AT=720.025n

* CHECK dout0_54 Vdout0_54ck143 = 0 time = 720
.meas tran vdout0_54ck143 FIND v(dout0_54) AT=720.025n

* CHECK dout0_55 Vdout0_55ck143 = 0.9 time = 720
.meas tran vdout0_55ck143 FIND v(dout0_55) AT=720.025n

* CHECK dout0_56 Vdout0_56ck143 = 0 time = 720
.meas tran vdout0_56ck143 FIND v(dout0_56) AT=720.025n

* CHECK dout0_57 Vdout0_57ck143 = 0 time = 720
.meas tran vdout0_57ck143 FIND v(dout0_57) AT=720.025n

* CHECK dout0_58 Vdout0_58ck143 = 0.9 time = 720
.meas tran vdout0_58ck143 FIND v(dout0_58) AT=720.025n

* CHECK dout0_59 Vdout0_59ck143 = 0.9 time = 720
.meas tran vdout0_59ck143 FIND v(dout0_59) AT=720.025n

* CHECK dout0_60 Vdout0_60ck143 = 0 time = 720
.meas tran vdout0_60ck143 FIND v(dout0_60) AT=720.025n

* CHECK dout0_61 Vdout0_61ck143 = 0.9 time = 720
.meas tran vdout0_61ck143 FIND v(dout0_61) AT=720.025n

* CHECK dout0_62 Vdout0_62ck143 = 0 time = 720
.meas tran vdout0_62ck143 FIND v(dout0_62) AT=720.025n

* CHECK dout0_63 Vdout0_63ck143 = 0 time = 720
.meas tran vdout0_63ck143 FIND v(dout0_63) AT=720.025n

* CHECK dout0_64 Vdout0_64ck143 = 0.9 time = 720
.meas tran vdout0_64ck143 FIND v(dout0_64) AT=720.025n

* CHECK dout0_65 Vdout0_65ck143 = 0 time = 720
.meas tran vdout0_65ck143 FIND v(dout0_65) AT=720.025n

* CHECK dout0_66 Vdout0_66ck143 = 0 time = 720
.meas tran vdout0_66ck143 FIND v(dout0_66) AT=720.025n

* CHECK dout0_67 Vdout0_67ck143 = 0 time = 720
.meas tran vdout0_67ck143 FIND v(dout0_67) AT=720.025n

* CHECK dout0_68 Vdout0_68ck143 = 0.9 time = 720
.meas tran vdout0_68ck143 FIND v(dout0_68) AT=720.025n

* CHECK dout0_69 Vdout0_69ck143 = 0 time = 720
.meas tran vdout0_69ck143 FIND v(dout0_69) AT=720.025n

* CHECK dout0_70 Vdout0_70ck143 = 0.9 time = 720
.meas tran vdout0_70ck143 FIND v(dout0_70) AT=720.025n

* CHECK dout0_71 Vdout0_71ck143 = 0.9 time = 720
.meas tran vdout0_71ck143 FIND v(dout0_71) AT=720.025n

* CHECK dout0_72 Vdout0_72ck143 = 0 time = 720
.meas tran vdout0_72ck143 FIND v(dout0_72) AT=720.025n

* CHECK dout0_73 Vdout0_73ck143 = 0 time = 720
.meas tran vdout0_73ck143 FIND v(dout0_73) AT=720.025n

* CHECK dout0_74 Vdout0_74ck143 = 0.9 time = 720
.meas tran vdout0_74ck143 FIND v(dout0_74) AT=720.025n

* CHECK dout0_75 Vdout0_75ck143 = 0 time = 720
.meas tran vdout0_75ck143 FIND v(dout0_75) AT=720.025n

* CHECK dout0_76 Vdout0_76ck143 = 0.9 time = 720
.meas tran vdout0_76ck143 FIND v(dout0_76) AT=720.025n

* CHECK dout0_77 Vdout0_77ck143 = 0 time = 720
.meas tran vdout0_77ck143 FIND v(dout0_77) AT=720.025n

* CHECK dout0_78 Vdout0_78ck143 = 0.9 time = 720
.meas tran vdout0_78ck143 FIND v(dout0_78) AT=720.025n

* CHECK dout0_79 Vdout0_79ck143 = 0 time = 720
.meas tran vdout0_79ck143 FIND v(dout0_79) AT=720.025n

* CHECK dout0_80 Vdout0_80ck143 = 0 time = 720
.meas tran vdout0_80ck143 FIND v(dout0_80) AT=720.025n

* CHECK dout0_81 Vdout0_81ck143 = 0 time = 720
.meas tran vdout0_81ck143 FIND v(dout0_81) AT=720.025n

* CHECK dout0_82 Vdout0_82ck143 = 0 time = 720
.meas tran vdout0_82ck143 FIND v(dout0_82) AT=720.025n

* CHECK dout0_83 Vdout0_83ck143 = 0.9 time = 720
.meas tran vdout0_83ck143 FIND v(dout0_83) AT=720.025n

* CHECK dout0_84 Vdout0_84ck143 = 0.9 time = 720
.meas tran vdout0_84ck143 FIND v(dout0_84) AT=720.025n

* CHECK dout0_85 Vdout0_85ck143 = 0 time = 720
.meas tran vdout0_85ck143 FIND v(dout0_85) AT=720.025n

* CHECK dout0_86 Vdout0_86ck143 = 0.9 time = 720
.meas tran vdout0_86ck143 FIND v(dout0_86) AT=720.025n

* CHECK dout0_87 Vdout0_87ck143 = 0.9 time = 720
.meas tran vdout0_87ck143 FIND v(dout0_87) AT=720.025n

* CHECK dout0_0 Vdout0_0ck144 = 0.9 time = 725
.meas tran vdout0_0ck144 FIND v(dout0_0) AT=725.025n

* CHECK dout0_1 Vdout0_1ck144 = 0 time = 725
.meas tran vdout0_1ck144 FIND v(dout0_1) AT=725.025n

* CHECK dout0_2 Vdout0_2ck144 = 0 time = 725
.meas tran vdout0_2ck144 FIND v(dout0_2) AT=725.025n

* CHECK dout0_3 Vdout0_3ck144 = 0 time = 725
.meas tran vdout0_3ck144 FIND v(dout0_3) AT=725.025n

* CHECK dout0_4 Vdout0_4ck144 = 0 time = 725
.meas tran vdout0_4ck144 FIND v(dout0_4) AT=725.025n

* CHECK dout0_5 Vdout0_5ck144 = 0 time = 725
.meas tran vdout0_5ck144 FIND v(dout0_5) AT=725.025n

* CHECK dout0_6 Vdout0_6ck144 = 0.9 time = 725
.meas tran vdout0_6ck144 FIND v(dout0_6) AT=725.025n

* CHECK dout0_7 Vdout0_7ck144 = 0.9 time = 725
.meas tran vdout0_7ck144 FIND v(dout0_7) AT=725.025n

* CHECK dout0_8 Vdout0_8ck144 = 0.9 time = 725
.meas tran vdout0_8ck144 FIND v(dout0_8) AT=725.025n

* CHECK dout0_9 Vdout0_9ck144 = 0 time = 725
.meas tran vdout0_9ck144 FIND v(dout0_9) AT=725.025n

* CHECK dout0_10 Vdout0_10ck144 = 0 time = 725
.meas tran vdout0_10ck144 FIND v(dout0_10) AT=725.025n

* CHECK dout0_11 Vdout0_11ck144 = 0 time = 725
.meas tran vdout0_11ck144 FIND v(dout0_11) AT=725.025n

* CHECK dout0_12 Vdout0_12ck144 = 0.9 time = 725
.meas tran vdout0_12ck144 FIND v(dout0_12) AT=725.025n

* CHECK dout0_13 Vdout0_13ck144 = 0.9 time = 725
.meas tran vdout0_13ck144 FIND v(dout0_13) AT=725.025n

* CHECK dout0_14 Vdout0_14ck144 = 0 time = 725
.meas tran vdout0_14ck144 FIND v(dout0_14) AT=725.025n

* CHECK dout0_15 Vdout0_15ck144 = 0.9 time = 725
.meas tran vdout0_15ck144 FIND v(dout0_15) AT=725.025n

* CHECK dout0_16 Vdout0_16ck144 = 0 time = 725
.meas tran vdout0_16ck144 FIND v(dout0_16) AT=725.025n

* CHECK dout0_17 Vdout0_17ck144 = 0 time = 725
.meas tran vdout0_17ck144 FIND v(dout0_17) AT=725.025n

* CHECK dout0_18 Vdout0_18ck144 = 0 time = 725
.meas tran vdout0_18ck144 FIND v(dout0_18) AT=725.025n

* CHECK dout0_19 Vdout0_19ck144 = 0 time = 725
.meas tran vdout0_19ck144 FIND v(dout0_19) AT=725.025n

* CHECK dout0_20 Vdout0_20ck144 = 0 time = 725
.meas tran vdout0_20ck144 FIND v(dout0_20) AT=725.025n

* CHECK dout0_21 Vdout0_21ck144 = 0 time = 725
.meas tran vdout0_21ck144 FIND v(dout0_21) AT=725.025n

* CHECK dout0_22 Vdout0_22ck144 = 0 time = 725
.meas tran vdout0_22ck144 FIND v(dout0_22) AT=725.025n

* CHECK dout0_23 Vdout0_23ck144 = 0.9 time = 725
.meas tran vdout0_23ck144 FIND v(dout0_23) AT=725.025n

* CHECK dout0_24 Vdout0_24ck144 = 0.9 time = 725
.meas tran vdout0_24ck144 FIND v(dout0_24) AT=725.025n

* CHECK dout0_25 Vdout0_25ck144 = 0.9 time = 725
.meas tran vdout0_25ck144 FIND v(dout0_25) AT=725.025n

* CHECK dout0_26 Vdout0_26ck144 = 0 time = 725
.meas tran vdout0_26ck144 FIND v(dout0_26) AT=725.025n

* CHECK dout0_27 Vdout0_27ck144 = 0.9 time = 725
.meas tran vdout0_27ck144 FIND v(dout0_27) AT=725.025n

* CHECK dout0_28 Vdout0_28ck144 = 0 time = 725
.meas tran vdout0_28ck144 FIND v(dout0_28) AT=725.025n

* CHECK dout0_29 Vdout0_29ck144 = 0 time = 725
.meas tran vdout0_29ck144 FIND v(dout0_29) AT=725.025n

* CHECK dout0_30 Vdout0_30ck144 = 0.9 time = 725
.meas tran vdout0_30ck144 FIND v(dout0_30) AT=725.025n

* CHECK dout0_31 Vdout0_31ck144 = 0 time = 725
.meas tran vdout0_31ck144 FIND v(dout0_31) AT=725.025n

* CHECK dout0_32 Vdout0_32ck144 = 0 time = 725
.meas tran vdout0_32ck144 FIND v(dout0_32) AT=725.025n

* CHECK dout0_33 Vdout0_33ck144 = 0.9 time = 725
.meas tran vdout0_33ck144 FIND v(dout0_33) AT=725.025n

* CHECK dout0_34 Vdout0_34ck144 = 0.9 time = 725
.meas tran vdout0_34ck144 FIND v(dout0_34) AT=725.025n

* CHECK dout0_35 Vdout0_35ck144 = 0.9 time = 725
.meas tran vdout0_35ck144 FIND v(dout0_35) AT=725.025n

* CHECK dout0_36 Vdout0_36ck144 = 0 time = 725
.meas tran vdout0_36ck144 FIND v(dout0_36) AT=725.025n

* CHECK dout0_37 Vdout0_37ck144 = 0.9 time = 725
.meas tran vdout0_37ck144 FIND v(dout0_37) AT=725.025n

* CHECK dout0_38 Vdout0_38ck144 = 0 time = 725
.meas tran vdout0_38ck144 FIND v(dout0_38) AT=725.025n

* CHECK dout0_39 Vdout0_39ck144 = 0 time = 725
.meas tran vdout0_39ck144 FIND v(dout0_39) AT=725.025n

* CHECK dout0_40 Vdout0_40ck144 = 0.9 time = 725
.meas tran vdout0_40ck144 FIND v(dout0_40) AT=725.025n

* CHECK dout0_41 Vdout0_41ck144 = 0 time = 725
.meas tran vdout0_41ck144 FIND v(dout0_41) AT=725.025n

* CHECK dout0_42 Vdout0_42ck144 = 0.9 time = 725
.meas tran vdout0_42ck144 FIND v(dout0_42) AT=725.025n

* CHECK dout0_43 Vdout0_43ck144 = 0 time = 725
.meas tran vdout0_43ck144 FIND v(dout0_43) AT=725.025n

* CHECK dout0_44 Vdout0_44ck144 = 0 time = 725
.meas tran vdout0_44ck144 FIND v(dout0_44) AT=725.025n

* CHECK dout0_45 Vdout0_45ck144 = 0 time = 725
.meas tran vdout0_45ck144 FIND v(dout0_45) AT=725.025n

* CHECK dout0_46 Vdout0_46ck144 = 0 time = 725
.meas tran vdout0_46ck144 FIND v(dout0_46) AT=725.025n

* CHECK dout0_47 Vdout0_47ck144 = 0 time = 725
.meas tran vdout0_47ck144 FIND v(dout0_47) AT=725.025n

* CHECK dout0_48 Vdout0_48ck144 = 0 time = 725
.meas tran vdout0_48ck144 FIND v(dout0_48) AT=725.025n

* CHECK dout0_49 Vdout0_49ck144 = 0 time = 725
.meas tran vdout0_49ck144 FIND v(dout0_49) AT=725.025n

* CHECK dout0_50 Vdout0_50ck144 = 0 time = 725
.meas tran vdout0_50ck144 FIND v(dout0_50) AT=725.025n

* CHECK dout0_51 Vdout0_51ck144 = 0.9 time = 725
.meas tran vdout0_51ck144 FIND v(dout0_51) AT=725.025n

* CHECK dout0_52 Vdout0_52ck144 = 0 time = 725
.meas tran vdout0_52ck144 FIND v(dout0_52) AT=725.025n

* CHECK dout0_53 Vdout0_53ck144 = 0.9 time = 725
.meas tran vdout0_53ck144 FIND v(dout0_53) AT=725.025n

* CHECK dout0_54 Vdout0_54ck144 = 0 time = 725
.meas tran vdout0_54ck144 FIND v(dout0_54) AT=725.025n

* CHECK dout0_55 Vdout0_55ck144 = 0.9 time = 725
.meas tran vdout0_55ck144 FIND v(dout0_55) AT=725.025n

* CHECK dout0_56 Vdout0_56ck144 = 0 time = 725
.meas tran vdout0_56ck144 FIND v(dout0_56) AT=725.025n

* CHECK dout0_57 Vdout0_57ck144 = 0 time = 725
.meas tran vdout0_57ck144 FIND v(dout0_57) AT=725.025n

* CHECK dout0_58 Vdout0_58ck144 = 0.9 time = 725
.meas tran vdout0_58ck144 FIND v(dout0_58) AT=725.025n

* CHECK dout0_59 Vdout0_59ck144 = 0.9 time = 725
.meas tran vdout0_59ck144 FIND v(dout0_59) AT=725.025n

* CHECK dout0_60 Vdout0_60ck144 = 0 time = 725
.meas tran vdout0_60ck144 FIND v(dout0_60) AT=725.025n

* CHECK dout0_61 Vdout0_61ck144 = 0.9 time = 725
.meas tran vdout0_61ck144 FIND v(dout0_61) AT=725.025n

* CHECK dout0_62 Vdout0_62ck144 = 0 time = 725
.meas tran vdout0_62ck144 FIND v(dout0_62) AT=725.025n

* CHECK dout0_63 Vdout0_63ck144 = 0 time = 725
.meas tran vdout0_63ck144 FIND v(dout0_63) AT=725.025n

* CHECK dout0_64 Vdout0_64ck144 = 0.9 time = 725
.meas tran vdout0_64ck144 FIND v(dout0_64) AT=725.025n

* CHECK dout0_65 Vdout0_65ck144 = 0 time = 725
.meas tran vdout0_65ck144 FIND v(dout0_65) AT=725.025n

* CHECK dout0_66 Vdout0_66ck144 = 0 time = 725
.meas tran vdout0_66ck144 FIND v(dout0_66) AT=725.025n

* CHECK dout0_67 Vdout0_67ck144 = 0 time = 725
.meas tran vdout0_67ck144 FIND v(dout0_67) AT=725.025n

* CHECK dout0_68 Vdout0_68ck144 = 0.9 time = 725
.meas tran vdout0_68ck144 FIND v(dout0_68) AT=725.025n

* CHECK dout0_69 Vdout0_69ck144 = 0 time = 725
.meas tran vdout0_69ck144 FIND v(dout0_69) AT=725.025n

* CHECK dout0_70 Vdout0_70ck144 = 0.9 time = 725
.meas tran vdout0_70ck144 FIND v(dout0_70) AT=725.025n

* CHECK dout0_71 Vdout0_71ck144 = 0.9 time = 725
.meas tran vdout0_71ck144 FIND v(dout0_71) AT=725.025n

* CHECK dout0_72 Vdout0_72ck144 = 0 time = 725
.meas tran vdout0_72ck144 FIND v(dout0_72) AT=725.025n

* CHECK dout0_73 Vdout0_73ck144 = 0 time = 725
.meas tran vdout0_73ck144 FIND v(dout0_73) AT=725.025n

* CHECK dout0_74 Vdout0_74ck144 = 0.9 time = 725
.meas tran vdout0_74ck144 FIND v(dout0_74) AT=725.025n

* CHECK dout0_75 Vdout0_75ck144 = 0 time = 725
.meas tran vdout0_75ck144 FIND v(dout0_75) AT=725.025n

* CHECK dout0_76 Vdout0_76ck144 = 0.9 time = 725
.meas tran vdout0_76ck144 FIND v(dout0_76) AT=725.025n

* CHECK dout0_77 Vdout0_77ck144 = 0 time = 725
.meas tran vdout0_77ck144 FIND v(dout0_77) AT=725.025n

* CHECK dout0_78 Vdout0_78ck144 = 0.9 time = 725
.meas tran vdout0_78ck144 FIND v(dout0_78) AT=725.025n

* CHECK dout0_79 Vdout0_79ck144 = 0 time = 725
.meas tran vdout0_79ck144 FIND v(dout0_79) AT=725.025n

* CHECK dout0_80 Vdout0_80ck144 = 0 time = 725
.meas tran vdout0_80ck144 FIND v(dout0_80) AT=725.025n

* CHECK dout0_81 Vdout0_81ck144 = 0 time = 725
.meas tran vdout0_81ck144 FIND v(dout0_81) AT=725.025n

* CHECK dout0_82 Vdout0_82ck144 = 0 time = 725
.meas tran vdout0_82ck144 FIND v(dout0_82) AT=725.025n

* CHECK dout0_83 Vdout0_83ck144 = 0.9 time = 725
.meas tran vdout0_83ck144 FIND v(dout0_83) AT=725.025n

* CHECK dout0_84 Vdout0_84ck144 = 0.9 time = 725
.meas tran vdout0_84ck144 FIND v(dout0_84) AT=725.025n

* CHECK dout0_85 Vdout0_85ck144 = 0 time = 725
.meas tran vdout0_85ck144 FIND v(dout0_85) AT=725.025n

* CHECK dout0_86 Vdout0_86ck144 = 0.9 time = 725
.meas tran vdout0_86ck144 FIND v(dout0_86) AT=725.025n

* CHECK dout0_87 Vdout0_87ck144 = 0.9 time = 725
.meas tran vdout0_87ck144 FIND v(dout0_87) AT=725.025n

* CHECK dout0_0 Vdout0_0ck153 = 0.9 time = 770
.meas tran vdout0_0ck153 FIND v(dout0_0) AT=770.025n

* CHECK dout0_1 Vdout0_1ck153 = 0 time = 770
.meas tran vdout0_1ck153 FIND v(dout0_1) AT=770.025n

* CHECK dout0_2 Vdout0_2ck153 = 0 time = 770
.meas tran vdout0_2ck153 FIND v(dout0_2) AT=770.025n

* CHECK dout0_3 Vdout0_3ck153 = 0.9 time = 770
.meas tran vdout0_3ck153 FIND v(dout0_3) AT=770.025n

* CHECK dout0_4 Vdout0_4ck153 = 0.9 time = 770
.meas tran vdout0_4ck153 FIND v(dout0_4) AT=770.025n

* CHECK dout0_5 Vdout0_5ck153 = 0 time = 770
.meas tran vdout0_5ck153 FIND v(dout0_5) AT=770.025n

* CHECK dout0_6 Vdout0_6ck153 = 0.9 time = 770
.meas tran vdout0_6ck153 FIND v(dout0_6) AT=770.025n

* CHECK dout0_7 Vdout0_7ck153 = 0 time = 770
.meas tran vdout0_7ck153 FIND v(dout0_7) AT=770.025n

* CHECK dout0_8 Vdout0_8ck153 = 0.9 time = 770
.meas tran vdout0_8ck153 FIND v(dout0_8) AT=770.025n

* CHECK dout0_9 Vdout0_9ck153 = 0 time = 770
.meas tran vdout0_9ck153 FIND v(dout0_9) AT=770.025n

* CHECK dout0_10 Vdout0_10ck153 = 0.9 time = 770
.meas tran vdout0_10ck153 FIND v(dout0_10) AT=770.025n

* CHECK dout0_11 Vdout0_11ck153 = 0 time = 770
.meas tran vdout0_11ck153 FIND v(dout0_11) AT=770.025n

* CHECK dout0_12 Vdout0_12ck153 = 0 time = 770
.meas tran vdout0_12ck153 FIND v(dout0_12) AT=770.025n

* CHECK dout0_13 Vdout0_13ck153 = 0 time = 770
.meas tran vdout0_13ck153 FIND v(dout0_13) AT=770.025n

* CHECK dout0_14 Vdout0_14ck153 = 0.9 time = 770
.meas tran vdout0_14ck153 FIND v(dout0_14) AT=770.025n

* CHECK dout0_15 Vdout0_15ck153 = 0 time = 770
.meas tran vdout0_15ck153 FIND v(dout0_15) AT=770.025n

* CHECK dout0_16 Vdout0_16ck153 = 0 time = 770
.meas tran vdout0_16ck153 FIND v(dout0_16) AT=770.025n

* CHECK dout0_17 Vdout0_17ck153 = 0 time = 770
.meas tran vdout0_17ck153 FIND v(dout0_17) AT=770.025n

* CHECK dout0_18 Vdout0_18ck153 = 0.9 time = 770
.meas tran vdout0_18ck153 FIND v(dout0_18) AT=770.025n

* CHECK dout0_19 Vdout0_19ck153 = 0.9 time = 770
.meas tran vdout0_19ck153 FIND v(dout0_19) AT=770.025n

* CHECK dout0_20 Vdout0_20ck153 = 0 time = 770
.meas tran vdout0_20ck153 FIND v(dout0_20) AT=770.025n

* CHECK dout0_21 Vdout0_21ck153 = 0.9 time = 770
.meas tran vdout0_21ck153 FIND v(dout0_21) AT=770.025n

* CHECK dout0_22 Vdout0_22ck153 = 0.9 time = 770
.meas tran vdout0_22ck153 FIND v(dout0_22) AT=770.025n

* CHECK dout0_23 Vdout0_23ck153 = 0 time = 770
.meas tran vdout0_23ck153 FIND v(dout0_23) AT=770.025n

* CHECK dout0_24 Vdout0_24ck153 = 0 time = 770
.meas tran vdout0_24ck153 FIND v(dout0_24) AT=770.025n

* CHECK dout0_25 Vdout0_25ck153 = 0 time = 770
.meas tran vdout0_25ck153 FIND v(dout0_25) AT=770.025n

* CHECK dout0_26 Vdout0_26ck153 = 0 time = 770
.meas tran vdout0_26ck153 FIND v(dout0_26) AT=770.025n

* CHECK dout0_27 Vdout0_27ck153 = 0.9 time = 770
.meas tran vdout0_27ck153 FIND v(dout0_27) AT=770.025n

* CHECK dout0_28 Vdout0_28ck153 = 0.9 time = 770
.meas tran vdout0_28ck153 FIND v(dout0_28) AT=770.025n

* CHECK dout0_29 Vdout0_29ck153 = 0.9 time = 770
.meas tran vdout0_29ck153 FIND v(dout0_29) AT=770.025n

* CHECK dout0_30 Vdout0_30ck153 = 0.9 time = 770
.meas tran vdout0_30ck153 FIND v(dout0_30) AT=770.025n

* CHECK dout0_31 Vdout0_31ck153 = 0.9 time = 770
.meas tran vdout0_31ck153 FIND v(dout0_31) AT=770.025n

* CHECK dout0_32 Vdout0_32ck153 = 0.9 time = 770
.meas tran vdout0_32ck153 FIND v(dout0_32) AT=770.025n

* CHECK dout0_33 Vdout0_33ck153 = 0 time = 770
.meas tran vdout0_33ck153 FIND v(dout0_33) AT=770.025n

* CHECK dout0_34 Vdout0_34ck153 = 0 time = 770
.meas tran vdout0_34ck153 FIND v(dout0_34) AT=770.025n

* CHECK dout0_35 Vdout0_35ck153 = 0.9 time = 770
.meas tran vdout0_35ck153 FIND v(dout0_35) AT=770.025n

* CHECK dout0_36 Vdout0_36ck153 = 0 time = 770
.meas tran vdout0_36ck153 FIND v(dout0_36) AT=770.025n

* CHECK dout0_37 Vdout0_37ck153 = 0 time = 770
.meas tran vdout0_37ck153 FIND v(dout0_37) AT=770.025n

* CHECK dout0_38 Vdout0_38ck153 = 0.9 time = 770
.meas tran vdout0_38ck153 FIND v(dout0_38) AT=770.025n

* CHECK dout0_39 Vdout0_39ck153 = 0.9 time = 770
.meas tran vdout0_39ck153 FIND v(dout0_39) AT=770.025n

* CHECK dout0_40 Vdout0_40ck153 = 0 time = 770
.meas tran vdout0_40ck153 FIND v(dout0_40) AT=770.025n

* CHECK dout0_41 Vdout0_41ck153 = 0 time = 770
.meas tran vdout0_41ck153 FIND v(dout0_41) AT=770.025n

* CHECK dout0_42 Vdout0_42ck153 = 0.9 time = 770
.meas tran vdout0_42ck153 FIND v(dout0_42) AT=770.025n

* CHECK dout0_43 Vdout0_43ck153 = 0 time = 770
.meas tran vdout0_43ck153 FIND v(dout0_43) AT=770.025n

* CHECK dout0_44 Vdout0_44ck153 = 0.9 time = 770
.meas tran vdout0_44ck153 FIND v(dout0_44) AT=770.025n

* CHECK dout0_45 Vdout0_45ck153 = 0.9 time = 770
.meas tran vdout0_45ck153 FIND v(dout0_45) AT=770.025n

* CHECK dout0_46 Vdout0_46ck153 = 0.9 time = 770
.meas tran vdout0_46ck153 FIND v(dout0_46) AT=770.025n

* CHECK dout0_47 Vdout0_47ck153 = 0 time = 770
.meas tran vdout0_47ck153 FIND v(dout0_47) AT=770.025n

* CHECK dout0_48 Vdout0_48ck153 = 0.9 time = 770
.meas tran vdout0_48ck153 FIND v(dout0_48) AT=770.025n

* CHECK dout0_49 Vdout0_49ck153 = 0 time = 770
.meas tran vdout0_49ck153 FIND v(dout0_49) AT=770.025n

* CHECK dout0_50 Vdout0_50ck153 = 0 time = 770
.meas tran vdout0_50ck153 FIND v(dout0_50) AT=770.025n

* CHECK dout0_51 Vdout0_51ck153 = 0 time = 770
.meas tran vdout0_51ck153 FIND v(dout0_51) AT=770.025n

* CHECK dout0_52 Vdout0_52ck153 = 0.9 time = 770
.meas tran vdout0_52ck153 FIND v(dout0_52) AT=770.025n

* CHECK dout0_53 Vdout0_53ck153 = 0.9 time = 770
.meas tran vdout0_53ck153 FIND v(dout0_53) AT=770.025n

* CHECK dout0_54 Vdout0_54ck153 = 0.9 time = 770
.meas tran vdout0_54ck153 FIND v(dout0_54) AT=770.025n

* CHECK dout0_55 Vdout0_55ck153 = 0 time = 770
.meas tran vdout0_55ck153 FIND v(dout0_55) AT=770.025n

* CHECK dout0_56 Vdout0_56ck153 = 0 time = 770
.meas tran vdout0_56ck153 FIND v(dout0_56) AT=770.025n

* CHECK dout0_57 Vdout0_57ck153 = 0 time = 770
.meas tran vdout0_57ck153 FIND v(dout0_57) AT=770.025n

* CHECK dout0_58 Vdout0_58ck153 = 0.9 time = 770
.meas tran vdout0_58ck153 FIND v(dout0_58) AT=770.025n

* CHECK dout0_59 Vdout0_59ck153 = 0 time = 770
.meas tran vdout0_59ck153 FIND v(dout0_59) AT=770.025n

* CHECK dout0_60 Vdout0_60ck153 = 0.9 time = 770
.meas tran vdout0_60ck153 FIND v(dout0_60) AT=770.025n

* CHECK dout0_61 Vdout0_61ck153 = 0 time = 770
.meas tran vdout0_61ck153 FIND v(dout0_61) AT=770.025n

* CHECK dout0_62 Vdout0_62ck153 = 0 time = 770
.meas tran vdout0_62ck153 FIND v(dout0_62) AT=770.025n

* CHECK dout0_63 Vdout0_63ck153 = 0 time = 770
.meas tran vdout0_63ck153 FIND v(dout0_63) AT=770.025n

* CHECK dout0_64 Vdout0_64ck153 = 0 time = 770
.meas tran vdout0_64ck153 FIND v(dout0_64) AT=770.025n

* CHECK dout0_65 Vdout0_65ck153 = 0 time = 770
.meas tran vdout0_65ck153 FIND v(dout0_65) AT=770.025n

* CHECK dout0_66 Vdout0_66ck153 = 0.9 time = 770
.meas tran vdout0_66ck153 FIND v(dout0_66) AT=770.025n

* CHECK dout0_67 Vdout0_67ck153 = 0 time = 770
.meas tran vdout0_67ck153 FIND v(dout0_67) AT=770.025n

* CHECK dout0_68 Vdout0_68ck153 = 0 time = 770
.meas tran vdout0_68ck153 FIND v(dout0_68) AT=770.025n

* CHECK dout0_69 Vdout0_69ck153 = 0.9 time = 770
.meas tran vdout0_69ck153 FIND v(dout0_69) AT=770.025n

* CHECK dout0_70 Vdout0_70ck153 = 0.9 time = 770
.meas tran vdout0_70ck153 FIND v(dout0_70) AT=770.025n

* CHECK dout0_71 Vdout0_71ck153 = 0 time = 770
.meas tran vdout0_71ck153 FIND v(dout0_71) AT=770.025n

* CHECK dout0_72 Vdout0_72ck153 = 0.9 time = 770
.meas tran vdout0_72ck153 FIND v(dout0_72) AT=770.025n

* CHECK dout0_73 Vdout0_73ck153 = 0 time = 770
.meas tran vdout0_73ck153 FIND v(dout0_73) AT=770.025n

* CHECK dout0_74 Vdout0_74ck153 = 0 time = 770
.meas tran vdout0_74ck153 FIND v(dout0_74) AT=770.025n

* CHECK dout0_75 Vdout0_75ck153 = 0.9 time = 770
.meas tran vdout0_75ck153 FIND v(dout0_75) AT=770.025n

* CHECK dout0_76 Vdout0_76ck153 = 0.9 time = 770
.meas tran vdout0_76ck153 FIND v(dout0_76) AT=770.025n

* CHECK dout0_77 Vdout0_77ck153 = 0.9 time = 770
.meas tran vdout0_77ck153 FIND v(dout0_77) AT=770.025n

* CHECK dout0_78 Vdout0_78ck153 = 0 time = 770
.meas tran vdout0_78ck153 FIND v(dout0_78) AT=770.025n

* CHECK dout0_79 Vdout0_79ck153 = 0.9 time = 770
.meas tran vdout0_79ck153 FIND v(dout0_79) AT=770.025n

* CHECK dout0_80 Vdout0_80ck153 = 0 time = 770
.meas tran vdout0_80ck153 FIND v(dout0_80) AT=770.025n

* CHECK dout0_81 Vdout0_81ck153 = 0 time = 770
.meas tran vdout0_81ck153 FIND v(dout0_81) AT=770.025n

* CHECK dout0_82 Vdout0_82ck153 = 0 time = 770
.meas tran vdout0_82ck153 FIND v(dout0_82) AT=770.025n

* CHECK dout0_83 Vdout0_83ck153 = 0 time = 770
.meas tran vdout0_83ck153 FIND v(dout0_83) AT=770.025n

* CHECK dout0_84 Vdout0_84ck153 = 0 time = 770
.meas tran vdout0_84ck153 FIND v(dout0_84) AT=770.025n

* CHECK dout0_85 Vdout0_85ck153 = 0 time = 770
.meas tran vdout0_85ck153 FIND v(dout0_85) AT=770.025n

* CHECK dout0_86 Vdout0_86ck153 = 0 time = 770
.meas tran vdout0_86ck153 FIND v(dout0_86) AT=770.025n

* CHECK dout0_87 Vdout0_87ck153 = 0.9 time = 770
.meas tran vdout0_87ck153 FIND v(dout0_87) AT=770.025n

* CHECK dout0_0 Vdout0_0ck158 = 0.9 time = 795
.meas tran vdout0_0ck158 FIND v(dout0_0) AT=795.025n

* CHECK dout0_1 Vdout0_1ck158 = 0 time = 795
.meas tran vdout0_1ck158 FIND v(dout0_1) AT=795.025n

* CHECK dout0_2 Vdout0_2ck158 = 0.9 time = 795
.meas tran vdout0_2ck158 FIND v(dout0_2) AT=795.025n

* CHECK dout0_3 Vdout0_3ck158 = 0.9 time = 795
.meas tran vdout0_3ck158 FIND v(dout0_3) AT=795.025n

* CHECK dout0_4 Vdout0_4ck158 = 0 time = 795
.meas tran vdout0_4ck158 FIND v(dout0_4) AT=795.025n

* CHECK dout0_5 Vdout0_5ck158 = 0 time = 795
.meas tran vdout0_5ck158 FIND v(dout0_5) AT=795.025n

* CHECK dout0_6 Vdout0_6ck158 = 0.9 time = 795
.meas tran vdout0_6ck158 FIND v(dout0_6) AT=795.025n

* CHECK dout0_7 Vdout0_7ck158 = 0 time = 795
.meas tran vdout0_7ck158 FIND v(dout0_7) AT=795.025n

* CHECK dout0_8 Vdout0_8ck158 = 0 time = 795
.meas tran vdout0_8ck158 FIND v(dout0_8) AT=795.025n

* CHECK dout0_9 Vdout0_9ck158 = 0 time = 795
.meas tran vdout0_9ck158 FIND v(dout0_9) AT=795.025n

* CHECK dout0_10 Vdout0_10ck158 = 0.9 time = 795
.meas tran vdout0_10ck158 FIND v(dout0_10) AT=795.025n

* CHECK dout0_11 Vdout0_11ck158 = 0 time = 795
.meas tran vdout0_11ck158 FIND v(dout0_11) AT=795.025n

* CHECK dout0_12 Vdout0_12ck158 = 0 time = 795
.meas tran vdout0_12ck158 FIND v(dout0_12) AT=795.025n

* CHECK dout0_13 Vdout0_13ck158 = 0 time = 795
.meas tran vdout0_13ck158 FIND v(dout0_13) AT=795.025n

* CHECK dout0_14 Vdout0_14ck158 = 0.9 time = 795
.meas tran vdout0_14ck158 FIND v(dout0_14) AT=795.025n

* CHECK dout0_15 Vdout0_15ck158 = 0.9 time = 795
.meas tran vdout0_15ck158 FIND v(dout0_15) AT=795.025n

* CHECK dout0_16 Vdout0_16ck158 = 0 time = 795
.meas tran vdout0_16ck158 FIND v(dout0_16) AT=795.025n

* CHECK dout0_17 Vdout0_17ck158 = 0.9 time = 795
.meas tran vdout0_17ck158 FIND v(dout0_17) AT=795.025n

* CHECK dout0_18 Vdout0_18ck158 = 0.9 time = 795
.meas tran vdout0_18ck158 FIND v(dout0_18) AT=795.025n

* CHECK dout0_19 Vdout0_19ck158 = 0 time = 795
.meas tran vdout0_19ck158 FIND v(dout0_19) AT=795.025n

* CHECK dout0_20 Vdout0_20ck158 = 0 time = 795
.meas tran vdout0_20ck158 FIND v(dout0_20) AT=795.025n

* CHECK dout0_21 Vdout0_21ck158 = 0.9 time = 795
.meas tran vdout0_21ck158 FIND v(dout0_21) AT=795.025n

* CHECK dout0_22 Vdout0_22ck158 = 0 time = 795
.meas tran vdout0_22ck158 FIND v(dout0_22) AT=795.025n

* CHECK dout0_23 Vdout0_23ck158 = 0 time = 795
.meas tran vdout0_23ck158 FIND v(dout0_23) AT=795.025n

* CHECK dout0_24 Vdout0_24ck158 = 0.9 time = 795
.meas tran vdout0_24ck158 FIND v(dout0_24) AT=795.025n

* CHECK dout0_25 Vdout0_25ck158 = 0.9 time = 795
.meas tran vdout0_25ck158 FIND v(dout0_25) AT=795.025n

* CHECK dout0_26 Vdout0_26ck158 = 0.9 time = 795
.meas tran vdout0_26ck158 FIND v(dout0_26) AT=795.025n

* CHECK dout0_27 Vdout0_27ck158 = 0.9 time = 795
.meas tran vdout0_27ck158 FIND v(dout0_27) AT=795.025n

* CHECK dout0_28 Vdout0_28ck158 = 0.9 time = 795
.meas tran vdout0_28ck158 FIND v(dout0_28) AT=795.025n

* CHECK dout0_29 Vdout0_29ck158 = 0.9 time = 795
.meas tran vdout0_29ck158 FIND v(dout0_29) AT=795.025n

* CHECK dout0_30 Vdout0_30ck158 = 0.9 time = 795
.meas tran vdout0_30ck158 FIND v(dout0_30) AT=795.025n

* CHECK dout0_31 Vdout0_31ck158 = 0.9 time = 795
.meas tran vdout0_31ck158 FIND v(dout0_31) AT=795.025n

* CHECK dout0_32 Vdout0_32ck158 = 0.9 time = 795
.meas tran vdout0_32ck158 FIND v(dout0_32) AT=795.025n

* CHECK dout0_33 Vdout0_33ck158 = 0 time = 795
.meas tran vdout0_33ck158 FIND v(dout0_33) AT=795.025n

* CHECK dout0_34 Vdout0_34ck158 = 0.9 time = 795
.meas tran vdout0_34ck158 FIND v(dout0_34) AT=795.025n

* CHECK dout0_35 Vdout0_35ck158 = 0.9 time = 795
.meas tran vdout0_35ck158 FIND v(dout0_35) AT=795.025n

* CHECK dout0_36 Vdout0_36ck158 = 0 time = 795
.meas tran vdout0_36ck158 FIND v(dout0_36) AT=795.025n

* CHECK dout0_37 Vdout0_37ck158 = 0.9 time = 795
.meas tran vdout0_37ck158 FIND v(dout0_37) AT=795.025n

* CHECK dout0_38 Vdout0_38ck158 = 0.9 time = 795
.meas tran vdout0_38ck158 FIND v(dout0_38) AT=795.025n

* CHECK dout0_39 Vdout0_39ck158 = 0.9 time = 795
.meas tran vdout0_39ck158 FIND v(dout0_39) AT=795.025n

* CHECK dout0_40 Vdout0_40ck158 = 0 time = 795
.meas tran vdout0_40ck158 FIND v(dout0_40) AT=795.025n

* CHECK dout0_41 Vdout0_41ck158 = 0.9 time = 795
.meas tran vdout0_41ck158 FIND v(dout0_41) AT=795.025n

* CHECK dout0_42 Vdout0_42ck158 = 0.9 time = 795
.meas tran vdout0_42ck158 FIND v(dout0_42) AT=795.025n

* CHECK dout0_43 Vdout0_43ck158 = 0.9 time = 795
.meas tran vdout0_43ck158 FIND v(dout0_43) AT=795.025n

* CHECK dout0_44 Vdout0_44ck158 = 0.9 time = 795
.meas tran vdout0_44ck158 FIND v(dout0_44) AT=795.025n

* CHECK dout0_45 Vdout0_45ck158 = 0.9 time = 795
.meas tran vdout0_45ck158 FIND v(dout0_45) AT=795.025n

* CHECK dout0_46 Vdout0_46ck158 = 0.9 time = 795
.meas tran vdout0_46ck158 FIND v(dout0_46) AT=795.025n

* CHECK dout0_47 Vdout0_47ck158 = 0 time = 795
.meas tran vdout0_47ck158 FIND v(dout0_47) AT=795.025n

* CHECK dout0_48 Vdout0_48ck158 = 0 time = 795
.meas tran vdout0_48ck158 FIND v(dout0_48) AT=795.025n

* CHECK dout0_49 Vdout0_49ck158 = 0.9 time = 795
.meas tran vdout0_49ck158 FIND v(dout0_49) AT=795.025n

* CHECK dout0_50 Vdout0_50ck158 = 0 time = 795
.meas tran vdout0_50ck158 FIND v(dout0_50) AT=795.025n

* CHECK dout0_51 Vdout0_51ck158 = 0.9 time = 795
.meas tran vdout0_51ck158 FIND v(dout0_51) AT=795.025n

* CHECK dout0_52 Vdout0_52ck158 = 0.9 time = 795
.meas tran vdout0_52ck158 FIND v(dout0_52) AT=795.025n

* CHECK dout0_53 Vdout0_53ck158 = 0 time = 795
.meas tran vdout0_53ck158 FIND v(dout0_53) AT=795.025n

* CHECK dout0_54 Vdout0_54ck158 = 0.9 time = 795
.meas tran vdout0_54ck158 FIND v(dout0_54) AT=795.025n

* CHECK dout0_55 Vdout0_55ck158 = 0.9 time = 795
.meas tran vdout0_55ck158 FIND v(dout0_55) AT=795.025n

* CHECK dout0_56 Vdout0_56ck158 = 0.9 time = 795
.meas tran vdout0_56ck158 FIND v(dout0_56) AT=795.025n

* CHECK dout0_57 Vdout0_57ck158 = 0 time = 795
.meas tran vdout0_57ck158 FIND v(dout0_57) AT=795.025n

* CHECK dout0_58 Vdout0_58ck158 = 0 time = 795
.meas tran vdout0_58ck158 FIND v(dout0_58) AT=795.025n

* CHECK dout0_59 Vdout0_59ck158 = 0.9 time = 795
.meas tran vdout0_59ck158 FIND v(dout0_59) AT=795.025n

* CHECK dout0_60 Vdout0_60ck158 = 0.9 time = 795
.meas tran vdout0_60ck158 FIND v(dout0_60) AT=795.025n

* CHECK dout0_61 Vdout0_61ck158 = 0.9 time = 795
.meas tran vdout0_61ck158 FIND v(dout0_61) AT=795.025n

* CHECK dout0_62 Vdout0_62ck158 = 0.9 time = 795
.meas tran vdout0_62ck158 FIND v(dout0_62) AT=795.025n

* CHECK dout0_63 Vdout0_63ck158 = 0 time = 795
.meas tran vdout0_63ck158 FIND v(dout0_63) AT=795.025n

* CHECK dout0_64 Vdout0_64ck158 = 0.9 time = 795
.meas tran vdout0_64ck158 FIND v(dout0_64) AT=795.025n

* CHECK dout0_65 Vdout0_65ck158 = 0 time = 795
.meas tran vdout0_65ck158 FIND v(dout0_65) AT=795.025n

* CHECK dout0_66 Vdout0_66ck158 = 0.9 time = 795
.meas tran vdout0_66ck158 FIND v(dout0_66) AT=795.025n

* CHECK dout0_67 Vdout0_67ck158 = 0.9 time = 795
.meas tran vdout0_67ck158 FIND v(dout0_67) AT=795.025n

* CHECK dout0_68 Vdout0_68ck158 = 0.9 time = 795
.meas tran vdout0_68ck158 FIND v(dout0_68) AT=795.025n

* CHECK dout0_69 Vdout0_69ck158 = 0 time = 795
.meas tran vdout0_69ck158 FIND v(dout0_69) AT=795.025n

* CHECK dout0_70 Vdout0_70ck158 = 0.9 time = 795
.meas tran vdout0_70ck158 FIND v(dout0_70) AT=795.025n

* CHECK dout0_71 Vdout0_71ck158 = 0.9 time = 795
.meas tran vdout0_71ck158 FIND v(dout0_71) AT=795.025n

* CHECK dout0_72 Vdout0_72ck158 = 0.9 time = 795
.meas tran vdout0_72ck158 FIND v(dout0_72) AT=795.025n

* CHECK dout0_73 Vdout0_73ck158 = 0.9 time = 795
.meas tran vdout0_73ck158 FIND v(dout0_73) AT=795.025n

* CHECK dout0_74 Vdout0_74ck158 = 0 time = 795
.meas tran vdout0_74ck158 FIND v(dout0_74) AT=795.025n

* CHECK dout0_75 Vdout0_75ck158 = 0.9 time = 795
.meas tran vdout0_75ck158 FIND v(dout0_75) AT=795.025n

* CHECK dout0_76 Vdout0_76ck158 = 0 time = 795
.meas tran vdout0_76ck158 FIND v(dout0_76) AT=795.025n

* CHECK dout0_77 Vdout0_77ck158 = 0 time = 795
.meas tran vdout0_77ck158 FIND v(dout0_77) AT=795.025n

* CHECK dout0_78 Vdout0_78ck158 = 0.9 time = 795
.meas tran vdout0_78ck158 FIND v(dout0_78) AT=795.025n

* CHECK dout0_79 Vdout0_79ck158 = 0 time = 795
.meas tran vdout0_79ck158 FIND v(dout0_79) AT=795.025n

* CHECK dout0_80 Vdout0_80ck158 = 0 time = 795
.meas tran vdout0_80ck158 FIND v(dout0_80) AT=795.025n

* CHECK dout0_81 Vdout0_81ck158 = 0.9 time = 795
.meas tran vdout0_81ck158 FIND v(dout0_81) AT=795.025n

* CHECK dout0_82 Vdout0_82ck158 = 0.9 time = 795
.meas tran vdout0_82ck158 FIND v(dout0_82) AT=795.025n

* CHECK dout0_83 Vdout0_83ck158 = 0.9 time = 795
.meas tran vdout0_83ck158 FIND v(dout0_83) AT=795.025n

* CHECK dout0_84 Vdout0_84ck158 = 0 time = 795
.meas tran vdout0_84ck158 FIND v(dout0_84) AT=795.025n

* CHECK dout0_85 Vdout0_85ck158 = 0 time = 795
.meas tran vdout0_85ck158 FIND v(dout0_85) AT=795.025n

* CHECK dout0_86 Vdout0_86ck158 = 0 time = 795
.meas tran vdout0_86ck158 FIND v(dout0_86) AT=795.025n

* CHECK dout0_87 Vdout0_87ck158 = 0.9 time = 795
.meas tran vdout0_87ck158 FIND v(dout0_87) AT=795.025n

* CHECK dout0_0 Vdout0_0ck162 = 0 time = 815
.meas tran vdout0_0ck162 FIND v(dout0_0) AT=815.025n

* CHECK dout0_1 Vdout0_1ck162 = 0.9 time = 815
.meas tran vdout0_1ck162 FIND v(dout0_1) AT=815.025n

* CHECK dout0_2 Vdout0_2ck162 = 0 time = 815
.meas tran vdout0_2ck162 FIND v(dout0_2) AT=815.025n

* CHECK dout0_3 Vdout0_3ck162 = 0 time = 815
.meas tran vdout0_3ck162 FIND v(dout0_3) AT=815.025n

* CHECK dout0_4 Vdout0_4ck162 = 0.9 time = 815
.meas tran vdout0_4ck162 FIND v(dout0_4) AT=815.025n

* CHECK dout0_5 Vdout0_5ck162 = 0.9 time = 815
.meas tran vdout0_5ck162 FIND v(dout0_5) AT=815.025n

* CHECK dout0_6 Vdout0_6ck162 = 0.9 time = 815
.meas tran vdout0_6ck162 FIND v(dout0_6) AT=815.025n

* CHECK dout0_7 Vdout0_7ck162 = 0.9 time = 815
.meas tran vdout0_7ck162 FIND v(dout0_7) AT=815.025n

* CHECK dout0_8 Vdout0_8ck162 = 0 time = 815
.meas tran vdout0_8ck162 FIND v(dout0_8) AT=815.025n

* CHECK dout0_9 Vdout0_9ck162 = 0.9 time = 815
.meas tran vdout0_9ck162 FIND v(dout0_9) AT=815.025n

* CHECK dout0_10 Vdout0_10ck162 = 0 time = 815
.meas tran vdout0_10ck162 FIND v(dout0_10) AT=815.025n

* CHECK dout0_11 Vdout0_11ck162 = 0 time = 815
.meas tran vdout0_11ck162 FIND v(dout0_11) AT=815.025n

* CHECK dout0_12 Vdout0_12ck162 = 0 time = 815
.meas tran vdout0_12ck162 FIND v(dout0_12) AT=815.025n

* CHECK dout0_13 Vdout0_13ck162 = 0.9 time = 815
.meas tran vdout0_13ck162 FIND v(dout0_13) AT=815.025n

* CHECK dout0_14 Vdout0_14ck162 = 0.9 time = 815
.meas tran vdout0_14ck162 FIND v(dout0_14) AT=815.025n

* CHECK dout0_15 Vdout0_15ck162 = 0 time = 815
.meas tran vdout0_15ck162 FIND v(dout0_15) AT=815.025n

* CHECK dout0_16 Vdout0_16ck162 = 0 time = 815
.meas tran vdout0_16ck162 FIND v(dout0_16) AT=815.025n

* CHECK dout0_17 Vdout0_17ck162 = 0 time = 815
.meas tran vdout0_17ck162 FIND v(dout0_17) AT=815.025n

* CHECK dout0_18 Vdout0_18ck162 = 0.9 time = 815
.meas tran vdout0_18ck162 FIND v(dout0_18) AT=815.025n

* CHECK dout0_19 Vdout0_19ck162 = 0 time = 815
.meas tran vdout0_19ck162 FIND v(dout0_19) AT=815.025n

* CHECK dout0_20 Vdout0_20ck162 = 0 time = 815
.meas tran vdout0_20ck162 FIND v(dout0_20) AT=815.025n

* CHECK dout0_21 Vdout0_21ck162 = 0.9 time = 815
.meas tran vdout0_21ck162 FIND v(dout0_21) AT=815.025n

* CHECK dout0_22 Vdout0_22ck162 = 0 time = 815
.meas tran vdout0_22ck162 FIND v(dout0_22) AT=815.025n

* CHECK dout0_23 Vdout0_23ck162 = 0 time = 815
.meas tran vdout0_23ck162 FIND v(dout0_23) AT=815.025n

* CHECK dout0_24 Vdout0_24ck162 = 0.9 time = 815
.meas tran vdout0_24ck162 FIND v(dout0_24) AT=815.025n

* CHECK dout0_25 Vdout0_25ck162 = 0.9 time = 815
.meas tran vdout0_25ck162 FIND v(dout0_25) AT=815.025n

* CHECK dout0_26 Vdout0_26ck162 = 0 time = 815
.meas tran vdout0_26ck162 FIND v(dout0_26) AT=815.025n

* CHECK dout0_27 Vdout0_27ck162 = 0 time = 815
.meas tran vdout0_27ck162 FIND v(dout0_27) AT=815.025n

* CHECK dout0_28 Vdout0_28ck162 = 0 time = 815
.meas tran vdout0_28ck162 FIND v(dout0_28) AT=815.025n

* CHECK dout0_29 Vdout0_29ck162 = 0.9 time = 815
.meas tran vdout0_29ck162 FIND v(dout0_29) AT=815.025n

* CHECK dout0_30 Vdout0_30ck162 = 0.9 time = 815
.meas tran vdout0_30ck162 FIND v(dout0_30) AT=815.025n

* CHECK dout0_31 Vdout0_31ck162 = 0.9 time = 815
.meas tran vdout0_31ck162 FIND v(dout0_31) AT=815.025n

* CHECK dout0_32 Vdout0_32ck162 = 0.9 time = 815
.meas tran vdout0_32ck162 FIND v(dout0_32) AT=815.025n

* CHECK dout0_33 Vdout0_33ck162 = 0.9 time = 815
.meas tran vdout0_33ck162 FIND v(dout0_33) AT=815.025n

* CHECK dout0_34 Vdout0_34ck162 = 0.9 time = 815
.meas tran vdout0_34ck162 FIND v(dout0_34) AT=815.025n

* CHECK dout0_35 Vdout0_35ck162 = 0.9 time = 815
.meas tran vdout0_35ck162 FIND v(dout0_35) AT=815.025n

* CHECK dout0_36 Vdout0_36ck162 = 0 time = 815
.meas tran vdout0_36ck162 FIND v(dout0_36) AT=815.025n

* CHECK dout0_37 Vdout0_37ck162 = 0.9 time = 815
.meas tran vdout0_37ck162 FIND v(dout0_37) AT=815.025n

* CHECK dout0_38 Vdout0_38ck162 = 0 time = 815
.meas tran vdout0_38ck162 FIND v(dout0_38) AT=815.025n

* CHECK dout0_39 Vdout0_39ck162 = 0.9 time = 815
.meas tran vdout0_39ck162 FIND v(dout0_39) AT=815.025n

* CHECK dout0_40 Vdout0_40ck162 = 0.9 time = 815
.meas tran vdout0_40ck162 FIND v(dout0_40) AT=815.025n

* CHECK dout0_41 Vdout0_41ck162 = 0 time = 815
.meas tran vdout0_41ck162 FIND v(dout0_41) AT=815.025n

* CHECK dout0_42 Vdout0_42ck162 = 0.9 time = 815
.meas tran vdout0_42ck162 FIND v(dout0_42) AT=815.025n

* CHECK dout0_43 Vdout0_43ck162 = 0 time = 815
.meas tran vdout0_43ck162 FIND v(dout0_43) AT=815.025n

* CHECK dout0_44 Vdout0_44ck162 = 0.9 time = 815
.meas tran vdout0_44ck162 FIND v(dout0_44) AT=815.025n

* CHECK dout0_45 Vdout0_45ck162 = 0.9 time = 815
.meas tran vdout0_45ck162 FIND v(dout0_45) AT=815.025n

* CHECK dout0_46 Vdout0_46ck162 = 0.9 time = 815
.meas tran vdout0_46ck162 FIND v(dout0_46) AT=815.025n

* CHECK dout0_47 Vdout0_47ck162 = 0 time = 815
.meas tran vdout0_47ck162 FIND v(dout0_47) AT=815.025n

* CHECK dout0_48 Vdout0_48ck162 = 0.9 time = 815
.meas tran vdout0_48ck162 FIND v(dout0_48) AT=815.025n

* CHECK dout0_49 Vdout0_49ck162 = 0 time = 815
.meas tran vdout0_49ck162 FIND v(dout0_49) AT=815.025n

* CHECK dout0_50 Vdout0_50ck162 = 0.9 time = 815
.meas tran vdout0_50ck162 FIND v(dout0_50) AT=815.025n

* CHECK dout0_51 Vdout0_51ck162 = 0 time = 815
.meas tran vdout0_51ck162 FIND v(dout0_51) AT=815.025n

* CHECK dout0_52 Vdout0_52ck162 = 0.9 time = 815
.meas tran vdout0_52ck162 FIND v(dout0_52) AT=815.025n

* CHECK dout0_53 Vdout0_53ck162 = 0.9 time = 815
.meas tran vdout0_53ck162 FIND v(dout0_53) AT=815.025n

* CHECK dout0_54 Vdout0_54ck162 = 0.9 time = 815
.meas tran vdout0_54ck162 FIND v(dout0_54) AT=815.025n

* CHECK dout0_55 Vdout0_55ck162 = 0 time = 815
.meas tran vdout0_55ck162 FIND v(dout0_55) AT=815.025n

* CHECK dout0_56 Vdout0_56ck162 = 0 time = 815
.meas tran vdout0_56ck162 FIND v(dout0_56) AT=815.025n

* CHECK dout0_57 Vdout0_57ck162 = 0 time = 815
.meas tran vdout0_57ck162 FIND v(dout0_57) AT=815.025n

* CHECK dout0_58 Vdout0_58ck162 = 0.9 time = 815
.meas tran vdout0_58ck162 FIND v(dout0_58) AT=815.025n

* CHECK dout0_59 Vdout0_59ck162 = 0.9 time = 815
.meas tran vdout0_59ck162 FIND v(dout0_59) AT=815.025n

* CHECK dout0_60 Vdout0_60ck162 = 0 time = 815
.meas tran vdout0_60ck162 FIND v(dout0_60) AT=815.025n

* CHECK dout0_61 Vdout0_61ck162 = 0 time = 815
.meas tran vdout0_61ck162 FIND v(dout0_61) AT=815.025n

* CHECK dout0_62 Vdout0_62ck162 = 0 time = 815
.meas tran vdout0_62ck162 FIND v(dout0_62) AT=815.025n

* CHECK dout0_63 Vdout0_63ck162 = 0 time = 815
.meas tran vdout0_63ck162 FIND v(dout0_63) AT=815.025n

* CHECK dout0_64 Vdout0_64ck162 = 0.9 time = 815
.meas tran vdout0_64ck162 FIND v(dout0_64) AT=815.025n

* CHECK dout0_65 Vdout0_65ck162 = 0 time = 815
.meas tran vdout0_65ck162 FIND v(dout0_65) AT=815.025n

* CHECK dout0_66 Vdout0_66ck162 = 0 time = 815
.meas tran vdout0_66ck162 FIND v(dout0_66) AT=815.025n

* CHECK dout0_67 Vdout0_67ck162 = 0 time = 815
.meas tran vdout0_67ck162 FIND v(dout0_67) AT=815.025n

* CHECK dout0_68 Vdout0_68ck162 = 0.9 time = 815
.meas tran vdout0_68ck162 FIND v(dout0_68) AT=815.025n

* CHECK dout0_69 Vdout0_69ck162 = 0 time = 815
.meas tran vdout0_69ck162 FIND v(dout0_69) AT=815.025n

* CHECK dout0_70 Vdout0_70ck162 = 0.9 time = 815
.meas tran vdout0_70ck162 FIND v(dout0_70) AT=815.025n

* CHECK dout0_71 Vdout0_71ck162 = 0.9 time = 815
.meas tran vdout0_71ck162 FIND v(dout0_71) AT=815.025n

* CHECK dout0_72 Vdout0_72ck162 = 0 time = 815
.meas tran vdout0_72ck162 FIND v(dout0_72) AT=815.025n

* CHECK dout0_73 Vdout0_73ck162 = 0.9 time = 815
.meas tran vdout0_73ck162 FIND v(dout0_73) AT=815.025n

* CHECK dout0_74 Vdout0_74ck162 = 0 time = 815
.meas tran vdout0_74ck162 FIND v(dout0_74) AT=815.025n

* CHECK dout0_75 Vdout0_75ck162 = 0 time = 815
.meas tran vdout0_75ck162 FIND v(dout0_75) AT=815.025n

* CHECK dout0_76 Vdout0_76ck162 = 0.9 time = 815
.meas tran vdout0_76ck162 FIND v(dout0_76) AT=815.025n

* CHECK dout0_77 Vdout0_77ck162 = 0.9 time = 815
.meas tran vdout0_77ck162 FIND v(dout0_77) AT=815.025n

* CHECK dout0_78 Vdout0_78ck162 = 0.9 time = 815
.meas tran vdout0_78ck162 FIND v(dout0_78) AT=815.025n

* CHECK dout0_79 Vdout0_79ck162 = 0.9 time = 815
.meas tran vdout0_79ck162 FIND v(dout0_79) AT=815.025n

* CHECK dout0_80 Vdout0_80ck162 = 0 time = 815
.meas tran vdout0_80ck162 FIND v(dout0_80) AT=815.025n

* CHECK dout0_81 Vdout0_81ck162 = 0.9 time = 815
.meas tran vdout0_81ck162 FIND v(dout0_81) AT=815.025n

* CHECK dout0_82 Vdout0_82ck162 = 0.9 time = 815
.meas tran vdout0_82ck162 FIND v(dout0_82) AT=815.025n

* CHECK dout0_83 Vdout0_83ck162 = 0.9 time = 815
.meas tran vdout0_83ck162 FIND v(dout0_83) AT=815.025n

* CHECK dout0_84 Vdout0_84ck162 = 0 time = 815
.meas tran vdout0_84ck162 FIND v(dout0_84) AT=815.025n

* CHECK dout0_85 Vdout0_85ck162 = 0.9 time = 815
.meas tran vdout0_85ck162 FIND v(dout0_85) AT=815.025n

* CHECK dout0_86 Vdout0_86ck162 = 0 time = 815
.meas tran vdout0_86ck162 FIND v(dout0_86) AT=815.025n

* CHECK dout0_87 Vdout0_87ck162 = 0.9 time = 815
.meas tran vdout0_87ck162 FIND v(dout0_87) AT=815.025n

* CHECK dout0_0 Vdout0_0ck163 = 0.9 time = 820
.meas tran vdout0_0ck163 FIND v(dout0_0) AT=820.025n

* CHECK dout0_1 Vdout0_1ck163 = 0 time = 820
.meas tran vdout0_1ck163 FIND v(dout0_1) AT=820.025n

* CHECK dout0_2 Vdout0_2ck163 = 0.9 time = 820
.meas tran vdout0_2ck163 FIND v(dout0_2) AT=820.025n

* CHECK dout0_3 Vdout0_3ck163 = 0.9 time = 820
.meas tran vdout0_3ck163 FIND v(dout0_3) AT=820.025n

* CHECK dout0_4 Vdout0_4ck163 = 0 time = 820
.meas tran vdout0_4ck163 FIND v(dout0_4) AT=820.025n

* CHECK dout0_5 Vdout0_5ck163 = 0 time = 820
.meas tran vdout0_5ck163 FIND v(dout0_5) AT=820.025n

* CHECK dout0_6 Vdout0_6ck163 = 0.9 time = 820
.meas tran vdout0_6ck163 FIND v(dout0_6) AT=820.025n

* CHECK dout0_7 Vdout0_7ck163 = 0 time = 820
.meas tran vdout0_7ck163 FIND v(dout0_7) AT=820.025n

* CHECK dout0_8 Vdout0_8ck163 = 0 time = 820
.meas tran vdout0_8ck163 FIND v(dout0_8) AT=820.025n

* CHECK dout0_9 Vdout0_9ck163 = 0 time = 820
.meas tran vdout0_9ck163 FIND v(dout0_9) AT=820.025n

* CHECK dout0_10 Vdout0_10ck163 = 0.9 time = 820
.meas tran vdout0_10ck163 FIND v(dout0_10) AT=820.025n

* CHECK dout0_11 Vdout0_11ck163 = 0 time = 820
.meas tran vdout0_11ck163 FIND v(dout0_11) AT=820.025n

* CHECK dout0_12 Vdout0_12ck163 = 0 time = 820
.meas tran vdout0_12ck163 FIND v(dout0_12) AT=820.025n

* CHECK dout0_13 Vdout0_13ck163 = 0 time = 820
.meas tran vdout0_13ck163 FIND v(dout0_13) AT=820.025n

* CHECK dout0_14 Vdout0_14ck163 = 0.9 time = 820
.meas tran vdout0_14ck163 FIND v(dout0_14) AT=820.025n

* CHECK dout0_15 Vdout0_15ck163 = 0.9 time = 820
.meas tran vdout0_15ck163 FIND v(dout0_15) AT=820.025n

* CHECK dout0_16 Vdout0_16ck163 = 0 time = 820
.meas tran vdout0_16ck163 FIND v(dout0_16) AT=820.025n

* CHECK dout0_17 Vdout0_17ck163 = 0.9 time = 820
.meas tran vdout0_17ck163 FIND v(dout0_17) AT=820.025n

* CHECK dout0_18 Vdout0_18ck163 = 0.9 time = 820
.meas tran vdout0_18ck163 FIND v(dout0_18) AT=820.025n

* CHECK dout0_19 Vdout0_19ck163 = 0 time = 820
.meas tran vdout0_19ck163 FIND v(dout0_19) AT=820.025n

* CHECK dout0_20 Vdout0_20ck163 = 0 time = 820
.meas tran vdout0_20ck163 FIND v(dout0_20) AT=820.025n

* CHECK dout0_21 Vdout0_21ck163 = 0.9 time = 820
.meas tran vdout0_21ck163 FIND v(dout0_21) AT=820.025n

* CHECK dout0_22 Vdout0_22ck163 = 0 time = 820
.meas tran vdout0_22ck163 FIND v(dout0_22) AT=820.025n

* CHECK dout0_23 Vdout0_23ck163 = 0 time = 820
.meas tran vdout0_23ck163 FIND v(dout0_23) AT=820.025n

* CHECK dout0_24 Vdout0_24ck163 = 0.9 time = 820
.meas tran vdout0_24ck163 FIND v(dout0_24) AT=820.025n

* CHECK dout0_25 Vdout0_25ck163 = 0.9 time = 820
.meas tran vdout0_25ck163 FIND v(dout0_25) AT=820.025n

* CHECK dout0_26 Vdout0_26ck163 = 0.9 time = 820
.meas tran vdout0_26ck163 FIND v(dout0_26) AT=820.025n

* CHECK dout0_27 Vdout0_27ck163 = 0.9 time = 820
.meas tran vdout0_27ck163 FIND v(dout0_27) AT=820.025n

* CHECK dout0_28 Vdout0_28ck163 = 0.9 time = 820
.meas tran vdout0_28ck163 FIND v(dout0_28) AT=820.025n

* CHECK dout0_29 Vdout0_29ck163 = 0.9 time = 820
.meas tran vdout0_29ck163 FIND v(dout0_29) AT=820.025n

* CHECK dout0_30 Vdout0_30ck163 = 0.9 time = 820
.meas tran vdout0_30ck163 FIND v(dout0_30) AT=820.025n

* CHECK dout0_31 Vdout0_31ck163 = 0.9 time = 820
.meas tran vdout0_31ck163 FIND v(dout0_31) AT=820.025n

* CHECK dout0_32 Vdout0_32ck163 = 0.9 time = 820
.meas tran vdout0_32ck163 FIND v(dout0_32) AT=820.025n

* CHECK dout0_33 Vdout0_33ck163 = 0 time = 820
.meas tran vdout0_33ck163 FIND v(dout0_33) AT=820.025n

* CHECK dout0_34 Vdout0_34ck163 = 0.9 time = 820
.meas tran vdout0_34ck163 FIND v(dout0_34) AT=820.025n

* CHECK dout0_35 Vdout0_35ck163 = 0.9 time = 820
.meas tran vdout0_35ck163 FIND v(dout0_35) AT=820.025n

* CHECK dout0_36 Vdout0_36ck163 = 0 time = 820
.meas tran vdout0_36ck163 FIND v(dout0_36) AT=820.025n

* CHECK dout0_37 Vdout0_37ck163 = 0.9 time = 820
.meas tran vdout0_37ck163 FIND v(dout0_37) AT=820.025n

* CHECK dout0_38 Vdout0_38ck163 = 0.9 time = 820
.meas tran vdout0_38ck163 FIND v(dout0_38) AT=820.025n

* CHECK dout0_39 Vdout0_39ck163 = 0.9 time = 820
.meas tran vdout0_39ck163 FIND v(dout0_39) AT=820.025n

* CHECK dout0_40 Vdout0_40ck163 = 0 time = 820
.meas tran vdout0_40ck163 FIND v(dout0_40) AT=820.025n

* CHECK dout0_41 Vdout0_41ck163 = 0.9 time = 820
.meas tran vdout0_41ck163 FIND v(dout0_41) AT=820.025n

* CHECK dout0_42 Vdout0_42ck163 = 0.9 time = 820
.meas tran vdout0_42ck163 FIND v(dout0_42) AT=820.025n

* CHECK dout0_43 Vdout0_43ck163 = 0.9 time = 820
.meas tran vdout0_43ck163 FIND v(dout0_43) AT=820.025n

* CHECK dout0_44 Vdout0_44ck163 = 0.9 time = 820
.meas tran vdout0_44ck163 FIND v(dout0_44) AT=820.025n

* CHECK dout0_45 Vdout0_45ck163 = 0.9 time = 820
.meas tran vdout0_45ck163 FIND v(dout0_45) AT=820.025n

* CHECK dout0_46 Vdout0_46ck163 = 0.9 time = 820
.meas tran vdout0_46ck163 FIND v(dout0_46) AT=820.025n

* CHECK dout0_47 Vdout0_47ck163 = 0 time = 820
.meas tran vdout0_47ck163 FIND v(dout0_47) AT=820.025n

* CHECK dout0_48 Vdout0_48ck163 = 0 time = 820
.meas tran vdout0_48ck163 FIND v(dout0_48) AT=820.025n

* CHECK dout0_49 Vdout0_49ck163 = 0.9 time = 820
.meas tran vdout0_49ck163 FIND v(dout0_49) AT=820.025n

* CHECK dout0_50 Vdout0_50ck163 = 0 time = 820
.meas tran vdout0_50ck163 FIND v(dout0_50) AT=820.025n

* CHECK dout0_51 Vdout0_51ck163 = 0.9 time = 820
.meas tran vdout0_51ck163 FIND v(dout0_51) AT=820.025n

* CHECK dout0_52 Vdout0_52ck163 = 0.9 time = 820
.meas tran vdout0_52ck163 FIND v(dout0_52) AT=820.025n

* CHECK dout0_53 Vdout0_53ck163 = 0 time = 820
.meas tran vdout0_53ck163 FIND v(dout0_53) AT=820.025n

* CHECK dout0_54 Vdout0_54ck163 = 0.9 time = 820
.meas tran vdout0_54ck163 FIND v(dout0_54) AT=820.025n

* CHECK dout0_55 Vdout0_55ck163 = 0.9 time = 820
.meas tran vdout0_55ck163 FIND v(dout0_55) AT=820.025n

* CHECK dout0_56 Vdout0_56ck163 = 0.9 time = 820
.meas tran vdout0_56ck163 FIND v(dout0_56) AT=820.025n

* CHECK dout0_57 Vdout0_57ck163 = 0 time = 820
.meas tran vdout0_57ck163 FIND v(dout0_57) AT=820.025n

* CHECK dout0_58 Vdout0_58ck163 = 0 time = 820
.meas tran vdout0_58ck163 FIND v(dout0_58) AT=820.025n

* CHECK dout0_59 Vdout0_59ck163 = 0.9 time = 820
.meas tran vdout0_59ck163 FIND v(dout0_59) AT=820.025n

* CHECK dout0_60 Vdout0_60ck163 = 0.9 time = 820
.meas tran vdout0_60ck163 FIND v(dout0_60) AT=820.025n

* CHECK dout0_61 Vdout0_61ck163 = 0.9 time = 820
.meas tran vdout0_61ck163 FIND v(dout0_61) AT=820.025n

* CHECK dout0_62 Vdout0_62ck163 = 0.9 time = 820
.meas tran vdout0_62ck163 FIND v(dout0_62) AT=820.025n

* CHECK dout0_63 Vdout0_63ck163 = 0 time = 820
.meas tran vdout0_63ck163 FIND v(dout0_63) AT=820.025n

* CHECK dout0_64 Vdout0_64ck163 = 0.9 time = 820
.meas tran vdout0_64ck163 FIND v(dout0_64) AT=820.025n

* CHECK dout0_65 Vdout0_65ck163 = 0 time = 820
.meas tran vdout0_65ck163 FIND v(dout0_65) AT=820.025n

* CHECK dout0_66 Vdout0_66ck163 = 0.9 time = 820
.meas tran vdout0_66ck163 FIND v(dout0_66) AT=820.025n

* CHECK dout0_67 Vdout0_67ck163 = 0.9 time = 820
.meas tran vdout0_67ck163 FIND v(dout0_67) AT=820.025n

* CHECK dout0_68 Vdout0_68ck163 = 0.9 time = 820
.meas tran vdout0_68ck163 FIND v(dout0_68) AT=820.025n

* CHECK dout0_69 Vdout0_69ck163 = 0 time = 820
.meas tran vdout0_69ck163 FIND v(dout0_69) AT=820.025n

* CHECK dout0_70 Vdout0_70ck163 = 0.9 time = 820
.meas tran vdout0_70ck163 FIND v(dout0_70) AT=820.025n

* CHECK dout0_71 Vdout0_71ck163 = 0.9 time = 820
.meas tran vdout0_71ck163 FIND v(dout0_71) AT=820.025n

* CHECK dout0_72 Vdout0_72ck163 = 0.9 time = 820
.meas tran vdout0_72ck163 FIND v(dout0_72) AT=820.025n

* CHECK dout0_73 Vdout0_73ck163 = 0.9 time = 820
.meas tran vdout0_73ck163 FIND v(dout0_73) AT=820.025n

* CHECK dout0_74 Vdout0_74ck163 = 0 time = 820
.meas tran vdout0_74ck163 FIND v(dout0_74) AT=820.025n

* CHECK dout0_75 Vdout0_75ck163 = 0.9 time = 820
.meas tran vdout0_75ck163 FIND v(dout0_75) AT=820.025n

* CHECK dout0_76 Vdout0_76ck163 = 0 time = 820
.meas tran vdout0_76ck163 FIND v(dout0_76) AT=820.025n

* CHECK dout0_77 Vdout0_77ck163 = 0 time = 820
.meas tran vdout0_77ck163 FIND v(dout0_77) AT=820.025n

* CHECK dout0_78 Vdout0_78ck163 = 0.9 time = 820
.meas tran vdout0_78ck163 FIND v(dout0_78) AT=820.025n

* CHECK dout0_79 Vdout0_79ck163 = 0 time = 820
.meas tran vdout0_79ck163 FIND v(dout0_79) AT=820.025n

* CHECK dout0_80 Vdout0_80ck163 = 0 time = 820
.meas tran vdout0_80ck163 FIND v(dout0_80) AT=820.025n

* CHECK dout0_81 Vdout0_81ck163 = 0.9 time = 820
.meas tran vdout0_81ck163 FIND v(dout0_81) AT=820.025n

* CHECK dout0_82 Vdout0_82ck163 = 0.9 time = 820
.meas tran vdout0_82ck163 FIND v(dout0_82) AT=820.025n

* CHECK dout0_83 Vdout0_83ck163 = 0.9 time = 820
.meas tran vdout0_83ck163 FIND v(dout0_83) AT=820.025n

* CHECK dout0_84 Vdout0_84ck163 = 0 time = 820
.meas tran vdout0_84ck163 FIND v(dout0_84) AT=820.025n

* CHECK dout0_85 Vdout0_85ck163 = 0 time = 820
.meas tran vdout0_85ck163 FIND v(dout0_85) AT=820.025n

* CHECK dout0_86 Vdout0_86ck163 = 0 time = 820
.meas tran vdout0_86ck163 FIND v(dout0_86) AT=820.025n

* CHECK dout0_87 Vdout0_87ck163 = 0.9 time = 820
.meas tran vdout0_87ck163 FIND v(dout0_87) AT=820.025n

* CHECK dout0_0 Vdout0_0ck167 = 0 time = 840
.meas tran vdout0_0ck167 FIND v(dout0_0) AT=840.025n

* CHECK dout0_1 Vdout0_1ck167 = 0.9 time = 840
.meas tran vdout0_1ck167 FIND v(dout0_1) AT=840.025n

* CHECK dout0_2 Vdout0_2ck167 = 0 time = 840
.meas tran vdout0_2ck167 FIND v(dout0_2) AT=840.025n

* CHECK dout0_3 Vdout0_3ck167 = 0.9 time = 840
.meas tran vdout0_3ck167 FIND v(dout0_3) AT=840.025n

* CHECK dout0_4 Vdout0_4ck167 = 0 time = 840
.meas tran vdout0_4ck167 FIND v(dout0_4) AT=840.025n

* CHECK dout0_5 Vdout0_5ck167 = 0.9 time = 840
.meas tran vdout0_5ck167 FIND v(dout0_5) AT=840.025n

* CHECK dout0_6 Vdout0_6ck167 = 0 time = 840
.meas tran vdout0_6ck167 FIND v(dout0_6) AT=840.025n

* CHECK dout0_7 Vdout0_7ck167 = 0.9 time = 840
.meas tran vdout0_7ck167 FIND v(dout0_7) AT=840.025n

* CHECK dout0_8 Vdout0_8ck167 = 0 time = 840
.meas tran vdout0_8ck167 FIND v(dout0_8) AT=840.025n

* CHECK dout0_9 Vdout0_9ck167 = 0 time = 840
.meas tran vdout0_9ck167 FIND v(dout0_9) AT=840.025n

* CHECK dout0_10 Vdout0_10ck167 = 0.9 time = 840
.meas tran vdout0_10ck167 FIND v(dout0_10) AT=840.025n

* CHECK dout0_11 Vdout0_11ck167 = 0 time = 840
.meas tran vdout0_11ck167 FIND v(dout0_11) AT=840.025n

* CHECK dout0_12 Vdout0_12ck167 = 0.9 time = 840
.meas tran vdout0_12ck167 FIND v(dout0_12) AT=840.025n

* CHECK dout0_13 Vdout0_13ck167 = 0 time = 840
.meas tran vdout0_13ck167 FIND v(dout0_13) AT=840.025n

* CHECK dout0_14 Vdout0_14ck167 = 0.9 time = 840
.meas tran vdout0_14ck167 FIND v(dout0_14) AT=840.025n

* CHECK dout0_15 Vdout0_15ck167 = 0.9 time = 840
.meas tran vdout0_15ck167 FIND v(dout0_15) AT=840.025n

* CHECK dout0_16 Vdout0_16ck167 = 0.9 time = 840
.meas tran vdout0_16ck167 FIND v(dout0_16) AT=840.025n

* CHECK dout0_17 Vdout0_17ck167 = 0 time = 840
.meas tran vdout0_17ck167 FIND v(dout0_17) AT=840.025n

* CHECK dout0_18 Vdout0_18ck167 = 0 time = 840
.meas tran vdout0_18ck167 FIND v(dout0_18) AT=840.025n

* CHECK dout0_19 Vdout0_19ck167 = 0.9 time = 840
.meas tran vdout0_19ck167 FIND v(dout0_19) AT=840.025n

* CHECK dout0_20 Vdout0_20ck167 = 0.9 time = 840
.meas tran vdout0_20ck167 FIND v(dout0_20) AT=840.025n

* CHECK dout0_21 Vdout0_21ck167 = 0 time = 840
.meas tran vdout0_21ck167 FIND v(dout0_21) AT=840.025n

* CHECK dout0_22 Vdout0_22ck167 = 0.9 time = 840
.meas tran vdout0_22ck167 FIND v(dout0_22) AT=840.025n

* CHECK dout0_23 Vdout0_23ck167 = 0.9 time = 840
.meas tran vdout0_23ck167 FIND v(dout0_23) AT=840.025n

* CHECK dout0_24 Vdout0_24ck167 = 0 time = 840
.meas tran vdout0_24ck167 FIND v(dout0_24) AT=840.025n

* CHECK dout0_25 Vdout0_25ck167 = 0.9 time = 840
.meas tran vdout0_25ck167 FIND v(dout0_25) AT=840.025n

* CHECK dout0_26 Vdout0_26ck167 = 0 time = 840
.meas tran vdout0_26ck167 FIND v(dout0_26) AT=840.025n

* CHECK dout0_27 Vdout0_27ck167 = 0.9 time = 840
.meas tran vdout0_27ck167 FIND v(dout0_27) AT=840.025n

* CHECK dout0_28 Vdout0_28ck167 = 0.9 time = 840
.meas tran vdout0_28ck167 FIND v(dout0_28) AT=840.025n

* CHECK dout0_29 Vdout0_29ck167 = 0 time = 840
.meas tran vdout0_29ck167 FIND v(dout0_29) AT=840.025n

* CHECK dout0_30 Vdout0_30ck167 = 0 time = 840
.meas tran vdout0_30ck167 FIND v(dout0_30) AT=840.025n

* CHECK dout0_31 Vdout0_31ck167 = 0.9 time = 840
.meas tran vdout0_31ck167 FIND v(dout0_31) AT=840.025n

* CHECK dout0_32 Vdout0_32ck167 = 0 time = 840
.meas tran vdout0_32ck167 FIND v(dout0_32) AT=840.025n

* CHECK dout0_33 Vdout0_33ck167 = 0.9 time = 840
.meas tran vdout0_33ck167 FIND v(dout0_33) AT=840.025n

* CHECK dout0_34 Vdout0_34ck167 = 0.9 time = 840
.meas tran vdout0_34ck167 FIND v(dout0_34) AT=840.025n

* CHECK dout0_35 Vdout0_35ck167 = 0 time = 840
.meas tran vdout0_35ck167 FIND v(dout0_35) AT=840.025n

* CHECK dout0_36 Vdout0_36ck167 = 0 time = 840
.meas tran vdout0_36ck167 FIND v(dout0_36) AT=840.025n

* CHECK dout0_37 Vdout0_37ck167 = 0.9 time = 840
.meas tran vdout0_37ck167 FIND v(dout0_37) AT=840.025n

* CHECK dout0_38 Vdout0_38ck167 = 0.9 time = 840
.meas tran vdout0_38ck167 FIND v(dout0_38) AT=840.025n

* CHECK dout0_39 Vdout0_39ck167 = 0 time = 840
.meas tran vdout0_39ck167 FIND v(dout0_39) AT=840.025n

* CHECK dout0_40 Vdout0_40ck167 = 0 time = 840
.meas tran vdout0_40ck167 FIND v(dout0_40) AT=840.025n

* CHECK dout0_41 Vdout0_41ck167 = 0.9 time = 840
.meas tran vdout0_41ck167 FIND v(dout0_41) AT=840.025n

* CHECK dout0_42 Vdout0_42ck167 = 0.9 time = 840
.meas tran vdout0_42ck167 FIND v(dout0_42) AT=840.025n

* CHECK dout0_43 Vdout0_43ck167 = 0.9 time = 840
.meas tran vdout0_43ck167 FIND v(dout0_43) AT=840.025n

* CHECK dout0_44 Vdout0_44ck167 = 0 time = 840
.meas tran vdout0_44ck167 FIND v(dout0_44) AT=840.025n

* CHECK dout0_45 Vdout0_45ck167 = 0 time = 840
.meas tran vdout0_45ck167 FIND v(dout0_45) AT=840.025n

* CHECK dout0_46 Vdout0_46ck167 = 0.9 time = 840
.meas tran vdout0_46ck167 FIND v(dout0_46) AT=840.025n

* CHECK dout0_47 Vdout0_47ck167 = 0 time = 840
.meas tran vdout0_47ck167 FIND v(dout0_47) AT=840.025n

* CHECK dout0_48 Vdout0_48ck167 = 0.9 time = 840
.meas tran vdout0_48ck167 FIND v(dout0_48) AT=840.025n

* CHECK dout0_49 Vdout0_49ck167 = 0 time = 840
.meas tran vdout0_49ck167 FIND v(dout0_49) AT=840.025n

* CHECK dout0_50 Vdout0_50ck167 = 0 time = 840
.meas tran vdout0_50ck167 FIND v(dout0_50) AT=840.025n

* CHECK dout0_51 Vdout0_51ck167 = 0.9 time = 840
.meas tran vdout0_51ck167 FIND v(dout0_51) AT=840.025n

* CHECK dout0_52 Vdout0_52ck167 = 0.9 time = 840
.meas tran vdout0_52ck167 FIND v(dout0_52) AT=840.025n

* CHECK dout0_53 Vdout0_53ck167 = 0.9 time = 840
.meas tran vdout0_53ck167 FIND v(dout0_53) AT=840.025n

* CHECK dout0_54 Vdout0_54ck167 = 0 time = 840
.meas tran vdout0_54ck167 FIND v(dout0_54) AT=840.025n

* CHECK dout0_55 Vdout0_55ck167 = 0 time = 840
.meas tran vdout0_55ck167 FIND v(dout0_55) AT=840.025n

* CHECK dout0_56 Vdout0_56ck167 = 0.9 time = 840
.meas tran vdout0_56ck167 FIND v(dout0_56) AT=840.025n

* CHECK dout0_57 Vdout0_57ck167 = 0 time = 840
.meas tran vdout0_57ck167 FIND v(dout0_57) AT=840.025n

* CHECK dout0_58 Vdout0_58ck167 = 0 time = 840
.meas tran vdout0_58ck167 FIND v(dout0_58) AT=840.025n

* CHECK dout0_59 Vdout0_59ck167 = 0 time = 840
.meas tran vdout0_59ck167 FIND v(dout0_59) AT=840.025n

* CHECK dout0_60 Vdout0_60ck167 = 0.9 time = 840
.meas tran vdout0_60ck167 FIND v(dout0_60) AT=840.025n

* CHECK dout0_61 Vdout0_61ck167 = 0 time = 840
.meas tran vdout0_61ck167 FIND v(dout0_61) AT=840.025n

* CHECK dout0_62 Vdout0_62ck167 = 0.9 time = 840
.meas tran vdout0_62ck167 FIND v(dout0_62) AT=840.025n

* CHECK dout0_63 Vdout0_63ck167 = 0.9 time = 840
.meas tran vdout0_63ck167 FIND v(dout0_63) AT=840.025n

* CHECK dout0_64 Vdout0_64ck167 = 0.9 time = 840
.meas tran vdout0_64ck167 FIND v(dout0_64) AT=840.025n

* CHECK dout0_65 Vdout0_65ck167 = 0.9 time = 840
.meas tran vdout0_65ck167 FIND v(dout0_65) AT=840.025n

* CHECK dout0_66 Vdout0_66ck167 = 0.9 time = 840
.meas tran vdout0_66ck167 FIND v(dout0_66) AT=840.025n

* CHECK dout0_67 Vdout0_67ck167 = 0 time = 840
.meas tran vdout0_67ck167 FIND v(dout0_67) AT=840.025n

* CHECK dout0_68 Vdout0_68ck167 = 0.9 time = 840
.meas tran vdout0_68ck167 FIND v(dout0_68) AT=840.025n

* CHECK dout0_69 Vdout0_69ck167 = 0 time = 840
.meas tran vdout0_69ck167 FIND v(dout0_69) AT=840.025n

* CHECK dout0_70 Vdout0_70ck167 = 0.9 time = 840
.meas tran vdout0_70ck167 FIND v(dout0_70) AT=840.025n

* CHECK dout0_71 Vdout0_71ck167 = 0.9 time = 840
.meas tran vdout0_71ck167 FIND v(dout0_71) AT=840.025n

* CHECK dout0_72 Vdout0_72ck167 = 0 time = 840
.meas tran vdout0_72ck167 FIND v(dout0_72) AT=840.025n

* CHECK dout0_73 Vdout0_73ck167 = 0.9 time = 840
.meas tran vdout0_73ck167 FIND v(dout0_73) AT=840.025n

* CHECK dout0_74 Vdout0_74ck167 = 0.9 time = 840
.meas tran vdout0_74ck167 FIND v(dout0_74) AT=840.025n

* CHECK dout0_75 Vdout0_75ck167 = 0 time = 840
.meas tran vdout0_75ck167 FIND v(dout0_75) AT=840.025n

* CHECK dout0_76 Vdout0_76ck167 = 0 time = 840
.meas tran vdout0_76ck167 FIND v(dout0_76) AT=840.025n

* CHECK dout0_77 Vdout0_77ck167 = 0.9 time = 840
.meas tran vdout0_77ck167 FIND v(dout0_77) AT=840.025n

* CHECK dout0_78 Vdout0_78ck167 = 0 time = 840
.meas tran vdout0_78ck167 FIND v(dout0_78) AT=840.025n

* CHECK dout0_79 Vdout0_79ck167 = 0.9 time = 840
.meas tran vdout0_79ck167 FIND v(dout0_79) AT=840.025n

* CHECK dout0_80 Vdout0_80ck167 = 0 time = 840
.meas tran vdout0_80ck167 FIND v(dout0_80) AT=840.025n

* CHECK dout0_81 Vdout0_81ck167 = 0.9 time = 840
.meas tran vdout0_81ck167 FIND v(dout0_81) AT=840.025n

* CHECK dout0_82 Vdout0_82ck167 = 0.9 time = 840
.meas tran vdout0_82ck167 FIND v(dout0_82) AT=840.025n

* CHECK dout0_83 Vdout0_83ck167 = 0.9 time = 840
.meas tran vdout0_83ck167 FIND v(dout0_83) AT=840.025n

* CHECK dout0_84 Vdout0_84ck167 = 0.9 time = 840
.meas tran vdout0_84ck167 FIND v(dout0_84) AT=840.025n

* CHECK dout0_85 Vdout0_85ck167 = 0.9 time = 840
.meas tran vdout0_85ck167 FIND v(dout0_85) AT=840.025n

* CHECK dout0_86 Vdout0_86ck167 = 0.9 time = 840
.meas tran vdout0_86ck167 FIND v(dout0_86) AT=840.025n

* CHECK dout0_87 Vdout0_87ck167 = 0.9 time = 840
.meas tran vdout0_87ck167 FIND v(dout0_87) AT=840.025n

* CHECK dout0_0 Vdout0_0ck174 = 0 time = 875
.meas tran vdout0_0ck174 FIND v(dout0_0) AT=875.025n

* CHECK dout0_1 Vdout0_1ck174 = 0.9 time = 875
.meas tran vdout0_1ck174 FIND v(dout0_1) AT=875.025n

* CHECK dout0_2 Vdout0_2ck174 = 0 time = 875
.meas tran vdout0_2ck174 FIND v(dout0_2) AT=875.025n

* CHECK dout0_3 Vdout0_3ck174 = 0.9 time = 875
.meas tran vdout0_3ck174 FIND v(dout0_3) AT=875.025n

* CHECK dout0_4 Vdout0_4ck174 = 0.9 time = 875
.meas tran vdout0_4ck174 FIND v(dout0_4) AT=875.025n

* CHECK dout0_5 Vdout0_5ck174 = 0 time = 875
.meas tran vdout0_5ck174 FIND v(dout0_5) AT=875.025n

* CHECK dout0_6 Vdout0_6ck174 = 0 time = 875
.meas tran vdout0_6ck174 FIND v(dout0_6) AT=875.025n

* CHECK dout0_7 Vdout0_7ck174 = 0 time = 875
.meas tran vdout0_7ck174 FIND v(dout0_7) AT=875.025n

* CHECK dout0_8 Vdout0_8ck174 = 0 time = 875
.meas tran vdout0_8ck174 FIND v(dout0_8) AT=875.025n

* CHECK dout0_9 Vdout0_9ck174 = 0 time = 875
.meas tran vdout0_9ck174 FIND v(dout0_9) AT=875.025n

* CHECK dout0_10 Vdout0_10ck174 = 0.9 time = 875
.meas tran vdout0_10ck174 FIND v(dout0_10) AT=875.025n

* CHECK dout0_11 Vdout0_11ck174 = 0.9 time = 875
.meas tran vdout0_11ck174 FIND v(dout0_11) AT=875.025n

* CHECK dout0_12 Vdout0_12ck174 = 0 time = 875
.meas tran vdout0_12ck174 FIND v(dout0_12) AT=875.025n

* CHECK dout0_13 Vdout0_13ck174 = 0 time = 875
.meas tran vdout0_13ck174 FIND v(dout0_13) AT=875.025n

* CHECK dout0_14 Vdout0_14ck174 = 0.9 time = 875
.meas tran vdout0_14ck174 FIND v(dout0_14) AT=875.025n

* CHECK dout0_15 Vdout0_15ck174 = 0.9 time = 875
.meas tran vdout0_15ck174 FIND v(dout0_15) AT=875.025n

* CHECK dout0_16 Vdout0_16ck174 = 0 time = 875
.meas tran vdout0_16ck174 FIND v(dout0_16) AT=875.025n

* CHECK dout0_17 Vdout0_17ck174 = 0.9 time = 875
.meas tran vdout0_17ck174 FIND v(dout0_17) AT=875.025n

* CHECK dout0_18 Vdout0_18ck174 = 0 time = 875
.meas tran vdout0_18ck174 FIND v(dout0_18) AT=875.025n

* CHECK dout0_19 Vdout0_19ck174 = 0 time = 875
.meas tran vdout0_19ck174 FIND v(dout0_19) AT=875.025n

* CHECK dout0_20 Vdout0_20ck174 = 0 time = 875
.meas tran vdout0_20ck174 FIND v(dout0_20) AT=875.025n

* CHECK dout0_21 Vdout0_21ck174 = 0.9 time = 875
.meas tran vdout0_21ck174 FIND v(dout0_21) AT=875.025n

* CHECK dout0_22 Vdout0_22ck174 = 0.9 time = 875
.meas tran vdout0_22ck174 FIND v(dout0_22) AT=875.025n

* CHECK dout0_23 Vdout0_23ck174 = 0.9 time = 875
.meas tran vdout0_23ck174 FIND v(dout0_23) AT=875.025n

* CHECK dout0_24 Vdout0_24ck174 = 0.9 time = 875
.meas tran vdout0_24ck174 FIND v(dout0_24) AT=875.025n

* CHECK dout0_25 Vdout0_25ck174 = 0.9 time = 875
.meas tran vdout0_25ck174 FIND v(dout0_25) AT=875.025n

* CHECK dout0_26 Vdout0_26ck174 = 0 time = 875
.meas tran vdout0_26ck174 FIND v(dout0_26) AT=875.025n

* CHECK dout0_27 Vdout0_27ck174 = 0.9 time = 875
.meas tran vdout0_27ck174 FIND v(dout0_27) AT=875.025n

* CHECK dout0_28 Vdout0_28ck174 = 0 time = 875
.meas tran vdout0_28ck174 FIND v(dout0_28) AT=875.025n

* CHECK dout0_29 Vdout0_29ck174 = 0.9 time = 875
.meas tran vdout0_29ck174 FIND v(dout0_29) AT=875.025n

* CHECK dout0_30 Vdout0_30ck174 = 0 time = 875
.meas tran vdout0_30ck174 FIND v(dout0_30) AT=875.025n

* CHECK dout0_31 Vdout0_31ck174 = 0 time = 875
.meas tran vdout0_31ck174 FIND v(dout0_31) AT=875.025n

* CHECK dout0_32 Vdout0_32ck174 = 0.9 time = 875
.meas tran vdout0_32ck174 FIND v(dout0_32) AT=875.025n

* CHECK dout0_33 Vdout0_33ck174 = 0 time = 875
.meas tran vdout0_33ck174 FIND v(dout0_33) AT=875.025n

* CHECK dout0_34 Vdout0_34ck174 = 0 time = 875
.meas tran vdout0_34ck174 FIND v(dout0_34) AT=875.025n

* CHECK dout0_35 Vdout0_35ck174 = 0 time = 875
.meas tran vdout0_35ck174 FIND v(dout0_35) AT=875.025n

* CHECK dout0_36 Vdout0_36ck174 = 0 time = 875
.meas tran vdout0_36ck174 FIND v(dout0_36) AT=875.025n

* CHECK dout0_37 Vdout0_37ck174 = 0 time = 875
.meas tran vdout0_37ck174 FIND v(dout0_37) AT=875.025n

* CHECK dout0_38 Vdout0_38ck174 = 0 time = 875
.meas tran vdout0_38ck174 FIND v(dout0_38) AT=875.025n

* CHECK dout0_39 Vdout0_39ck174 = 0 time = 875
.meas tran vdout0_39ck174 FIND v(dout0_39) AT=875.025n

* CHECK dout0_40 Vdout0_40ck174 = 0 time = 875
.meas tran vdout0_40ck174 FIND v(dout0_40) AT=875.025n

* CHECK dout0_41 Vdout0_41ck174 = 0 time = 875
.meas tran vdout0_41ck174 FIND v(dout0_41) AT=875.025n

* CHECK dout0_42 Vdout0_42ck174 = 0.9 time = 875
.meas tran vdout0_42ck174 FIND v(dout0_42) AT=875.025n

* CHECK dout0_43 Vdout0_43ck174 = 0.9 time = 875
.meas tran vdout0_43ck174 FIND v(dout0_43) AT=875.025n

* CHECK dout0_44 Vdout0_44ck174 = 0.9 time = 875
.meas tran vdout0_44ck174 FIND v(dout0_44) AT=875.025n

* CHECK dout0_45 Vdout0_45ck174 = 0 time = 875
.meas tran vdout0_45ck174 FIND v(dout0_45) AT=875.025n

* CHECK dout0_46 Vdout0_46ck174 = 0 time = 875
.meas tran vdout0_46ck174 FIND v(dout0_46) AT=875.025n

* CHECK dout0_47 Vdout0_47ck174 = 0.9 time = 875
.meas tran vdout0_47ck174 FIND v(dout0_47) AT=875.025n

* CHECK dout0_48 Vdout0_48ck174 = 0.9 time = 875
.meas tran vdout0_48ck174 FIND v(dout0_48) AT=875.025n

* CHECK dout0_49 Vdout0_49ck174 = 0 time = 875
.meas tran vdout0_49ck174 FIND v(dout0_49) AT=875.025n

* CHECK dout0_50 Vdout0_50ck174 = 0 time = 875
.meas tran vdout0_50ck174 FIND v(dout0_50) AT=875.025n

* CHECK dout0_51 Vdout0_51ck174 = 0.9 time = 875
.meas tran vdout0_51ck174 FIND v(dout0_51) AT=875.025n

* CHECK dout0_52 Vdout0_52ck174 = 0 time = 875
.meas tran vdout0_52ck174 FIND v(dout0_52) AT=875.025n

* CHECK dout0_53 Vdout0_53ck174 = 0 time = 875
.meas tran vdout0_53ck174 FIND v(dout0_53) AT=875.025n

* CHECK dout0_54 Vdout0_54ck174 = 0 time = 875
.meas tran vdout0_54ck174 FIND v(dout0_54) AT=875.025n

* CHECK dout0_55 Vdout0_55ck174 = 0 time = 875
.meas tran vdout0_55ck174 FIND v(dout0_55) AT=875.025n

* CHECK dout0_56 Vdout0_56ck174 = 0 time = 875
.meas tran vdout0_56ck174 FIND v(dout0_56) AT=875.025n

* CHECK dout0_57 Vdout0_57ck174 = 0 time = 875
.meas tran vdout0_57ck174 FIND v(dout0_57) AT=875.025n

* CHECK dout0_58 Vdout0_58ck174 = 0.9 time = 875
.meas tran vdout0_58ck174 FIND v(dout0_58) AT=875.025n

* CHECK dout0_59 Vdout0_59ck174 = 0 time = 875
.meas tran vdout0_59ck174 FIND v(dout0_59) AT=875.025n

* CHECK dout0_60 Vdout0_60ck174 = 0.9 time = 875
.meas tran vdout0_60ck174 FIND v(dout0_60) AT=875.025n

* CHECK dout0_61 Vdout0_61ck174 = 0.9 time = 875
.meas tran vdout0_61ck174 FIND v(dout0_61) AT=875.025n

* CHECK dout0_62 Vdout0_62ck174 = 0 time = 875
.meas tran vdout0_62ck174 FIND v(dout0_62) AT=875.025n

* CHECK dout0_63 Vdout0_63ck174 = 0.9 time = 875
.meas tran vdout0_63ck174 FIND v(dout0_63) AT=875.025n

* CHECK dout0_64 Vdout0_64ck174 = 0.9 time = 875
.meas tran vdout0_64ck174 FIND v(dout0_64) AT=875.025n

* CHECK dout0_65 Vdout0_65ck174 = 0.9 time = 875
.meas tran vdout0_65ck174 FIND v(dout0_65) AT=875.025n

* CHECK dout0_66 Vdout0_66ck174 = 0.9 time = 875
.meas tran vdout0_66ck174 FIND v(dout0_66) AT=875.025n

* CHECK dout0_67 Vdout0_67ck174 = 0 time = 875
.meas tran vdout0_67ck174 FIND v(dout0_67) AT=875.025n

* CHECK dout0_68 Vdout0_68ck174 = 0 time = 875
.meas tran vdout0_68ck174 FIND v(dout0_68) AT=875.025n

* CHECK dout0_69 Vdout0_69ck174 = 0 time = 875
.meas tran vdout0_69ck174 FIND v(dout0_69) AT=875.025n

* CHECK dout0_70 Vdout0_70ck174 = 0 time = 875
.meas tran vdout0_70ck174 FIND v(dout0_70) AT=875.025n

* CHECK dout0_71 Vdout0_71ck174 = 0.9 time = 875
.meas tran vdout0_71ck174 FIND v(dout0_71) AT=875.025n

* CHECK dout0_72 Vdout0_72ck174 = 0.9 time = 875
.meas tran vdout0_72ck174 FIND v(dout0_72) AT=875.025n

* CHECK dout0_73 Vdout0_73ck174 = 0 time = 875
.meas tran vdout0_73ck174 FIND v(dout0_73) AT=875.025n

* CHECK dout0_74 Vdout0_74ck174 = 0.9 time = 875
.meas tran vdout0_74ck174 FIND v(dout0_74) AT=875.025n

* CHECK dout0_75 Vdout0_75ck174 = 0.9 time = 875
.meas tran vdout0_75ck174 FIND v(dout0_75) AT=875.025n

* CHECK dout0_76 Vdout0_76ck174 = 0 time = 875
.meas tran vdout0_76ck174 FIND v(dout0_76) AT=875.025n

* CHECK dout0_77 Vdout0_77ck174 = 0.9 time = 875
.meas tran vdout0_77ck174 FIND v(dout0_77) AT=875.025n

* CHECK dout0_78 Vdout0_78ck174 = 0.9 time = 875
.meas tran vdout0_78ck174 FIND v(dout0_78) AT=875.025n

* CHECK dout0_79 Vdout0_79ck174 = 0.9 time = 875
.meas tran vdout0_79ck174 FIND v(dout0_79) AT=875.025n

* CHECK dout0_80 Vdout0_80ck174 = 0 time = 875
.meas tran vdout0_80ck174 FIND v(dout0_80) AT=875.025n

* CHECK dout0_81 Vdout0_81ck174 = 0.9 time = 875
.meas tran vdout0_81ck174 FIND v(dout0_81) AT=875.025n

* CHECK dout0_82 Vdout0_82ck174 = 0 time = 875
.meas tran vdout0_82ck174 FIND v(dout0_82) AT=875.025n

* CHECK dout0_83 Vdout0_83ck174 = 0.9 time = 875
.meas tran vdout0_83ck174 FIND v(dout0_83) AT=875.025n

* CHECK dout0_84 Vdout0_84ck174 = 0 time = 875
.meas tran vdout0_84ck174 FIND v(dout0_84) AT=875.025n

* CHECK dout0_85 Vdout0_85ck174 = 0.9 time = 875
.meas tran vdout0_85ck174 FIND v(dout0_85) AT=875.025n

* CHECK dout0_86 Vdout0_86ck174 = 0 time = 875
.meas tran vdout0_86ck174 FIND v(dout0_86) AT=875.025n

* CHECK dout0_87 Vdout0_87ck174 = 0.9 time = 875
.meas tran vdout0_87ck174 FIND v(dout0_87) AT=875.025n

* CHECK dout0_0 Vdout0_0ck177 = 0 time = 890
.meas tran vdout0_0ck177 FIND v(dout0_0) AT=890.025n

* CHECK dout0_1 Vdout0_1ck177 = 0.9 time = 890
.meas tran vdout0_1ck177 FIND v(dout0_1) AT=890.025n

* CHECK dout0_2 Vdout0_2ck177 = 0 time = 890
.meas tran vdout0_2ck177 FIND v(dout0_2) AT=890.025n

* CHECK dout0_3 Vdout0_3ck177 = 0.9 time = 890
.meas tran vdout0_3ck177 FIND v(dout0_3) AT=890.025n

* CHECK dout0_4 Vdout0_4ck177 = 0.9 time = 890
.meas tran vdout0_4ck177 FIND v(dout0_4) AT=890.025n

* CHECK dout0_5 Vdout0_5ck177 = 0 time = 890
.meas tran vdout0_5ck177 FIND v(dout0_5) AT=890.025n

* CHECK dout0_6 Vdout0_6ck177 = 0 time = 890
.meas tran vdout0_6ck177 FIND v(dout0_6) AT=890.025n

* CHECK dout0_7 Vdout0_7ck177 = 0 time = 890
.meas tran vdout0_7ck177 FIND v(dout0_7) AT=890.025n

* CHECK dout0_8 Vdout0_8ck177 = 0 time = 890
.meas tran vdout0_8ck177 FIND v(dout0_8) AT=890.025n

* CHECK dout0_9 Vdout0_9ck177 = 0 time = 890
.meas tran vdout0_9ck177 FIND v(dout0_9) AT=890.025n

* CHECK dout0_10 Vdout0_10ck177 = 0.9 time = 890
.meas tran vdout0_10ck177 FIND v(dout0_10) AT=890.025n

* CHECK dout0_11 Vdout0_11ck177 = 0.9 time = 890
.meas tran vdout0_11ck177 FIND v(dout0_11) AT=890.025n

* CHECK dout0_12 Vdout0_12ck177 = 0 time = 890
.meas tran vdout0_12ck177 FIND v(dout0_12) AT=890.025n

* CHECK dout0_13 Vdout0_13ck177 = 0 time = 890
.meas tran vdout0_13ck177 FIND v(dout0_13) AT=890.025n

* CHECK dout0_14 Vdout0_14ck177 = 0.9 time = 890
.meas tran vdout0_14ck177 FIND v(dout0_14) AT=890.025n

* CHECK dout0_15 Vdout0_15ck177 = 0.9 time = 890
.meas tran vdout0_15ck177 FIND v(dout0_15) AT=890.025n

* CHECK dout0_16 Vdout0_16ck177 = 0 time = 890
.meas tran vdout0_16ck177 FIND v(dout0_16) AT=890.025n

* CHECK dout0_17 Vdout0_17ck177 = 0.9 time = 890
.meas tran vdout0_17ck177 FIND v(dout0_17) AT=890.025n

* CHECK dout0_18 Vdout0_18ck177 = 0 time = 890
.meas tran vdout0_18ck177 FIND v(dout0_18) AT=890.025n

* CHECK dout0_19 Vdout0_19ck177 = 0 time = 890
.meas tran vdout0_19ck177 FIND v(dout0_19) AT=890.025n

* CHECK dout0_20 Vdout0_20ck177 = 0 time = 890
.meas tran vdout0_20ck177 FIND v(dout0_20) AT=890.025n

* CHECK dout0_21 Vdout0_21ck177 = 0.9 time = 890
.meas tran vdout0_21ck177 FIND v(dout0_21) AT=890.025n

* CHECK dout0_22 Vdout0_22ck177 = 0.9 time = 890
.meas tran vdout0_22ck177 FIND v(dout0_22) AT=890.025n

* CHECK dout0_23 Vdout0_23ck177 = 0.9 time = 890
.meas tran vdout0_23ck177 FIND v(dout0_23) AT=890.025n

* CHECK dout0_24 Vdout0_24ck177 = 0.9 time = 890
.meas tran vdout0_24ck177 FIND v(dout0_24) AT=890.025n

* CHECK dout0_25 Vdout0_25ck177 = 0.9 time = 890
.meas tran vdout0_25ck177 FIND v(dout0_25) AT=890.025n

* CHECK dout0_26 Vdout0_26ck177 = 0 time = 890
.meas tran vdout0_26ck177 FIND v(dout0_26) AT=890.025n

* CHECK dout0_27 Vdout0_27ck177 = 0.9 time = 890
.meas tran vdout0_27ck177 FIND v(dout0_27) AT=890.025n

* CHECK dout0_28 Vdout0_28ck177 = 0 time = 890
.meas tran vdout0_28ck177 FIND v(dout0_28) AT=890.025n

* CHECK dout0_29 Vdout0_29ck177 = 0.9 time = 890
.meas tran vdout0_29ck177 FIND v(dout0_29) AT=890.025n

* CHECK dout0_30 Vdout0_30ck177 = 0 time = 890
.meas tran vdout0_30ck177 FIND v(dout0_30) AT=890.025n

* CHECK dout0_31 Vdout0_31ck177 = 0 time = 890
.meas tran vdout0_31ck177 FIND v(dout0_31) AT=890.025n

* CHECK dout0_32 Vdout0_32ck177 = 0.9 time = 890
.meas tran vdout0_32ck177 FIND v(dout0_32) AT=890.025n

* CHECK dout0_33 Vdout0_33ck177 = 0 time = 890
.meas tran vdout0_33ck177 FIND v(dout0_33) AT=890.025n

* CHECK dout0_34 Vdout0_34ck177 = 0 time = 890
.meas tran vdout0_34ck177 FIND v(dout0_34) AT=890.025n

* CHECK dout0_35 Vdout0_35ck177 = 0 time = 890
.meas tran vdout0_35ck177 FIND v(dout0_35) AT=890.025n

* CHECK dout0_36 Vdout0_36ck177 = 0 time = 890
.meas tran vdout0_36ck177 FIND v(dout0_36) AT=890.025n

* CHECK dout0_37 Vdout0_37ck177 = 0 time = 890
.meas tran vdout0_37ck177 FIND v(dout0_37) AT=890.025n

* CHECK dout0_38 Vdout0_38ck177 = 0 time = 890
.meas tran vdout0_38ck177 FIND v(dout0_38) AT=890.025n

* CHECK dout0_39 Vdout0_39ck177 = 0 time = 890
.meas tran vdout0_39ck177 FIND v(dout0_39) AT=890.025n

* CHECK dout0_40 Vdout0_40ck177 = 0 time = 890
.meas tran vdout0_40ck177 FIND v(dout0_40) AT=890.025n

* CHECK dout0_41 Vdout0_41ck177 = 0 time = 890
.meas tran vdout0_41ck177 FIND v(dout0_41) AT=890.025n

* CHECK dout0_42 Vdout0_42ck177 = 0.9 time = 890
.meas tran vdout0_42ck177 FIND v(dout0_42) AT=890.025n

* CHECK dout0_43 Vdout0_43ck177 = 0.9 time = 890
.meas tran vdout0_43ck177 FIND v(dout0_43) AT=890.025n

* CHECK dout0_44 Vdout0_44ck177 = 0.9 time = 890
.meas tran vdout0_44ck177 FIND v(dout0_44) AT=890.025n

* CHECK dout0_45 Vdout0_45ck177 = 0 time = 890
.meas tran vdout0_45ck177 FIND v(dout0_45) AT=890.025n

* CHECK dout0_46 Vdout0_46ck177 = 0 time = 890
.meas tran vdout0_46ck177 FIND v(dout0_46) AT=890.025n

* CHECK dout0_47 Vdout0_47ck177 = 0.9 time = 890
.meas tran vdout0_47ck177 FIND v(dout0_47) AT=890.025n

* CHECK dout0_48 Vdout0_48ck177 = 0.9 time = 890
.meas tran vdout0_48ck177 FIND v(dout0_48) AT=890.025n

* CHECK dout0_49 Vdout0_49ck177 = 0 time = 890
.meas tran vdout0_49ck177 FIND v(dout0_49) AT=890.025n

* CHECK dout0_50 Vdout0_50ck177 = 0 time = 890
.meas tran vdout0_50ck177 FIND v(dout0_50) AT=890.025n

* CHECK dout0_51 Vdout0_51ck177 = 0.9 time = 890
.meas tran vdout0_51ck177 FIND v(dout0_51) AT=890.025n

* CHECK dout0_52 Vdout0_52ck177 = 0 time = 890
.meas tran vdout0_52ck177 FIND v(dout0_52) AT=890.025n

* CHECK dout0_53 Vdout0_53ck177 = 0 time = 890
.meas tran vdout0_53ck177 FIND v(dout0_53) AT=890.025n

* CHECK dout0_54 Vdout0_54ck177 = 0 time = 890
.meas tran vdout0_54ck177 FIND v(dout0_54) AT=890.025n

* CHECK dout0_55 Vdout0_55ck177 = 0 time = 890
.meas tran vdout0_55ck177 FIND v(dout0_55) AT=890.025n

* CHECK dout0_56 Vdout0_56ck177 = 0 time = 890
.meas tran vdout0_56ck177 FIND v(dout0_56) AT=890.025n

* CHECK dout0_57 Vdout0_57ck177 = 0 time = 890
.meas tran vdout0_57ck177 FIND v(dout0_57) AT=890.025n

* CHECK dout0_58 Vdout0_58ck177 = 0.9 time = 890
.meas tran vdout0_58ck177 FIND v(dout0_58) AT=890.025n

* CHECK dout0_59 Vdout0_59ck177 = 0 time = 890
.meas tran vdout0_59ck177 FIND v(dout0_59) AT=890.025n

* CHECK dout0_60 Vdout0_60ck177 = 0.9 time = 890
.meas tran vdout0_60ck177 FIND v(dout0_60) AT=890.025n

* CHECK dout0_61 Vdout0_61ck177 = 0.9 time = 890
.meas tran vdout0_61ck177 FIND v(dout0_61) AT=890.025n

* CHECK dout0_62 Vdout0_62ck177 = 0 time = 890
.meas tran vdout0_62ck177 FIND v(dout0_62) AT=890.025n

* CHECK dout0_63 Vdout0_63ck177 = 0.9 time = 890
.meas tran vdout0_63ck177 FIND v(dout0_63) AT=890.025n

* CHECK dout0_64 Vdout0_64ck177 = 0.9 time = 890
.meas tran vdout0_64ck177 FIND v(dout0_64) AT=890.025n

* CHECK dout0_65 Vdout0_65ck177 = 0.9 time = 890
.meas tran vdout0_65ck177 FIND v(dout0_65) AT=890.025n

* CHECK dout0_66 Vdout0_66ck177 = 0.9 time = 890
.meas tran vdout0_66ck177 FIND v(dout0_66) AT=890.025n

* CHECK dout0_67 Vdout0_67ck177 = 0 time = 890
.meas tran vdout0_67ck177 FIND v(dout0_67) AT=890.025n

* CHECK dout0_68 Vdout0_68ck177 = 0 time = 890
.meas tran vdout0_68ck177 FIND v(dout0_68) AT=890.025n

* CHECK dout0_69 Vdout0_69ck177 = 0 time = 890
.meas tran vdout0_69ck177 FIND v(dout0_69) AT=890.025n

* CHECK dout0_70 Vdout0_70ck177 = 0 time = 890
.meas tran vdout0_70ck177 FIND v(dout0_70) AT=890.025n

* CHECK dout0_71 Vdout0_71ck177 = 0.9 time = 890
.meas tran vdout0_71ck177 FIND v(dout0_71) AT=890.025n

* CHECK dout0_72 Vdout0_72ck177 = 0.9 time = 890
.meas tran vdout0_72ck177 FIND v(dout0_72) AT=890.025n

* CHECK dout0_73 Vdout0_73ck177 = 0 time = 890
.meas tran vdout0_73ck177 FIND v(dout0_73) AT=890.025n

* CHECK dout0_74 Vdout0_74ck177 = 0.9 time = 890
.meas tran vdout0_74ck177 FIND v(dout0_74) AT=890.025n

* CHECK dout0_75 Vdout0_75ck177 = 0.9 time = 890
.meas tran vdout0_75ck177 FIND v(dout0_75) AT=890.025n

* CHECK dout0_76 Vdout0_76ck177 = 0 time = 890
.meas tran vdout0_76ck177 FIND v(dout0_76) AT=890.025n

* CHECK dout0_77 Vdout0_77ck177 = 0.9 time = 890
.meas tran vdout0_77ck177 FIND v(dout0_77) AT=890.025n

* CHECK dout0_78 Vdout0_78ck177 = 0.9 time = 890
.meas tran vdout0_78ck177 FIND v(dout0_78) AT=890.025n

* CHECK dout0_79 Vdout0_79ck177 = 0.9 time = 890
.meas tran vdout0_79ck177 FIND v(dout0_79) AT=890.025n

* CHECK dout0_80 Vdout0_80ck177 = 0 time = 890
.meas tran vdout0_80ck177 FIND v(dout0_80) AT=890.025n

* CHECK dout0_81 Vdout0_81ck177 = 0.9 time = 890
.meas tran vdout0_81ck177 FIND v(dout0_81) AT=890.025n

* CHECK dout0_82 Vdout0_82ck177 = 0 time = 890
.meas tran vdout0_82ck177 FIND v(dout0_82) AT=890.025n

* CHECK dout0_83 Vdout0_83ck177 = 0.9 time = 890
.meas tran vdout0_83ck177 FIND v(dout0_83) AT=890.025n

* CHECK dout0_84 Vdout0_84ck177 = 0 time = 890
.meas tran vdout0_84ck177 FIND v(dout0_84) AT=890.025n

* CHECK dout0_85 Vdout0_85ck177 = 0.9 time = 890
.meas tran vdout0_85ck177 FIND v(dout0_85) AT=890.025n

* CHECK dout0_86 Vdout0_86ck177 = 0 time = 890
.meas tran vdout0_86ck177 FIND v(dout0_86) AT=890.025n

* CHECK dout0_87 Vdout0_87ck177 = 0.9 time = 890
.meas tran vdout0_87ck177 FIND v(dout0_87) AT=890.025n

* CHECK dout0_0 Vdout0_0ck178 = 0 time = 895
.meas tran vdout0_0ck178 FIND v(dout0_0) AT=895.025n

* CHECK dout0_1 Vdout0_1ck178 = 0.9 time = 895
.meas tran vdout0_1ck178 FIND v(dout0_1) AT=895.025n

* CHECK dout0_2 Vdout0_2ck178 = 0 time = 895
.meas tran vdout0_2ck178 FIND v(dout0_2) AT=895.025n

* CHECK dout0_3 Vdout0_3ck178 = 0.9 time = 895
.meas tran vdout0_3ck178 FIND v(dout0_3) AT=895.025n

* CHECK dout0_4 Vdout0_4ck178 = 0.9 time = 895
.meas tran vdout0_4ck178 FIND v(dout0_4) AT=895.025n

* CHECK dout0_5 Vdout0_5ck178 = 0 time = 895
.meas tran vdout0_5ck178 FIND v(dout0_5) AT=895.025n

* CHECK dout0_6 Vdout0_6ck178 = 0 time = 895
.meas tran vdout0_6ck178 FIND v(dout0_6) AT=895.025n

* CHECK dout0_7 Vdout0_7ck178 = 0 time = 895
.meas tran vdout0_7ck178 FIND v(dout0_7) AT=895.025n

* CHECK dout0_8 Vdout0_8ck178 = 0 time = 895
.meas tran vdout0_8ck178 FIND v(dout0_8) AT=895.025n

* CHECK dout0_9 Vdout0_9ck178 = 0 time = 895
.meas tran vdout0_9ck178 FIND v(dout0_9) AT=895.025n

* CHECK dout0_10 Vdout0_10ck178 = 0.9 time = 895
.meas tran vdout0_10ck178 FIND v(dout0_10) AT=895.025n

* CHECK dout0_11 Vdout0_11ck178 = 0.9 time = 895
.meas tran vdout0_11ck178 FIND v(dout0_11) AT=895.025n

* CHECK dout0_12 Vdout0_12ck178 = 0 time = 895
.meas tran vdout0_12ck178 FIND v(dout0_12) AT=895.025n

* CHECK dout0_13 Vdout0_13ck178 = 0 time = 895
.meas tran vdout0_13ck178 FIND v(dout0_13) AT=895.025n

* CHECK dout0_14 Vdout0_14ck178 = 0.9 time = 895
.meas tran vdout0_14ck178 FIND v(dout0_14) AT=895.025n

* CHECK dout0_15 Vdout0_15ck178 = 0.9 time = 895
.meas tran vdout0_15ck178 FIND v(dout0_15) AT=895.025n

* CHECK dout0_16 Vdout0_16ck178 = 0 time = 895
.meas tran vdout0_16ck178 FIND v(dout0_16) AT=895.025n

* CHECK dout0_17 Vdout0_17ck178 = 0.9 time = 895
.meas tran vdout0_17ck178 FIND v(dout0_17) AT=895.025n

* CHECK dout0_18 Vdout0_18ck178 = 0 time = 895
.meas tran vdout0_18ck178 FIND v(dout0_18) AT=895.025n

* CHECK dout0_19 Vdout0_19ck178 = 0 time = 895
.meas tran vdout0_19ck178 FIND v(dout0_19) AT=895.025n

* CHECK dout0_20 Vdout0_20ck178 = 0 time = 895
.meas tran vdout0_20ck178 FIND v(dout0_20) AT=895.025n

* CHECK dout0_21 Vdout0_21ck178 = 0.9 time = 895
.meas tran vdout0_21ck178 FIND v(dout0_21) AT=895.025n

* CHECK dout0_22 Vdout0_22ck178 = 0.9 time = 895
.meas tran vdout0_22ck178 FIND v(dout0_22) AT=895.025n

* CHECK dout0_23 Vdout0_23ck178 = 0.9 time = 895
.meas tran vdout0_23ck178 FIND v(dout0_23) AT=895.025n

* CHECK dout0_24 Vdout0_24ck178 = 0.9 time = 895
.meas tran vdout0_24ck178 FIND v(dout0_24) AT=895.025n

* CHECK dout0_25 Vdout0_25ck178 = 0.9 time = 895
.meas tran vdout0_25ck178 FIND v(dout0_25) AT=895.025n

* CHECK dout0_26 Vdout0_26ck178 = 0 time = 895
.meas tran vdout0_26ck178 FIND v(dout0_26) AT=895.025n

* CHECK dout0_27 Vdout0_27ck178 = 0.9 time = 895
.meas tran vdout0_27ck178 FIND v(dout0_27) AT=895.025n

* CHECK dout0_28 Vdout0_28ck178 = 0 time = 895
.meas tran vdout0_28ck178 FIND v(dout0_28) AT=895.025n

* CHECK dout0_29 Vdout0_29ck178 = 0.9 time = 895
.meas tran vdout0_29ck178 FIND v(dout0_29) AT=895.025n

* CHECK dout0_30 Vdout0_30ck178 = 0 time = 895
.meas tran vdout0_30ck178 FIND v(dout0_30) AT=895.025n

* CHECK dout0_31 Vdout0_31ck178 = 0 time = 895
.meas tran vdout0_31ck178 FIND v(dout0_31) AT=895.025n

* CHECK dout0_32 Vdout0_32ck178 = 0.9 time = 895
.meas tran vdout0_32ck178 FIND v(dout0_32) AT=895.025n

* CHECK dout0_33 Vdout0_33ck178 = 0 time = 895
.meas tran vdout0_33ck178 FIND v(dout0_33) AT=895.025n

* CHECK dout0_34 Vdout0_34ck178 = 0 time = 895
.meas tran vdout0_34ck178 FIND v(dout0_34) AT=895.025n

* CHECK dout0_35 Vdout0_35ck178 = 0 time = 895
.meas tran vdout0_35ck178 FIND v(dout0_35) AT=895.025n

* CHECK dout0_36 Vdout0_36ck178 = 0 time = 895
.meas tran vdout0_36ck178 FIND v(dout0_36) AT=895.025n

* CHECK dout0_37 Vdout0_37ck178 = 0 time = 895
.meas tran vdout0_37ck178 FIND v(dout0_37) AT=895.025n

* CHECK dout0_38 Vdout0_38ck178 = 0 time = 895
.meas tran vdout0_38ck178 FIND v(dout0_38) AT=895.025n

* CHECK dout0_39 Vdout0_39ck178 = 0 time = 895
.meas tran vdout0_39ck178 FIND v(dout0_39) AT=895.025n

* CHECK dout0_40 Vdout0_40ck178 = 0 time = 895
.meas tran vdout0_40ck178 FIND v(dout0_40) AT=895.025n

* CHECK dout0_41 Vdout0_41ck178 = 0 time = 895
.meas tran vdout0_41ck178 FIND v(dout0_41) AT=895.025n

* CHECK dout0_42 Vdout0_42ck178 = 0.9 time = 895
.meas tran vdout0_42ck178 FIND v(dout0_42) AT=895.025n

* CHECK dout0_43 Vdout0_43ck178 = 0.9 time = 895
.meas tran vdout0_43ck178 FIND v(dout0_43) AT=895.025n

* CHECK dout0_44 Vdout0_44ck178 = 0.9 time = 895
.meas tran vdout0_44ck178 FIND v(dout0_44) AT=895.025n

* CHECK dout0_45 Vdout0_45ck178 = 0 time = 895
.meas tran vdout0_45ck178 FIND v(dout0_45) AT=895.025n

* CHECK dout0_46 Vdout0_46ck178 = 0 time = 895
.meas tran vdout0_46ck178 FIND v(dout0_46) AT=895.025n

* CHECK dout0_47 Vdout0_47ck178 = 0.9 time = 895
.meas tran vdout0_47ck178 FIND v(dout0_47) AT=895.025n

* CHECK dout0_48 Vdout0_48ck178 = 0.9 time = 895
.meas tran vdout0_48ck178 FIND v(dout0_48) AT=895.025n

* CHECK dout0_49 Vdout0_49ck178 = 0 time = 895
.meas tran vdout0_49ck178 FIND v(dout0_49) AT=895.025n

* CHECK dout0_50 Vdout0_50ck178 = 0 time = 895
.meas tran vdout0_50ck178 FIND v(dout0_50) AT=895.025n

* CHECK dout0_51 Vdout0_51ck178 = 0.9 time = 895
.meas tran vdout0_51ck178 FIND v(dout0_51) AT=895.025n

* CHECK dout0_52 Vdout0_52ck178 = 0 time = 895
.meas tran vdout0_52ck178 FIND v(dout0_52) AT=895.025n

* CHECK dout0_53 Vdout0_53ck178 = 0 time = 895
.meas tran vdout0_53ck178 FIND v(dout0_53) AT=895.025n

* CHECK dout0_54 Vdout0_54ck178 = 0 time = 895
.meas tran vdout0_54ck178 FIND v(dout0_54) AT=895.025n

* CHECK dout0_55 Vdout0_55ck178 = 0 time = 895
.meas tran vdout0_55ck178 FIND v(dout0_55) AT=895.025n

* CHECK dout0_56 Vdout0_56ck178 = 0 time = 895
.meas tran vdout0_56ck178 FIND v(dout0_56) AT=895.025n

* CHECK dout0_57 Vdout0_57ck178 = 0 time = 895
.meas tran vdout0_57ck178 FIND v(dout0_57) AT=895.025n

* CHECK dout0_58 Vdout0_58ck178 = 0.9 time = 895
.meas tran vdout0_58ck178 FIND v(dout0_58) AT=895.025n

* CHECK dout0_59 Vdout0_59ck178 = 0 time = 895
.meas tran vdout0_59ck178 FIND v(dout0_59) AT=895.025n

* CHECK dout0_60 Vdout0_60ck178 = 0.9 time = 895
.meas tran vdout0_60ck178 FIND v(dout0_60) AT=895.025n

* CHECK dout0_61 Vdout0_61ck178 = 0.9 time = 895
.meas tran vdout0_61ck178 FIND v(dout0_61) AT=895.025n

* CHECK dout0_62 Vdout0_62ck178 = 0 time = 895
.meas tran vdout0_62ck178 FIND v(dout0_62) AT=895.025n

* CHECK dout0_63 Vdout0_63ck178 = 0.9 time = 895
.meas tran vdout0_63ck178 FIND v(dout0_63) AT=895.025n

* CHECK dout0_64 Vdout0_64ck178 = 0.9 time = 895
.meas tran vdout0_64ck178 FIND v(dout0_64) AT=895.025n

* CHECK dout0_65 Vdout0_65ck178 = 0.9 time = 895
.meas tran vdout0_65ck178 FIND v(dout0_65) AT=895.025n

* CHECK dout0_66 Vdout0_66ck178 = 0.9 time = 895
.meas tran vdout0_66ck178 FIND v(dout0_66) AT=895.025n

* CHECK dout0_67 Vdout0_67ck178 = 0 time = 895
.meas tran vdout0_67ck178 FIND v(dout0_67) AT=895.025n

* CHECK dout0_68 Vdout0_68ck178 = 0 time = 895
.meas tran vdout0_68ck178 FIND v(dout0_68) AT=895.025n

* CHECK dout0_69 Vdout0_69ck178 = 0 time = 895
.meas tran vdout0_69ck178 FIND v(dout0_69) AT=895.025n

* CHECK dout0_70 Vdout0_70ck178 = 0 time = 895
.meas tran vdout0_70ck178 FIND v(dout0_70) AT=895.025n

* CHECK dout0_71 Vdout0_71ck178 = 0.9 time = 895
.meas tran vdout0_71ck178 FIND v(dout0_71) AT=895.025n

* CHECK dout0_72 Vdout0_72ck178 = 0.9 time = 895
.meas tran vdout0_72ck178 FIND v(dout0_72) AT=895.025n

* CHECK dout0_73 Vdout0_73ck178 = 0 time = 895
.meas tran vdout0_73ck178 FIND v(dout0_73) AT=895.025n

* CHECK dout0_74 Vdout0_74ck178 = 0.9 time = 895
.meas tran vdout0_74ck178 FIND v(dout0_74) AT=895.025n

* CHECK dout0_75 Vdout0_75ck178 = 0.9 time = 895
.meas tran vdout0_75ck178 FIND v(dout0_75) AT=895.025n

* CHECK dout0_76 Vdout0_76ck178 = 0 time = 895
.meas tran vdout0_76ck178 FIND v(dout0_76) AT=895.025n

* CHECK dout0_77 Vdout0_77ck178 = 0.9 time = 895
.meas tran vdout0_77ck178 FIND v(dout0_77) AT=895.025n

* CHECK dout0_78 Vdout0_78ck178 = 0.9 time = 895
.meas tran vdout0_78ck178 FIND v(dout0_78) AT=895.025n

* CHECK dout0_79 Vdout0_79ck178 = 0.9 time = 895
.meas tran vdout0_79ck178 FIND v(dout0_79) AT=895.025n

* CHECK dout0_80 Vdout0_80ck178 = 0 time = 895
.meas tran vdout0_80ck178 FIND v(dout0_80) AT=895.025n

* CHECK dout0_81 Vdout0_81ck178 = 0.9 time = 895
.meas tran vdout0_81ck178 FIND v(dout0_81) AT=895.025n

* CHECK dout0_82 Vdout0_82ck178 = 0 time = 895
.meas tran vdout0_82ck178 FIND v(dout0_82) AT=895.025n

* CHECK dout0_83 Vdout0_83ck178 = 0.9 time = 895
.meas tran vdout0_83ck178 FIND v(dout0_83) AT=895.025n

* CHECK dout0_84 Vdout0_84ck178 = 0 time = 895
.meas tran vdout0_84ck178 FIND v(dout0_84) AT=895.025n

* CHECK dout0_85 Vdout0_85ck178 = 0.9 time = 895
.meas tran vdout0_85ck178 FIND v(dout0_85) AT=895.025n

* CHECK dout0_86 Vdout0_86ck178 = 0 time = 895
.meas tran vdout0_86ck178 FIND v(dout0_86) AT=895.025n

* CHECK dout0_87 Vdout0_87ck178 = 0.9 time = 895
.meas tran vdout0_87ck178 FIND v(dout0_87) AT=895.025n

* CHECK dout0_0 Vdout0_0ck179 = 0 time = 900
.meas tran vdout0_0ck179 FIND v(dout0_0) AT=900.025n

* CHECK dout0_1 Vdout0_1ck179 = 0.9 time = 900
.meas tran vdout0_1ck179 FIND v(dout0_1) AT=900.025n

* CHECK dout0_2 Vdout0_2ck179 = 0 time = 900
.meas tran vdout0_2ck179 FIND v(dout0_2) AT=900.025n

* CHECK dout0_3 Vdout0_3ck179 = 0.9 time = 900
.meas tran vdout0_3ck179 FIND v(dout0_3) AT=900.025n

* CHECK dout0_4 Vdout0_4ck179 = 0.9 time = 900
.meas tran vdout0_4ck179 FIND v(dout0_4) AT=900.025n

* CHECK dout0_5 Vdout0_5ck179 = 0 time = 900
.meas tran vdout0_5ck179 FIND v(dout0_5) AT=900.025n

* CHECK dout0_6 Vdout0_6ck179 = 0 time = 900
.meas tran vdout0_6ck179 FIND v(dout0_6) AT=900.025n

* CHECK dout0_7 Vdout0_7ck179 = 0 time = 900
.meas tran vdout0_7ck179 FIND v(dout0_7) AT=900.025n

* CHECK dout0_8 Vdout0_8ck179 = 0 time = 900
.meas tran vdout0_8ck179 FIND v(dout0_8) AT=900.025n

* CHECK dout0_9 Vdout0_9ck179 = 0 time = 900
.meas tran vdout0_9ck179 FIND v(dout0_9) AT=900.025n

* CHECK dout0_10 Vdout0_10ck179 = 0.9 time = 900
.meas tran vdout0_10ck179 FIND v(dout0_10) AT=900.025n

* CHECK dout0_11 Vdout0_11ck179 = 0.9 time = 900
.meas tran vdout0_11ck179 FIND v(dout0_11) AT=900.025n

* CHECK dout0_12 Vdout0_12ck179 = 0 time = 900
.meas tran vdout0_12ck179 FIND v(dout0_12) AT=900.025n

* CHECK dout0_13 Vdout0_13ck179 = 0 time = 900
.meas tran vdout0_13ck179 FIND v(dout0_13) AT=900.025n

* CHECK dout0_14 Vdout0_14ck179 = 0.9 time = 900
.meas tran vdout0_14ck179 FIND v(dout0_14) AT=900.025n

* CHECK dout0_15 Vdout0_15ck179 = 0.9 time = 900
.meas tran vdout0_15ck179 FIND v(dout0_15) AT=900.025n

* CHECK dout0_16 Vdout0_16ck179 = 0 time = 900
.meas tran vdout0_16ck179 FIND v(dout0_16) AT=900.025n

* CHECK dout0_17 Vdout0_17ck179 = 0.9 time = 900
.meas tran vdout0_17ck179 FIND v(dout0_17) AT=900.025n

* CHECK dout0_18 Vdout0_18ck179 = 0 time = 900
.meas tran vdout0_18ck179 FIND v(dout0_18) AT=900.025n

* CHECK dout0_19 Vdout0_19ck179 = 0 time = 900
.meas tran vdout0_19ck179 FIND v(dout0_19) AT=900.025n

* CHECK dout0_20 Vdout0_20ck179 = 0 time = 900
.meas tran vdout0_20ck179 FIND v(dout0_20) AT=900.025n

* CHECK dout0_21 Vdout0_21ck179 = 0.9 time = 900
.meas tran vdout0_21ck179 FIND v(dout0_21) AT=900.025n

* CHECK dout0_22 Vdout0_22ck179 = 0.9 time = 900
.meas tran vdout0_22ck179 FIND v(dout0_22) AT=900.025n

* CHECK dout0_23 Vdout0_23ck179 = 0.9 time = 900
.meas tran vdout0_23ck179 FIND v(dout0_23) AT=900.025n

* CHECK dout0_24 Vdout0_24ck179 = 0.9 time = 900
.meas tran vdout0_24ck179 FIND v(dout0_24) AT=900.025n

* CHECK dout0_25 Vdout0_25ck179 = 0.9 time = 900
.meas tran vdout0_25ck179 FIND v(dout0_25) AT=900.025n

* CHECK dout0_26 Vdout0_26ck179 = 0 time = 900
.meas tran vdout0_26ck179 FIND v(dout0_26) AT=900.025n

* CHECK dout0_27 Vdout0_27ck179 = 0.9 time = 900
.meas tran vdout0_27ck179 FIND v(dout0_27) AT=900.025n

* CHECK dout0_28 Vdout0_28ck179 = 0 time = 900
.meas tran vdout0_28ck179 FIND v(dout0_28) AT=900.025n

* CHECK dout0_29 Vdout0_29ck179 = 0.9 time = 900
.meas tran vdout0_29ck179 FIND v(dout0_29) AT=900.025n

* CHECK dout0_30 Vdout0_30ck179 = 0 time = 900
.meas tran vdout0_30ck179 FIND v(dout0_30) AT=900.025n

* CHECK dout0_31 Vdout0_31ck179 = 0 time = 900
.meas tran vdout0_31ck179 FIND v(dout0_31) AT=900.025n

* CHECK dout0_32 Vdout0_32ck179 = 0.9 time = 900
.meas tran vdout0_32ck179 FIND v(dout0_32) AT=900.025n

* CHECK dout0_33 Vdout0_33ck179 = 0 time = 900
.meas tran vdout0_33ck179 FIND v(dout0_33) AT=900.025n

* CHECK dout0_34 Vdout0_34ck179 = 0 time = 900
.meas tran vdout0_34ck179 FIND v(dout0_34) AT=900.025n

* CHECK dout0_35 Vdout0_35ck179 = 0 time = 900
.meas tran vdout0_35ck179 FIND v(dout0_35) AT=900.025n

* CHECK dout0_36 Vdout0_36ck179 = 0 time = 900
.meas tran vdout0_36ck179 FIND v(dout0_36) AT=900.025n

* CHECK dout0_37 Vdout0_37ck179 = 0 time = 900
.meas tran vdout0_37ck179 FIND v(dout0_37) AT=900.025n

* CHECK dout0_38 Vdout0_38ck179 = 0 time = 900
.meas tran vdout0_38ck179 FIND v(dout0_38) AT=900.025n

* CHECK dout0_39 Vdout0_39ck179 = 0 time = 900
.meas tran vdout0_39ck179 FIND v(dout0_39) AT=900.025n

* CHECK dout0_40 Vdout0_40ck179 = 0 time = 900
.meas tran vdout0_40ck179 FIND v(dout0_40) AT=900.025n

* CHECK dout0_41 Vdout0_41ck179 = 0 time = 900
.meas tran vdout0_41ck179 FIND v(dout0_41) AT=900.025n

* CHECK dout0_42 Vdout0_42ck179 = 0.9 time = 900
.meas tran vdout0_42ck179 FIND v(dout0_42) AT=900.025n

* CHECK dout0_43 Vdout0_43ck179 = 0.9 time = 900
.meas tran vdout0_43ck179 FIND v(dout0_43) AT=900.025n

* CHECK dout0_44 Vdout0_44ck179 = 0.9 time = 900
.meas tran vdout0_44ck179 FIND v(dout0_44) AT=900.025n

* CHECK dout0_45 Vdout0_45ck179 = 0 time = 900
.meas tran vdout0_45ck179 FIND v(dout0_45) AT=900.025n

* CHECK dout0_46 Vdout0_46ck179 = 0 time = 900
.meas tran vdout0_46ck179 FIND v(dout0_46) AT=900.025n

* CHECK dout0_47 Vdout0_47ck179 = 0.9 time = 900
.meas tran vdout0_47ck179 FIND v(dout0_47) AT=900.025n

* CHECK dout0_48 Vdout0_48ck179 = 0.9 time = 900
.meas tran vdout0_48ck179 FIND v(dout0_48) AT=900.025n

* CHECK dout0_49 Vdout0_49ck179 = 0 time = 900
.meas tran vdout0_49ck179 FIND v(dout0_49) AT=900.025n

* CHECK dout0_50 Vdout0_50ck179 = 0 time = 900
.meas tran vdout0_50ck179 FIND v(dout0_50) AT=900.025n

* CHECK dout0_51 Vdout0_51ck179 = 0.9 time = 900
.meas tran vdout0_51ck179 FIND v(dout0_51) AT=900.025n

* CHECK dout0_52 Vdout0_52ck179 = 0 time = 900
.meas tran vdout0_52ck179 FIND v(dout0_52) AT=900.025n

* CHECK dout0_53 Vdout0_53ck179 = 0 time = 900
.meas tran vdout0_53ck179 FIND v(dout0_53) AT=900.025n

* CHECK dout0_54 Vdout0_54ck179 = 0 time = 900
.meas tran vdout0_54ck179 FIND v(dout0_54) AT=900.025n

* CHECK dout0_55 Vdout0_55ck179 = 0 time = 900
.meas tran vdout0_55ck179 FIND v(dout0_55) AT=900.025n

* CHECK dout0_56 Vdout0_56ck179 = 0 time = 900
.meas tran vdout0_56ck179 FIND v(dout0_56) AT=900.025n

* CHECK dout0_57 Vdout0_57ck179 = 0 time = 900
.meas tran vdout0_57ck179 FIND v(dout0_57) AT=900.025n

* CHECK dout0_58 Vdout0_58ck179 = 0.9 time = 900
.meas tran vdout0_58ck179 FIND v(dout0_58) AT=900.025n

* CHECK dout0_59 Vdout0_59ck179 = 0 time = 900
.meas tran vdout0_59ck179 FIND v(dout0_59) AT=900.025n

* CHECK dout0_60 Vdout0_60ck179 = 0.9 time = 900
.meas tran vdout0_60ck179 FIND v(dout0_60) AT=900.025n

* CHECK dout0_61 Vdout0_61ck179 = 0.9 time = 900
.meas tran vdout0_61ck179 FIND v(dout0_61) AT=900.025n

* CHECK dout0_62 Vdout0_62ck179 = 0 time = 900
.meas tran vdout0_62ck179 FIND v(dout0_62) AT=900.025n

* CHECK dout0_63 Vdout0_63ck179 = 0.9 time = 900
.meas tran vdout0_63ck179 FIND v(dout0_63) AT=900.025n

* CHECK dout0_64 Vdout0_64ck179 = 0.9 time = 900
.meas tran vdout0_64ck179 FIND v(dout0_64) AT=900.025n

* CHECK dout0_65 Vdout0_65ck179 = 0.9 time = 900
.meas tran vdout0_65ck179 FIND v(dout0_65) AT=900.025n

* CHECK dout0_66 Vdout0_66ck179 = 0.9 time = 900
.meas tran vdout0_66ck179 FIND v(dout0_66) AT=900.025n

* CHECK dout0_67 Vdout0_67ck179 = 0 time = 900
.meas tran vdout0_67ck179 FIND v(dout0_67) AT=900.025n

* CHECK dout0_68 Vdout0_68ck179 = 0 time = 900
.meas tran vdout0_68ck179 FIND v(dout0_68) AT=900.025n

* CHECK dout0_69 Vdout0_69ck179 = 0 time = 900
.meas tran vdout0_69ck179 FIND v(dout0_69) AT=900.025n

* CHECK dout0_70 Vdout0_70ck179 = 0 time = 900
.meas tran vdout0_70ck179 FIND v(dout0_70) AT=900.025n

* CHECK dout0_71 Vdout0_71ck179 = 0.9 time = 900
.meas tran vdout0_71ck179 FIND v(dout0_71) AT=900.025n

* CHECK dout0_72 Vdout0_72ck179 = 0.9 time = 900
.meas tran vdout0_72ck179 FIND v(dout0_72) AT=900.025n

* CHECK dout0_73 Vdout0_73ck179 = 0 time = 900
.meas tran vdout0_73ck179 FIND v(dout0_73) AT=900.025n

* CHECK dout0_74 Vdout0_74ck179 = 0.9 time = 900
.meas tran vdout0_74ck179 FIND v(dout0_74) AT=900.025n

* CHECK dout0_75 Vdout0_75ck179 = 0.9 time = 900
.meas tran vdout0_75ck179 FIND v(dout0_75) AT=900.025n

* CHECK dout0_76 Vdout0_76ck179 = 0 time = 900
.meas tran vdout0_76ck179 FIND v(dout0_76) AT=900.025n

* CHECK dout0_77 Vdout0_77ck179 = 0.9 time = 900
.meas tran vdout0_77ck179 FIND v(dout0_77) AT=900.025n

* CHECK dout0_78 Vdout0_78ck179 = 0.9 time = 900
.meas tran vdout0_78ck179 FIND v(dout0_78) AT=900.025n

* CHECK dout0_79 Vdout0_79ck179 = 0.9 time = 900
.meas tran vdout0_79ck179 FIND v(dout0_79) AT=900.025n

* CHECK dout0_80 Vdout0_80ck179 = 0 time = 900
.meas tran vdout0_80ck179 FIND v(dout0_80) AT=900.025n

* CHECK dout0_81 Vdout0_81ck179 = 0.9 time = 900
.meas tran vdout0_81ck179 FIND v(dout0_81) AT=900.025n

* CHECK dout0_82 Vdout0_82ck179 = 0 time = 900
.meas tran vdout0_82ck179 FIND v(dout0_82) AT=900.025n

* CHECK dout0_83 Vdout0_83ck179 = 0.9 time = 900
.meas tran vdout0_83ck179 FIND v(dout0_83) AT=900.025n

* CHECK dout0_84 Vdout0_84ck179 = 0 time = 900
.meas tran vdout0_84ck179 FIND v(dout0_84) AT=900.025n

* CHECK dout0_85 Vdout0_85ck179 = 0.9 time = 900
.meas tran vdout0_85ck179 FIND v(dout0_85) AT=900.025n

* CHECK dout0_86 Vdout0_86ck179 = 0 time = 900
.meas tran vdout0_86ck179 FIND v(dout0_86) AT=900.025n

* CHECK dout0_87 Vdout0_87ck179 = 0.9 time = 900
.meas tran vdout0_87ck179 FIND v(dout0_87) AT=900.025n

* CHECK dout0_0 Vdout0_0ck181 = 0 time = 910
.meas tran vdout0_0ck181 FIND v(dout0_0) AT=910.025n

* CHECK dout0_1 Vdout0_1ck181 = 0.9 time = 910
.meas tran vdout0_1ck181 FIND v(dout0_1) AT=910.025n

* CHECK dout0_2 Vdout0_2ck181 = 0 time = 910
.meas tran vdout0_2ck181 FIND v(dout0_2) AT=910.025n

* CHECK dout0_3 Vdout0_3ck181 = 0.9 time = 910
.meas tran vdout0_3ck181 FIND v(dout0_3) AT=910.025n

* CHECK dout0_4 Vdout0_4ck181 = 0.9 time = 910
.meas tran vdout0_4ck181 FIND v(dout0_4) AT=910.025n

* CHECK dout0_5 Vdout0_5ck181 = 0 time = 910
.meas tran vdout0_5ck181 FIND v(dout0_5) AT=910.025n

* CHECK dout0_6 Vdout0_6ck181 = 0 time = 910
.meas tran vdout0_6ck181 FIND v(dout0_6) AT=910.025n

* CHECK dout0_7 Vdout0_7ck181 = 0 time = 910
.meas tran vdout0_7ck181 FIND v(dout0_7) AT=910.025n

* CHECK dout0_8 Vdout0_8ck181 = 0 time = 910
.meas tran vdout0_8ck181 FIND v(dout0_8) AT=910.025n

* CHECK dout0_9 Vdout0_9ck181 = 0 time = 910
.meas tran vdout0_9ck181 FIND v(dout0_9) AT=910.025n

* CHECK dout0_10 Vdout0_10ck181 = 0.9 time = 910
.meas tran vdout0_10ck181 FIND v(dout0_10) AT=910.025n

* CHECK dout0_11 Vdout0_11ck181 = 0.9 time = 910
.meas tran vdout0_11ck181 FIND v(dout0_11) AT=910.025n

* CHECK dout0_12 Vdout0_12ck181 = 0 time = 910
.meas tran vdout0_12ck181 FIND v(dout0_12) AT=910.025n

* CHECK dout0_13 Vdout0_13ck181 = 0 time = 910
.meas tran vdout0_13ck181 FIND v(dout0_13) AT=910.025n

* CHECK dout0_14 Vdout0_14ck181 = 0.9 time = 910
.meas tran vdout0_14ck181 FIND v(dout0_14) AT=910.025n

* CHECK dout0_15 Vdout0_15ck181 = 0.9 time = 910
.meas tran vdout0_15ck181 FIND v(dout0_15) AT=910.025n

* CHECK dout0_16 Vdout0_16ck181 = 0 time = 910
.meas tran vdout0_16ck181 FIND v(dout0_16) AT=910.025n

* CHECK dout0_17 Vdout0_17ck181 = 0.9 time = 910
.meas tran vdout0_17ck181 FIND v(dout0_17) AT=910.025n

* CHECK dout0_18 Vdout0_18ck181 = 0 time = 910
.meas tran vdout0_18ck181 FIND v(dout0_18) AT=910.025n

* CHECK dout0_19 Vdout0_19ck181 = 0 time = 910
.meas tran vdout0_19ck181 FIND v(dout0_19) AT=910.025n

* CHECK dout0_20 Vdout0_20ck181 = 0 time = 910
.meas tran vdout0_20ck181 FIND v(dout0_20) AT=910.025n

* CHECK dout0_21 Vdout0_21ck181 = 0.9 time = 910
.meas tran vdout0_21ck181 FIND v(dout0_21) AT=910.025n

* CHECK dout0_22 Vdout0_22ck181 = 0.9 time = 910
.meas tran vdout0_22ck181 FIND v(dout0_22) AT=910.025n

* CHECK dout0_23 Vdout0_23ck181 = 0.9 time = 910
.meas tran vdout0_23ck181 FIND v(dout0_23) AT=910.025n

* CHECK dout0_24 Vdout0_24ck181 = 0.9 time = 910
.meas tran vdout0_24ck181 FIND v(dout0_24) AT=910.025n

* CHECK dout0_25 Vdout0_25ck181 = 0.9 time = 910
.meas tran vdout0_25ck181 FIND v(dout0_25) AT=910.025n

* CHECK dout0_26 Vdout0_26ck181 = 0 time = 910
.meas tran vdout0_26ck181 FIND v(dout0_26) AT=910.025n

* CHECK dout0_27 Vdout0_27ck181 = 0.9 time = 910
.meas tran vdout0_27ck181 FIND v(dout0_27) AT=910.025n

* CHECK dout0_28 Vdout0_28ck181 = 0 time = 910
.meas tran vdout0_28ck181 FIND v(dout0_28) AT=910.025n

* CHECK dout0_29 Vdout0_29ck181 = 0.9 time = 910
.meas tran vdout0_29ck181 FIND v(dout0_29) AT=910.025n

* CHECK dout0_30 Vdout0_30ck181 = 0 time = 910
.meas tran vdout0_30ck181 FIND v(dout0_30) AT=910.025n

* CHECK dout0_31 Vdout0_31ck181 = 0 time = 910
.meas tran vdout0_31ck181 FIND v(dout0_31) AT=910.025n

* CHECK dout0_32 Vdout0_32ck181 = 0.9 time = 910
.meas tran vdout0_32ck181 FIND v(dout0_32) AT=910.025n

* CHECK dout0_33 Vdout0_33ck181 = 0 time = 910
.meas tran vdout0_33ck181 FIND v(dout0_33) AT=910.025n

* CHECK dout0_34 Vdout0_34ck181 = 0 time = 910
.meas tran vdout0_34ck181 FIND v(dout0_34) AT=910.025n

* CHECK dout0_35 Vdout0_35ck181 = 0 time = 910
.meas tran vdout0_35ck181 FIND v(dout0_35) AT=910.025n

* CHECK dout0_36 Vdout0_36ck181 = 0 time = 910
.meas tran vdout0_36ck181 FIND v(dout0_36) AT=910.025n

* CHECK dout0_37 Vdout0_37ck181 = 0 time = 910
.meas tran vdout0_37ck181 FIND v(dout0_37) AT=910.025n

* CHECK dout0_38 Vdout0_38ck181 = 0 time = 910
.meas tran vdout0_38ck181 FIND v(dout0_38) AT=910.025n

* CHECK dout0_39 Vdout0_39ck181 = 0 time = 910
.meas tran vdout0_39ck181 FIND v(dout0_39) AT=910.025n

* CHECK dout0_40 Vdout0_40ck181 = 0 time = 910
.meas tran vdout0_40ck181 FIND v(dout0_40) AT=910.025n

* CHECK dout0_41 Vdout0_41ck181 = 0 time = 910
.meas tran vdout0_41ck181 FIND v(dout0_41) AT=910.025n

* CHECK dout0_42 Vdout0_42ck181 = 0.9 time = 910
.meas tran vdout0_42ck181 FIND v(dout0_42) AT=910.025n

* CHECK dout0_43 Vdout0_43ck181 = 0.9 time = 910
.meas tran vdout0_43ck181 FIND v(dout0_43) AT=910.025n

* CHECK dout0_44 Vdout0_44ck181 = 0.9 time = 910
.meas tran vdout0_44ck181 FIND v(dout0_44) AT=910.025n

* CHECK dout0_45 Vdout0_45ck181 = 0 time = 910
.meas tran vdout0_45ck181 FIND v(dout0_45) AT=910.025n

* CHECK dout0_46 Vdout0_46ck181 = 0 time = 910
.meas tran vdout0_46ck181 FIND v(dout0_46) AT=910.025n

* CHECK dout0_47 Vdout0_47ck181 = 0.9 time = 910
.meas tran vdout0_47ck181 FIND v(dout0_47) AT=910.025n

* CHECK dout0_48 Vdout0_48ck181 = 0.9 time = 910
.meas tran vdout0_48ck181 FIND v(dout0_48) AT=910.025n

* CHECK dout0_49 Vdout0_49ck181 = 0 time = 910
.meas tran vdout0_49ck181 FIND v(dout0_49) AT=910.025n

* CHECK dout0_50 Vdout0_50ck181 = 0 time = 910
.meas tran vdout0_50ck181 FIND v(dout0_50) AT=910.025n

* CHECK dout0_51 Vdout0_51ck181 = 0.9 time = 910
.meas tran vdout0_51ck181 FIND v(dout0_51) AT=910.025n

* CHECK dout0_52 Vdout0_52ck181 = 0 time = 910
.meas tran vdout0_52ck181 FIND v(dout0_52) AT=910.025n

* CHECK dout0_53 Vdout0_53ck181 = 0 time = 910
.meas tran vdout0_53ck181 FIND v(dout0_53) AT=910.025n

* CHECK dout0_54 Vdout0_54ck181 = 0 time = 910
.meas tran vdout0_54ck181 FIND v(dout0_54) AT=910.025n

* CHECK dout0_55 Vdout0_55ck181 = 0 time = 910
.meas tran vdout0_55ck181 FIND v(dout0_55) AT=910.025n

* CHECK dout0_56 Vdout0_56ck181 = 0 time = 910
.meas tran vdout0_56ck181 FIND v(dout0_56) AT=910.025n

* CHECK dout0_57 Vdout0_57ck181 = 0 time = 910
.meas tran vdout0_57ck181 FIND v(dout0_57) AT=910.025n

* CHECK dout0_58 Vdout0_58ck181 = 0.9 time = 910
.meas tran vdout0_58ck181 FIND v(dout0_58) AT=910.025n

* CHECK dout0_59 Vdout0_59ck181 = 0 time = 910
.meas tran vdout0_59ck181 FIND v(dout0_59) AT=910.025n

* CHECK dout0_60 Vdout0_60ck181 = 0.9 time = 910
.meas tran vdout0_60ck181 FIND v(dout0_60) AT=910.025n

* CHECK dout0_61 Vdout0_61ck181 = 0.9 time = 910
.meas tran vdout0_61ck181 FIND v(dout0_61) AT=910.025n

* CHECK dout0_62 Vdout0_62ck181 = 0 time = 910
.meas tran vdout0_62ck181 FIND v(dout0_62) AT=910.025n

* CHECK dout0_63 Vdout0_63ck181 = 0.9 time = 910
.meas tran vdout0_63ck181 FIND v(dout0_63) AT=910.025n

* CHECK dout0_64 Vdout0_64ck181 = 0.9 time = 910
.meas tran vdout0_64ck181 FIND v(dout0_64) AT=910.025n

* CHECK dout0_65 Vdout0_65ck181 = 0.9 time = 910
.meas tran vdout0_65ck181 FIND v(dout0_65) AT=910.025n

* CHECK dout0_66 Vdout0_66ck181 = 0.9 time = 910
.meas tran vdout0_66ck181 FIND v(dout0_66) AT=910.025n

* CHECK dout0_67 Vdout0_67ck181 = 0 time = 910
.meas tran vdout0_67ck181 FIND v(dout0_67) AT=910.025n

* CHECK dout0_68 Vdout0_68ck181 = 0 time = 910
.meas tran vdout0_68ck181 FIND v(dout0_68) AT=910.025n

* CHECK dout0_69 Vdout0_69ck181 = 0 time = 910
.meas tran vdout0_69ck181 FIND v(dout0_69) AT=910.025n

* CHECK dout0_70 Vdout0_70ck181 = 0 time = 910
.meas tran vdout0_70ck181 FIND v(dout0_70) AT=910.025n

* CHECK dout0_71 Vdout0_71ck181 = 0.9 time = 910
.meas tran vdout0_71ck181 FIND v(dout0_71) AT=910.025n

* CHECK dout0_72 Vdout0_72ck181 = 0.9 time = 910
.meas tran vdout0_72ck181 FIND v(dout0_72) AT=910.025n

* CHECK dout0_73 Vdout0_73ck181 = 0 time = 910
.meas tran vdout0_73ck181 FIND v(dout0_73) AT=910.025n

* CHECK dout0_74 Vdout0_74ck181 = 0.9 time = 910
.meas tran vdout0_74ck181 FIND v(dout0_74) AT=910.025n

* CHECK dout0_75 Vdout0_75ck181 = 0.9 time = 910
.meas tran vdout0_75ck181 FIND v(dout0_75) AT=910.025n

* CHECK dout0_76 Vdout0_76ck181 = 0 time = 910
.meas tran vdout0_76ck181 FIND v(dout0_76) AT=910.025n

* CHECK dout0_77 Vdout0_77ck181 = 0.9 time = 910
.meas tran vdout0_77ck181 FIND v(dout0_77) AT=910.025n

* CHECK dout0_78 Vdout0_78ck181 = 0.9 time = 910
.meas tran vdout0_78ck181 FIND v(dout0_78) AT=910.025n

* CHECK dout0_79 Vdout0_79ck181 = 0.9 time = 910
.meas tran vdout0_79ck181 FIND v(dout0_79) AT=910.025n

* CHECK dout0_80 Vdout0_80ck181 = 0 time = 910
.meas tran vdout0_80ck181 FIND v(dout0_80) AT=910.025n

* CHECK dout0_81 Vdout0_81ck181 = 0.9 time = 910
.meas tran vdout0_81ck181 FIND v(dout0_81) AT=910.025n

* CHECK dout0_82 Vdout0_82ck181 = 0 time = 910
.meas tran vdout0_82ck181 FIND v(dout0_82) AT=910.025n

* CHECK dout0_83 Vdout0_83ck181 = 0.9 time = 910
.meas tran vdout0_83ck181 FIND v(dout0_83) AT=910.025n

* CHECK dout0_84 Vdout0_84ck181 = 0 time = 910
.meas tran vdout0_84ck181 FIND v(dout0_84) AT=910.025n

* CHECK dout0_85 Vdout0_85ck181 = 0.9 time = 910
.meas tran vdout0_85ck181 FIND v(dout0_85) AT=910.025n

* CHECK dout0_86 Vdout0_86ck181 = 0 time = 910
.meas tran vdout0_86ck181 FIND v(dout0_86) AT=910.025n

* CHECK dout0_87 Vdout0_87ck181 = 0.9 time = 910
.meas tran vdout0_87ck181 FIND v(dout0_87) AT=910.025n

* CHECK dout0_0 Vdout0_0ck185 = 0.9 time = 930
.meas tran vdout0_0ck185 FIND v(dout0_0) AT=930.025n

* CHECK dout0_1 Vdout0_1ck185 = 0.9 time = 930
.meas tran vdout0_1ck185 FIND v(dout0_1) AT=930.025n

* CHECK dout0_2 Vdout0_2ck185 = 0.9 time = 930
.meas tran vdout0_2ck185 FIND v(dout0_2) AT=930.025n

* CHECK dout0_3 Vdout0_3ck185 = 0 time = 930
.meas tran vdout0_3ck185 FIND v(dout0_3) AT=930.025n

* CHECK dout0_4 Vdout0_4ck185 = 0.9 time = 930
.meas tran vdout0_4ck185 FIND v(dout0_4) AT=930.025n

* CHECK dout0_5 Vdout0_5ck185 = 0.9 time = 930
.meas tran vdout0_5ck185 FIND v(dout0_5) AT=930.025n

* CHECK dout0_6 Vdout0_6ck185 = 0 time = 930
.meas tran vdout0_6ck185 FIND v(dout0_6) AT=930.025n

* CHECK dout0_7 Vdout0_7ck185 = 0.9 time = 930
.meas tran vdout0_7ck185 FIND v(dout0_7) AT=930.025n

* CHECK dout0_8 Vdout0_8ck185 = 0 time = 930
.meas tran vdout0_8ck185 FIND v(dout0_8) AT=930.025n

* CHECK dout0_9 Vdout0_9ck185 = 0 time = 930
.meas tran vdout0_9ck185 FIND v(dout0_9) AT=930.025n

* CHECK dout0_10 Vdout0_10ck185 = 0.9 time = 930
.meas tran vdout0_10ck185 FIND v(dout0_10) AT=930.025n

* CHECK dout0_11 Vdout0_11ck185 = 0.9 time = 930
.meas tran vdout0_11ck185 FIND v(dout0_11) AT=930.025n

* CHECK dout0_12 Vdout0_12ck185 = 0.9 time = 930
.meas tran vdout0_12ck185 FIND v(dout0_12) AT=930.025n

* CHECK dout0_13 Vdout0_13ck185 = 0 time = 930
.meas tran vdout0_13ck185 FIND v(dout0_13) AT=930.025n

* CHECK dout0_14 Vdout0_14ck185 = 0 time = 930
.meas tran vdout0_14ck185 FIND v(dout0_14) AT=930.025n

* CHECK dout0_15 Vdout0_15ck185 = 0.9 time = 930
.meas tran vdout0_15ck185 FIND v(dout0_15) AT=930.025n

* CHECK dout0_16 Vdout0_16ck185 = 0.9 time = 930
.meas tran vdout0_16ck185 FIND v(dout0_16) AT=930.025n

* CHECK dout0_17 Vdout0_17ck185 = 0 time = 930
.meas tran vdout0_17ck185 FIND v(dout0_17) AT=930.025n

* CHECK dout0_18 Vdout0_18ck185 = 0.9 time = 930
.meas tran vdout0_18ck185 FIND v(dout0_18) AT=930.025n

* CHECK dout0_19 Vdout0_19ck185 = 0 time = 930
.meas tran vdout0_19ck185 FIND v(dout0_19) AT=930.025n

* CHECK dout0_20 Vdout0_20ck185 = 0.9 time = 930
.meas tran vdout0_20ck185 FIND v(dout0_20) AT=930.025n

* CHECK dout0_21 Vdout0_21ck185 = 0 time = 930
.meas tran vdout0_21ck185 FIND v(dout0_21) AT=930.025n

* CHECK dout0_22 Vdout0_22ck185 = 0.9 time = 930
.meas tran vdout0_22ck185 FIND v(dout0_22) AT=930.025n

* CHECK dout0_23 Vdout0_23ck185 = 0.9 time = 930
.meas tran vdout0_23ck185 FIND v(dout0_23) AT=930.025n

* CHECK dout0_24 Vdout0_24ck185 = 0 time = 930
.meas tran vdout0_24ck185 FIND v(dout0_24) AT=930.025n

* CHECK dout0_25 Vdout0_25ck185 = 0.9 time = 930
.meas tran vdout0_25ck185 FIND v(dout0_25) AT=930.025n

* CHECK dout0_26 Vdout0_26ck185 = 0.9 time = 930
.meas tran vdout0_26ck185 FIND v(dout0_26) AT=930.025n

* CHECK dout0_27 Vdout0_27ck185 = 0.9 time = 930
.meas tran vdout0_27ck185 FIND v(dout0_27) AT=930.025n

* CHECK dout0_28 Vdout0_28ck185 = 0.9 time = 930
.meas tran vdout0_28ck185 FIND v(dout0_28) AT=930.025n

* CHECK dout0_29 Vdout0_29ck185 = 0.9 time = 930
.meas tran vdout0_29ck185 FIND v(dout0_29) AT=930.025n

* CHECK dout0_30 Vdout0_30ck185 = 0 time = 930
.meas tran vdout0_30ck185 FIND v(dout0_30) AT=930.025n

* CHECK dout0_31 Vdout0_31ck185 = 0 time = 930
.meas tran vdout0_31ck185 FIND v(dout0_31) AT=930.025n

* CHECK dout0_32 Vdout0_32ck185 = 0 time = 930
.meas tran vdout0_32ck185 FIND v(dout0_32) AT=930.025n

* CHECK dout0_33 Vdout0_33ck185 = 0 time = 930
.meas tran vdout0_33ck185 FIND v(dout0_33) AT=930.025n

* CHECK dout0_34 Vdout0_34ck185 = 0.9 time = 930
.meas tran vdout0_34ck185 FIND v(dout0_34) AT=930.025n

* CHECK dout0_35 Vdout0_35ck185 = 0 time = 930
.meas tran vdout0_35ck185 FIND v(dout0_35) AT=930.025n

* CHECK dout0_36 Vdout0_36ck185 = 0 time = 930
.meas tran vdout0_36ck185 FIND v(dout0_36) AT=930.025n

* CHECK dout0_37 Vdout0_37ck185 = 0 time = 930
.meas tran vdout0_37ck185 FIND v(dout0_37) AT=930.025n

* CHECK dout0_38 Vdout0_38ck185 = 0.9 time = 930
.meas tran vdout0_38ck185 FIND v(dout0_38) AT=930.025n

* CHECK dout0_39 Vdout0_39ck185 = 0 time = 930
.meas tran vdout0_39ck185 FIND v(dout0_39) AT=930.025n

* CHECK dout0_40 Vdout0_40ck185 = 0 time = 930
.meas tran vdout0_40ck185 FIND v(dout0_40) AT=930.025n

* CHECK dout0_41 Vdout0_41ck185 = 0 time = 930
.meas tran vdout0_41ck185 FIND v(dout0_41) AT=930.025n

* CHECK dout0_42 Vdout0_42ck185 = 0.9 time = 930
.meas tran vdout0_42ck185 FIND v(dout0_42) AT=930.025n

* CHECK dout0_43 Vdout0_43ck185 = 0.9 time = 930
.meas tran vdout0_43ck185 FIND v(dout0_43) AT=930.025n

* CHECK dout0_44 Vdout0_44ck185 = 0 time = 930
.meas tran vdout0_44ck185 FIND v(dout0_44) AT=930.025n

* CHECK dout0_45 Vdout0_45ck185 = 0.9 time = 930
.meas tran vdout0_45ck185 FIND v(dout0_45) AT=930.025n

* CHECK dout0_46 Vdout0_46ck185 = 0.9 time = 930
.meas tran vdout0_46ck185 FIND v(dout0_46) AT=930.025n

* CHECK dout0_47 Vdout0_47ck185 = 0 time = 930
.meas tran vdout0_47ck185 FIND v(dout0_47) AT=930.025n

* CHECK dout0_48 Vdout0_48ck185 = 0.9 time = 930
.meas tran vdout0_48ck185 FIND v(dout0_48) AT=930.025n

* CHECK dout0_49 Vdout0_49ck185 = 0.9 time = 930
.meas tran vdout0_49ck185 FIND v(dout0_49) AT=930.025n

* CHECK dout0_50 Vdout0_50ck185 = 0.9 time = 930
.meas tran vdout0_50ck185 FIND v(dout0_50) AT=930.025n

* CHECK dout0_51 Vdout0_51ck185 = 0 time = 930
.meas tran vdout0_51ck185 FIND v(dout0_51) AT=930.025n

* CHECK dout0_52 Vdout0_52ck185 = 0.9 time = 930
.meas tran vdout0_52ck185 FIND v(dout0_52) AT=930.025n

* CHECK dout0_53 Vdout0_53ck185 = 0 time = 930
.meas tran vdout0_53ck185 FIND v(dout0_53) AT=930.025n

* CHECK dout0_54 Vdout0_54ck185 = 0 time = 930
.meas tran vdout0_54ck185 FIND v(dout0_54) AT=930.025n

* CHECK dout0_55 Vdout0_55ck185 = 0.9 time = 930
.meas tran vdout0_55ck185 FIND v(dout0_55) AT=930.025n

* CHECK dout0_56 Vdout0_56ck185 = 0.9 time = 930
.meas tran vdout0_56ck185 FIND v(dout0_56) AT=930.025n

* CHECK dout0_57 Vdout0_57ck185 = 0 time = 930
.meas tran vdout0_57ck185 FIND v(dout0_57) AT=930.025n

* CHECK dout0_58 Vdout0_58ck185 = 0.9 time = 930
.meas tran vdout0_58ck185 FIND v(dout0_58) AT=930.025n

* CHECK dout0_59 Vdout0_59ck185 = 0.9 time = 930
.meas tran vdout0_59ck185 FIND v(dout0_59) AT=930.025n

* CHECK dout0_60 Vdout0_60ck185 = 0 time = 930
.meas tran vdout0_60ck185 FIND v(dout0_60) AT=930.025n

* CHECK dout0_61 Vdout0_61ck185 = 0 time = 930
.meas tran vdout0_61ck185 FIND v(dout0_61) AT=930.025n

* CHECK dout0_62 Vdout0_62ck185 = 0.9 time = 930
.meas tran vdout0_62ck185 FIND v(dout0_62) AT=930.025n

* CHECK dout0_63 Vdout0_63ck185 = 0 time = 930
.meas tran vdout0_63ck185 FIND v(dout0_63) AT=930.025n

* CHECK dout0_64 Vdout0_64ck185 = 0 time = 930
.meas tran vdout0_64ck185 FIND v(dout0_64) AT=930.025n

* CHECK dout0_65 Vdout0_65ck185 = 0 time = 930
.meas tran vdout0_65ck185 FIND v(dout0_65) AT=930.025n

* CHECK dout0_66 Vdout0_66ck185 = 0.9 time = 930
.meas tran vdout0_66ck185 FIND v(dout0_66) AT=930.025n

* CHECK dout0_67 Vdout0_67ck185 = 0 time = 930
.meas tran vdout0_67ck185 FIND v(dout0_67) AT=930.025n

* CHECK dout0_68 Vdout0_68ck185 = 0 time = 930
.meas tran vdout0_68ck185 FIND v(dout0_68) AT=930.025n

* CHECK dout0_69 Vdout0_69ck185 = 0.9 time = 930
.meas tran vdout0_69ck185 FIND v(dout0_69) AT=930.025n

* CHECK dout0_70 Vdout0_70ck185 = 0.9 time = 930
.meas tran vdout0_70ck185 FIND v(dout0_70) AT=930.025n

* CHECK dout0_71 Vdout0_71ck185 = 0 time = 930
.meas tran vdout0_71ck185 FIND v(dout0_71) AT=930.025n

* CHECK dout0_72 Vdout0_72ck185 = 0 time = 930
.meas tran vdout0_72ck185 FIND v(dout0_72) AT=930.025n

* CHECK dout0_73 Vdout0_73ck185 = 0 time = 930
.meas tran vdout0_73ck185 FIND v(dout0_73) AT=930.025n

* CHECK dout0_74 Vdout0_74ck185 = 0 time = 930
.meas tran vdout0_74ck185 FIND v(dout0_74) AT=930.025n

* CHECK dout0_75 Vdout0_75ck185 = 0 time = 930
.meas tran vdout0_75ck185 FIND v(dout0_75) AT=930.025n

* CHECK dout0_76 Vdout0_76ck185 = 0.9 time = 930
.meas tran vdout0_76ck185 FIND v(dout0_76) AT=930.025n

* CHECK dout0_77 Vdout0_77ck185 = 0.9 time = 930
.meas tran vdout0_77ck185 FIND v(dout0_77) AT=930.025n

* CHECK dout0_78 Vdout0_78ck185 = 0 time = 930
.meas tran vdout0_78ck185 FIND v(dout0_78) AT=930.025n

* CHECK dout0_79 Vdout0_79ck185 = 0.9 time = 930
.meas tran vdout0_79ck185 FIND v(dout0_79) AT=930.025n

* CHECK dout0_80 Vdout0_80ck185 = 0 time = 930
.meas tran vdout0_80ck185 FIND v(dout0_80) AT=930.025n

* CHECK dout0_81 Vdout0_81ck185 = 0.9 time = 930
.meas tran vdout0_81ck185 FIND v(dout0_81) AT=930.025n

* CHECK dout0_82 Vdout0_82ck185 = 0 time = 930
.meas tran vdout0_82ck185 FIND v(dout0_82) AT=930.025n

* CHECK dout0_83 Vdout0_83ck185 = 0 time = 930
.meas tran vdout0_83ck185 FIND v(dout0_83) AT=930.025n

* CHECK dout0_84 Vdout0_84ck185 = 0 time = 930
.meas tran vdout0_84ck185 FIND v(dout0_84) AT=930.025n

* CHECK dout0_85 Vdout0_85ck185 = 0.9 time = 930
.meas tran vdout0_85ck185 FIND v(dout0_85) AT=930.025n

* CHECK dout0_86 Vdout0_86ck185 = 0.9 time = 930
.meas tran vdout0_86ck185 FIND v(dout0_86) AT=930.025n

* CHECK dout0_87 Vdout0_87ck185 = 0.9 time = 930
.meas tran vdout0_87ck185 FIND v(dout0_87) AT=930.025n

* CHECK dout0_0 Vdout0_0ck188 = 0 time = 945
.meas tran vdout0_0ck188 FIND v(dout0_0) AT=945.025n

* CHECK dout0_1 Vdout0_1ck188 = 0 time = 945
.meas tran vdout0_1ck188 FIND v(dout0_1) AT=945.025n

* CHECK dout0_2 Vdout0_2ck188 = 0.9 time = 945
.meas tran vdout0_2ck188 FIND v(dout0_2) AT=945.025n

* CHECK dout0_3 Vdout0_3ck188 = 0.9 time = 945
.meas tran vdout0_3ck188 FIND v(dout0_3) AT=945.025n

* CHECK dout0_4 Vdout0_4ck188 = 0.9 time = 945
.meas tran vdout0_4ck188 FIND v(dout0_4) AT=945.025n

* CHECK dout0_5 Vdout0_5ck188 = 0.9 time = 945
.meas tran vdout0_5ck188 FIND v(dout0_5) AT=945.025n

* CHECK dout0_6 Vdout0_6ck188 = 0.9 time = 945
.meas tran vdout0_6ck188 FIND v(dout0_6) AT=945.025n

* CHECK dout0_7 Vdout0_7ck188 = 0.9 time = 945
.meas tran vdout0_7ck188 FIND v(dout0_7) AT=945.025n

* CHECK dout0_8 Vdout0_8ck188 = 0 time = 945
.meas tran vdout0_8ck188 FIND v(dout0_8) AT=945.025n

* CHECK dout0_9 Vdout0_9ck188 = 0 time = 945
.meas tran vdout0_9ck188 FIND v(dout0_9) AT=945.025n

* CHECK dout0_10 Vdout0_10ck188 = 0 time = 945
.meas tran vdout0_10ck188 FIND v(dout0_10) AT=945.025n

* CHECK dout0_11 Vdout0_11ck188 = 0.9 time = 945
.meas tran vdout0_11ck188 FIND v(dout0_11) AT=945.025n

* CHECK dout0_12 Vdout0_12ck188 = 0 time = 945
.meas tran vdout0_12ck188 FIND v(dout0_12) AT=945.025n

* CHECK dout0_13 Vdout0_13ck188 = 0.9 time = 945
.meas tran vdout0_13ck188 FIND v(dout0_13) AT=945.025n

* CHECK dout0_14 Vdout0_14ck188 = 0 time = 945
.meas tran vdout0_14ck188 FIND v(dout0_14) AT=945.025n

* CHECK dout0_15 Vdout0_15ck188 = 0 time = 945
.meas tran vdout0_15ck188 FIND v(dout0_15) AT=945.025n

* CHECK dout0_16 Vdout0_16ck188 = 0 time = 945
.meas tran vdout0_16ck188 FIND v(dout0_16) AT=945.025n

* CHECK dout0_17 Vdout0_17ck188 = 0 time = 945
.meas tran vdout0_17ck188 FIND v(dout0_17) AT=945.025n

* CHECK dout0_18 Vdout0_18ck188 = 0.9 time = 945
.meas tran vdout0_18ck188 FIND v(dout0_18) AT=945.025n

* CHECK dout0_19 Vdout0_19ck188 = 0.9 time = 945
.meas tran vdout0_19ck188 FIND v(dout0_19) AT=945.025n

* CHECK dout0_20 Vdout0_20ck188 = 0 time = 945
.meas tran vdout0_20ck188 FIND v(dout0_20) AT=945.025n

* CHECK dout0_21 Vdout0_21ck188 = 0.9 time = 945
.meas tran vdout0_21ck188 FIND v(dout0_21) AT=945.025n

* CHECK dout0_22 Vdout0_22ck188 = 0.9 time = 945
.meas tran vdout0_22ck188 FIND v(dout0_22) AT=945.025n

* CHECK dout0_23 Vdout0_23ck188 = 0 time = 945
.meas tran vdout0_23ck188 FIND v(dout0_23) AT=945.025n

* CHECK dout0_24 Vdout0_24ck188 = 0 time = 945
.meas tran vdout0_24ck188 FIND v(dout0_24) AT=945.025n

* CHECK dout0_25 Vdout0_25ck188 = 0.9 time = 945
.meas tran vdout0_25ck188 FIND v(dout0_25) AT=945.025n

* CHECK dout0_26 Vdout0_26ck188 = 0 time = 945
.meas tran vdout0_26ck188 FIND v(dout0_26) AT=945.025n

* CHECK dout0_27 Vdout0_27ck188 = 0.9 time = 945
.meas tran vdout0_27ck188 FIND v(dout0_27) AT=945.025n

* CHECK dout0_28 Vdout0_28ck188 = 0 time = 945
.meas tran vdout0_28ck188 FIND v(dout0_28) AT=945.025n

* CHECK dout0_29 Vdout0_29ck188 = 0 time = 945
.meas tran vdout0_29ck188 FIND v(dout0_29) AT=945.025n

* CHECK dout0_30 Vdout0_30ck188 = 0 time = 945
.meas tran vdout0_30ck188 FIND v(dout0_30) AT=945.025n

* CHECK dout0_31 Vdout0_31ck188 = 0 time = 945
.meas tran vdout0_31ck188 FIND v(dout0_31) AT=945.025n

* CHECK dout0_32 Vdout0_32ck188 = 0.9 time = 945
.meas tran vdout0_32ck188 FIND v(dout0_32) AT=945.025n

* CHECK dout0_33 Vdout0_33ck188 = 0 time = 945
.meas tran vdout0_33ck188 FIND v(dout0_33) AT=945.025n

* CHECK dout0_34 Vdout0_34ck188 = 0.9 time = 945
.meas tran vdout0_34ck188 FIND v(dout0_34) AT=945.025n

* CHECK dout0_35 Vdout0_35ck188 = 0.9 time = 945
.meas tran vdout0_35ck188 FIND v(dout0_35) AT=945.025n

* CHECK dout0_36 Vdout0_36ck188 = 0.9 time = 945
.meas tran vdout0_36ck188 FIND v(dout0_36) AT=945.025n

* CHECK dout0_37 Vdout0_37ck188 = 0 time = 945
.meas tran vdout0_37ck188 FIND v(dout0_37) AT=945.025n

* CHECK dout0_38 Vdout0_38ck188 = 0.9 time = 945
.meas tran vdout0_38ck188 FIND v(dout0_38) AT=945.025n

* CHECK dout0_39 Vdout0_39ck188 = 0 time = 945
.meas tran vdout0_39ck188 FIND v(dout0_39) AT=945.025n

* CHECK dout0_40 Vdout0_40ck188 = 0 time = 945
.meas tran vdout0_40ck188 FIND v(dout0_40) AT=945.025n

* CHECK dout0_41 Vdout0_41ck188 = 0.9 time = 945
.meas tran vdout0_41ck188 FIND v(dout0_41) AT=945.025n

* CHECK dout0_42 Vdout0_42ck188 = 0.9 time = 945
.meas tran vdout0_42ck188 FIND v(dout0_42) AT=945.025n

* CHECK dout0_43 Vdout0_43ck188 = 0 time = 945
.meas tran vdout0_43ck188 FIND v(dout0_43) AT=945.025n

* CHECK dout0_44 Vdout0_44ck188 = 0 time = 945
.meas tran vdout0_44ck188 FIND v(dout0_44) AT=945.025n

* CHECK dout0_45 Vdout0_45ck188 = 0.9 time = 945
.meas tran vdout0_45ck188 FIND v(dout0_45) AT=945.025n

* CHECK dout0_46 Vdout0_46ck188 = 0.9 time = 945
.meas tran vdout0_46ck188 FIND v(dout0_46) AT=945.025n

* CHECK dout0_47 Vdout0_47ck188 = 0.9 time = 945
.meas tran vdout0_47ck188 FIND v(dout0_47) AT=945.025n

* CHECK dout0_48 Vdout0_48ck188 = 0.9 time = 945
.meas tran vdout0_48ck188 FIND v(dout0_48) AT=945.025n

* CHECK dout0_49 Vdout0_49ck188 = 0 time = 945
.meas tran vdout0_49ck188 FIND v(dout0_49) AT=945.025n

* CHECK dout0_50 Vdout0_50ck188 = 0.9 time = 945
.meas tran vdout0_50ck188 FIND v(dout0_50) AT=945.025n

* CHECK dout0_51 Vdout0_51ck188 = 0 time = 945
.meas tran vdout0_51ck188 FIND v(dout0_51) AT=945.025n

* CHECK dout0_52 Vdout0_52ck188 = 0 time = 945
.meas tran vdout0_52ck188 FIND v(dout0_52) AT=945.025n

* CHECK dout0_53 Vdout0_53ck188 = 0.9 time = 945
.meas tran vdout0_53ck188 FIND v(dout0_53) AT=945.025n

* CHECK dout0_54 Vdout0_54ck188 = 0.9 time = 945
.meas tran vdout0_54ck188 FIND v(dout0_54) AT=945.025n

* CHECK dout0_55 Vdout0_55ck188 = 0 time = 945
.meas tran vdout0_55ck188 FIND v(dout0_55) AT=945.025n

* CHECK dout0_56 Vdout0_56ck188 = 0.9 time = 945
.meas tran vdout0_56ck188 FIND v(dout0_56) AT=945.025n

* CHECK dout0_57 Vdout0_57ck188 = 0.9 time = 945
.meas tran vdout0_57ck188 FIND v(dout0_57) AT=945.025n

* CHECK dout0_58 Vdout0_58ck188 = 0.9 time = 945
.meas tran vdout0_58ck188 FIND v(dout0_58) AT=945.025n

* CHECK dout0_59 Vdout0_59ck188 = 0 time = 945
.meas tran vdout0_59ck188 FIND v(dout0_59) AT=945.025n

* CHECK dout0_60 Vdout0_60ck188 = 0 time = 945
.meas tran vdout0_60ck188 FIND v(dout0_60) AT=945.025n

* CHECK dout0_61 Vdout0_61ck188 = 0.9 time = 945
.meas tran vdout0_61ck188 FIND v(dout0_61) AT=945.025n

* CHECK dout0_62 Vdout0_62ck188 = 0 time = 945
.meas tran vdout0_62ck188 FIND v(dout0_62) AT=945.025n

* CHECK dout0_63 Vdout0_63ck188 = 0 time = 945
.meas tran vdout0_63ck188 FIND v(dout0_63) AT=945.025n

* CHECK dout0_64 Vdout0_64ck188 = 0 time = 945
.meas tran vdout0_64ck188 FIND v(dout0_64) AT=945.025n

* CHECK dout0_65 Vdout0_65ck188 = 0 time = 945
.meas tran vdout0_65ck188 FIND v(dout0_65) AT=945.025n

* CHECK dout0_66 Vdout0_66ck188 = 0 time = 945
.meas tran vdout0_66ck188 FIND v(dout0_66) AT=945.025n

* CHECK dout0_67 Vdout0_67ck188 = 0 time = 945
.meas tran vdout0_67ck188 FIND v(dout0_67) AT=945.025n

* CHECK dout0_68 Vdout0_68ck188 = 0.9 time = 945
.meas tran vdout0_68ck188 FIND v(dout0_68) AT=945.025n

* CHECK dout0_69 Vdout0_69ck188 = 0 time = 945
.meas tran vdout0_69ck188 FIND v(dout0_69) AT=945.025n

* CHECK dout0_70 Vdout0_70ck188 = 0.9 time = 945
.meas tran vdout0_70ck188 FIND v(dout0_70) AT=945.025n

* CHECK dout0_71 Vdout0_71ck188 = 0.9 time = 945
.meas tran vdout0_71ck188 FIND v(dout0_71) AT=945.025n

* CHECK dout0_72 Vdout0_72ck188 = 0 time = 945
.meas tran vdout0_72ck188 FIND v(dout0_72) AT=945.025n

* CHECK dout0_73 Vdout0_73ck188 = 0.9 time = 945
.meas tran vdout0_73ck188 FIND v(dout0_73) AT=945.025n

* CHECK dout0_74 Vdout0_74ck188 = 0 time = 945
.meas tran vdout0_74ck188 FIND v(dout0_74) AT=945.025n

* CHECK dout0_75 Vdout0_75ck188 = 0.9 time = 945
.meas tran vdout0_75ck188 FIND v(dout0_75) AT=945.025n

* CHECK dout0_76 Vdout0_76ck188 = 0 time = 945
.meas tran vdout0_76ck188 FIND v(dout0_76) AT=945.025n

* CHECK dout0_77 Vdout0_77ck188 = 0 time = 945
.meas tran vdout0_77ck188 FIND v(dout0_77) AT=945.025n

* CHECK dout0_78 Vdout0_78ck188 = 0 time = 945
.meas tran vdout0_78ck188 FIND v(dout0_78) AT=945.025n

* CHECK dout0_79 Vdout0_79ck188 = 0.9 time = 945
.meas tran vdout0_79ck188 FIND v(dout0_79) AT=945.025n

* CHECK dout0_80 Vdout0_80ck188 = 0 time = 945
.meas tran vdout0_80ck188 FIND v(dout0_80) AT=945.025n

* CHECK dout0_81 Vdout0_81ck188 = 0 time = 945
.meas tran vdout0_81ck188 FIND v(dout0_81) AT=945.025n

* CHECK dout0_82 Vdout0_82ck188 = 0.9 time = 945
.meas tran vdout0_82ck188 FIND v(dout0_82) AT=945.025n

* CHECK dout0_83 Vdout0_83ck188 = 0.9 time = 945
.meas tran vdout0_83ck188 FIND v(dout0_83) AT=945.025n

* CHECK dout0_84 Vdout0_84ck188 = 0.9 time = 945
.meas tran vdout0_84ck188 FIND v(dout0_84) AT=945.025n

* CHECK dout0_85 Vdout0_85ck188 = 0.9 time = 945
.meas tran vdout0_85ck188 FIND v(dout0_85) AT=945.025n

* CHECK dout0_86 Vdout0_86ck188 = 0 time = 945
.meas tran vdout0_86ck188 FIND v(dout0_86) AT=945.025n

* CHECK dout0_87 Vdout0_87ck188 = 0 time = 945
.meas tran vdout0_87ck188 FIND v(dout0_87) AT=945.025n

* CHECK dout0_0 Vdout0_0ck192 = 0 time = 965
.meas tran vdout0_0ck192 FIND v(dout0_0) AT=965.025n

* CHECK dout0_1 Vdout0_1ck192 = 0.9 time = 965
.meas tran vdout0_1ck192 FIND v(dout0_1) AT=965.025n

* CHECK dout0_2 Vdout0_2ck192 = 0.9 time = 965
.meas tran vdout0_2ck192 FIND v(dout0_2) AT=965.025n

* CHECK dout0_3 Vdout0_3ck192 = 0 time = 965
.meas tran vdout0_3ck192 FIND v(dout0_3) AT=965.025n

* CHECK dout0_4 Vdout0_4ck192 = 0.9 time = 965
.meas tran vdout0_4ck192 FIND v(dout0_4) AT=965.025n

* CHECK dout0_5 Vdout0_5ck192 = 0.9 time = 965
.meas tran vdout0_5ck192 FIND v(dout0_5) AT=965.025n

* CHECK dout0_6 Vdout0_6ck192 = 0 time = 965
.meas tran vdout0_6ck192 FIND v(dout0_6) AT=965.025n

* CHECK dout0_7 Vdout0_7ck192 = 0.9 time = 965
.meas tran vdout0_7ck192 FIND v(dout0_7) AT=965.025n

* CHECK dout0_8 Vdout0_8ck192 = 0.9 time = 965
.meas tran vdout0_8ck192 FIND v(dout0_8) AT=965.025n

* CHECK dout0_9 Vdout0_9ck192 = 0 time = 965
.meas tran vdout0_9ck192 FIND v(dout0_9) AT=965.025n

* CHECK dout0_10 Vdout0_10ck192 = 0 time = 965
.meas tran vdout0_10ck192 FIND v(dout0_10) AT=965.025n

* CHECK dout0_11 Vdout0_11ck192 = 0 time = 965
.meas tran vdout0_11ck192 FIND v(dout0_11) AT=965.025n

* CHECK dout0_12 Vdout0_12ck192 = 0 time = 965
.meas tran vdout0_12ck192 FIND v(dout0_12) AT=965.025n

* CHECK dout0_13 Vdout0_13ck192 = 0 time = 965
.meas tran vdout0_13ck192 FIND v(dout0_13) AT=965.025n

* CHECK dout0_14 Vdout0_14ck192 = 0 time = 965
.meas tran vdout0_14ck192 FIND v(dout0_14) AT=965.025n

* CHECK dout0_15 Vdout0_15ck192 = 0 time = 965
.meas tran vdout0_15ck192 FIND v(dout0_15) AT=965.025n

* CHECK dout0_16 Vdout0_16ck192 = 0.9 time = 965
.meas tran vdout0_16ck192 FIND v(dout0_16) AT=965.025n

* CHECK dout0_17 Vdout0_17ck192 = 0 time = 965
.meas tran vdout0_17ck192 FIND v(dout0_17) AT=965.025n

* CHECK dout0_18 Vdout0_18ck192 = 0 time = 965
.meas tran vdout0_18ck192 FIND v(dout0_18) AT=965.025n

* CHECK dout0_19 Vdout0_19ck192 = 0.9 time = 965
.meas tran vdout0_19ck192 FIND v(dout0_19) AT=965.025n

* CHECK dout0_20 Vdout0_20ck192 = 0 time = 965
.meas tran vdout0_20ck192 FIND v(dout0_20) AT=965.025n

* CHECK dout0_21 Vdout0_21ck192 = 0.9 time = 965
.meas tran vdout0_21ck192 FIND v(dout0_21) AT=965.025n

* CHECK dout0_22 Vdout0_22ck192 = 0 time = 965
.meas tran vdout0_22ck192 FIND v(dout0_22) AT=965.025n

* CHECK dout0_23 Vdout0_23ck192 = 0 time = 965
.meas tran vdout0_23ck192 FIND v(dout0_23) AT=965.025n

* CHECK dout0_24 Vdout0_24ck192 = 0.9 time = 965
.meas tran vdout0_24ck192 FIND v(dout0_24) AT=965.025n

* CHECK dout0_25 Vdout0_25ck192 = 0.9 time = 965
.meas tran vdout0_25ck192 FIND v(dout0_25) AT=965.025n

* CHECK dout0_26 Vdout0_26ck192 = 0 time = 965
.meas tran vdout0_26ck192 FIND v(dout0_26) AT=965.025n

* CHECK dout0_27 Vdout0_27ck192 = 0 time = 965
.meas tran vdout0_27ck192 FIND v(dout0_27) AT=965.025n

* CHECK dout0_28 Vdout0_28ck192 = 0 time = 965
.meas tran vdout0_28ck192 FIND v(dout0_28) AT=965.025n

* CHECK dout0_29 Vdout0_29ck192 = 0 time = 965
.meas tran vdout0_29ck192 FIND v(dout0_29) AT=965.025n

* CHECK dout0_30 Vdout0_30ck192 = 0 time = 965
.meas tran vdout0_30ck192 FIND v(dout0_30) AT=965.025n

* CHECK dout0_31 Vdout0_31ck192 = 0.9 time = 965
.meas tran vdout0_31ck192 FIND v(dout0_31) AT=965.025n

* CHECK dout0_32 Vdout0_32ck192 = 0.9 time = 965
.meas tran vdout0_32ck192 FIND v(dout0_32) AT=965.025n

* CHECK dout0_33 Vdout0_33ck192 = 0 time = 965
.meas tran vdout0_33ck192 FIND v(dout0_33) AT=965.025n

* CHECK dout0_34 Vdout0_34ck192 = 0.9 time = 965
.meas tran vdout0_34ck192 FIND v(dout0_34) AT=965.025n

* CHECK dout0_35 Vdout0_35ck192 = 0 time = 965
.meas tran vdout0_35ck192 FIND v(dout0_35) AT=965.025n

* CHECK dout0_36 Vdout0_36ck192 = 0.9 time = 965
.meas tran vdout0_36ck192 FIND v(dout0_36) AT=965.025n

* CHECK dout0_37 Vdout0_37ck192 = 0.9 time = 965
.meas tran vdout0_37ck192 FIND v(dout0_37) AT=965.025n

* CHECK dout0_38 Vdout0_38ck192 = 0.9 time = 965
.meas tran vdout0_38ck192 FIND v(dout0_38) AT=965.025n

* CHECK dout0_39 Vdout0_39ck192 = 0.9 time = 965
.meas tran vdout0_39ck192 FIND v(dout0_39) AT=965.025n

* CHECK dout0_40 Vdout0_40ck192 = 0 time = 965
.meas tran vdout0_40ck192 FIND v(dout0_40) AT=965.025n

* CHECK dout0_41 Vdout0_41ck192 = 0 time = 965
.meas tran vdout0_41ck192 FIND v(dout0_41) AT=965.025n

* CHECK dout0_42 Vdout0_42ck192 = 0.9 time = 965
.meas tran vdout0_42ck192 FIND v(dout0_42) AT=965.025n

* CHECK dout0_43 Vdout0_43ck192 = 0.9 time = 965
.meas tran vdout0_43ck192 FIND v(dout0_43) AT=965.025n

* CHECK dout0_44 Vdout0_44ck192 = 0 time = 965
.meas tran vdout0_44ck192 FIND v(dout0_44) AT=965.025n

* CHECK dout0_45 Vdout0_45ck192 = 0.9 time = 965
.meas tran vdout0_45ck192 FIND v(dout0_45) AT=965.025n

* CHECK dout0_46 Vdout0_46ck192 = 0 time = 965
.meas tran vdout0_46ck192 FIND v(dout0_46) AT=965.025n

* CHECK dout0_47 Vdout0_47ck192 = 0.9 time = 965
.meas tran vdout0_47ck192 FIND v(dout0_47) AT=965.025n

* CHECK dout0_48 Vdout0_48ck192 = 0 time = 965
.meas tran vdout0_48ck192 FIND v(dout0_48) AT=965.025n

* CHECK dout0_49 Vdout0_49ck192 = 0.9 time = 965
.meas tran vdout0_49ck192 FIND v(dout0_49) AT=965.025n

* CHECK dout0_50 Vdout0_50ck192 = 0 time = 965
.meas tran vdout0_50ck192 FIND v(dout0_50) AT=965.025n

* CHECK dout0_51 Vdout0_51ck192 = 0 time = 965
.meas tran vdout0_51ck192 FIND v(dout0_51) AT=965.025n

* CHECK dout0_52 Vdout0_52ck192 = 0 time = 965
.meas tran vdout0_52ck192 FIND v(dout0_52) AT=965.025n

* CHECK dout0_53 Vdout0_53ck192 = 0 time = 965
.meas tran vdout0_53ck192 FIND v(dout0_53) AT=965.025n

* CHECK dout0_54 Vdout0_54ck192 = 0 time = 965
.meas tran vdout0_54ck192 FIND v(dout0_54) AT=965.025n

* CHECK dout0_55 Vdout0_55ck192 = 0 time = 965
.meas tran vdout0_55ck192 FIND v(dout0_55) AT=965.025n

* CHECK dout0_56 Vdout0_56ck192 = 0.9 time = 965
.meas tran vdout0_56ck192 FIND v(dout0_56) AT=965.025n

* CHECK dout0_57 Vdout0_57ck192 = 0 time = 965
.meas tran vdout0_57ck192 FIND v(dout0_57) AT=965.025n

* CHECK dout0_58 Vdout0_58ck192 = 0 time = 965
.meas tran vdout0_58ck192 FIND v(dout0_58) AT=965.025n

* CHECK dout0_59 Vdout0_59ck192 = 0.9 time = 965
.meas tran vdout0_59ck192 FIND v(dout0_59) AT=965.025n

* CHECK dout0_60 Vdout0_60ck192 = 0 time = 965
.meas tran vdout0_60ck192 FIND v(dout0_60) AT=965.025n

* CHECK dout0_61 Vdout0_61ck192 = 0.9 time = 965
.meas tran vdout0_61ck192 FIND v(dout0_61) AT=965.025n

* CHECK dout0_62 Vdout0_62ck192 = 0.9 time = 965
.meas tran vdout0_62ck192 FIND v(dout0_62) AT=965.025n

* CHECK dout0_63 Vdout0_63ck192 = 0.9 time = 965
.meas tran vdout0_63ck192 FIND v(dout0_63) AT=965.025n

* CHECK dout0_64 Vdout0_64ck192 = 0 time = 965
.meas tran vdout0_64ck192 FIND v(dout0_64) AT=965.025n

* CHECK dout0_65 Vdout0_65ck192 = 0.9 time = 965
.meas tran vdout0_65ck192 FIND v(dout0_65) AT=965.025n

* CHECK dout0_66 Vdout0_66ck192 = 0.9 time = 965
.meas tran vdout0_66ck192 FIND v(dout0_66) AT=965.025n

* CHECK dout0_67 Vdout0_67ck192 = 0.9 time = 965
.meas tran vdout0_67ck192 FIND v(dout0_67) AT=965.025n

* CHECK dout0_68 Vdout0_68ck192 = 0.9 time = 965
.meas tran vdout0_68ck192 FIND v(dout0_68) AT=965.025n

* CHECK dout0_69 Vdout0_69ck192 = 0.9 time = 965
.meas tran vdout0_69ck192 FIND v(dout0_69) AT=965.025n

* CHECK dout0_70 Vdout0_70ck192 = 0.9 time = 965
.meas tran vdout0_70ck192 FIND v(dout0_70) AT=965.025n

* CHECK dout0_71 Vdout0_71ck192 = 0 time = 965
.meas tran vdout0_71ck192 FIND v(dout0_71) AT=965.025n

* CHECK dout0_72 Vdout0_72ck192 = 0.9 time = 965
.meas tran vdout0_72ck192 FIND v(dout0_72) AT=965.025n

* CHECK dout0_73 Vdout0_73ck192 = 0.9 time = 965
.meas tran vdout0_73ck192 FIND v(dout0_73) AT=965.025n

* CHECK dout0_74 Vdout0_74ck192 = 0.9 time = 965
.meas tran vdout0_74ck192 FIND v(dout0_74) AT=965.025n

* CHECK dout0_75 Vdout0_75ck192 = 0 time = 965
.meas tran vdout0_75ck192 FIND v(dout0_75) AT=965.025n

* CHECK dout0_76 Vdout0_76ck192 = 0.9 time = 965
.meas tran vdout0_76ck192 FIND v(dout0_76) AT=965.025n

* CHECK dout0_77 Vdout0_77ck192 = 0.9 time = 965
.meas tran vdout0_77ck192 FIND v(dout0_77) AT=965.025n

* CHECK dout0_78 Vdout0_78ck192 = 0.9 time = 965
.meas tran vdout0_78ck192 FIND v(dout0_78) AT=965.025n

* CHECK dout0_79 Vdout0_79ck192 = 0.9 time = 965
.meas tran vdout0_79ck192 FIND v(dout0_79) AT=965.025n

* CHECK dout0_80 Vdout0_80ck192 = 0.9 time = 965
.meas tran vdout0_80ck192 FIND v(dout0_80) AT=965.025n

* CHECK dout0_81 Vdout0_81ck192 = 0 time = 965
.meas tran vdout0_81ck192 FIND v(dout0_81) AT=965.025n

* CHECK dout0_82 Vdout0_82ck192 = 0 time = 965
.meas tran vdout0_82ck192 FIND v(dout0_82) AT=965.025n

* CHECK dout0_83 Vdout0_83ck192 = 0.9 time = 965
.meas tran vdout0_83ck192 FIND v(dout0_83) AT=965.025n

* CHECK dout0_84 Vdout0_84ck192 = 0 time = 965
.meas tran vdout0_84ck192 FIND v(dout0_84) AT=965.025n

* CHECK dout0_85 Vdout0_85ck192 = 0.9 time = 965
.meas tran vdout0_85ck192 FIND v(dout0_85) AT=965.025n

* CHECK dout0_86 Vdout0_86ck192 = 0.9 time = 965
.meas tran vdout0_86ck192 FIND v(dout0_86) AT=965.025n

* CHECK dout0_87 Vdout0_87ck192 = 0.9 time = 965
.meas tran vdout0_87ck192 FIND v(dout0_87) AT=965.025n

* CHECK dout0_0 Vdout0_0ck193 = 0 time = 970
.meas tran vdout0_0ck193 FIND v(dout0_0) AT=970.025n

* CHECK dout0_1 Vdout0_1ck193 = 0.9 time = 970
.meas tran vdout0_1ck193 FIND v(dout0_1) AT=970.025n

* CHECK dout0_2 Vdout0_2ck193 = 0.9 time = 970
.meas tran vdout0_2ck193 FIND v(dout0_2) AT=970.025n

* CHECK dout0_3 Vdout0_3ck193 = 0 time = 970
.meas tran vdout0_3ck193 FIND v(dout0_3) AT=970.025n

* CHECK dout0_4 Vdout0_4ck193 = 0.9 time = 970
.meas tran vdout0_4ck193 FIND v(dout0_4) AT=970.025n

* CHECK dout0_5 Vdout0_5ck193 = 0.9 time = 970
.meas tran vdout0_5ck193 FIND v(dout0_5) AT=970.025n

* CHECK dout0_6 Vdout0_6ck193 = 0 time = 970
.meas tran vdout0_6ck193 FIND v(dout0_6) AT=970.025n

* CHECK dout0_7 Vdout0_7ck193 = 0.9 time = 970
.meas tran vdout0_7ck193 FIND v(dout0_7) AT=970.025n

* CHECK dout0_8 Vdout0_8ck193 = 0.9 time = 970
.meas tran vdout0_8ck193 FIND v(dout0_8) AT=970.025n

* CHECK dout0_9 Vdout0_9ck193 = 0 time = 970
.meas tran vdout0_9ck193 FIND v(dout0_9) AT=970.025n

* CHECK dout0_10 Vdout0_10ck193 = 0 time = 970
.meas tran vdout0_10ck193 FIND v(dout0_10) AT=970.025n

* CHECK dout0_11 Vdout0_11ck193 = 0 time = 970
.meas tran vdout0_11ck193 FIND v(dout0_11) AT=970.025n

* CHECK dout0_12 Vdout0_12ck193 = 0 time = 970
.meas tran vdout0_12ck193 FIND v(dout0_12) AT=970.025n

* CHECK dout0_13 Vdout0_13ck193 = 0 time = 970
.meas tran vdout0_13ck193 FIND v(dout0_13) AT=970.025n

* CHECK dout0_14 Vdout0_14ck193 = 0 time = 970
.meas tran vdout0_14ck193 FIND v(dout0_14) AT=970.025n

* CHECK dout0_15 Vdout0_15ck193 = 0 time = 970
.meas tran vdout0_15ck193 FIND v(dout0_15) AT=970.025n

* CHECK dout0_16 Vdout0_16ck193 = 0.9 time = 970
.meas tran vdout0_16ck193 FIND v(dout0_16) AT=970.025n

* CHECK dout0_17 Vdout0_17ck193 = 0 time = 970
.meas tran vdout0_17ck193 FIND v(dout0_17) AT=970.025n

* CHECK dout0_18 Vdout0_18ck193 = 0 time = 970
.meas tran vdout0_18ck193 FIND v(dout0_18) AT=970.025n

* CHECK dout0_19 Vdout0_19ck193 = 0.9 time = 970
.meas tran vdout0_19ck193 FIND v(dout0_19) AT=970.025n

* CHECK dout0_20 Vdout0_20ck193 = 0 time = 970
.meas tran vdout0_20ck193 FIND v(dout0_20) AT=970.025n

* CHECK dout0_21 Vdout0_21ck193 = 0.9 time = 970
.meas tran vdout0_21ck193 FIND v(dout0_21) AT=970.025n

* CHECK dout0_22 Vdout0_22ck193 = 0 time = 970
.meas tran vdout0_22ck193 FIND v(dout0_22) AT=970.025n

* CHECK dout0_23 Vdout0_23ck193 = 0 time = 970
.meas tran vdout0_23ck193 FIND v(dout0_23) AT=970.025n

* CHECK dout0_24 Vdout0_24ck193 = 0.9 time = 970
.meas tran vdout0_24ck193 FIND v(dout0_24) AT=970.025n

* CHECK dout0_25 Vdout0_25ck193 = 0.9 time = 970
.meas tran vdout0_25ck193 FIND v(dout0_25) AT=970.025n

* CHECK dout0_26 Vdout0_26ck193 = 0 time = 970
.meas tran vdout0_26ck193 FIND v(dout0_26) AT=970.025n

* CHECK dout0_27 Vdout0_27ck193 = 0 time = 970
.meas tran vdout0_27ck193 FIND v(dout0_27) AT=970.025n

* CHECK dout0_28 Vdout0_28ck193 = 0 time = 970
.meas tran vdout0_28ck193 FIND v(dout0_28) AT=970.025n

* CHECK dout0_29 Vdout0_29ck193 = 0 time = 970
.meas tran vdout0_29ck193 FIND v(dout0_29) AT=970.025n

* CHECK dout0_30 Vdout0_30ck193 = 0 time = 970
.meas tran vdout0_30ck193 FIND v(dout0_30) AT=970.025n

* CHECK dout0_31 Vdout0_31ck193 = 0.9 time = 970
.meas tran vdout0_31ck193 FIND v(dout0_31) AT=970.025n

* CHECK dout0_32 Vdout0_32ck193 = 0.9 time = 970
.meas tran vdout0_32ck193 FIND v(dout0_32) AT=970.025n

* CHECK dout0_33 Vdout0_33ck193 = 0 time = 970
.meas tran vdout0_33ck193 FIND v(dout0_33) AT=970.025n

* CHECK dout0_34 Vdout0_34ck193 = 0.9 time = 970
.meas tran vdout0_34ck193 FIND v(dout0_34) AT=970.025n

* CHECK dout0_35 Vdout0_35ck193 = 0 time = 970
.meas tran vdout0_35ck193 FIND v(dout0_35) AT=970.025n

* CHECK dout0_36 Vdout0_36ck193 = 0.9 time = 970
.meas tran vdout0_36ck193 FIND v(dout0_36) AT=970.025n

* CHECK dout0_37 Vdout0_37ck193 = 0.9 time = 970
.meas tran vdout0_37ck193 FIND v(dout0_37) AT=970.025n

* CHECK dout0_38 Vdout0_38ck193 = 0.9 time = 970
.meas tran vdout0_38ck193 FIND v(dout0_38) AT=970.025n

* CHECK dout0_39 Vdout0_39ck193 = 0.9 time = 970
.meas tran vdout0_39ck193 FIND v(dout0_39) AT=970.025n

* CHECK dout0_40 Vdout0_40ck193 = 0 time = 970
.meas tran vdout0_40ck193 FIND v(dout0_40) AT=970.025n

* CHECK dout0_41 Vdout0_41ck193 = 0 time = 970
.meas tran vdout0_41ck193 FIND v(dout0_41) AT=970.025n

* CHECK dout0_42 Vdout0_42ck193 = 0.9 time = 970
.meas tran vdout0_42ck193 FIND v(dout0_42) AT=970.025n

* CHECK dout0_43 Vdout0_43ck193 = 0.9 time = 970
.meas tran vdout0_43ck193 FIND v(dout0_43) AT=970.025n

* CHECK dout0_44 Vdout0_44ck193 = 0 time = 970
.meas tran vdout0_44ck193 FIND v(dout0_44) AT=970.025n

* CHECK dout0_45 Vdout0_45ck193 = 0.9 time = 970
.meas tran vdout0_45ck193 FIND v(dout0_45) AT=970.025n

* CHECK dout0_46 Vdout0_46ck193 = 0 time = 970
.meas tran vdout0_46ck193 FIND v(dout0_46) AT=970.025n

* CHECK dout0_47 Vdout0_47ck193 = 0.9 time = 970
.meas tran vdout0_47ck193 FIND v(dout0_47) AT=970.025n

* CHECK dout0_48 Vdout0_48ck193 = 0 time = 970
.meas tran vdout0_48ck193 FIND v(dout0_48) AT=970.025n

* CHECK dout0_49 Vdout0_49ck193 = 0.9 time = 970
.meas tran vdout0_49ck193 FIND v(dout0_49) AT=970.025n

* CHECK dout0_50 Vdout0_50ck193 = 0 time = 970
.meas tran vdout0_50ck193 FIND v(dout0_50) AT=970.025n

* CHECK dout0_51 Vdout0_51ck193 = 0 time = 970
.meas tran vdout0_51ck193 FIND v(dout0_51) AT=970.025n

* CHECK dout0_52 Vdout0_52ck193 = 0 time = 970
.meas tran vdout0_52ck193 FIND v(dout0_52) AT=970.025n

* CHECK dout0_53 Vdout0_53ck193 = 0 time = 970
.meas tran vdout0_53ck193 FIND v(dout0_53) AT=970.025n

* CHECK dout0_54 Vdout0_54ck193 = 0 time = 970
.meas tran vdout0_54ck193 FIND v(dout0_54) AT=970.025n

* CHECK dout0_55 Vdout0_55ck193 = 0 time = 970
.meas tran vdout0_55ck193 FIND v(dout0_55) AT=970.025n

* CHECK dout0_56 Vdout0_56ck193 = 0.9 time = 970
.meas tran vdout0_56ck193 FIND v(dout0_56) AT=970.025n

* CHECK dout0_57 Vdout0_57ck193 = 0 time = 970
.meas tran vdout0_57ck193 FIND v(dout0_57) AT=970.025n

* CHECK dout0_58 Vdout0_58ck193 = 0 time = 970
.meas tran vdout0_58ck193 FIND v(dout0_58) AT=970.025n

* CHECK dout0_59 Vdout0_59ck193 = 0.9 time = 970
.meas tran vdout0_59ck193 FIND v(dout0_59) AT=970.025n

* CHECK dout0_60 Vdout0_60ck193 = 0 time = 970
.meas tran vdout0_60ck193 FIND v(dout0_60) AT=970.025n

* CHECK dout0_61 Vdout0_61ck193 = 0.9 time = 970
.meas tran vdout0_61ck193 FIND v(dout0_61) AT=970.025n

* CHECK dout0_62 Vdout0_62ck193 = 0.9 time = 970
.meas tran vdout0_62ck193 FIND v(dout0_62) AT=970.025n

* CHECK dout0_63 Vdout0_63ck193 = 0.9 time = 970
.meas tran vdout0_63ck193 FIND v(dout0_63) AT=970.025n

* CHECK dout0_64 Vdout0_64ck193 = 0 time = 970
.meas tran vdout0_64ck193 FIND v(dout0_64) AT=970.025n

* CHECK dout0_65 Vdout0_65ck193 = 0.9 time = 970
.meas tran vdout0_65ck193 FIND v(dout0_65) AT=970.025n

* CHECK dout0_66 Vdout0_66ck193 = 0.9 time = 970
.meas tran vdout0_66ck193 FIND v(dout0_66) AT=970.025n

* CHECK dout0_67 Vdout0_67ck193 = 0.9 time = 970
.meas tran vdout0_67ck193 FIND v(dout0_67) AT=970.025n

* CHECK dout0_68 Vdout0_68ck193 = 0.9 time = 970
.meas tran vdout0_68ck193 FIND v(dout0_68) AT=970.025n

* CHECK dout0_69 Vdout0_69ck193 = 0.9 time = 970
.meas tran vdout0_69ck193 FIND v(dout0_69) AT=970.025n

* CHECK dout0_70 Vdout0_70ck193 = 0.9 time = 970
.meas tran vdout0_70ck193 FIND v(dout0_70) AT=970.025n

* CHECK dout0_71 Vdout0_71ck193 = 0 time = 970
.meas tran vdout0_71ck193 FIND v(dout0_71) AT=970.025n

* CHECK dout0_72 Vdout0_72ck193 = 0.9 time = 970
.meas tran vdout0_72ck193 FIND v(dout0_72) AT=970.025n

* CHECK dout0_73 Vdout0_73ck193 = 0.9 time = 970
.meas tran vdout0_73ck193 FIND v(dout0_73) AT=970.025n

* CHECK dout0_74 Vdout0_74ck193 = 0.9 time = 970
.meas tran vdout0_74ck193 FIND v(dout0_74) AT=970.025n

* CHECK dout0_75 Vdout0_75ck193 = 0 time = 970
.meas tran vdout0_75ck193 FIND v(dout0_75) AT=970.025n

* CHECK dout0_76 Vdout0_76ck193 = 0.9 time = 970
.meas tran vdout0_76ck193 FIND v(dout0_76) AT=970.025n

* CHECK dout0_77 Vdout0_77ck193 = 0.9 time = 970
.meas tran vdout0_77ck193 FIND v(dout0_77) AT=970.025n

* CHECK dout0_78 Vdout0_78ck193 = 0.9 time = 970
.meas tran vdout0_78ck193 FIND v(dout0_78) AT=970.025n

* CHECK dout0_79 Vdout0_79ck193 = 0.9 time = 970
.meas tran vdout0_79ck193 FIND v(dout0_79) AT=970.025n

* CHECK dout0_80 Vdout0_80ck193 = 0.9 time = 970
.meas tran vdout0_80ck193 FIND v(dout0_80) AT=970.025n

* CHECK dout0_81 Vdout0_81ck193 = 0 time = 970
.meas tran vdout0_81ck193 FIND v(dout0_81) AT=970.025n

* CHECK dout0_82 Vdout0_82ck193 = 0 time = 970
.meas tran vdout0_82ck193 FIND v(dout0_82) AT=970.025n

* CHECK dout0_83 Vdout0_83ck193 = 0.9 time = 970
.meas tran vdout0_83ck193 FIND v(dout0_83) AT=970.025n

* CHECK dout0_84 Vdout0_84ck193 = 0 time = 970
.meas tran vdout0_84ck193 FIND v(dout0_84) AT=970.025n

* CHECK dout0_85 Vdout0_85ck193 = 0.9 time = 970
.meas tran vdout0_85ck193 FIND v(dout0_85) AT=970.025n

* CHECK dout0_86 Vdout0_86ck193 = 0.9 time = 970
.meas tran vdout0_86ck193 FIND v(dout0_86) AT=970.025n

* CHECK dout0_87 Vdout0_87ck193 = 0.9 time = 970
.meas tran vdout0_87ck193 FIND v(dout0_87) AT=970.025n

* CHECK dout0_0 Vdout0_0ck196 = 0.9 time = 985
.meas tran vdout0_0ck196 FIND v(dout0_0) AT=985.025n

* CHECK dout0_1 Vdout0_1ck196 = 0.9 time = 985
.meas tran vdout0_1ck196 FIND v(dout0_1) AT=985.025n

* CHECK dout0_2 Vdout0_2ck196 = 0.9 time = 985
.meas tran vdout0_2ck196 FIND v(dout0_2) AT=985.025n

* CHECK dout0_3 Vdout0_3ck196 = 0 time = 985
.meas tran vdout0_3ck196 FIND v(dout0_3) AT=985.025n

* CHECK dout0_4 Vdout0_4ck196 = 0 time = 985
.meas tran vdout0_4ck196 FIND v(dout0_4) AT=985.025n

* CHECK dout0_5 Vdout0_5ck196 = 0.9 time = 985
.meas tran vdout0_5ck196 FIND v(dout0_5) AT=985.025n

* CHECK dout0_6 Vdout0_6ck196 = 0 time = 985
.meas tran vdout0_6ck196 FIND v(dout0_6) AT=985.025n

* CHECK dout0_7 Vdout0_7ck196 = 0 time = 985
.meas tran vdout0_7ck196 FIND v(dout0_7) AT=985.025n

* CHECK dout0_8 Vdout0_8ck196 = 0 time = 985
.meas tran vdout0_8ck196 FIND v(dout0_8) AT=985.025n

* CHECK dout0_9 Vdout0_9ck196 = 0 time = 985
.meas tran vdout0_9ck196 FIND v(dout0_9) AT=985.025n

* CHECK dout0_10 Vdout0_10ck196 = 0.9 time = 985
.meas tran vdout0_10ck196 FIND v(dout0_10) AT=985.025n

* CHECK dout0_11 Vdout0_11ck196 = 0 time = 985
.meas tran vdout0_11ck196 FIND v(dout0_11) AT=985.025n

* CHECK dout0_12 Vdout0_12ck196 = 0 time = 985
.meas tran vdout0_12ck196 FIND v(dout0_12) AT=985.025n

* CHECK dout0_13 Vdout0_13ck196 = 0 time = 985
.meas tran vdout0_13ck196 FIND v(dout0_13) AT=985.025n

* CHECK dout0_14 Vdout0_14ck196 = 0 time = 985
.meas tran vdout0_14ck196 FIND v(dout0_14) AT=985.025n

* CHECK dout0_15 Vdout0_15ck196 = 0.9 time = 985
.meas tran vdout0_15ck196 FIND v(dout0_15) AT=985.025n

* CHECK dout0_16 Vdout0_16ck196 = 0 time = 985
.meas tran vdout0_16ck196 FIND v(dout0_16) AT=985.025n

* CHECK dout0_17 Vdout0_17ck196 = 0 time = 985
.meas tran vdout0_17ck196 FIND v(dout0_17) AT=985.025n

* CHECK dout0_18 Vdout0_18ck196 = 0.9 time = 985
.meas tran vdout0_18ck196 FIND v(dout0_18) AT=985.025n

* CHECK dout0_19 Vdout0_19ck196 = 0 time = 985
.meas tran vdout0_19ck196 FIND v(dout0_19) AT=985.025n

* CHECK dout0_20 Vdout0_20ck196 = 0 time = 985
.meas tran vdout0_20ck196 FIND v(dout0_20) AT=985.025n

* CHECK dout0_21 Vdout0_21ck196 = 0.9 time = 985
.meas tran vdout0_21ck196 FIND v(dout0_21) AT=985.025n

* CHECK dout0_22 Vdout0_22ck196 = 0 time = 985
.meas tran vdout0_22ck196 FIND v(dout0_22) AT=985.025n

* CHECK dout0_23 Vdout0_23ck196 = 0 time = 985
.meas tran vdout0_23ck196 FIND v(dout0_23) AT=985.025n

* CHECK dout0_24 Vdout0_24ck196 = 0 time = 985
.meas tran vdout0_24ck196 FIND v(dout0_24) AT=985.025n

* CHECK dout0_25 Vdout0_25ck196 = 0.9 time = 985
.meas tran vdout0_25ck196 FIND v(dout0_25) AT=985.025n

* CHECK dout0_26 Vdout0_26ck196 = 0 time = 985
.meas tran vdout0_26ck196 FIND v(dout0_26) AT=985.025n

* CHECK dout0_27 Vdout0_27ck196 = 0 time = 985
.meas tran vdout0_27ck196 FIND v(dout0_27) AT=985.025n

* CHECK dout0_28 Vdout0_28ck196 = 0.9 time = 985
.meas tran vdout0_28ck196 FIND v(dout0_28) AT=985.025n

* CHECK dout0_29 Vdout0_29ck196 = 0.9 time = 985
.meas tran vdout0_29ck196 FIND v(dout0_29) AT=985.025n

* CHECK dout0_30 Vdout0_30ck196 = 0 time = 985
.meas tran vdout0_30ck196 FIND v(dout0_30) AT=985.025n

* CHECK dout0_31 Vdout0_31ck196 = 0.9 time = 985
.meas tran vdout0_31ck196 FIND v(dout0_31) AT=985.025n

* CHECK dout0_32 Vdout0_32ck196 = 0.9 time = 985
.meas tran vdout0_32ck196 FIND v(dout0_32) AT=985.025n

* CHECK dout0_33 Vdout0_33ck196 = 0.9 time = 985
.meas tran vdout0_33ck196 FIND v(dout0_33) AT=985.025n

* CHECK dout0_34 Vdout0_34ck196 = 0 time = 985
.meas tran vdout0_34ck196 FIND v(dout0_34) AT=985.025n

* CHECK dout0_35 Vdout0_35ck196 = 0 time = 985
.meas tran vdout0_35ck196 FIND v(dout0_35) AT=985.025n

* CHECK dout0_36 Vdout0_36ck196 = 0.9 time = 985
.meas tran vdout0_36ck196 FIND v(dout0_36) AT=985.025n

* CHECK dout0_37 Vdout0_37ck196 = 0.9 time = 985
.meas tran vdout0_37ck196 FIND v(dout0_37) AT=985.025n

* CHECK dout0_38 Vdout0_38ck196 = 0.9 time = 985
.meas tran vdout0_38ck196 FIND v(dout0_38) AT=985.025n

* CHECK dout0_39 Vdout0_39ck196 = 0.9 time = 985
.meas tran vdout0_39ck196 FIND v(dout0_39) AT=985.025n

* CHECK dout0_40 Vdout0_40ck196 = 0 time = 985
.meas tran vdout0_40ck196 FIND v(dout0_40) AT=985.025n

* CHECK dout0_41 Vdout0_41ck196 = 0.9 time = 985
.meas tran vdout0_41ck196 FIND v(dout0_41) AT=985.025n

* CHECK dout0_42 Vdout0_42ck196 = 0.9 time = 985
.meas tran vdout0_42ck196 FIND v(dout0_42) AT=985.025n

* CHECK dout0_43 Vdout0_43ck196 = 0 time = 985
.meas tran vdout0_43ck196 FIND v(dout0_43) AT=985.025n

* CHECK dout0_44 Vdout0_44ck196 = 0.9 time = 985
.meas tran vdout0_44ck196 FIND v(dout0_44) AT=985.025n

* CHECK dout0_45 Vdout0_45ck196 = 0 time = 985
.meas tran vdout0_45ck196 FIND v(dout0_45) AT=985.025n

* CHECK dout0_46 Vdout0_46ck196 = 0 time = 985
.meas tran vdout0_46ck196 FIND v(dout0_46) AT=985.025n

* CHECK dout0_47 Vdout0_47ck196 = 0 time = 985
.meas tran vdout0_47ck196 FIND v(dout0_47) AT=985.025n

* CHECK dout0_48 Vdout0_48ck196 = 0 time = 985
.meas tran vdout0_48ck196 FIND v(dout0_48) AT=985.025n

* CHECK dout0_49 Vdout0_49ck196 = 0.9 time = 985
.meas tran vdout0_49ck196 FIND v(dout0_49) AT=985.025n

* CHECK dout0_50 Vdout0_50ck196 = 0.9 time = 985
.meas tran vdout0_50ck196 FIND v(dout0_50) AT=985.025n

* CHECK dout0_51 Vdout0_51ck196 = 0.9 time = 985
.meas tran vdout0_51ck196 FIND v(dout0_51) AT=985.025n

* CHECK dout0_52 Vdout0_52ck196 = 0.9 time = 985
.meas tran vdout0_52ck196 FIND v(dout0_52) AT=985.025n

* CHECK dout0_53 Vdout0_53ck196 = 0 time = 985
.meas tran vdout0_53ck196 FIND v(dout0_53) AT=985.025n

* CHECK dout0_54 Vdout0_54ck196 = 0 time = 985
.meas tran vdout0_54ck196 FIND v(dout0_54) AT=985.025n

* CHECK dout0_55 Vdout0_55ck196 = 0 time = 985
.meas tran vdout0_55ck196 FIND v(dout0_55) AT=985.025n

* CHECK dout0_56 Vdout0_56ck196 = 0.9 time = 985
.meas tran vdout0_56ck196 FIND v(dout0_56) AT=985.025n

* CHECK dout0_57 Vdout0_57ck196 = 0.9 time = 985
.meas tran vdout0_57ck196 FIND v(dout0_57) AT=985.025n

* CHECK dout0_58 Vdout0_58ck196 = 0 time = 985
.meas tran vdout0_58ck196 FIND v(dout0_58) AT=985.025n

* CHECK dout0_59 Vdout0_59ck196 = 0 time = 985
.meas tran vdout0_59ck196 FIND v(dout0_59) AT=985.025n

* CHECK dout0_60 Vdout0_60ck196 = 0.9 time = 985
.meas tran vdout0_60ck196 FIND v(dout0_60) AT=985.025n

* CHECK dout0_61 Vdout0_61ck196 = 0 time = 985
.meas tran vdout0_61ck196 FIND v(dout0_61) AT=985.025n

* CHECK dout0_62 Vdout0_62ck196 = 0.9 time = 985
.meas tran vdout0_62ck196 FIND v(dout0_62) AT=985.025n

* CHECK dout0_63 Vdout0_63ck196 = 0.9 time = 985
.meas tran vdout0_63ck196 FIND v(dout0_63) AT=985.025n

* CHECK dout0_64 Vdout0_64ck196 = 0 time = 985
.meas tran vdout0_64ck196 FIND v(dout0_64) AT=985.025n

* CHECK dout0_65 Vdout0_65ck196 = 0.9 time = 985
.meas tran vdout0_65ck196 FIND v(dout0_65) AT=985.025n

* CHECK dout0_66 Vdout0_66ck196 = 0 time = 985
.meas tran vdout0_66ck196 FIND v(dout0_66) AT=985.025n

* CHECK dout0_67 Vdout0_67ck196 = 0.9 time = 985
.meas tran vdout0_67ck196 FIND v(dout0_67) AT=985.025n

* CHECK dout0_68 Vdout0_68ck196 = 0 time = 985
.meas tran vdout0_68ck196 FIND v(dout0_68) AT=985.025n

* CHECK dout0_69 Vdout0_69ck196 = 0 time = 985
.meas tran vdout0_69ck196 FIND v(dout0_69) AT=985.025n

* CHECK dout0_70 Vdout0_70ck196 = 0.9 time = 985
.meas tran vdout0_70ck196 FIND v(dout0_70) AT=985.025n

* CHECK dout0_71 Vdout0_71ck196 = 0 time = 985
.meas tran vdout0_71ck196 FIND v(dout0_71) AT=985.025n

* CHECK dout0_72 Vdout0_72ck196 = 0 time = 985
.meas tran vdout0_72ck196 FIND v(dout0_72) AT=985.025n

* CHECK dout0_73 Vdout0_73ck196 = 0.9 time = 985
.meas tran vdout0_73ck196 FIND v(dout0_73) AT=985.025n

* CHECK dout0_74 Vdout0_74ck196 = 0.9 time = 985
.meas tran vdout0_74ck196 FIND v(dout0_74) AT=985.025n

* CHECK dout0_75 Vdout0_75ck196 = 0.9 time = 985
.meas tran vdout0_75ck196 FIND v(dout0_75) AT=985.025n

* CHECK dout0_76 Vdout0_76ck196 = 0 time = 985
.meas tran vdout0_76ck196 FIND v(dout0_76) AT=985.025n

* CHECK dout0_77 Vdout0_77ck196 = 0 time = 985
.meas tran vdout0_77ck196 FIND v(dout0_77) AT=985.025n

* CHECK dout0_78 Vdout0_78ck196 = 0.9 time = 985
.meas tran vdout0_78ck196 FIND v(dout0_78) AT=985.025n

* CHECK dout0_79 Vdout0_79ck196 = 0.9 time = 985
.meas tran vdout0_79ck196 FIND v(dout0_79) AT=985.025n

* CHECK dout0_80 Vdout0_80ck196 = 0.9 time = 985
.meas tran vdout0_80ck196 FIND v(dout0_80) AT=985.025n

* CHECK dout0_81 Vdout0_81ck196 = 0.9 time = 985
.meas tran vdout0_81ck196 FIND v(dout0_81) AT=985.025n

* CHECK dout0_82 Vdout0_82ck196 = 0.9 time = 985
.meas tran vdout0_82ck196 FIND v(dout0_82) AT=985.025n

* CHECK dout0_83 Vdout0_83ck196 = 0 time = 985
.meas tran vdout0_83ck196 FIND v(dout0_83) AT=985.025n

* CHECK dout0_84 Vdout0_84ck196 = 0.9 time = 985
.meas tran vdout0_84ck196 FIND v(dout0_84) AT=985.025n

* CHECK dout0_85 Vdout0_85ck196 = 0 time = 985
.meas tran vdout0_85ck196 FIND v(dout0_85) AT=985.025n

* CHECK dout0_86 Vdout0_86ck196 = 0 time = 985
.meas tran vdout0_86ck196 FIND v(dout0_86) AT=985.025n

* CHECK dout0_87 Vdout0_87ck196 = 0 time = 985
.meas tran vdout0_87ck196 FIND v(dout0_87) AT=985.025n

* CHECK dout0_0 Vdout0_0ck197 = 0 time = 990
.meas tran vdout0_0ck197 FIND v(dout0_0) AT=990.025n

* CHECK dout0_1 Vdout0_1ck197 = 0.9 time = 990
.meas tran vdout0_1ck197 FIND v(dout0_1) AT=990.025n

* CHECK dout0_2 Vdout0_2ck197 = 0 time = 990
.meas tran vdout0_2ck197 FIND v(dout0_2) AT=990.025n

* CHECK dout0_3 Vdout0_3ck197 = 0 time = 990
.meas tran vdout0_3ck197 FIND v(dout0_3) AT=990.025n

* CHECK dout0_4 Vdout0_4ck197 = 0 time = 990
.meas tran vdout0_4ck197 FIND v(dout0_4) AT=990.025n

* CHECK dout0_5 Vdout0_5ck197 = 0.9 time = 990
.meas tran vdout0_5ck197 FIND v(dout0_5) AT=990.025n

* CHECK dout0_6 Vdout0_6ck197 = 0.9 time = 990
.meas tran vdout0_6ck197 FIND v(dout0_6) AT=990.025n

* CHECK dout0_7 Vdout0_7ck197 = 0 time = 990
.meas tran vdout0_7ck197 FIND v(dout0_7) AT=990.025n

* CHECK dout0_8 Vdout0_8ck197 = 0 time = 990
.meas tran vdout0_8ck197 FIND v(dout0_8) AT=990.025n

* CHECK dout0_9 Vdout0_9ck197 = 0 time = 990
.meas tran vdout0_9ck197 FIND v(dout0_9) AT=990.025n

* CHECK dout0_10 Vdout0_10ck197 = 0 time = 990
.meas tran vdout0_10ck197 FIND v(dout0_10) AT=990.025n

* CHECK dout0_11 Vdout0_11ck197 = 0.9 time = 990
.meas tran vdout0_11ck197 FIND v(dout0_11) AT=990.025n

* CHECK dout0_12 Vdout0_12ck197 = 0.9 time = 990
.meas tran vdout0_12ck197 FIND v(dout0_12) AT=990.025n

* CHECK dout0_13 Vdout0_13ck197 = 0.9 time = 990
.meas tran vdout0_13ck197 FIND v(dout0_13) AT=990.025n

* CHECK dout0_14 Vdout0_14ck197 = 0.9 time = 990
.meas tran vdout0_14ck197 FIND v(dout0_14) AT=990.025n

* CHECK dout0_15 Vdout0_15ck197 = 0.9 time = 990
.meas tran vdout0_15ck197 FIND v(dout0_15) AT=990.025n

* CHECK dout0_16 Vdout0_16ck197 = 0 time = 990
.meas tran vdout0_16ck197 FIND v(dout0_16) AT=990.025n

* CHECK dout0_17 Vdout0_17ck197 = 0.9 time = 990
.meas tran vdout0_17ck197 FIND v(dout0_17) AT=990.025n

* CHECK dout0_18 Vdout0_18ck197 = 0.9 time = 990
.meas tran vdout0_18ck197 FIND v(dout0_18) AT=990.025n

* CHECK dout0_19 Vdout0_19ck197 = 0 time = 990
.meas tran vdout0_19ck197 FIND v(dout0_19) AT=990.025n

* CHECK dout0_20 Vdout0_20ck197 = 0.9 time = 990
.meas tran vdout0_20ck197 FIND v(dout0_20) AT=990.025n

* CHECK dout0_21 Vdout0_21ck197 = 0 time = 990
.meas tran vdout0_21ck197 FIND v(dout0_21) AT=990.025n

* CHECK dout0_22 Vdout0_22ck197 = 0.9 time = 990
.meas tran vdout0_22ck197 FIND v(dout0_22) AT=990.025n

* CHECK dout0_23 Vdout0_23ck197 = 0 time = 990
.meas tran vdout0_23ck197 FIND v(dout0_23) AT=990.025n

* CHECK dout0_24 Vdout0_24ck197 = 0.9 time = 990
.meas tran vdout0_24ck197 FIND v(dout0_24) AT=990.025n

* CHECK dout0_25 Vdout0_25ck197 = 0 time = 990
.meas tran vdout0_25ck197 FIND v(dout0_25) AT=990.025n

* CHECK dout0_26 Vdout0_26ck197 = 0 time = 990
.meas tran vdout0_26ck197 FIND v(dout0_26) AT=990.025n

* CHECK dout0_27 Vdout0_27ck197 = 0 time = 990
.meas tran vdout0_27ck197 FIND v(dout0_27) AT=990.025n

* CHECK dout0_28 Vdout0_28ck197 = 0 time = 990
.meas tran vdout0_28ck197 FIND v(dout0_28) AT=990.025n

* CHECK dout0_29 Vdout0_29ck197 = 0 time = 990
.meas tran vdout0_29ck197 FIND v(dout0_29) AT=990.025n

* CHECK dout0_30 Vdout0_30ck197 = 0.9 time = 990
.meas tran vdout0_30ck197 FIND v(dout0_30) AT=990.025n

* CHECK dout0_31 Vdout0_31ck197 = 0.9 time = 990
.meas tran vdout0_31ck197 FIND v(dout0_31) AT=990.025n

* CHECK dout0_32 Vdout0_32ck197 = 0.9 time = 990
.meas tran vdout0_32ck197 FIND v(dout0_32) AT=990.025n

* CHECK dout0_33 Vdout0_33ck197 = 0.9 time = 990
.meas tran vdout0_33ck197 FIND v(dout0_33) AT=990.025n

* CHECK dout0_34 Vdout0_34ck197 = 0 time = 990
.meas tran vdout0_34ck197 FIND v(dout0_34) AT=990.025n

* CHECK dout0_35 Vdout0_35ck197 = 0 time = 990
.meas tran vdout0_35ck197 FIND v(dout0_35) AT=990.025n

* CHECK dout0_36 Vdout0_36ck197 = 0.9 time = 990
.meas tran vdout0_36ck197 FIND v(dout0_36) AT=990.025n

* CHECK dout0_37 Vdout0_37ck197 = 0.9 time = 990
.meas tran vdout0_37ck197 FIND v(dout0_37) AT=990.025n

* CHECK dout0_38 Vdout0_38ck197 = 0.9 time = 990
.meas tran vdout0_38ck197 FIND v(dout0_38) AT=990.025n

* CHECK dout0_39 Vdout0_39ck197 = 0.9 time = 990
.meas tran vdout0_39ck197 FIND v(dout0_39) AT=990.025n

* CHECK dout0_40 Vdout0_40ck197 = 0.9 time = 990
.meas tran vdout0_40ck197 FIND v(dout0_40) AT=990.025n

* CHECK dout0_41 Vdout0_41ck197 = 0.9 time = 990
.meas tran vdout0_41ck197 FIND v(dout0_41) AT=990.025n

* CHECK dout0_42 Vdout0_42ck197 = 0.9 time = 990
.meas tran vdout0_42ck197 FIND v(dout0_42) AT=990.025n

* CHECK dout0_43 Vdout0_43ck197 = 0.9 time = 990
.meas tran vdout0_43ck197 FIND v(dout0_43) AT=990.025n

* CHECK dout0_44 Vdout0_44ck197 = 0.9 time = 990
.meas tran vdout0_44ck197 FIND v(dout0_44) AT=990.025n

* CHECK dout0_45 Vdout0_45ck197 = 0 time = 990
.meas tran vdout0_45ck197 FIND v(dout0_45) AT=990.025n

* CHECK dout0_46 Vdout0_46ck197 = 0.9 time = 990
.meas tran vdout0_46ck197 FIND v(dout0_46) AT=990.025n

* CHECK dout0_47 Vdout0_47ck197 = 0.9 time = 990
.meas tran vdout0_47ck197 FIND v(dout0_47) AT=990.025n

* CHECK dout0_48 Vdout0_48ck197 = 0 time = 990
.meas tran vdout0_48ck197 FIND v(dout0_48) AT=990.025n

* CHECK dout0_49 Vdout0_49ck197 = 0.9 time = 990
.meas tran vdout0_49ck197 FIND v(dout0_49) AT=990.025n

* CHECK dout0_50 Vdout0_50ck197 = 0 time = 990
.meas tran vdout0_50ck197 FIND v(dout0_50) AT=990.025n

* CHECK dout0_51 Vdout0_51ck197 = 0.9 time = 990
.meas tran vdout0_51ck197 FIND v(dout0_51) AT=990.025n

* CHECK dout0_52 Vdout0_52ck197 = 0.9 time = 990
.meas tran vdout0_52ck197 FIND v(dout0_52) AT=990.025n

* CHECK dout0_53 Vdout0_53ck197 = 0.9 time = 990
.meas tran vdout0_53ck197 FIND v(dout0_53) AT=990.025n

* CHECK dout0_54 Vdout0_54ck197 = 0.9 time = 990
.meas tran vdout0_54ck197 FIND v(dout0_54) AT=990.025n

* CHECK dout0_55 Vdout0_55ck197 = 0.9 time = 990
.meas tran vdout0_55ck197 FIND v(dout0_55) AT=990.025n

* CHECK dout0_56 Vdout0_56ck197 = 0.9 time = 990
.meas tran vdout0_56ck197 FIND v(dout0_56) AT=990.025n

* CHECK dout0_57 Vdout0_57ck197 = 0 time = 990
.meas tran vdout0_57ck197 FIND v(dout0_57) AT=990.025n

* CHECK dout0_58 Vdout0_58ck197 = 0.9 time = 990
.meas tran vdout0_58ck197 FIND v(dout0_58) AT=990.025n

* CHECK dout0_59 Vdout0_59ck197 = 0 time = 990
.meas tran vdout0_59ck197 FIND v(dout0_59) AT=990.025n

* CHECK dout0_60 Vdout0_60ck197 = 0 time = 990
.meas tran vdout0_60ck197 FIND v(dout0_60) AT=990.025n

* CHECK dout0_61 Vdout0_61ck197 = 0.9 time = 990
.meas tran vdout0_61ck197 FIND v(dout0_61) AT=990.025n

* CHECK dout0_62 Vdout0_62ck197 = 0 time = 990
.meas tran vdout0_62ck197 FIND v(dout0_62) AT=990.025n

* CHECK dout0_63 Vdout0_63ck197 = 0 time = 990
.meas tran vdout0_63ck197 FIND v(dout0_63) AT=990.025n

* CHECK dout0_64 Vdout0_64ck197 = 0 time = 990
.meas tran vdout0_64ck197 FIND v(dout0_64) AT=990.025n

* CHECK dout0_65 Vdout0_65ck197 = 0 time = 990
.meas tran vdout0_65ck197 FIND v(dout0_65) AT=990.025n

* CHECK dout0_66 Vdout0_66ck197 = 0 time = 990
.meas tran vdout0_66ck197 FIND v(dout0_66) AT=990.025n

* CHECK dout0_67 Vdout0_67ck197 = 0.9 time = 990
.meas tran vdout0_67ck197 FIND v(dout0_67) AT=990.025n

* CHECK dout0_68 Vdout0_68ck197 = 0.9 time = 990
.meas tran vdout0_68ck197 FIND v(dout0_68) AT=990.025n

* CHECK dout0_69 Vdout0_69ck197 = 0 time = 990
.meas tran vdout0_69ck197 FIND v(dout0_69) AT=990.025n

* CHECK dout0_70 Vdout0_70ck197 = 0 time = 990
.meas tran vdout0_70ck197 FIND v(dout0_70) AT=990.025n

* CHECK dout0_71 Vdout0_71ck197 = 0.9 time = 990
.meas tran vdout0_71ck197 FIND v(dout0_71) AT=990.025n

* CHECK dout0_72 Vdout0_72ck197 = 0 time = 990
.meas tran vdout0_72ck197 FIND v(dout0_72) AT=990.025n

* CHECK dout0_73 Vdout0_73ck197 = 0.9 time = 990
.meas tran vdout0_73ck197 FIND v(dout0_73) AT=990.025n

* CHECK dout0_74 Vdout0_74ck197 = 0 time = 990
.meas tran vdout0_74ck197 FIND v(dout0_74) AT=990.025n

* CHECK dout0_75 Vdout0_75ck197 = 0 time = 990
.meas tran vdout0_75ck197 FIND v(dout0_75) AT=990.025n

* CHECK dout0_76 Vdout0_76ck197 = 0.9 time = 990
.meas tran vdout0_76ck197 FIND v(dout0_76) AT=990.025n

* CHECK dout0_77 Vdout0_77ck197 = 0 time = 990
.meas tran vdout0_77ck197 FIND v(dout0_77) AT=990.025n

* CHECK dout0_78 Vdout0_78ck197 = 0.9 time = 990
.meas tran vdout0_78ck197 FIND v(dout0_78) AT=990.025n

* CHECK dout0_79 Vdout0_79ck197 = 0.9 time = 990
.meas tran vdout0_79ck197 FIND v(dout0_79) AT=990.025n

* CHECK dout0_80 Vdout0_80ck197 = 0 time = 990
.meas tran vdout0_80ck197 FIND v(dout0_80) AT=990.025n

* CHECK dout0_81 Vdout0_81ck197 = 0 time = 990
.meas tran vdout0_81ck197 FIND v(dout0_81) AT=990.025n

* CHECK dout0_82 Vdout0_82ck197 = 0 time = 990
.meas tran vdout0_82ck197 FIND v(dout0_82) AT=990.025n

* CHECK dout0_83 Vdout0_83ck197 = 0.9 time = 990
.meas tran vdout0_83ck197 FIND v(dout0_83) AT=990.025n

* CHECK dout0_84 Vdout0_84ck197 = 0.9 time = 990
.meas tran vdout0_84ck197 FIND v(dout0_84) AT=990.025n

* CHECK dout0_85 Vdout0_85ck197 = 0.9 time = 990
.meas tran vdout0_85ck197 FIND v(dout0_85) AT=990.025n

* CHECK dout0_86 Vdout0_86ck197 = 0.9 time = 990
.meas tran vdout0_86ck197 FIND v(dout0_86) AT=990.025n

* CHECK dout0_87 Vdout0_87ck197 = 0 time = 990
.meas tran vdout0_87ck197 FIND v(dout0_87) AT=990.025n

* CHECK dout0_0 Vdout0_0ck201 = 0 time = 1010
.meas tran vdout0_0ck201 FIND v(dout0_0) AT=1010.025n

* CHECK dout0_1 Vdout0_1ck201 = 0.9 time = 1010
.meas tran vdout0_1ck201 FIND v(dout0_1) AT=1010.025n

* CHECK dout0_2 Vdout0_2ck201 = 0.9 time = 1010
.meas tran vdout0_2ck201 FIND v(dout0_2) AT=1010.025n

* CHECK dout0_3 Vdout0_3ck201 = 0 time = 1010
.meas tran vdout0_3ck201 FIND v(dout0_3) AT=1010.025n

* CHECK dout0_4 Vdout0_4ck201 = 0 time = 1010
.meas tran vdout0_4ck201 FIND v(dout0_4) AT=1010.025n

* CHECK dout0_5 Vdout0_5ck201 = 0 time = 1010
.meas tran vdout0_5ck201 FIND v(dout0_5) AT=1010.025n

* CHECK dout0_6 Vdout0_6ck201 = 0.9 time = 1010
.meas tran vdout0_6ck201 FIND v(dout0_6) AT=1010.025n

* CHECK dout0_7 Vdout0_7ck201 = 0 time = 1010
.meas tran vdout0_7ck201 FIND v(dout0_7) AT=1010.025n

* CHECK dout0_8 Vdout0_8ck201 = 0 time = 1010
.meas tran vdout0_8ck201 FIND v(dout0_8) AT=1010.025n

* CHECK dout0_9 Vdout0_9ck201 = 0.9 time = 1010
.meas tran vdout0_9ck201 FIND v(dout0_9) AT=1010.025n

* CHECK dout0_10 Vdout0_10ck201 = 0 time = 1010
.meas tran vdout0_10ck201 FIND v(dout0_10) AT=1010.025n

* CHECK dout0_11 Vdout0_11ck201 = 0 time = 1010
.meas tran vdout0_11ck201 FIND v(dout0_11) AT=1010.025n

* CHECK dout0_12 Vdout0_12ck201 = 0 time = 1010
.meas tran vdout0_12ck201 FIND v(dout0_12) AT=1010.025n

* CHECK dout0_13 Vdout0_13ck201 = 0 time = 1010
.meas tran vdout0_13ck201 FIND v(dout0_13) AT=1010.025n

* CHECK dout0_14 Vdout0_14ck201 = 0 time = 1010
.meas tran vdout0_14ck201 FIND v(dout0_14) AT=1010.025n

* CHECK dout0_15 Vdout0_15ck201 = 0.9 time = 1010
.meas tran vdout0_15ck201 FIND v(dout0_15) AT=1010.025n

* CHECK dout0_16 Vdout0_16ck201 = 0.9 time = 1010
.meas tran vdout0_16ck201 FIND v(dout0_16) AT=1010.025n

* CHECK dout0_17 Vdout0_17ck201 = 0 time = 1010
.meas tran vdout0_17ck201 FIND v(dout0_17) AT=1010.025n

* CHECK dout0_18 Vdout0_18ck201 = 0 time = 1010
.meas tran vdout0_18ck201 FIND v(dout0_18) AT=1010.025n

* CHECK dout0_19 Vdout0_19ck201 = 0.9 time = 1010
.meas tran vdout0_19ck201 FIND v(dout0_19) AT=1010.025n

* CHECK dout0_20 Vdout0_20ck201 = 0.9 time = 1010
.meas tran vdout0_20ck201 FIND v(dout0_20) AT=1010.025n

* CHECK dout0_21 Vdout0_21ck201 = 0.9 time = 1010
.meas tran vdout0_21ck201 FIND v(dout0_21) AT=1010.025n

* CHECK dout0_22 Vdout0_22ck201 = 0.9 time = 1010
.meas tran vdout0_22ck201 FIND v(dout0_22) AT=1010.025n

* CHECK dout0_23 Vdout0_23ck201 = 0 time = 1010
.meas tran vdout0_23ck201 FIND v(dout0_23) AT=1010.025n

* CHECK dout0_24 Vdout0_24ck201 = 0.9 time = 1010
.meas tran vdout0_24ck201 FIND v(dout0_24) AT=1010.025n

* CHECK dout0_25 Vdout0_25ck201 = 0.9 time = 1010
.meas tran vdout0_25ck201 FIND v(dout0_25) AT=1010.025n

* CHECK dout0_26 Vdout0_26ck201 = 0 time = 1010
.meas tran vdout0_26ck201 FIND v(dout0_26) AT=1010.025n

* CHECK dout0_27 Vdout0_27ck201 = 0.9 time = 1010
.meas tran vdout0_27ck201 FIND v(dout0_27) AT=1010.025n

* CHECK dout0_28 Vdout0_28ck201 = 0 time = 1010
.meas tran vdout0_28ck201 FIND v(dout0_28) AT=1010.025n

* CHECK dout0_29 Vdout0_29ck201 = 0 time = 1010
.meas tran vdout0_29ck201 FIND v(dout0_29) AT=1010.025n

* CHECK dout0_30 Vdout0_30ck201 = 0.9 time = 1010
.meas tran vdout0_30ck201 FIND v(dout0_30) AT=1010.025n

* CHECK dout0_31 Vdout0_31ck201 = 0 time = 1010
.meas tran vdout0_31ck201 FIND v(dout0_31) AT=1010.025n

* CHECK dout0_32 Vdout0_32ck201 = 0 time = 1010
.meas tran vdout0_32ck201 FIND v(dout0_32) AT=1010.025n

* CHECK dout0_33 Vdout0_33ck201 = 0.9 time = 1010
.meas tran vdout0_33ck201 FIND v(dout0_33) AT=1010.025n

* CHECK dout0_34 Vdout0_34ck201 = 0 time = 1010
.meas tran vdout0_34ck201 FIND v(dout0_34) AT=1010.025n

* CHECK dout0_35 Vdout0_35ck201 = 0.9 time = 1010
.meas tran vdout0_35ck201 FIND v(dout0_35) AT=1010.025n

* CHECK dout0_36 Vdout0_36ck201 = 0.9 time = 1010
.meas tran vdout0_36ck201 FIND v(dout0_36) AT=1010.025n

* CHECK dout0_37 Vdout0_37ck201 = 0.9 time = 1010
.meas tran vdout0_37ck201 FIND v(dout0_37) AT=1010.025n

* CHECK dout0_38 Vdout0_38ck201 = 0.9 time = 1010
.meas tran vdout0_38ck201 FIND v(dout0_38) AT=1010.025n

* CHECK dout0_39 Vdout0_39ck201 = 0.9 time = 1010
.meas tran vdout0_39ck201 FIND v(dout0_39) AT=1010.025n

* CHECK dout0_40 Vdout0_40ck201 = 0 time = 1010
.meas tran vdout0_40ck201 FIND v(dout0_40) AT=1010.025n

* CHECK dout0_41 Vdout0_41ck201 = 0 time = 1010
.meas tran vdout0_41ck201 FIND v(dout0_41) AT=1010.025n

* CHECK dout0_42 Vdout0_42ck201 = 0 time = 1010
.meas tran vdout0_42ck201 FIND v(dout0_42) AT=1010.025n

* CHECK dout0_43 Vdout0_43ck201 = 0.9 time = 1010
.meas tran vdout0_43ck201 FIND v(dout0_43) AT=1010.025n

* CHECK dout0_44 Vdout0_44ck201 = 0.9 time = 1010
.meas tran vdout0_44ck201 FIND v(dout0_44) AT=1010.025n

* CHECK dout0_45 Vdout0_45ck201 = 0.9 time = 1010
.meas tran vdout0_45ck201 FIND v(dout0_45) AT=1010.025n

* CHECK dout0_46 Vdout0_46ck201 = 0 time = 1010
.meas tran vdout0_46ck201 FIND v(dout0_46) AT=1010.025n

* CHECK dout0_47 Vdout0_47ck201 = 0.9 time = 1010
.meas tran vdout0_47ck201 FIND v(dout0_47) AT=1010.025n

* CHECK dout0_48 Vdout0_48ck201 = 0 time = 1010
.meas tran vdout0_48ck201 FIND v(dout0_48) AT=1010.025n

* CHECK dout0_49 Vdout0_49ck201 = 0 time = 1010
.meas tran vdout0_49ck201 FIND v(dout0_49) AT=1010.025n

* CHECK dout0_50 Vdout0_50ck201 = 0.9 time = 1010
.meas tran vdout0_50ck201 FIND v(dout0_50) AT=1010.025n

* CHECK dout0_51 Vdout0_51ck201 = 0.9 time = 1010
.meas tran vdout0_51ck201 FIND v(dout0_51) AT=1010.025n

* CHECK dout0_52 Vdout0_52ck201 = 0 time = 1010
.meas tran vdout0_52ck201 FIND v(dout0_52) AT=1010.025n

* CHECK dout0_53 Vdout0_53ck201 = 0.9 time = 1010
.meas tran vdout0_53ck201 FIND v(dout0_53) AT=1010.025n

* CHECK dout0_54 Vdout0_54ck201 = 0 time = 1010
.meas tran vdout0_54ck201 FIND v(dout0_54) AT=1010.025n

* CHECK dout0_55 Vdout0_55ck201 = 0 time = 1010
.meas tran vdout0_55ck201 FIND v(dout0_55) AT=1010.025n

* CHECK dout0_56 Vdout0_56ck201 = 0.9 time = 1010
.meas tran vdout0_56ck201 FIND v(dout0_56) AT=1010.025n

* CHECK dout0_57 Vdout0_57ck201 = 0 time = 1010
.meas tran vdout0_57ck201 FIND v(dout0_57) AT=1010.025n

* CHECK dout0_58 Vdout0_58ck201 = 0.9 time = 1010
.meas tran vdout0_58ck201 FIND v(dout0_58) AT=1010.025n

* CHECK dout0_59 Vdout0_59ck201 = 0.9 time = 1010
.meas tran vdout0_59ck201 FIND v(dout0_59) AT=1010.025n

* CHECK dout0_60 Vdout0_60ck201 = 0 time = 1010
.meas tran vdout0_60ck201 FIND v(dout0_60) AT=1010.025n

* CHECK dout0_61 Vdout0_61ck201 = 0 time = 1010
.meas tran vdout0_61ck201 FIND v(dout0_61) AT=1010.025n

* CHECK dout0_62 Vdout0_62ck201 = 0.9 time = 1010
.meas tran vdout0_62ck201 FIND v(dout0_62) AT=1010.025n

* CHECK dout0_63 Vdout0_63ck201 = 0.9 time = 1010
.meas tran vdout0_63ck201 FIND v(dout0_63) AT=1010.025n

* CHECK dout0_64 Vdout0_64ck201 = 0 time = 1010
.meas tran vdout0_64ck201 FIND v(dout0_64) AT=1010.025n

* CHECK dout0_65 Vdout0_65ck201 = 0 time = 1010
.meas tran vdout0_65ck201 FIND v(dout0_65) AT=1010.025n

* CHECK dout0_66 Vdout0_66ck201 = 0.9 time = 1010
.meas tran vdout0_66ck201 FIND v(dout0_66) AT=1010.025n

* CHECK dout0_67 Vdout0_67ck201 = 0.9 time = 1010
.meas tran vdout0_67ck201 FIND v(dout0_67) AT=1010.025n

* CHECK dout0_68 Vdout0_68ck201 = 0 time = 1010
.meas tran vdout0_68ck201 FIND v(dout0_68) AT=1010.025n

* CHECK dout0_69 Vdout0_69ck201 = 0 time = 1010
.meas tran vdout0_69ck201 FIND v(dout0_69) AT=1010.025n

* CHECK dout0_70 Vdout0_70ck201 = 0.9 time = 1010
.meas tran vdout0_70ck201 FIND v(dout0_70) AT=1010.025n

* CHECK dout0_71 Vdout0_71ck201 = 0 time = 1010
.meas tran vdout0_71ck201 FIND v(dout0_71) AT=1010.025n

* CHECK dout0_72 Vdout0_72ck201 = 0 time = 1010
.meas tran vdout0_72ck201 FIND v(dout0_72) AT=1010.025n

* CHECK dout0_73 Vdout0_73ck201 = 0 time = 1010
.meas tran vdout0_73ck201 FIND v(dout0_73) AT=1010.025n

* CHECK dout0_74 Vdout0_74ck201 = 0.9 time = 1010
.meas tran vdout0_74ck201 FIND v(dout0_74) AT=1010.025n

* CHECK dout0_75 Vdout0_75ck201 = 0 time = 1010
.meas tran vdout0_75ck201 FIND v(dout0_75) AT=1010.025n

* CHECK dout0_76 Vdout0_76ck201 = 0 time = 1010
.meas tran vdout0_76ck201 FIND v(dout0_76) AT=1010.025n

* CHECK dout0_77 Vdout0_77ck201 = 0.9 time = 1010
.meas tran vdout0_77ck201 FIND v(dout0_77) AT=1010.025n

* CHECK dout0_78 Vdout0_78ck201 = 0 time = 1010
.meas tran vdout0_78ck201 FIND v(dout0_78) AT=1010.025n

* CHECK dout0_79 Vdout0_79ck201 = 0 time = 1010
.meas tran vdout0_79ck201 FIND v(dout0_79) AT=1010.025n

* CHECK dout0_80 Vdout0_80ck201 = 0 time = 1010
.meas tran vdout0_80ck201 FIND v(dout0_80) AT=1010.025n

* CHECK dout0_81 Vdout0_81ck201 = 0.9 time = 1010
.meas tran vdout0_81ck201 FIND v(dout0_81) AT=1010.025n

* CHECK dout0_82 Vdout0_82ck201 = 0 time = 1010
.meas tran vdout0_82ck201 FIND v(dout0_82) AT=1010.025n

* CHECK dout0_83 Vdout0_83ck201 = 0 time = 1010
.meas tran vdout0_83ck201 FIND v(dout0_83) AT=1010.025n

* CHECK dout0_84 Vdout0_84ck201 = 0 time = 1010
.meas tran vdout0_84ck201 FIND v(dout0_84) AT=1010.025n

* CHECK dout0_85 Vdout0_85ck201 = 0.9 time = 1010
.meas tran vdout0_85ck201 FIND v(dout0_85) AT=1010.025n

* CHECK dout0_86 Vdout0_86ck201 = 0 time = 1010
.meas tran vdout0_86ck201 FIND v(dout0_86) AT=1010.025n

* CHECK dout0_87 Vdout0_87ck201 = 0 time = 1010
.meas tran vdout0_87ck201 FIND v(dout0_87) AT=1010.025n

* CHECK dout0_0 Vdout0_0ck204 = 0.9 time = 1025
.meas tran vdout0_0ck204 FIND v(dout0_0) AT=1025.025n

* CHECK dout0_1 Vdout0_1ck204 = 0.9 time = 1025
.meas tran vdout0_1ck204 FIND v(dout0_1) AT=1025.025n

* CHECK dout0_2 Vdout0_2ck204 = 0.9 time = 1025
.meas tran vdout0_2ck204 FIND v(dout0_2) AT=1025.025n

* CHECK dout0_3 Vdout0_3ck204 = 0 time = 1025
.meas tran vdout0_3ck204 FIND v(dout0_3) AT=1025.025n

* CHECK dout0_4 Vdout0_4ck204 = 0.9 time = 1025
.meas tran vdout0_4ck204 FIND v(dout0_4) AT=1025.025n

* CHECK dout0_5 Vdout0_5ck204 = 0 time = 1025
.meas tran vdout0_5ck204 FIND v(dout0_5) AT=1025.025n

* CHECK dout0_6 Vdout0_6ck204 = 0.9 time = 1025
.meas tran vdout0_6ck204 FIND v(dout0_6) AT=1025.025n

* CHECK dout0_7 Vdout0_7ck204 = 0 time = 1025
.meas tran vdout0_7ck204 FIND v(dout0_7) AT=1025.025n

* CHECK dout0_8 Vdout0_8ck204 = 0 time = 1025
.meas tran vdout0_8ck204 FIND v(dout0_8) AT=1025.025n

* CHECK dout0_9 Vdout0_9ck204 = 0 time = 1025
.meas tran vdout0_9ck204 FIND v(dout0_9) AT=1025.025n

* CHECK dout0_10 Vdout0_10ck204 = 0.9 time = 1025
.meas tran vdout0_10ck204 FIND v(dout0_10) AT=1025.025n

* CHECK dout0_11 Vdout0_11ck204 = 0 time = 1025
.meas tran vdout0_11ck204 FIND v(dout0_11) AT=1025.025n

* CHECK dout0_12 Vdout0_12ck204 = 0.9 time = 1025
.meas tran vdout0_12ck204 FIND v(dout0_12) AT=1025.025n

* CHECK dout0_13 Vdout0_13ck204 = 0 time = 1025
.meas tran vdout0_13ck204 FIND v(dout0_13) AT=1025.025n

* CHECK dout0_14 Vdout0_14ck204 = 0 time = 1025
.meas tran vdout0_14ck204 FIND v(dout0_14) AT=1025.025n

* CHECK dout0_15 Vdout0_15ck204 = 0.9 time = 1025
.meas tran vdout0_15ck204 FIND v(dout0_15) AT=1025.025n

* CHECK dout0_16 Vdout0_16ck204 = 0.9 time = 1025
.meas tran vdout0_16ck204 FIND v(dout0_16) AT=1025.025n

* CHECK dout0_17 Vdout0_17ck204 = 0.9 time = 1025
.meas tran vdout0_17ck204 FIND v(dout0_17) AT=1025.025n

* CHECK dout0_18 Vdout0_18ck204 = 0 time = 1025
.meas tran vdout0_18ck204 FIND v(dout0_18) AT=1025.025n

* CHECK dout0_19 Vdout0_19ck204 = 0 time = 1025
.meas tran vdout0_19ck204 FIND v(dout0_19) AT=1025.025n

* CHECK dout0_20 Vdout0_20ck204 = 0.9 time = 1025
.meas tran vdout0_20ck204 FIND v(dout0_20) AT=1025.025n

* CHECK dout0_21 Vdout0_21ck204 = 0 time = 1025
.meas tran vdout0_21ck204 FIND v(dout0_21) AT=1025.025n

* CHECK dout0_22 Vdout0_22ck204 = 0.9 time = 1025
.meas tran vdout0_22ck204 FIND v(dout0_22) AT=1025.025n

* CHECK dout0_23 Vdout0_23ck204 = 0 time = 1025
.meas tran vdout0_23ck204 FIND v(dout0_23) AT=1025.025n

* CHECK dout0_24 Vdout0_24ck204 = 0.9 time = 1025
.meas tran vdout0_24ck204 FIND v(dout0_24) AT=1025.025n

* CHECK dout0_25 Vdout0_25ck204 = 0.9 time = 1025
.meas tran vdout0_25ck204 FIND v(dout0_25) AT=1025.025n

* CHECK dout0_26 Vdout0_26ck204 = 0 time = 1025
.meas tran vdout0_26ck204 FIND v(dout0_26) AT=1025.025n

* CHECK dout0_27 Vdout0_27ck204 = 0.9 time = 1025
.meas tran vdout0_27ck204 FIND v(dout0_27) AT=1025.025n

* CHECK dout0_28 Vdout0_28ck204 = 0.9 time = 1025
.meas tran vdout0_28ck204 FIND v(dout0_28) AT=1025.025n

* CHECK dout0_29 Vdout0_29ck204 = 0.9 time = 1025
.meas tran vdout0_29ck204 FIND v(dout0_29) AT=1025.025n

* CHECK dout0_30 Vdout0_30ck204 = 0.9 time = 1025
.meas tran vdout0_30ck204 FIND v(dout0_30) AT=1025.025n

* CHECK dout0_31 Vdout0_31ck204 = 0.9 time = 1025
.meas tran vdout0_31ck204 FIND v(dout0_31) AT=1025.025n

* CHECK dout0_32 Vdout0_32ck204 = 0 time = 1025
.meas tran vdout0_32ck204 FIND v(dout0_32) AT=1025.025n

* CHECK dout0_33 Vdout0_33ck204 = 0.9 time = 1025
.meas tran vdout0_33ck204 FIND v(dout0_33) AT=1025.025n

* CHECK dout0_34 Vdout0_34ck204 = 0.9 time = 1025
.meas tran vdout0_34ck204 FIND v(dout0_34) AT=1025.025n

* CHECK dout0_35 Vdout0_35ck204 = 0 time = 1025
.meas tran vdout0_35ck204 FIND v(dout0_35) AT=1025.025n

* CHECK dout0_36 Vdout0_36ck204 = 0.9 time = 1025
.meas tran vdout0_36ck204 FIND v(dout0_36) AT=1025.025n

* CHECK dout0_37 Vdout0_37ck204 = 0 time = 1025
.meas tran vdout0_37ck204 FIND v(dout0_37) AT=1025.025n

* CHECK dout0_38 Vdout0_38ck204 = 0 time = 1025
.meas tran vdout0_38ck204 FIND v(dout0_38) AT=1025.025n

* CHECK dout0_39 Vdout0_39ck204 = 0.9 time = 1025
.meas tran vdout0_39ck204 FIND v(dout0_39) AT=1025.025n

* CHECK dout0_40 Vdout0_40ck204 = 0 time = 1025
.meas tran vdout0_40ck204 FIND v(dout0_40) AT=1025.025n

* CHECK dout0_41 Vdout0_41ck204 = 0 time = 1025
.meas tran vdout0_41ck204 FIND v(dout0_41) AT=1025.025n

* CHECK dout0_42 Vdout0_42ck204 = 0.9 time = 1025
.meas tran vdout0_42ck204 FIND v(dout0_42) AT=1025.025n

* CHECK dout0_43 Vdout0_43ck204 = 0 time = 1025
.meas tran vdout0_43ck204 FIND v(dout0_43) AT=1025.025n

* CHECK dout0_44 Vdout0_44ck204 = 0.9 time = 1025
.meas tran vdout0_44ck204 FIND v(dout0_44) AT=1025.025n

* CHECK dout0_45 Vdout0_45ck204 = 0 time = 1025
.meas tran vdout0_45ck204 FIND v(dout0_45) AT=1025.025n

* CHECK dout0_46 Vdout0_46ck204 = 0.9 time = 1025
.meas tran vdout0_46ck204 FIND v(dout0_46) AT=1025.025n

* CHECK dout0_47 Vdout0_47ck204 = 0 time = 1025
.meas tran vdout0_47ck204 FIND v(dout0_47) AT=1025.025n

* CHECK dout0_48 Vdout0_48ck204 = 0.9 time = 1025
.meas tran vdout0_48ck204 FIND v(dout0_48) AT=1025.025n

* CHECK dout0_49 Vdout0_49ck204 = 0 time = 1025
.meas tran vdout0_49ck204 FIND v(dout0_49) AT=1025.025n

* CHECK dout0_50 Vdout0_50ck204 = 0.9 time = 1025
.meas tran vdout0_50ck204 FIND v(dout0_50) AT=1025.025n

* CHECK dout0_51 Vdout0_51ck204 = 0 time = 1025
.meas tran vdout0_51ck204 FIND v(dout0_51) AT=1025.025n

* CHECK dout0_52 Vdout0_52ck204 = 0.9 time = 1025
.meas tran vdout0_52ck204 FIND v(dout0_52) AT=1025.025n

* CHECK dout0_53 Vdout0_53ck204 = 0 time = 1025
.meas tran vdout0_53ck204 FIND v(dout0_53) AT=1025.025n

* CHECK dout0_54 Vdout0_54ck204 = 0.9 time = 1025
.meas tran vdout0_54ck204 FIND v(dout0_54) AT=1025.025n

* CHECK dout0_55 Vdout0_55ck204 = 0.9 time = 1025
.meas tran vdout0_55ck204 FIND v(dout0_55) AT=1025.025n

* CHECK dout0_56 Vdout0_56ck204 = 0.9 time = 1025
.meas tran vdout0_56ck204 FIND v(dout0_56) AT=1025.025n

* CHECK dout0_57 Vdout0_57ck204 = 0.9 time = 1025
.meas tran vdout0_57ck204 FIND v(dout0_57) AT=1025.025n

* CHECK dout0_58 Vdout0_58ck204 = 0.9 time = 1025
.meas tran vdout0_58ck204 FIND v(dout0_58) AT=1025.025n

* CHECK dout0_59 Vdout0_59ck204 = 0.9 time = 1025
.meas tran vdout0_59ck204 FIND v(dout0_59) AT=1025.025n

* CHECK dout0_60 Vdout0_60ck204 = 0.9 time = 1025
.meas tran vdout0_60ck204 FIND v(dout0_60) AT=1025.025n

* CHECK dout0_61 Vdout0_61ck204 = 0.9 time = 1025
.meas tran vdout0_61ck204 FIND v(dout0_61) AT=1025.025n

* CHECK dout0_62 Vdout0_62ck204 = 0.9 time = 1025
.meas tran vdout0_62ck204 FIND v(dout0_62) AT=1025.025n

* CHECK dout0_63 Vdout0_63ck204 = 0.9 time = 1025
.meas tran vdout0_63ck204 FIND v(dout0_63) AT=1025.025n

* CHECK dout0_64 Vdout0_64ck204 = 0.9 time = 1025
.meas tran vdout0_64ck204 FIND v(dout0_64) AT=1025.025n

* CHECK dout0_65 Vdout0_65ck204 = 0 time = 1025
.meas tran vdout0_65ck204 FIND v(dout0_65) AT=1025.025n

* CHECK dout0_66 Vdout0_66ck204 = 0.9 time = 1025
.meas tran vdout0_66ck204 FIND v(dout0_66) AT=1025.025n

* CHECK dout0_67 Vdout0_67ck204 = 0 time = 1025
.meas tran vdout0_67ck204 FIND v(dout0_67) AT=1025.025n

* CHECK dout0_68 Vdout0_68ck204 = 0.9 time = 1025
.meas tran vdout0_68ck204 FIND v(dout0_68) AT=1025.025n

* CHECK dout0_69 Vdout0_69ck204 = 0 time = 1025
.meas tran vdout0_69ck204 FIND v(dout0_69) AT=1025.025n

* CHECK dout0_70 Vdout0_70ck204 = 0 time = 1025
.meas tran vdout0_70ck204 FIND v(dout0_70) AT=1025.025n

* CHECK dout0_71 Vdout0_71ck204 = 0.9 time = 1025
.meas tran vdout0_71ck204 FIND v(dout0_71) AT=1025.025n

* CHECK dout0_72 Vdout0_72ck204 = 0 time = 1025
.meas tran vdout0_72ck204 FIND v(dout0_72) AT=1025.025n

* CHECK dout0_73 Vdout0_73ck204 = 0.9 time = 1025
.meas tran vdout0_73ck204 FIND v(dout0_73) AT=1025.025n

* CHECK dout0_74 Vdout0_74ck204 = 0 time = 1025
.meas tran vdout0_74ck204 FIND v(dout0_74) AT=1025.025n

* CHECK dout0_75 Vdout0_75ck204 = 0.9 time = 1025
.meas tran vdout0_75ck204 FIND v(dout0_75) AT=1025.025n

* CHECK dout0_76 Vdout0_76ck204 = 0.9 time = 1025
.meas tran vdout0_76ck204 FIND v(dout0_76) AT=1025.025n

* CHECK dout0_77 Vdout0_77ck204 = 0 time = 1025
.meas tran vdout0_77ck204 FIND v(dout0_77) AT=1025.025n

* CHECK dout0_78 Vdout0_78ck204 = 0 time = 1025
.meas tran vdout0_78ck204 FIND v(dout0_78) AT=1025.025n

* CHECK dout0_79 Vdout0_79ck204 = 0 time = 1025
.meas tran vdout0_79ck204 FIND v(dout0_79) AT=1025.025n

* CHECK dout0_80 Vdout0_80ck204 = 0 time = 1025
.meas tran vdout0_80ck204 FIND v(dout0_80) AT=1025.025n

* CHECK dout0_81 Vdout0_81ck204 = 0 time = 1025
.meas tran vdout0_81ck204 FIND v(dout0_81) AT=1025.025n

* CHECK dout0_82 Vdout0_82ck204 = 0 time = 1025
.meas tran vdout0_82ck204 FIND v(dout0_82) AT=1025.025n

* CHECK dout0_83 Vdout0_83ck204 = 0.9 time = 1025
.meas tran vdout0_83ck204 FIND v(dout0_83) AT=1025.025n

* CHECK dout0_84 Vdout0_84ck204 = 0.9 time = 1025
.meas tran vdout0_84ck204 FIND v(dout0_84) AT=1025.025n

* CHECK dout0_85 Vdout0_85ck204 = 0.9 time = 1025
.meas tran vdout0_85ck204 FIND v(dout0_85) AT=1025.025n

* CHECK dout0_86 Vdout0_86ck204 = 0.9 time = 1025
.meas tran vdout0_86ck204 FIND v(dout0_86) AT=1025.025n

* CHECK dout0_87 Vdout0_87ck204 = 0.9 time = 1025
.meas tran vdout0_87ck204 FIND v(dout0_87) AT=1025.025n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
